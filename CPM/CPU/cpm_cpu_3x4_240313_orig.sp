********************************************
* Ansys RedHawk-SC Chip Power Model [ Ver 2.00 ]
* Generated at Mar 09 03:28:04 2024
* Version: 2021 R1.RD  RHEL6 (Sep 29 00:01:22 2020)
* Run directory:  /fs/mm_imp46/user/kuma/03_240203_wDFT_for_STAPI/flat2020R32_CLK2/gp/asim_power_scratch.gv_rmv.4803
* CPM Options:
* perform powermodel -nx 3 -ny 4 -no_afs -noglobal_gnd -pincurrent -emi -plocnames
* Copyright (c) 2002-2020 ANSYS, Inc.
* Presimulation time  0.000000ps
********************************************

* Partitioning of flip chip bump pad area - Die Top View
* ------------------------------------
* | (0 Ny) | (1 Ny) | .... | (Nx Ny) |
* ------------------------------------
* | (0 ..) | (1 ..) | .... | (Nx ..) |
* ------------------------------------
* | (0  1) | (1  1) | .... | (Nx  1) |
* ------------------------------------
* | (0  0) | (1  0) | .... | (Nx  0) |
* ------------------------------------
* Begin Chip Package Protocol --->
 * generated by asim_power_model

* Start Units
*   Length um
* End Units
* VDD075CPU_01118	 :   (12108.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01356	 :   (11004.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01357	 :   (11188.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01358	 :   (11372.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01359	 :   (11556.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01122	 :   (12844.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01121	 :   (12660.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01120	 :   (12476.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01119	 :   (12292.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01355	 :   (10820.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01403	 :   (12844.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01402	 :   (12660.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01401	 :   (12476.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01400	 :   (12292.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01399	 :   (12108.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01398	 :   (11924.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01397	 :   (11740.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01396	 :   (11556.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01154	 :   (12660.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01430	 :   (11004.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01429	 :   (10820.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01291	 :   (12660.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01292	 :   (12844.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01074	 :   (10820.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01113	 :   (11188.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01114	 :   (11372.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01155	 :   (12844.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01395	 :   (11372.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01153	 :   (12476.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01152	 :   (12292.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01151	 :   (12108.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01150	 :   (11924.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01149	 :   (11740.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01148	 :   (11556.000000 3310.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01115	 :   (11556.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01329	 :   (12844.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01327	 :   (12476.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01043	 :   (11924.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01044	 :   (12108.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01045	 :   (12292.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01046	 :   (12476.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01047	 :   (12660.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01048	 :   (12844.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01325	 :   (12108.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01326	 :   (12292.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01042	 :   (11740.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01328	 :   (12660.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01366	 :   (12844.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01365	 :   (12660.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01364	 :   (12476.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01363	 :   (12292.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01362	 :   (12108.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01361	 :   (11924.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01360	 :   (11740.000000 2206.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01321	 :   (11372.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01394	 :   (11188.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01393	 :   (11004.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01392	 :   (10820.000000 2022.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01117	 :   (11924.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01116	 :   (11740.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01318	 :   (10820.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01319	 :   (11004.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01320	 :   (11188.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01431	 :   (11188.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01322	 :   (11556.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01323	 :   (11740.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01324	 :   (11924.000000 2390.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01037	 :   (10820.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01038	 :   (11004.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01039	 :   (11188.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01040	 :   (11372.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01041	 :   (11556.000000 3862.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01475	 :   (12476.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01218	 :   (12844.000000 2942.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01217	 :   (12660.000000 2942.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01216	 :   (12476.000000 2942.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01215	 :   (12292.000000 2942.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01214	 :   (12108.000000 2942.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01082	 :   (12292.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01477	 :   (12844.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01476	 :   (12660.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01083	 :   (12476.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01474	 :   (12292.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01473	 :   (12108.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01472	 :   (11924.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01471	 :   (11740.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01470	 :   (11556.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01469	 :   (11372.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01468	 :   (11188.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01467	 :   (11004.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01251	 :   (12108.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01111	 :   (10820.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01244	 :   (10820.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01245	 :   (11004.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01246	 :   (11188.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01247	 :   (11372.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01248	 :   (11556.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01249	 :   (11740.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01250	 :   (11924.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01432	 :   (11372.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01252	 :   (12292.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01253	 :   (12476.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01254	 :   (12660.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01255	 :   (12844.000000 2758.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01112	 :   (11004.000000 3494.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01085	 :   (12844.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01084	 :   (12660.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01440	 :   (12844.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01283	 :   (11188.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01284	 :   (11372.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01285	 :   (11556.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01286	 :   (11740.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01287	 :   (11924.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01288	 :   (12108.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01289	 :   (12292.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01290	 :   (12476.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01081	 :   (12108.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01439	 :   (12660.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01438	 :   (12476.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01437	 :   (12292.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01436	 :   (12108.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01435	 :   (11924.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01434	 :   (11740.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01433	 :   (11556.000000 1838.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01281	 :   (10820.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01466	 :   (10820.000000 1654.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01080	 :   (11924.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01079	 :   (11740.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01078	 :   (11556.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01077	 :   (11372.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01188	 :   (12844.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01187	 :   (12660.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01186	 :   (12476.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01185	 :   (12292.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01184	 :   (12108.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01183	 :   (11924.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01182	 :   (11740.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01181	 :   (11556.000000 3126.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01076	 :   (11188.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01075	 :   (11004.000000 3678.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VDD075CPU_01282	 :   (11004.000000 2574.000000)	 :   PAR_0_0_VDD075CPU	  = PAR_0_0_VDD075CPU
* VSS_04706	 :   (15144.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04896	 :   (15144.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04885	 :   (13120.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04224	 :   (13856.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04895	 :   (14960.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04894	 :   (14776.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04893	 :   (14592.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04892	 :   (14408.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04891	 :   (14224.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04890	 :   (14040.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04889	 :   (13856.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04888	 :   (13672.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04887	 :   (13488.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04886	 :   (13304.000000 2114.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04790	 :   (13120.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04801	 :   (15144.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04800	 :   (14960.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04799	 :   (14776.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04798	 :   (14592.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04797	 :   (14408.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04796	 :   (14224.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04795	 :   (14040.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04794	 :   (13856.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04793	 :   (13672.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04792	 :   (13488.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04791	 :   (13304.000000 2298.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04231	 :   (15144.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04038	 :   (14592.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04037	 :   (14408.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04036	 :   (14224.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04035	 :   (14040.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04034	 :   (13856.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04033	 :   (13672.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04032	 :   (13488.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04031	 :   (13304.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04030	 :   (13120.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04229	 :   (14776.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04230	 :   (14960.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04039	 :   (14776.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04315	 :   (13120.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04316	 :   (13304.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04317	 :   (13488.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04318	 :   (13672.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04319	 :   (13856.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04320	 :   (14040.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04321	 :   (14224.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04322	 :   (14408.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04323	 :   (14592.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04324	 :   (14776.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04325	 :   (14960.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04132	 :   (14408.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04223	 :   (13672.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04222	 :   (13488.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04221	 :   (13304.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04220	 :   (13120.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04225	 :   (14040.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04226	 :   (14224.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04227	 :   (14408.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04136	 :   (15144.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04135	 :   (14960.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04134	 :   (14776.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04133	 :   (14592.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04326	 :   (15144.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04131	 :   (14224.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04130	 :   (14040.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04129	 :   (13856.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04128	 :   (13672.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04127	 :   (13488.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04126	 :   (13304.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04125	 :   (13120.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04228	 :   (14592.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04041	 :   (15144.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04040	 :   (14960.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04609	 :   (14960.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04516	 :   (15144.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04599	 :   (13120.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04600	 :   (13304.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04601	 :   (13488.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04602	 :   (13672.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04603	 :   (13856.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04604	 :   (14040.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04605	 :   (14224.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04606	 :   (14408.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04607	 :   (14592.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04608	 :   (14776.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04515	 :   (14960.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04610	 :   (15144.000000 2666.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04695	 :   (13120.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04696	 :   (13304.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04697	 :   (13488.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04698	 :   (13672.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04699	 :   (13856.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04700	 :   (14040.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04701	 :   (14224.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04702	 :   (14408.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04703	 :   (14592.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04704	 :   (14776.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04424	 :   (15144.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04413	 :   (13120.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04414	 :   (13304.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04415	 :   (13488.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04416	 :   (13672.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04417	 :   (13856.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04418	 :   (14040.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04419	 :   (14224.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04420	 :   (14408.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04421	 :   (14592.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04422	 :   (14776.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04423	 :   (14960.000000 3034.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04705	 :   (14960.000000 2482.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04505	 :   (13120.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04506	 :   (13304.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04507	 :   (13488.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04508	 :   (13672.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04509	 :   (13856.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04510	 :   (14040.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04511	 :   (14224.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04512	 :   (14408.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04513	 :   (14592.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04514	 :   (14776.000000 2850.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04983	 :   (13488.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05180	 :   (14776.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05181	 :   (14960.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05182	 :   (15144.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05079	 :   (13672.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05078	 :   (13488.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05077	 :   (13304.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05076	 :   (13120.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04981	 :   (13120.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04982	 :   (13304.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05171	 :   (13120.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04984	 :   (13672.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04985	 :   (13856.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04986	 :   (14040.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04987	 :   (14224.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04988	 :   (14408.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04989	 :   (14592.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04990	 :   (14776.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04992	 :   (15144.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04991	 :   (14960.000000 1930.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05173	 :   (13488.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05178	 :   (14408.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05179	 :   (14592.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05177	 :   (14224.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05176	 :   (14040.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05082	 :   (14224.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05081	 :   (14040.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05080	 :   (13856.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05086	 :   (14960.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05087	 :   (15144.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05175	 :   (13856.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05174	 :   (13672.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05083	 :   (14408.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05172	 :   (13304.000000 1562.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05084	 :   (14592.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_05085	 :   (14776.000000 1746.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VDD075CPU_01090	 :   (13764.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01338	 :   (14500.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01091	 :   (13948.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01092	 :   (14132.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01093	 :   (14316.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01407	 :   (13580.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01448	 :   (14316.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01335	 :   (13948.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01336	 :   (14132.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01094	 :   (14500.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01095	 :   (14684.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01096	 :   (14868.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01097	 :   (15052.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01410	 :   (14132.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01098	 :   (15236.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01337	 :   (14316.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01331	 :   (13212.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01379	 :   (15236.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01124	 :   (13212.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01123	 :   (13028.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01404	 :   (13028.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01483	 :   (13948.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01482	 :   (13764.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01416	 :   (15236.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01415	 :   (15052.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01414	 :   (14868.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01330	 :   (13028.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01408	 :   (13764.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01332	 :   (13396.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01333	 :   (13580.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01334	 :   (13764.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01405	 :   (13212.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01406	 :   (13396.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01413	 :   (14684.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01412	 :   (14500.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01411	 :   (14316.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01125	 :   (13396.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01409	 :   (13948.000000 2022.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01050	 :   (13212.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01060	 :   (15052.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01059	 :   (14868.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01058	 :   (14684.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01057	 :   (14500.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01056	 :   (14316.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01055	 :   (14132.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01054	 :   (13948.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01053	 :   (13764.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01052	 :   (13580.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01051	 :   (13396.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01061	 :   (15236.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01049	 :   (13028.000000 3862.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01371	 :   (13764.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01372	 :   (13948.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01373	 :   (14132.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01374	 :   (14316.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01375	 :   (14500.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01376	 :   (14684.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01377	 :   (14868.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01378	 :   (15052.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01480	 :   (13396.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01088	 :   (13396.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01087	 :   (13212.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01086	 :   (13028.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01339	 :   (14684.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01340	 :   (14868.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01341	 :   (15052.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01342	 :   (15236.000000 2390.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01449	 :   (14500.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01450	 :   (14684.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01481	 :   (13580.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01089	 :   (13580.000000 3678.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01479	 :   (13212.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01478	 :   (13028.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01451	 :   (14868.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01452	 :   (15052.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01367	 :   (13028.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01368	 :   (13212.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01369	 :   (13396.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01370	 :   (13580.000000 2206.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01453	 :   (15236.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01196	 :   (14316.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01263	 :   (14316.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01264	 :   (14500.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01265	 :   (14684.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01266	 :   (14868.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01267	 :   (15052.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01268	 :   (15236.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01201	 :   (15236.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01200	 :   (15052.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01199	 :   (14868.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01198	 :   (14684.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01197	 :   (14500.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01262	 :   (14132.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01195	 :   (14132.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01194	 :   (13948.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01193	 :   (13764.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01192	 :   (13580.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01191	 :   (13396.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01190	 :   (13212.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01189	 :   (13028.000000 3126.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01443	 :   (13396.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01444	 :   (13580.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01445	 :   (13764.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01227	 :   (14500.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01441	 :   (13028.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01442	 :   (13212.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01256	 :   (13028.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01257	 :   (13212.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01258	 :   (13396.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01259	 :   (13580.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01231	 :   (15236.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01230	 :   (15052.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01229	 :   (14868.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01228	 :   (14684.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01127	 :   (13764.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01226	 :   (14316.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01225	 :   (14132.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01224	 :   (13948.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01223	 :   (13764.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01222	 :   (13580.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01221	 :   (13396.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01220	 :   (13212.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01219	 :   (13028.000000 2942.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01260	 :   (13764.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01261	 :   (13948.000000 2758.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01488	 :   (14868.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01159	 :   (13580.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01158	 :   (13396.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01157	 :   (13212.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01156	 :   (13028.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01296	 :   (13580.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01297	 :   (13764.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01298	 :   (13948.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01299	 :   (14132.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01300	 :   (14316.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01301	 :   (14500.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01302	 :   (14684.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01303	 :   (14868.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01304	 :   (15052.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01305	 :   (15236.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01447	 :   (14132.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01487	 :   (14684.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01486	 :   (14500.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01485	 :   (14316.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01484	 :   (14132.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01135	 :   (15236.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01134	 :   (15052.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01133	 :   (14868.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01132	 :   (14684.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01131	 :   (14500.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01130	 :   (14316.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01129	 :   (14132.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01128	 :   (13948.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01126	 :   (13580.000000 3494.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01161	 :   (13948.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01294	 :   (13212.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01295	 :   (13396.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01168	 :   (15236.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01167	 :   (15052.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01166	 :   (14868.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01165	 :   (14684.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01164	 :   (14500.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01163	 :   (14316.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01162	 :   (14132.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01160	 :   (13764.000000 3310.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01293	 :   (13028.000000 2574.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01489	 :   (15052.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01490	 :   (15236.000000 1654.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VDD075CPU_01446	 :   (13948.000000 1838.000000)	 :   PAR_1_0_VDD075CPU	  = PAR_1_0_VDD075CPU
* VSS_04331	 :   (16064.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04329	 :   (15696.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04330	 :   (15880.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04047	 :   (16248.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04328	 :   (15512.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04327	 :   (15328.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04241	 :   (16984.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04240	 :   (16800.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04339	 :   (17536.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04242	 :   (17168.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04243	 :   (17352.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04244	 :   (17536.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04332	 :   (16248.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04333	 :   (16432.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04334	 :   (16616.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04335	 :   (16800.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04336	 :   (16984.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04337	 :   (17168.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04338	 :   (17352.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04144	 :   (16616.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05186	 :   (15880.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05187	 :   (16064.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05188	 :   (16248.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05189	 :   (16432.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04137	 :   (15328.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04138	 :   (15512.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04139	 :   (15696.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04140	 :   (15880.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04141	 :   (16064.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04142	 :   (16248.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04143	 :   (16432.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04054	 :   (17536.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04145	 :   (16800.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04146	 :   (16984.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04147	 :   (17168.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04148	 :   (17352.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04149	 :   (17536.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05190	 :   (16616.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05191	 :   (16800.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05192	 :   (16984.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05193	 :   (17168.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05194	 :   (17352.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05195	 :   (17536.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04043	 :   (15512.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04238	 :   (16432.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04237	 :   (16248.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04236	 :   (16064.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04235	 :   (15880.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04234	 :   (15696.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04233	 :   (15512.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04232	 :   (15328.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05183	 :   (15328.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05184	 :   (15512.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05185	 :   (15696.000000 1562.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04042	 :   (15328.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04239	 :   (16616.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04044	 :   (15696.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04045	 :   (15880.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04046	 :   (16064.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04899	 :   (15696.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04048	 :   (16432.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04049	 :   (16616.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04050	 :   (16800.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04051	 :   (16984.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04052	 :   (17168.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04053	 :   (17352.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04712	 :   (16248.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04719	 :   (17536.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04718	 :   (17352.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04717	 :   (17168.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04716	 :   (16984.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04715	 :   (16800.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04993	 :   (15328.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04994	 :   (15512.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04995	 :   (15696.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04996	 :   (15880.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04997	 :   (16064.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04714	 :   (16616.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04713	 :   (16432.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04802	 :   (15328.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04711	 :   (16064.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04710	 :   (15880.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04709	 :   (15696.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04708	 :   (15512.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04707	 :   (15328.000000 2482.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04998	 :   (16248.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04999	 :   (16432.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05000	 :   (16616.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05001	 :   (16800.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05002	 :   (16984.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05003	 :   (17168.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05004	 :   (17352.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04809	 :   (16616.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04900	 :   (15880.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04898	 :   (15512.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04897	 :   (15328.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04901	 :   (16064.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04902	 :   (16248.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04903	 :   (16432.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04904	 :   (16616.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04814	 :   (17536.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04813	 :   (17352.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04812	 :   (17168.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04811	 :   (16984.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04810	 :   (16800.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05099	 :   (17352.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04905	 :   (16800.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04906	 :   (16984.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04907	 :   (17168.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04908	 :   (17352.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04909	 :   (17536.000000 2114.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04808	 :   (16432.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04807	 :   (16248.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04806	 :   (16064.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04805	 :   (15880.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04804	 :   (15696.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04803	 :   (15512.000000 2298.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04431	 :   (16432.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04520	 :   (16064.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04519	 :   (15880.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04518	 :   (15512.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04517	 :   (15328.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05092	 :   (16064.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05093	 :   (16248.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04437	 :   (17536.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04436	 :   (17352.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04435	 :   (17168.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04434	 :   (16984.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04433	 :   (16800.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04432	 :   (16616.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04623	 :   (17536.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04430	 :   (16248.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04429	 :   (16064.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04428	 :   (15880.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04427	 :   (15696.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04426	 :   (15512.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04425	 :   (15328.000000 3034.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05094	 :   (16432.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05095	 :   (16616.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05096	 :   (16800.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05097	 :   (16984.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05098	 :   (17168.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05100	 :   (17536.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04522	 :   (16432.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05005	 :   (17536.000000 1930.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04622	 :   (17352.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04621	 :   (17168.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04620	 :   (16984.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04619	 :   (16800.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04618	 :   (16616.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04617	 :   (16432.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04616	 :   (16248.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04615	 :   (16064.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04614	 :   (15880.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04613	 :   (15696.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04612	 :   (15512.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04611	 :   (15328.000000 2666.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05088	 :   (15328.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05089	 :   (15512.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05090	 :   (15696.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_05091	 :   (15880.000000 1746.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04528	 :   (17536.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04527	 :   (17352.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04526	 :   (17168.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04525	 :   (16984.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04524	 :   (16800.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04523	 :   (16616.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04521	 :   (16248.000000 2850.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VDD075CPU_01502	 :   (17444.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01501	 :   (17260.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01169	 :   (15420.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01110	 :   (17444.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01136	 :   (15420.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01137	 :   (15604.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01138	 :   (15788.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01139	 :   (15972.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01140	 :   (16156.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01141	 :   (16340.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01142	 :   (16524.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01143	 :   (16708.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01144	 :   (16892.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01145	 :   (17076.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01146	 :   (17260.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01147	 :   (17444.000000 3494.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01109	 :   (17260.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01170	 :   (15604.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01171	 :   (15788.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01172	 :   (15972.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01173	 :   (16156.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01174	 :   (16340.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01175	 :   (16524.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01176	 :   (16708.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01177	 :   (16892.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01178	 :   (17076.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01179	 :   (17260.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01180	 :   (17444.000000 3310.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01202	 :   (15420.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01203	 :   (15604.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01070	 :   (16892.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01381	 :   (15604.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01380	 :   (15420.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01354	 :   (17444.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01353	 :   (17260.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01352	 :   (17076.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01062	 :   (15420.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01063	 :   (15604.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01064	 :   (15788.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01065	 :   (15972.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01066	 :   (16156.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01067	 :   (16340.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01068	 :   (16524.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01069	 :   (16708.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01204	 :   (15788.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01071	 :   (17076.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01072	 :   (17260.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01073	 :   (17444.000000 3862.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01099	 :   (15420.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01100	 :   (15604.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01101	 :   (15788.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01102	 :   (15972.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01103	 :   (16156.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01104	 :   (16340.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01105	 :   (16524.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01106	 :   (16708.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01107	 :   (16892.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01108	 :   (17076.000000 3678.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01313	 :   (16708.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01275	 :   (16524.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01276	 :   (16708.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01277	 :   (16892.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01278	 :   (17076.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01279	 :   (17260.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01280	 :   (17444.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01306	 :   (15420.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01307	 :   (15604.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01308	 :   (15788.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01309	 :   (15972.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01310	 :   (16156.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01311	 :   (16340.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01312	 :   (16524.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01274	 :   (16340.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01314	 :   (16892.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01315	 :   (17076.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01316	 :   (17260.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01317	 :   (17444.000000 2574.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01343	 :   (15420.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01344	 :   (15604.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01345	 :   (15788.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01346	 :   (15972.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01347	 :   (16156.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01348	 :   (16340.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01349	 :   (16524.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01350	 :   (16708.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01351	 :   (16892.000000 2390.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01236	 :   (16156.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01205	 :   (15972.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01206	 :   (16156.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01207	 :   (16340.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01208	 :   (16524.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01209	 :   (16708.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01210	 :   (16892.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01211	 :   (17076.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01212	 :   (17260.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01213	 :   (17444.000000 3126.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01232	 :   (15420.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01233	 :   (15604.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01234	 :   (15788.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01235	 :   (15972.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01382	 :   (15788.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01237	 :   (16340.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01238	 :   (16524.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01239	 :   (16708.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01240	 :   (16892.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01241	 :   (17076.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01242	 :   (17260.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01243	 :   (17444.000000 2942.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01269	 :   (15420.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01270	 :   (15604.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01271	 :   (15788.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01272	 :   (15972.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01273	 :   (16156.000000 2758.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01465	 :   (17444.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01455	 :   (15604.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01456	 :   (15788.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01457	 :   (15972.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01458	 :   (16156.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01459	 :   (16340.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01460	 :   (16524.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01461	 :   (16708.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01462	 :   (16892.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01463	 :   (17076.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01464	 :   (17260.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01383	 :   (15972.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01491	 :   (15420.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01492	 :   (15604.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01493	 :   (15788.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01494	 :   (15972.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01495	 :   (16156.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01496	 :   (16340.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01497	 :   (16524.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01498	 :   (16708.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01499	 :   (16892.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01500	 :   (17076.000000 1654.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01428	 :   (17444.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01454	 :   (15420.000000 1838.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01384	 :   (16156.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01385	 :   (16340.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01386	 :   (16524.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01387	 :   (16708.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01388	 :   (16892.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01389	 :   (17076.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01390	 :   (17260.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01391	 :   (17444.000000 2206.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01417	 :   (15420.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01419	 :   (15788.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01418	 :   (15604.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01427	 :   (17260.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01426	 :   (17076.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01425	 :   (16892.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01424	 :   (16708.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01423	 :   (16524.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01422	 :   (16340.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01421	 :   (16156.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VDD075CPU_01420	 :   (15972.000000 2022.000000)	 :   PAR_2_0_VDD075CPU	  = PAR_2_0_VDD075CPU
* VSS_02887	 :   (11096.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02888	 :   (11280.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02889	 :   (11464.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02890	 :   (11648.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02891	 :   (11832.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02892	 :   (12016.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02893	 :   (12200.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02894	 :   (12384.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02895	 :   (12568.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02896	 :   (12752.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02897	 :   (12936.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02974	 :   (10728.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02975	 :   (10912.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02976	 :   (11096.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02977	 :   (11280.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02978	 :   (11464.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02979	 :   (11648.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02800	 :   (11832.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03162	 :   (10912.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03166	 :   (11648.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02794	 :   (10728.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02795	 :   (10912.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02796	 :   (11096.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02797	 :   (11280.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02798	 :   (11464.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02799	 :   (11648.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02886	 :   (10912.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02801	 :   (12016.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02802	 :   (12200.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02803	 :   (12384.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02804	 :   (12568.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02805	 :   (12752.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02806	 :   (12936.000000 6162.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02885	 :   (10728.000000 5978.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03075	 :   (12384.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03071	 :   (11648.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03071_2584	 :   (11648.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03072	 :   (11832.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03072_2585	 :   (11832.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03073	 :   (12016.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03073_2586	 :   (12016.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03074	 :   (12200.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03074_2587	 :   (12200.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03070_2583	 :   (11464.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03075_2588	 :   (12384.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03076	 :   (12568.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03076_2589	 :   (12568.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03077	 :   (12752.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03077_2590	 :   (12752.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03078	 :   (12936.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03078_2591	 :   (12936.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02980	 :   (11832.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03070	 :   (11464.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03069_2582	 :   (11280.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03069	 :   (11280.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03068_2581	 :   (11096.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03068	 :   (11096.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03067_2580	 :   (10912.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03067	 :   (10912.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03066_2579	 :   (10728.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03066	 :   (10728.000000 5610.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02986	 :   (12936.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02985	 :   (12752.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02984	 :   (12568.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02983	 :   (12384.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02982	 :   (12200.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02981	 :   (12016.000000 5794.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03648	 :   (12752.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03744	 :   (12936.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03743	 :   (12752.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03742	 :   (12568.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03741	 :   (12384.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03740	 :   (12200.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03739	 :   (12016.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03738	 :   (11832.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03737	 :   (11648.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03736	 :   (11464.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03735	 :   (11280.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03734	 :   (11096.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03733	 :   (10912.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03732	 :   (10728.000000 4322.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03649	 :   (12936.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03827	 :   (10728.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03161	 :   (10728.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03647	 :   (12568.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03646	 :   (12384.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03645	 :   (12200.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03644	 :   (12016.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03643	 :   (11832.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03642	 :   (11648.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03641	 :   (11464.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03640	 :   (11280.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03639	 :   (11096.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03638	 :   (10912.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03637	 :   (10728.000000 4506.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03554	 :   (12936.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03923	 :   (10912.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03163	 :   (11096.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03164	 :   (11280.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03165	 :   (11464.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03934	 :   (12936.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03933	 :   (12752.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03932	 :   (12568.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03931	 :   (12384.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03930	 :   (12200.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03929	 :   (12016.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03928	 :   (11832.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03927	 :   (11648.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03926	 :   (11464.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03925	 :   (11280.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03924	 :   (11096.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03553	 :   (12752.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03922	 :   (10728.000000 3954.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03839	 :   (12936.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03838	 :   (12752.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03837	 :   (12568.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03836	 :   (12384.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03835	 :   (12200.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03834	 :   (12016.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03833	 :   (11832.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03832	 :   (11648.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03831	 :   (11464.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03830	 :   (11280.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03829	 :   (11096.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03828	 :   (10912.000000 4138.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03265	 :   (12016.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03360	 :   (12200.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03359	 :   (12016.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03358	 :   (11832.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03357	 :   (11648.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03356	 :   (11464.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03355	 :   (11280.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03354	 :   (11096.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03353	 :   (10912.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03352	 :   (10728.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03270	 :   (12936.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03269	 :   (12752.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03268	 :   (12568.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03267	 :   (12384.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03266	 :   (12200.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03361	 :   (12384.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03264	 :   (11832.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03263	 :   (11648.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03262	 :   (11464.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03261	 :   (11280.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03260	 :   (11096.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03259	 :   (10912.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03258	 :   (10728.000000 5242.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03173	 :   (12936.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03172	 :   (12752.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03171	 :   (12568.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03170	 :   (12384.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03169	 :   (12200.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03168	 :   (12016.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03457	 :   (12568.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03552	 :   (12568.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03551	 :   (12384.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03550	 :   (12200.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03549	 :   (12016.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03548	 :   (11832.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03547	 :   (11648.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03546	 :   (11464.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03545	 :   (11280.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03544	 :   (11096.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03543	 :   (10912.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03542	 :   (10728.000000 4690.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03459	 :   (12936.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03458	 :   (12752.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03167	 :   (11832.000000 5426.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03456	 :   (12384.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03455	 :   (12200.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03454	 :   (12016.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03453	 :   (11832.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03452	 :   (11648.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03451	 :   (11464.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03450	 :   (11280.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03449	 :   (11096.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03448	 :   (10912.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03447	 :   (10728.000000 4874.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03364	 :   (12936.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03363	 :   (12752.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_03362	 :   (12568.000000 5058.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VDD075CPU_00854	 :   (11188.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00964	 :   (11004.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00963	 :   (10820.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00822	 :   (12108.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00823	 :   (12292.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00824	 :   (12476.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00825	 :   (12660.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00826	 :   (12844.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00852	 :   (10820.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00853	 :   (11004.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00821	 :   (11924.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00855	 :   (11372.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00856	 :   (11556.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00857	 :   (11740.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00858	 :   (11924.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00859	 :   (12108.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00860	 :   (12292.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00861	 :   (12476.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00862	 :   (12660.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00787	 :   (12476.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00779	 :   (10820.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00780	 :   (11004.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00781	 :   (11188.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00782	 :   (11372.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00783	 :   (11556.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00784	 :   (11740.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00785	 :   (11924.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00786	 :   (12108.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00863	 :   (12844.000000 4782.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00788	 :   (12660.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00789	 :   (12844.000000 5150.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00815	 :   (10820.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00816	 :   (11004.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00817	 :   (11188.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00818	 :   (11372.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00819	 :   (11556.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00820	 :   (11740.000000 4966.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01000	 :   (10820.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01004	 :   (11556.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00926	 :   (10820.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00927	 :   (11004.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00928	 :   (11188.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00929	 :   (11372.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01003	 :   (11372.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01002	 :   (11188.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01001	 :   (11004.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01005	 :   (11740.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00930	 :   (11556.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00931	 :   (11740.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00932	 :   (11924.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00933	 :   (12108.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00934	 :   (12292.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00935	 :   (12476.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00936	 :   (12660.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00937	 :   (12844.000000 4414.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00898	 :   (12476.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00889	 :   (10820.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00890	 :   (11004.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00891	 :   (11188.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00893	 :   (11556.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00894	 :   (11740.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00895	 :   (11924.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00896	 :   (12108.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00897	 :   (12292.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00892	 :   (11372.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00899	 :   (12660.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00900	 :   (12844.000000 4598.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01011	 :   (12844.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01010	 :   (12660.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01009	 :   (12476.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01008	 :   (12292.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01007	 :   (12108.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_01006	 :   (11924.000000 4046.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00654	 :   (12292.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00678	 :   (11556.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00677	 :   (11372.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00676	 :   (11188.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00675	 :   (11004.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00747	 :   (10820.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00748	 :   (11004.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00657	 :   (12844.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00656	 :   (12660.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00655	 :   (12476.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00679	 :   (11740.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00653	 :   (12108.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00652	 :   (11924.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00651	 :   (11740.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00650	 :   (11556.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00649	 :   (11372.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00648	 :   (11188.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00647	 :   (11004.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00749	 :   (11188.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00719	 :   (12476.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00710	 :   (10820.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00711	 :   (11004.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00712	 :   (11188.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00713	 :   (11372.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00714	 :   (11556.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00715	 :   (11740.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00716	 :   (11924.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00717	 :   (12108.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00718	 :   (12292.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00674	 :   (10820.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00720	 :   (12660.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00721	 :   (12844.000000 5518.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00685	 :   (12844.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00684	 :   (12660.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00683	 :   (12476.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00682	 :   (12292.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00681	 :   (12108.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00680	 :   (11924.000000 5702.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00752	 :   (11740.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00622	 :   (11556.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00623	 :   (11740.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00624	 :   (11924.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00625	 :   (12108.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00626	 :   (12292.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00627	 :   (12476.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00628	 :   (12660.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00966	 :   (11372.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00965	 :   (11188.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00751	 :   (11556.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00753	 :   (11924.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00754	 :   (12108.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00755	 :   (12292.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00756	 :   (12476.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00757	 :   (12660.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00758	 :   (12844.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00646	 :   (10820.000000 5886.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00629	 :   (12844.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00620	 :   (11188.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00974	 :   (12844.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00973	 :   (12660.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00972	 :   (12476.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00971	 :   (12292.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00750	 :   (11372.000000 5334.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00970	 :   (12108.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00969	 :   (11924.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00968	 :   (11740.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00967	 :   (11556.000000 4230.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00621	 :   (11372.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00619	 :   (11004.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VDD075CPU_00618	 :   (10820.000000 6070.000000)	 :   PAR_0_1_VDD075CPU	  = PAR_0_1_VDD075CPU
* VSS_02817	 :   (14960.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02809	 :   (13488.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02810	 :   (13672.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02811	 :   (13856.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02812	 :   (14040.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02813	 :   (14224.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02814	 :   (14408.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02815	 :   (14592.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02816	 :   (14776.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03461	 :   (13304.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02818	 :   (15144.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03462	 :   (13488.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03463	 :   (13672.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03464	 :   (13856.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03465	 :   (14040.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03466	 :   (14224.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03467	 :   (14408.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03468	 :   (14592.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03469	 :   (14776.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03470	 :   (14960.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03944	 :   (14776.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03939	 :   (13856.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03940	 :   (14040.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03941	 :   (14224.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03942	 :   (14408.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03943	 :   (14592.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03556	 :   (13304.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03937	 :   (13488.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03936	 :   (13304.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03935	 :   (13120.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02808	 :   (13304.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03945	 :   (14960.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03946	 :   (15144.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03460	 :   (13120.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03555	 :   (13120.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03559	 :   (13856.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03560	 :   (14040.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03557	 :   (13488.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03938	 :   (13672.000000 3954.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02807	 :   (13120.000000 6162.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03085	 :   (14224.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03079	 :   (13120.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03079_2592	 :   (13120.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03080	 :   (13304.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03080_2593	 :   (13304.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03081	 :   (13488.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03081_2594	 :   (13488.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03082	 :   (13672.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03082_2595	 :   (13672.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03083	 :   (13856.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03083_2596	 :   (13856.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03084	 :   (14040.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03084_2597	 :   (14040.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02998	 :   (15144.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03085_2598	 :   (14224.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03086	 :   (14408.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03086_2599	 :   (14408.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03087	 :   (14592.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03087_2600	 :   (14592.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03088	 :   (14776.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03088_2601	 :   (14776.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03089	 :   (14960.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03089_2602	 :   (14960.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03090	 :   (15144.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03090_2603	 :   (15144.000000 5610.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03561	 :   (14224.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02987	 :   (13120.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02898	 :   (13120.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02899	 :   (13304.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02900	 :   (13488.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02901	 :   (13672.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02902	 :   (13856.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02903	 :   (14040.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02904	 :   (14224.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02905	 :   (14408.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02906	 :   (14592.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02907	 :   (14776.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02908	 :   (14960.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02909	 :   (15144.000000 5978.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03471	 :   (15144.000000 4874.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02988	 :   (13304.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02989	 :   (13488.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02990	 :   (13672.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02991	 :   (13856.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02992	 :   (14040.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02993	 :   (14224.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02994	 :   (14408.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02995	 :   (14592.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03558	 :   (13672.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02996	 :   (14776.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02997	 :   (14960.000000 5794.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03278	 :   (14408.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03370	 :   (14040.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03371	 :   (14224.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03372	 :   (14408.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03373	 :   (14592.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03658	 :   (14592.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03657	 :   (14408.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03374	 :   (14776.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03375	 :   (14960.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03376	 :   (15144.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03275	 :   (13856.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03276	 :   (14040.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03277	 :   (14224.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03369	 :   (13856.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03279	 :   (14592.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03280	 :   (14776.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03281	 :   (14960.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03282	 :   (15144.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03177	 :   (13672.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03749	 :   (13856.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03748	 :   (13672.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03656	 :   (14224.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03655	 :   (14040.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03840	 :   (13120.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03841	 :   (13304.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03752	 :   (14408.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03755	 :   (14960.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03754	 :   (14776.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03176	 :   (13488.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03175	 :   (13304.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03174	 :   (13120.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03753	 :   (14592.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03566	 :   (15144.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03565	 :   (14960.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03564	 :   (14776.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03563	 :   (14592.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03562	 :   (14408.000000 4690.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03842	 :   (13488.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03751	 :   (14224.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03750	 :   (14040.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03756	 :   (15144.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03274	 :   (13672.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03661	 :   (15144.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03660	 :   (14960.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03659	 :   (14776.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03365	 :   (13120.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03366	 :   (13304.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03367	 :   (13488.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03368	 :   (13672.000000 5058.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03651	 :   (13304.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03183	 :   (14776.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03184	 :   (14960.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03185	 :   (15144.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03650	 :   (13120.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03746	 :   (13304.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03745	 :   (13120.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03178	 :   (13856.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03851	 :   (15144.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03182	 :   (14592.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03843	 :   (13672.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03844	 :   (13856.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03845	 :   (14040.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03846	 :   (14224.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03847	 :   (14408.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03848	 :   (14592.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03849	 :   (14776.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03850	 :   (14960.000000 4138.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03271	 :   (13120.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03654	 :   (13856.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03653	 :   (13672.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03652	 :   (13488.000000 4506.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03200	 :   (13948.000000 5334.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03199	 :   (13396.000000 5334.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03747	 :   (13488.000000 4322.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03272	 :   (13304.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03273	 :   (13488.000000 5242.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03179	 :   (14040.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03180	 :   (14224.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_03181	 :   (14408.000000 5426.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VDD075CPU_00733	 :   (15052.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00734	 :   (15236.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00802	 :   (15236.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00827	 :   (13028.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00729	 :   (14316.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00828	 :   (13212.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00829	 :   (13396.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00830	 :   (13580.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00831	 :   (13764.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00832	 :   (13948.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00833	 :   (14132.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00834	 :   (14316.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00835	 :   (14500.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00836	 :   (14684.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00837	 :   (14868.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00838	 :   (15052.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00839	 :   (15236.000000 4966.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00686	 :   (13028.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00687	 :   (13212.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00688	 :   (13396.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00874	 :   (14868.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00696	 :   (14868.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00730	 :   (14500.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00731	 :   (14684.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00732	 :   (14868.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00695	 :   (14684.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00694	 :   (14500.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00693	 :   (14316.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00692	 :   (14132.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00691	 :   (13948.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00876	 :   (15236.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00875	 :   (15052.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00689	 :   (13580.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00873	 :   (14684.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00872	 :   (14500.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00871	 :   (14316.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00870	 :   (14132.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00869	 :   (13948.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00868	 :   (13764.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00867	 :   (13580.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00866	 :   (13396.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00865	 :   (13212.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00864	 :   (13028.000000 4782.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00690	 :   (13764.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00765	 :   (15052.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00637	 :   (14316.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00636	 :   (14132.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00635	 :   (13948.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00634	 :   (13764.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00633	 :   (13580.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00632	 :   (13396.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00631	 :   (13212.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00630	 :   (13028.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00638	 :   (14500.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00766	 :   (15236.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00663	 :   (13948.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00664	 :   (14132.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00665	 :   (14316.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00666	 :   (14500.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00667	 :   (14684.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00668	 :   (14868.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00761	 :   (14316.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00662	 :   (13764.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00661	 :   (13580.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00660	 :   (13396.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00659	 :   (13212.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00658	 :   (13028.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00975	 :   (13028.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00759	 :   (13028.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00760	 :   (13212.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00669	 :   (15052.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00762	 :   (14500.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00763	 :   (14684.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00764	 :   (14868.000000 5334.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00642	 :   (15236.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00641	 :   (15052.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00640	 :   (14868.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00639	 :   (14684.000000 6070.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00793	 :   (13580.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01021	 :   (14684.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01020	 :   (14500.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01019	 :   (14316.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01018	 :   (14132.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01017	 :   (13948.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00790	 :   (13028.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00791	 :   (13212.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00792	 :   (13396.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01022	 :   (14868.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00794	 :   (13764.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00795	 :   (13948.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00796	 :   (14132.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00797	 :   (14316.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00798	 :   (14500.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00799	 :   (14684.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00800	 :   (14868.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00801	 :   (15052.000000 5150.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01023	 :   (15052.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01024	 :   (15236.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00987	 :   (15236.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00986	 :   (15052.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00985	 :   (14868.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00984	 :   (14684.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00983	 :   (14500.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00982	 :   (14316.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00981	 :   (14132.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00980	 :   (13948.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00979	 :   (13764.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00978	 :   (13580.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00977	 :   (13396.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00976	 :   (13212.000000 4230.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00670	 :   (15236.000000 5886.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00906	 :   (13948.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01013	 :   (13212.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01014	 :   (13396.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00912	 :   (15052.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00911	 :   (14868.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00910	 :   (14684.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00909	 :   (14500.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00908	 :   (14316.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00907	 :   (14132.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01012	 :   (13028.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00905	 :   (13764.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00904	 :   (13580.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00903	 :   (13396.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00902	 :   (13212.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00901	 :   (13028.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01015	 :   (13580.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_01016	 :   (13764.000000 4046.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00946	 :   (14500.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00938	 :   (13028.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00939	 :   (13212.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00940	 :   (13396.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00941	 :   (13580.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00942	 :   (13764.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00943	 :   (13948.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00944	 :   (14132.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00945	 :   (14316.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00727	 :   (13948.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00947	 :   (14684.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00948	 :   (14868.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00949	 :   (15052.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00950	 :   (15236.000000 4414.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00698	 :   (15236.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00697	 :   (15052.000000 5702.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00913	 :   (15236.000000 4598.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00723	 :   (13212.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00728	 :   (14132.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00722	 :   (13028.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00724	 :   (13396.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00725	 :   (13580.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VDD075CPU_00726	 :   (13764.000000 5518.000000)	 :   PAR_1_1_VDD075CPU	  = PAR_1_1_VDD075CPU
* VSS_03378	 :   (15512.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03863	 :   (17352.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02822	 :   (15880.000000 6162.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02821	 :   (15696.000000 6162.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02820	 :   (15512.000000 6162.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02819	 :   (15328.000000 6162.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03377	 :   (15328.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03957	 :   (17168.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03379	 :   (15696.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03380	 :   (15880.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03381	 :   (16064.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03198	 :   (17536.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03382	 :   (16248.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03383	 :   (16432.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03959	 :   (17536.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03958	 :   (17352.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03956	 :   (16984.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03663	 :   (15512.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03295	 :   (17536.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03474	 :   (15696.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02913	 :   (15880.000000 5978.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02912	 :   (15696.000000 5978.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02911	 :   (15512.000000 5978.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02910	 :   (15328.000000 5978.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03666	 :   (16064.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03665	 :   (15880.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03664	 :   (15696.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03100	 :   (16984.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03662	 :   (15328.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03095	 :   (16064.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03096	 :   (16248.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03097	 :   (16432.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03473	 :   (15512.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03472	 :   (15328.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03098	 :   (16616.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03099	 :   (16800.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03389	 :   (17536.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03852	 :   (15328.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03191	 :   (16248.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03190	 :   (16064.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03189	 :   (15880.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03188	 :   (15696.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03187	 :   (15512.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03186	 :   (15328.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03853	 :   (15512.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03854	 :   (15696.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03388	 :   (17352.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03855	 :   (15880.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03856	 :   (16064.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03857	 :   (16248.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03858	 :   (16432.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03859	 :   (16616.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03860	 :   (16800.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03861	 :   (16984.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03862	 :   (17168.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03864	 :   (17536.000000 4138.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03384	 :   (16616.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03955	 :   (16800.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03954	 :   (16616.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03953	 :   (16432.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03952	 :   (16248.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03951	 :   (16064.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03950	 :   (15880.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03949	 :   (15696.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03948	 :   (15512.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03947	 :   (15328.000000 3954.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03567	 :   (15328.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03197	 :   (17352.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03385	 :   (16800.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03386	 :   (16984.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03387	 :   (17168.000000 5058.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03196	 :   (17168.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03195	 :   (16984.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03194	 :   (16800.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03193	 :   (16616.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03192	 :   (16432.000000 5426.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03103	 :   (17536.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03283	 :   (15328.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03284	 :   (15512.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03286	 :   (15880.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03484	 :   (17536.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03483	 :   (17352.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03576	 :   (16984.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03577	 :   (17168.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03578	 :   (17352.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03579	 :   (17536.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03674	 :   (17536.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03287	 :   (16064.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03102	 :   (17352.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03101	 :   (17168.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03673	 :   (17352.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03672	 :   (17168.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03671	 :   (16984.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03670	 :   (16800.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03669	 :   (16616.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03482	 :   (17168.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03481	 :   (16984.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03574	 :   (16616.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03294	 :   (17352.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03757	 :   (15328.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03758	 :   (15512.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03759	 :   (15696.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03568	 :   (15512.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03569	 :   (15696.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03570	 :   (15880.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03571	 :   (16064.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03572	 :   (16248.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03573	 :   (16432.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03480	 :   (16800.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03575	 :   (16800.000000 4690.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03760	 :   (15880.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03761	 :   (16064.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03293	 :   (17168.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03292	 :   (16984.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03291	 :   (16800.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03290	 :   (16616.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03289	 :   (16432.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03288	 :   (16248.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03764	 :   (16616.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03094_2607	 :   (15880.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03001	 :   (15696.000000 5794.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03000	 :   (15512.000000 5794.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02999	 :   (15328.000000 5794.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03092	 :   (15512.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03092_2605	 :   (15512.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03093	 :   (15696.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03762	 :   (16248.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03763	 :   (16432.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03002	 :   (15880.000000 5794.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03765	 :   (16800.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03766	 :   (16984.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03767	 :   (17168.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03768	 :   (17352.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03668	 :   (16432.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03667	 :   (16248.000000 4506.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03769	 :   (17536.000000 4322.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03093_2606	 :   (15696.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03094	 :   (15880.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03091	 :   (15328.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03285	 :   (15696.000000 5242.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03475	 :   (15880.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03476	 :   (16064.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03477	 :   (16248.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03478	 :   (16432.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03479	 :   (16616.000000 4874.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_03091_2604	 :   (15328.000000 5610.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VDD075CPU_00744	 :   (17076.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00735	 :   (15420.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00736	 :   (15604.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00737	 :   (15788.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00745	 :   (17260.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00738	 :   (15972.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00739	 :   (16156.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00740	 :   (16340.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00741	 :   (16524.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00742	 :   (16708.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00743	 :   (16892.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00746	 :   (17444.000000 5518.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01036	 :   (17444.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00881	 :   (16156.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00957	 :   (16524.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00888	 :   (17444.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00887	 :   (17260.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00886	 :   (17076.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00885	 :   (16892.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00884	 :   (16708.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00883	 :   (16524.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00882	 :   (16340.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00956	 :   (16340.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00880	 :   (15972.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00879	 :   (15788.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00878	 :   (15604.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00877	 :   (15420.000000 4782.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00958	 :   (16708.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00851	 :   (17444.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00850	 :   (17260.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00849	 :   (17076.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00917	 :   (15972.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00925	 :   (17444.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00924	 :   (17260.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00923	 :   (17076.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00922	 :   (16892.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00921	 :   (16708.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00920	 :   (16524.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00919	 :   (16340.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00918	 :   (16156.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00848	 :   (16892.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00916	 :   (15788.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00915	 :   (15604.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00914	 :   (15420.000000 4598.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00951	 :   (15420.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00952	 :   (15604.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00953	 :   (15788.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00954	 :   (15972.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00955	 :   (16156.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00776	 :   (17076.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00808	 :   (16340.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00807	 :   (16156.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00806	 :   (15972.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00805	 :   (15788.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00804	 :   (15604.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00803	 :   (15420.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00778	 :   (17444.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00777	 :   (17260.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00809	 :   (16524.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00775	 :   (16892.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00774	 :   (16708.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00773	 :   (16524.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00772	 :   (16340.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00771	 :   (16156.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00770	 :   (15972.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00769	 :   (15788.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00768	 :   (15604.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00959	 :   (16892.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00847	 :   (16708.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00846	 :   (16524.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00845	 :   (16340.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00844	 :   (16156.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00843	 :   (15972.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00842	 :   (15788.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00841	 :   (15604.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00840	 :   (15420.000000 4966.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00767	 :   (15420.000000 5334.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00960	 :   (17076.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00961	 :   (17260.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00962	 :   (17444.000000 4414.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00814	 :   (17444.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00813	 :   (17260.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00812	 :   (17076.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00811	 :   (16892.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00810	 :   (16708.000000 5150.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00672	 :   (15604.000000 5886.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00994	 :   (16524.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00995	 :   (16708.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00996	 :   (16892.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00997	 :   (17076.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00998	 :   (17260.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00999	 :   (17444.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00990	 :   (15788.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00989	 :   (15604.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00988	 :   (15420.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00673	 :   (15788.000000 5886.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00708	 :   (17260.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00671	 :   (15420.000000 5886.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00709	 :   (17444.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00645	 :   (15788.000000 6070.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00644	 :   (15604.000000 6070.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00643	 :   (15420.000000 6070.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01029	 :   (16156.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01028	 :   (15972.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01027	 :   (15788.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01025	 :   (15420.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01026	 :   (15604.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01033	 :   (16892.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00700	 :   (15788.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00699	 :   (15604.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00706	 :   (16892.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00705	 :   (16708.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00704	 :   (16524.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01035	 :   (17260.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01034	 :   (17076.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00993	 :   (16340.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01032	 :   (16708.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01031	 :   (16524.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00701	 :   (15972.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00702	 :   (16156.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00703	 :   (16340.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_01030	 :   (16340.000000 4046.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00992	 :   (16156.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00991	 :   (15972.000000 4230.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VDD075CPU_00707	 :   (17076.000000 5702.000000)	 :   PAR_2_1_VDD075CPU	  = PAR_2_1_VDD075CPU
* VSS_01894	 :   (11464.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01896	 :   (11832.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01893	 :   (11280.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01895	 :   (11648.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01892	 :   (11096.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01891	 :   (10912.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01890	 :   (10728.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02526	 :   (11096.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01901	 :   (12752.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02527	 :   (11280.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02528	 :   (11464.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02529	 :   (11648.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02530	 :   (11832.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02531	 :   (12016.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02532	 :   (12200.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02533	 :   (12384.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02534	 :   (12568.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02535	 :   (12752.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01984	 :   (11648.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02715	 :   (12936.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02073	 :   (11280.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02072	 :   (11096.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02071	 :   (10912.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02070	 :   (10728.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01991	 :   (12936.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01990	 :   (12752.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01989	 :   (12568.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01988	 :   (12384.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01987	 :   (12200.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01986	 :   (12016.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01985	 :   (11832.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01897	 :   (12016.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01983	 :   (11464.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01982	 :   (11280.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01981	 :   (11096.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01980	 :   (10912.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01979	 :   (10728.000000 7818.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02524	 :   (10728.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02525	 :   (10912.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01902	 :   (12936.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01808	 :   (12384.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01900	 :   (12568.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01899	 :   (12384.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01898	 :   (12200.000000 8002.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02624	 :   (12568.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01707	 :   (10728.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02614	 :   (10728.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02615	 :   (10912.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02616	 :   (11096.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02617	 :   (11280.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02618	 :   (11464.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02619	 :   (11648.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02620	 :   (11832.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02621	 :   (12016.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02622	 :   (12200.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02623	 :   (12384.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01708	 :   (10912.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02625	 :   (12752.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02703	 :   (10728.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02704	 :   (10912.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02705	 :   (11096.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02706	 :   (11280.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02707	 :   (11464.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02708	 :   (11648.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02626	 :   (12936.000000 6530.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02711	 :   (12200.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02710	 :   (12016.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02709	 :   (11832.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01799	 :   (10728.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01811	 :   (12936.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01810	 :   (12752.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01809	 :   (12568.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01807	 :   (12200.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01806	 :   (12016.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01805	 :   (11832.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01804	 :   (11648.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01803	 :   (11464.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01802	 :   (11280.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01801	 :   (11096.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01800	 :   (10912.000000 8186.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02536	 :   (12936.000000 6714.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01719	 :   (12936.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01718	 :   (12752.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01717	 :   (12568.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01716	 :   (12384.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01715	 :   (12200.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01714	 :   (12016.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01713	 :   (11832.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01712	 :   (11648.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01711	 :   (11464.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01710	 :   (11280.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_01709	 :   (11096.000000 8370.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02434	 :   (10912.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02256	 :   (11280.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02257	 :   (11464.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02258	 :   (11648.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02259	 :   (11832.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02260	 :   (12016.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02261	 :   (12200.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02262	 :   (12384.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02164	 :   (11096.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02163	 :   (10912.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02162	 :   (10728.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02433	 :   (10728.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02255	 :   (11096.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02435	 :   (11096.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02436	 :   (11280.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02437	 :   (11464.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02438	 :   (11648.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02439	 :   (11832.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02440	 :   (12016.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02263	 :   (12568.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02264	 :   (12752.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02265	 :   (12936.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02349	 :   (11832.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02254	 :   (10912.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02714	 :   (12752.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02713	 :   (12568.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02712	 :   (12384.000000 6346.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02355	 :   (12936.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02354	 :   (12752.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02353	 :   (12568.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02352	 :   (12384.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02351	 :   (12200.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02350	 :   (12016.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02253	 :   (10728.000000 7266.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02445	 :   (12936.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02174	 :   (12936.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02173	 :   (12752.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02172	 :   (12568.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02171	 :   (12384.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02170	 :   (12200.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02169	 :   (12016.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02168	 :   (11832.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02167	 :   (11648.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02166	 :   (11464.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02165	 :   (11280.000000 7450.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02075	 :   (11648.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02345	 :   (11096.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02082	 :   (12936.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02081	 :   (12752.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02080	 :   (12568.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02079	 :   (12384.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02078	 :   (12200.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02077	 :   (12016.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02076	 :   (11832.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02347	 :   (11464.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02074	 :   (11464.000000 7634.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02344	 :   (10912.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02343	 :   (10728.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02441	 :   (12200.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02442	 :   (12384.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02443	 :   (12568.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02444	 :   (12752.000000 6898.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02346	 :   (11280.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VSS_02348	 :   (11648.000000 7082.000000)	 :   PAR_0_2_VSS	  = PAR_0_2_VSS
* VDD075CPU_00288	 :   (11188.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00287	 :   (11004.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00506	 :   (10820.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00507	 :   (11004.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00508	 :   (11188.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00509	 :   (11372.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00510	 :   (11556.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00511	 :   (11740.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00289	 :   (11372.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00290	 :   (11556.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00291	 :   (11740.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00292	 :   (11924.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00293	 :   (12108.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00294	 :   (12292.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00295	 :   (12476.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00516	 :   (12660.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00310	 :   (10820.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00593	 :   (11372.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00594	 :   (11556.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00595	 :   (11740.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00596	 :   (11924.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00513	 :   (12108.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00514	 :   (12292.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00515	 :   (12476.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00286	 :   (10820.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00517	 :   (12844.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00441	 :   (12844.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00489	 :   (12844.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00488	 :   (12660.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00487	 :   (12476.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00486	 :   (12292.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00485	 :   (12108.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00571	 :   (12476.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00544	 :   (12660.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00543	 :   (12476.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00542	 :   (12292.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00541	 :   (12108.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00540	 :   (11924.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00539	 :   (11740.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00538	 :   (11556.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00537	 :   (11372.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00567	 :   (11740.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00568	 :   (11924.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00569	 :   (12108.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00570	 :   (12292.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00536	 :   (11188.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00535	 :   (11004.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00534	 :   (10820.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00566	 :   (11556.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00572	 :   (12660.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00573	 :   (12844.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00565	 :   (11372.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00564	 :   (11188.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00563	 :   (11004.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00562	 :   (10820.000000 6438.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00296	 :   (12660.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00297	 :   (12844.000000 8462.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00590	 :   (10820.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00591	 :   (11004.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00592	 :   (11188.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00545	 :   (12844.000000 6622.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00512	 :   (11924.000000 6806.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00312	 :   (11188.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00311	 :   (11004.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00388	 :   (11924.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00456	 :   (11188.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00457	 :   (11372.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00597	 :   (12108.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00598	 :   (12292.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00407	 :   (11004.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00406	 :   (10820.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00393	 :   (12844.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00392	 :   (12660.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00391	 :   (12476.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00390	 :   (12292.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00389	 :   (12108.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00455	 :   (11004.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00387	 :   (11740.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00386	 :   (11556.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00385	 :   (11372.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00384	 :   (11188.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00599	 :   (12476.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00600	 :   (12660.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00601	 :   (12844.000000 6254.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00458	 :   (11556.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00459	 :   (11740.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00460	 :   (11924.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00417	 :   (12844.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00440	 :   (12660.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00439	 :   (12476.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00438	 :   (12292.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00437	 :   (12108.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00436	 :   (11924.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00435	 :   (11740.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00434	 :   (11556.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00433	 :   (11372.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00432	 :   (11188.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00431	 :   (11004.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00430	 :   (10820.000000 7358.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00313	 :   (11372.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00416	 :   (12660.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00415	 :   (12476.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00414	 :   (12292.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00413	 :   (12108.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00412	 :   (11924.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00411	 :   (11740.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00410	 :   (11556.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00409	 :   (11372.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00408	 :   (11188.000000 7542.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00454	 :   (10820.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00483	 :   (11740.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00345	 :   (12844.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00344	 :   (12660.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00343	 :   (12476.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00342	 :   (12292.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00341	 :   (12108.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00340	 :   (11924.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00339	 :   (11740.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00338	 :   (11556.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00337	 :   (11372.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00336	 :   (11188.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00335	 :   (11004.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00462	 :   (12292.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00334	 :   (10820.000000 8094.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00321	 :   (12844.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00320	 :   (12660.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00319	 :   (12476.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00318	 :   (12292.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00317	 :   (12108.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00316	 :   (11924.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00315	 :   (11740.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00314	 :   (11556.000000 8278.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00484	 :   (11924.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00481	 :   (11372.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00461	 :   (12108.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00463	 :   (12476.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00464	 :   (12660.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00465	 :   (12844.000000 7174.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00478	 :   (10820.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00479	 :   (11004.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00383	 :   (11004.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00382	 :   (10820.000000 7726.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00369	 :   (12844.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00368	 :   (12660.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00367	 :   (12476.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00366	 :   (12292.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00365	 :   (12108.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00364	 :   (11924.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00363	 :   (11740.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00362	 :   (11556.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00361	 :   (11372.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00360	 :   (11188.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00359	 :   (11004.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00358	 :   (10820.000000 7910.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00480	 :   (11188.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VDD075CPU_00482	 :   (11556.000000 6990.000000)	 :   PAR_0_2_VDD075CPU	  = PAR_0_2_VDD075CPU
* VSS_01730	 :   (14960.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02086	 :   (13672.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02450	 :   (13856.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02449	 :   (13672.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02448	 :   (13488.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02447	 :   (13304.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02446	 :   (13120.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02083	 :   (13120.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02084	 :   (13304.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02085	 :   (13488.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02003	 :   (15144.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02087	 :   (13856.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02088	 :   (14040.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02089	 :   (14224.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02090	 :   (14408.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02091	 :   (14592.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02092	 :   (14776.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02367	 :   (15144.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02366	 :   (14960.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01994	 :   (13488.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02456	 :   (14960.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02455	 :   (14776.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02454	 :   (14592.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02453	 :   (14408.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02452	 :   (14224.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02451	 :   (14040.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01992	 :   (13120.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01993	 :   (13304.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02365	 :   (14776.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01995	 :   (13672.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01996	 :   (13856.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01997	 :   (14040.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01998	 :   (14224.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01999	 :   (14408.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02000	 :   (14592.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02001	 :   (14776.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02002	 :   (14960.000000 7818.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02269	 :   (13672.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02182	 :   (14408.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02183	 :   (14592.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02184	 :   (14776.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02185	 :   (14960.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02186	 :   (15144.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02266	 :   (13120.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02267	 :   (13304.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02268	 :   (13488.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02181	 :   (14224.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02277	 :   (15144.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02276	 :   (14960.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02275	 :   (14776.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02274	 :   (14592.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02273	 :   (14408.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02272	 :   (14224.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02270	 :   (13856.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02271	 :   (14040.000000 7266.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02179	 :   (13856.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02364	 :   (14592.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02363	 :   (14408.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02093	 :   (14960.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02094	 :   (15144.000000 7634.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02175	 :   (13120.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02176	 :   (13304.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02177	 :   (13488.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02178	 :   (13672.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02717	 :   (13304.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02180	 :   (14040.000000 7450.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02362	 :   (14224.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02361	 :   (14040.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02360	 :   (13856.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02359	 :   (13672.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02358	 :   (13488.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02357	 :   (13304.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02356	 :   (13120.000000 7082.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01723	 :   (13672.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02631	 :   (13856.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02630	 :   (13672.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02629	 :   (13488.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02628	 :   (13304.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02627	 :   (13120.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01720	 :   (13120.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01721	 :   (13304.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01722	 :   (13488.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02632	 :   (14040.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01724	 :   (13856.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01725	 :   (14040.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01726	 :   (14224.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01727	 :   (14408.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01728	 :   (14592.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01729	 :   (14776.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01731	 :   (15144.000000 8370.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02548	 :   (15144.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02725	 :   (14776.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02716	 :   (13120.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02718	 :   (13488.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02719	 :   (13672.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02720	 :   (13856.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02721	 :   (14040.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02722	 :   (14224.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02723	 :   (14408.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02724	 :   (14592.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01914	 :   (15144.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02726	 :   (14960.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02727	 :   (15144.000000 6346.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02638	 :   (15144.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02637	 :   (14960.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02636	 :   (14776.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02635	 :   (14592.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02634	 :   (14408.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02633	 :   (14224.000000 6530.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01906	 :   (13672.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01821	 :   (14776.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01822	 :   (14960.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01823	 :   (15144.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02538	 :   (13304.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02537	 :   (13120.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01903	 :   (13120.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01904	 :   (13304.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01905	 :   (13488.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02546	 :   (14776.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01907	 :   (13856.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01908	 :   (14040.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01909	 :   (14224.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01910	 :   (14408.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01911	 :   (14592.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01912	 :   (14776.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01913	 :   (14960.000000 8002.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02457	 :   (15144.000000 6898.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01819	 :   (14408.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02547	 :   (14960.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02545	 :   (14592.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02544	 :   (14408.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02543	 :   (14224.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02542	 :   (14040.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02541	 :   (13856.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02540	 :   (13672.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_02539	 :   (13488.000000 6714.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01812	 :   (13120.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01813	 :   (13304.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01814	 :   (13488.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01815	 :   (13672.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01816	 :   (13856.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01817	 :   (14040.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01818	 :   (14224.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VSS_01820	 :   (14592.000000 8186.000000)	 :   PAR_1_2_VSS	  = PAR_1_2_VSS
* VDD075CPU_00529	 :   (15052.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00424	 :   (14132.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00402	 :   (14500.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00403	 :   (14684.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00404	 :   (14868.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00405	 :   (15052.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00418	 :   (13028.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00419	 :   (13212.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00420	 :   (13396.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00421	 :   (13580.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00422	 :   (13764.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00423	 :   (13948.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00401	 :   (14316.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00425	 :   (14316.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00426	 :   (14500.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00427	 :   (14684.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00428	 :   (14868.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00429	 :   (15052.000000 7542.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00442	 :   (13028.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00443	 :   (13212.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00444	 :   (13396.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00445	 :   (13580.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00379	 :   (14684.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00370	 :   (13028.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00371	 :   (13212.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00372	 :   (13396.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00373	 :   (13580.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00374	 :   (13764.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00375	 :   (13948.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00376	 :   (14132.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00377	 :   (14316.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00378	 :   (14500.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00446	 :   (13764.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00380	 :   (14868.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00381	 :   (15052.000000 7910.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00394	 :   (13028.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00395	 :   (13212.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00396	 :   (13396.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00397	 :   (13580.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00398	 :   (13764.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00399	 :   (13948.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00400	 :   (14132.000000 7726.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00500	 :   (14868.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00491	 :   (13212.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00492	 :   (13396.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00493	 :   (13580.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00494	 :   (13764.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00495	 :   (13948.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00496	 :   (14132.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00497	 :   (14316.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00498	 :   (14500.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00499	 :   (14684.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00490	 :   (13028.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00501	 :   (15052.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00502	 :   (15236.000000 6990.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00518	 :   (13028.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00519	 :   (13212.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00520	 :   (13396.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00521	 :   (13580.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00522	 :   (13764.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00523	 :   (13948.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00524	 :   (14132.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00468	 :   (13396.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00447	 :   (13948.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00448	 :   (14132.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00449	 :   (14316.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00450	 :   (14500.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00451	 :   (14684.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00452	 :   (14868.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00453	 :   (15052.000000 7358.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00466	 :   (13028.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00467	 :   (13212.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00357	 :   (15052.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00469	 :   (13580.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00470	 :   (13764.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00471	 :   (13948.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00472	 :   (14132.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00473	 :   (14316.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00474	 :   (14500.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00475	 :   (14684.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00476	 :   (14868.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00477	 :   (15052.000000 7174.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00556	 :   (14868.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00580	 :   (14132.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00579	 :   (13948.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00578	 :   (13764.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00577	 :   (13580.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00576	 :   (13396.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00575	 :   (13212.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00574	 :   (13028.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00558	 :   (15236.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00557	 :   (15052.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00581	 :   (14316.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00555	 :   (14684.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00554	 :   (14500.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00553	 :   (14316.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00552	 :   (14132.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00551	 :   (13948.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00550	 :   (13764.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00549	 :   (13580.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00548	 :   (13396.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00547	 :   (13212.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00606	 :   (13764.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00530	 :   (15236.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00614	 :   (15236.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00613	 :   (15052.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00612	 :   (14868.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00611	 :   (14684.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00610	 :   (14500.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00609	 :   (14316.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00608	 :   (14132.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00607	 :   (13948.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00356	 :   (14868.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00605	 :   (13580.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00604	 :   (13396.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00603	 :   (13212.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00602	 :   (13028.000000 6254.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00586	 :   (15236.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00585	 :   (15052.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00584	 :   (14868.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00583	 :   (14684.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00582	 :   (14500.000000 6438.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00346	 :   (13028.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00325	 :   (13580.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00326	 :   (13764.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00327	 :   (13948.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00328	 :   (14132.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00329	 :   (14316.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00330	 :   (14500.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00331	 :   (14684.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00332	 :   (14868.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00333	 :   (15052.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00528	 :   (14868.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00347	 :   (13212.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00348	 :   (13396.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00349	 :   (13580.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00350	 :   (13764.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00351	 :   (13948.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00352	 :   (14132.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00353	 :   (14316.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00354	 :   (14500.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00355	 :   (14684.000000 8094.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00323	 :   (13212.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00546	 :   (13028.000000 6622.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00527	 :   (14684.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00526	 :   (14500.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00525	 :   (14316.000000 6806.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00298	 :   (13028.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00299	 :   (13212.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00300	 :   (13396.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00301	 :   (13580.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00302	 :   (13764.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00303	 :   (13948.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00304	 :   (14132.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00305	 :   (14316.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00306	 :   (14500.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00307	 :   (14684.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00308	 :   (14868.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00309	 :   (15052.000000 8462.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00322	 :   (13028.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VDD075CPU_00324	 :   (13396.000000 8278.000000)	 :   PAR_1_2_VDD075CPU	  = PAR_1_2_VDD075CPU
* VSS_02639	 :   (15328.000000 6530.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02640	 :   (15512.000000 6530.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02728	 :   (15328.000000 6346.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02729	 :   (15512.000000 6346.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02730	 :   (15696.000000 6346.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02731	 :   (15880.000000 6346.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02642	 :   (15880.000000 6530.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02641	 :   (15696.000000 6530.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02551	 :   (15696.000000 6714.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02550	 :   (15512.000000 6714.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02549	 :   (15328.000000 6714.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02461	 :   (15880.000000 6898.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02460	 :   (15696.000000 6898.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02459	 :   (15512.000000 6898.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02458	 :   (15328.000000 6898.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VSS_02552	 :   (15880.000000 6714.000000)	 :   PAR_2_2_VSS	  = PAR_2_2_VSS
* VDD075CPU_00505	 :   (15788.000000 6990.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00503	 :   (15420.000000 6990.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00504	 :   (15604.000000 6990.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00531	 :   (15420.000000 6806.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00532	 :   (15604.000000 6806.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00533	 :   (15788.000000 6806.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00559	 :   (15420.000000 6622.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00560	 :   (15604.000000 6622.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00587	 :   (15420.000000 6438.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00588	 :   (15604.000000 6438.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00589	 :   (15788.000000 6438.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00615	 :   (15420.000000 6254.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00561	 :   (15788.000000 6622.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00616	 :   (15604.000000 6254.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VDD075CPU_00617	 :   (15788.000000 6254.000000)	 :   PAR_2_2_VDD075CPU	  = PAR_2_2_VDD075CPU
* VSS_00808	 :   (12384.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00893	 :   (11648.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00809	 :   (12568.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00810	 :   (12752.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00811	 :   (12936.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00888	 :   (10728.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00889	 :   (10912.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00890	 :   (11096.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00891	 :   (11280.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00892	 :   (11464.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00807	 :   (12200.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00806	 :   (12016.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00805	 :   (11832.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00804	 :   (11648.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00803	 :   (11464.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00802	 :   (11280.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00801	 :   (11096.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00800	 :   (10912.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00989	 :   (12752.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00799	 :   (10728.000000 10210.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00980	 :   (11096.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00525	 :   (10728.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00988	 :   (12568.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00987	 :   (12384.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00986	 :   (12200.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00985	 :   (12016.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00984	 :   (11832.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00983	 :   (11648.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00982	 :   (11464.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00981	 :   (11280.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00894	 :   (11832.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00979	 :   (10912.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00978	 :   (10728.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00900	 :   (12936.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00899	 :   (12752.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00898	 :   (12568.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00897	 :   (12384.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00896	 :   (12200.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00895	 :   (12016.000000 10026.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00534	 :   (12384.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00618	 :   (11648.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00617	 :   (11464.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00616	 :   (11280.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00615	 :   (11096.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00614	 :   (10912.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00613	 :   (10728.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00537	 :   (12936.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00536	 :   (12752.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00535	 :   (12568.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00619	 :   (11832.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00533	 :   (12200.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00532	 :   (12016.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00531	 :   (11832.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00530	 :   (11648.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00529	 :   (11464.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00528	 :   (11280.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00527	 :   (11096.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00526	 :   (10912.000000 10762.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00709	 :   (11096.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00718	 :   (12752.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00717	 :   (12568.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00716	 :   (12384.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00715	 :   (12200.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00714	 :   (12016.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00713	 :   (11832.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00712	 :   (11648.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00711	 :   (11464.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00710	 :   (11280.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00719	 :   (12936.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00708	 :   (10912.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00707	 :   (10728.000000 10394.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00625	 :   (12936.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00624	 :   (12752.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00623	 :   (12568.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00622	 :   (12384.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00621	 :   (12200.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00620	 :   (12016.000000 10578.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01439	 :   (11280.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01528	 :   (11096.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01527	 :   (10912.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01526	 :   (10728.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01447	 :   (12752.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01446	 :   (12568.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01445	 :   (12384.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01444	 :   (12200.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01443	 :   (12016.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01442	 :   (11832.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01441	 :   (11648.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01440	 :   (11464.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01529	 :   (11280.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01438	 :   (11096.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01437	 :   (10912.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01436	 :   (10728.000000 8922.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01357	 :   (12936.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01356	 :   (12752.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01355	 :   (12568.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01354	 :   (12384.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01353	 :   (12200.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01352	 :   (12016.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01351	 :   (11832.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01618	 :   (10912.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01629	 :   (12936.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01628	 :   (12752.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01627	 :   (12568.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01626	 :   (12384.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01625	 :   (12200.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01624	 :   (12016.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01623	 :   (11832.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01622	 :   (11648.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01621	 :   (11464.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01620	 :   (11280.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01619	 :   (11096.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01350	 :   (11648.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01617	 :   (10728.000000 8554.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01538	 :   (12936.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01537	 :   (12752.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01536	 :   (12568.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01535	 :   (12384.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01534	 :   (12200.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01533	 :   (12016.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01532	 :   (11832.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01531	 :   (11648.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01530	 :   (11464.000000 8738.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01081	 :   (12568.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01169	 :   (12200.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01168	 :   (12016.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01167	 :   (11832.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01166	 :   (11648.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01165	 :   (11464.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01164	 :   (11280.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01163	 :   (11096.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01162	 :   (10912.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01161	 :   (10728.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01083	 :   (12936.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01082	 :   (12752.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01170	 :   (12384.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01080	 :   (12384.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01079	 :   (12200.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01078	 :   (12016.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01077	 :   (11832.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01076	 :   (11648.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01075	 :   (11464.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01074	 :   (11280.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01073	 :   (11096.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01072	 :   (10912.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01071	 :   (10728.000000 9658.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01260	 :   (12016.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01349	 :   (11464.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01348	 :   (11280.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01347	 :   (11096.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01346	 :   (10912.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01345	 :   (10728.000000 9106.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01285	 :   (11188.000000 9198.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01265	 :   (12936.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01264	 :   (12752.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01263	 :   (12568.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01262	 :   (12384.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01261	 :   (12200.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_00990	 :   (12936.000000 9842.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01259	 :   (11832.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01258	 :   (11648.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01257	 :   (11464.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01256	 :   (11280.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01255	 :   (11096.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01254	 :   (10912.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01253	 :   (10728.000000 9290.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01173	 :   (12936.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01172	 :   (12752.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VSS_01171	 :   (12568.000000 9474.000000)	 :   PAR_0_3_VSS	  = PAR_0_3_VSS
* VDD075CPU_00179	 :   (12844.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00096	 :   (10820.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00169	 :   (11004.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00170	 :   (11188.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00171	 :   (11372.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00172	 :   (11556.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00173	 :   (11740.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00174	 :   (11924.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00175	 :   (12108.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00176	 :   (12292.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00177	 :   (12476.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00178	 :   (12660.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00214	 :   (10820.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00083	 :   (12844.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00082	 :   (12660.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00081	 :   (12476.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00080	 :   (12292.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00079	 :   (12108.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00078	 :   (11924.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00077	 :   (11740.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00076	 :   (11556.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00075	 :   (11372.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00074	 :   (11188.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00073	 :   (11004.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00101	 :   (11740.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00225	 :   (12844.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00224	 :   (12660.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00223	 :   (12476.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00222	 :   (12292.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00221	 :   (12108.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00107	 :   (12844.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00106	 :   (12660.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00105	 :   (12476.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00104	 :   (12292.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00103	 :   (12108.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00102	 :   (11924.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00201	 :   (12844.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00100	 :   (11556.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00099	 :   (11372.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00098	 :   (11188.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00097	 :   (11004.000000 9934.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00220	 :   (11924.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00219	 :   (11740.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00218	 :   (11556.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00217	 :   (11372.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00216	 :   (11188.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00215	 :   (11004.000000 9014.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00035	 :   (12844.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00024	 :   (10820.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00025	 :   (11004.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00026	 :   (11188.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00027	 :   (11372.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00028	 :   (11556.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00029	 :   (11740.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00030	 :   (11924.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00031	 :   (12108.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00032	 :   (12292.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00033	 :   (12476.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00034	 :   (12660.000000 10486.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00192	 :   (10820.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00058	 :   (12660.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00057	 :   (12476.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00056	 :   (12292.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00055	 :   (12108.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00054	 :   (11924.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00053	 :   (11740.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00052	 :   (11556.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00051	 :   (11372.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00050	 :   (11188.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00049	 :   (11004.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00048	 :   (10820.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00004	 :   (11556.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00200	 :   (12660.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00199	 :   (12476.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00198	 :   (12292.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00197	 :   (12108.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00196	 :   (11924.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00195	 :   (11740.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00072	 :   (10820.000000 10118.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00000	 :   (10820.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00001	 :   (11004.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00002	 :   (11188.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00003	 :   (11372.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00155	 :   (12844.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00005	 :   (11740.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00006	 :   (11924.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00007	 :   (12108.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00008	 :   (12292.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00009	 :   (12476.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00010	 :   (12660.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00011	 :   (12844.000000 10670.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00059	 :   (12844.000000 10302.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00194	 :   (11556.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00193	 :   (11004.000000 9198.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00125	 :   (11740.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00239	 :   (11004.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00240	 :   (11188.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00241	 :   (11372.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00242	 :   (11556.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00243	 :   (11740.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00244	 :   (11924.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00245	 :   (12108.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00246	 :   (12292.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00121	 :   (11004.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00122	 :   (11188.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00123	 :   (11372.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00124	 :   (11556.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00238	 :   (10820.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00146	 :   (11188.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00126	 :   (11924.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00127	 :   (12108.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00128	 :   (12292.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00129	 :   (12476.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00145	 :   (11004.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00272	 :   (12660.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00271	 :   (12476.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00247	 :   (12476.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00248	 :   (12660.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00249	 :   (12844.000000 8830.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00120	 :   (10820.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00270	 :   (12292.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00144	 :   (10820.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00262	 :   (10820.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00263	 :   (11004.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00264	 :   (11188.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00265	 :   (11372.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00266	 :   (11556.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00267	 :   (11740.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00268	 :   (11924.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00269	 :   (12108.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00273	 :   (12844.000000 8646.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00131	 :   (12844.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00130	 :   (12660.000000 9750.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00154	 :   (12660.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00153	 :   (12476.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00152	 :   (12292.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00151	 :   (12108.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00150	 :   (11924.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00149	 :   (11740.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00148	 :   (11556.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00147	 :   (11372.000000 9566.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VDD075CPU_00168	 :   (10820.000000 9382.000000)	 :   PAR_0_3_VDD075CPU	  = PAR_0_3_VDD075CPU
* VSS_01182	 :   (14592.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01180	 :   (14224.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01181	 :   (14408.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01449	 :   (13304.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01183	 :   (14776.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01448	 :   (13120.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01094	 :   (14960.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01365	 :   (14408.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01636	 :   (14224.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01358	 :   (13120.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01359	 :   (13304.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01360	 :   (13488.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01361	 :   (13672.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01362	 :   (13856.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01363	 :   (14040.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01364	 :   (14224.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01179	 :   (14040.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01366	 :   (14592.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01367	 :   (14776.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01368	 :   (14960.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01369	 :   (15144.000000 9106.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01176	 :   (13488.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01177	 :   (13672.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01178	 :   (13856.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01269	 :   (13672.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01266	 :   (13120.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01277	 :   (15144.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01276	 :   (14960.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01630	 :   (13120.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01267	 :   (13304.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01631	 :   (13304.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01632	 :   (13488.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01633	 :   (13672.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01634	 :   (13856.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01635	 :   (14040.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01268	 :   (13488.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01550	 :   (15144.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01270	 :   (13856.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01271	 :   (14040.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01272	 :   (14224.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01273	 :   (14408.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01274	 :   (14592.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01275	 :   (14776.000000 9290.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01641	 :   (15144.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01640	 :   (14960.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01639	 :   (14776.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01638	 :   (14592.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01637	 :   (14408.000000 8554.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01539	 :   (13120.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01184	 :   (14960.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01185	 :   (15144.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01451	 :   (13672.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01452	 :   (13856.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01453	 :   (14040.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01454	 :   (14224.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01455	 :   (14408.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01456	 :   (14592.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01457	 :   (14776.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01458	 :   (14960.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01459	 :   (15144.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01450	 :   (13488.000000 8922.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01540	 :   (13304.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01541	 :   (13488.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01542	 :   (13672.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01543	 :   (13856.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01544	 :   (14040.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01545	 :   (14224.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01546	 :   (14408.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01547	 :   (14592.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01548	 :   (14776.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01549	 :   (14960.000000 8738.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00816	 :   (13856.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00723	 :   (13672.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00724	 :   (13856.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00725	 :   (14040.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00726	 :   (14224.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00727	 :   (14408.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00728	 :   (14592.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00729	 :   (14776.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00730	 :   (14960.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00731	 :   (15144.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00812	 :   (13120.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00813	 :   (13304.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00814	 :   (13488.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00815	 :   (13672.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00722	 :   (13488.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00817	 :   (14040.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00818	 :   (14224.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00819	 :   (14408.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00820	 :   (14592.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00821	 :   (14776.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00822	 :   (14960.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00823	 :   (15144.000000 10210.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00901	 :   (13120.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00902	 :   (13304.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00903	 :   (13488.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00904	 :   (13672.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00905	 :   (13856.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00906	 :   (14040.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00627	 :   (13304.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00538	 :   (13120.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00539	 :   (13304.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00540	 :   (13488.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00541	 :   (13672.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00542	 :   (13856.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00543	 :   (14040.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00544	 :   (14224.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00545	 :   (14408.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00546	 :   (14592.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00547	 :   (14776.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00548	 :   (14960.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00549	 :   (15144.000000 10762.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00626	 :   (13120.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01174	 :   (13120.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00628	 :   (13488.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00629	 :   (13672.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00630	 :   (13856.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00631	 :   (14040.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00632	 :   (14224.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00633	 :   (14408.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00634	 :   (14592.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00635	 :   (14776.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00636	 :   (14960.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00637	 :   (15144.000000 10578.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00720	 :   (13120.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00721	 :   (13304.000000 10394.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01092	 :   (14592.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01090	 :   (14224.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01091	 :   (14408.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00992	 :   (13304.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00993	 :   (13488.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00994	 :   (13672.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00995	 :   (13856.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00996	 :   (14040.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00997	 :   (14224.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00991	 :   (13120.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01093	 :   (14776.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00998	 :   (14408.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00999	 :   (14592.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01000	 :   (14776.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01001	 :   (14960.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01002	 :   (15144.000000 9842.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01084	 :   (13120.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01095	 :   (15144.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01089	 :   (14040.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00908	 :   (14408.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00909	 :   (14592.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00910	 :   (14776.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00911	 :   (14960.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00912	 :   (15144.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_00907	 :   (14224.000000 10026.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01085	 :   (13304.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01086	 :   (13488.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01087	 :   (13672.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01088	 :   (13856.000000 9658.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VSS_01175	 :   (13304.000000 9474.000000)	 :   PAR_1_3_VSS	  = PAR_1_3_VSS
* VDD075CPU_00181	 :   (13212.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00157	 :   (13212.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00158	 :   (13396.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00159	 :   (13580.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00285	 :   (15052.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00260	 :   (14868.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00284	 :   (14868.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00156	 :   (13028.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00160	 :   (13764.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00261	 :   (15052.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00274	 :   (13028.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00283	 :   (14684.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00282	 :   (14500.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00281	 :   (14316.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00280	 :   (14132.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00279	 :   (13948.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00278	 :   (13764.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00277	 :   (13580.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00276	 :   (13396.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00275	 :   (13212.000000 8646.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00191	 :   (15052.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00182	 :   (13396.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00183	 :   (13580.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00184	 :   (13764.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00185	 :   (13948.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00186	 :   (14132.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00187	 :   (14316.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00188	 :   (14500.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00189	 :   (14684.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00190	 :   (14868.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00212	 :   (14868.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00206	 :   (13764.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00207	 :   (13948.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00237	 :   (15052.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00236	 :   (14868.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00235	 :   (14684.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00234	 :   (14500.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00208	 :   (14132.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00209	 :   (14316.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00210	 :   (14500.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00211	 :   (14684.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00205	 :   (13580.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00233	 :   (14316.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00232	 :   (14132.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00231	 :   (13948.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00230	 :   (13764.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00229	 :   (13580.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00228	 :   (13396.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00227	 :   (13212.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00226	 :   (13028.000000 9014.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00213	 :   (15052.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00256	 :   (14132.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00162	 :   (14132.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00163	 :   (14316.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00164	 :   (14500.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00165	 :   (14684.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00166	 :   (14868.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00167	 :   (15052.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00180	 :   (13028.000000 9382.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00259	 :   (14684.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00258	 :   (14500.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00257	 :   (14316.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00161	 :   (13948.000000 9566.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00255	 :   (13948.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00254	 :   (13764.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00253	 :   (13580.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00252	 :   (13396.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00251	 :   (13212.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00250	 :   (13028.000000 8830.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00202	 :   (13028.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00203	 :   (13212.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00204	 :   (13396.000000 9198.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00062	 :   (13396.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00041	 :   (13948.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00042	 :   (14132.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00043	 :   (14316.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00044	 :   (14500.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00045	 :   (14684.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00046	 :   (14868.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00047	 :   (15052.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00060	 :   (13028.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00061	 :   (13212.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00040	 :   (13764.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00063	 :   (13580.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00064	 :   (13764.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00065	 :   (13948.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00066	 :   (14132.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00067	 :   (14316.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00068	 :   (14500.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00069	 :   (14684.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00070	 :   (14868.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00019	 :   (14316.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00143	 :   (15052.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00012	 :   (13028.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00013	 :   (13212.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00014	 :   (13396.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00015	 :   (13580.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00016	 :   (13764.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00017	 :   (13948.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00018	 :   (14132.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00142	 :   (14868.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00020	 :   (14500.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00021	 :   (14684.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00022	 :   (14868.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00023	 :   (15052.000000 10670.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00036	 :   (13028.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00037	 :   (13212.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00038	 :   (13396.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00039	 :   (13580.000000 10486.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00134	 :   (13396.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00114	 :   (14132.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00115	 :   (14316.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00116	 :   (14500.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00117	 :   (14684.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00118	 :   (14868.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00119	 :   (15052.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00132	 :   (13028.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00133	 :   (13212.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00084	 :   (13028.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00135	 :   (13580.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00136	 :   (13764.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00137	 :   (13948.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00138	 :   (14132.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00139	 :   (14316.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00140	 :   (14500.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00141	 :   (14684.000000 9750.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00071	 :   (15052.000000 10302.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00112	 :   (13764.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00113	 :   (13948.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00085	 :   (13212.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00086	 :   (13396.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00087	 :   (13580.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00088	 :   (13764.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00089	 :   (13948.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00090	 :   (14132.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00091	 :   (14316.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00093	 :   (14684.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00094	 :   (14868.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00095	 :   (15052.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00108	 :   (13028.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00109	 :   (13212.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00110	 :   (13396.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00111	 :   (13580.000000 9934.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VDD075CPU_00092	 :   (14500.000000 10118.000000)	 :   PAR_1_3_VDD075CPU	  = PAR_1_3_VDD075CPU
* VSS_04401	 :   (10912.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04402	 :   (11096.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04403	 :   (11280.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04404	 :   (11464.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04405	 :   (11648.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04406	 :   (11832.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04407	 :   (12016.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04408	 :   (12200.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04409	 :   (12384.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04410	 :   (12568.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04400	 :   (10728.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04314	 :   (12936.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04313	 :   (12752.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04312	 :   (12568.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04311	 :   (12384.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04310	 :   (12200.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04309	 :   (12016.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04308	 :   (11832.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04307	 :   (11648.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04306	 :   (11464.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04305	 :   (11280.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04503	 :   (12752.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04593	 :   (12016.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04017	 :   (10728.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04592	 :   (11832.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04591	 :   (11648.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04590	 :   (11464.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04589	 :   (11280.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04588	 :   (11096.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04587	 :   (10912.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04586	 :   (10728.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04504	 :   (12936.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04411	 :   (12752.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04502	 :   (12568.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04501	 :   (12384.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04500	 :   (12200.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04499	 :   (12016.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04498	 :   (11832.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04497	 :   (11464.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04496	 :   (11096.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04495	 :   (10728.000000 2850.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04412	 :   (12936.000000 3034.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04027	 :   (12568.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04119	 :   (12016.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04118	 :   (11832.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04117	 :   (11648.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04116	 :   (11464.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04115	 :   (11280.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04114	 :   (11096.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04113	 :   (10912.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04112	 :   (10728.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04029	 :   (12936.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04028	 :   (12752.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04120	 :   (12200.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04026	 :   (12384.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04025	 :   (12200.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04024	 :   (12016.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04023	 :   (11832.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04022	 :   (11648.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04021	 :   (11464.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04020	 :   (11280.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04019	 :   (11096.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04018	 :   (10912.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04212	 :   (11648.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04303	 :   (10912.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04302	 :   (10728.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04219	 :   (12936.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04218	 :   (12752.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04217	 :   (12568.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04216	 :   (12384.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04215	 :   (12200.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04214	 :   (12016.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04213	 :   (11832.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04304	 :   (11096.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04211	 :   (11464.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04210	 :   (11280.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04209	 :   (11096.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04208	 :   (10912.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04207	 :   (10728.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04124	 :   (12936.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04123	 :   (12752.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04122	 :   (12568.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04121	 :   (12384.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04975	 :   (12016.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05067	 :   (11464.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05066	 :   (11280.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05065	 :   (11096.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05064	 :   (10912.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05063	 :   (10728.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04980	 :   (12936.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04979	 :   (12752.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04978	 :   (12568.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04977	 :   (12384.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04976	 :   (12200.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05068	 :   (11648.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04974	 :   (11832.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04973	 :   (11648.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04972	 :   (11464.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04971	 :   (11280.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04970	 :   (11096.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04969	 :   (10912.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04968	 :   (10728.000000 1930.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04884	 :   (12936.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04883	 :   (12752.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05160	 :   (11096.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05170	 :   (12936.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05169	 :   (12752.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05168	 :   (12568.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05167	 :   (12384.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05166	 :   (12200.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05165	 :   (12016.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05164	 :   (11832.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05163	 :   (11648.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05162	 :   (11464.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05161	 :   (11280.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04882	 :   (12568.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05159	 :   (10912.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05158	 :   (10728.000000 1562.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05075	 :   (12936.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05074	 :   (12752.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05073	 :   (12568.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05072	 :   (12384.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05071	 :   (12200.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05070	 :   (12016.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_05069	 :   (11832.000000 1746.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04687	 :   (11648.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04779	 :   (11096.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04778	 :   (10912.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04777	 :   (10728.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04694	 :   (12936.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04693	 :   (12752.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04692	 :   (12568.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04691	 :   (12384.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04690	 :   (12200.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04689	 :   (12016.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04688	 :   (11832.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04780	 :   (11280.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04686	 :   (11464.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04685	 :   (11280.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04684	 :   (11096.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04683	 :   (10912.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04682	 :   (10728.000000 2482.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04598	 :   (12936.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04597	 :   (12752.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04596	 :   (12568.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04595	 :   (12384.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04872	 :   (10728.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04881	 :   (12384.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04880	 :   (12200.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04879	 :   (12016.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04878	 :   (11832.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04877	 :   (11648.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04876	 :   (11464.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04875	 :   (11280.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04874	 :   (11096.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04873	 :   (10912.000000 2114.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04594	 :   (12200.000000 2666.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04789	 :   (12936.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04788	 :   (12752.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04787	 :   (12568.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04786	 :   (12384.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04785	 :   (12200.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04784	 :   (12016.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04783	 :   (11832.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04782	 :   (11648.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04781	 :   (11464.000000 2298.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* End Chip Package Protocol <---

.subckt adsPowerModel
+ PAR_0_0_VDD075CPU PAR_1_0_VSS PAR_1_0_VDD075CPU PAR_2_0_VSS PAR_2_0_VDD075CPU
+ PAR_0_1_VSS PAR_0_1_VDD075CPU PAR_1_1_VSS PAR_1_1_VDD075CPU PAR_2_1_VSS
+ PAR_2_1_VDD075CPU PAR_0_2_VSS PAR_0_2_VDD075CPU PAR_1_2_VSS PAR_1_2_VDD075CPU
+ PAR_2_2_VSS PAR_2_2_VDD075CPU PAR_0_3_VSS PAR_0_3_VDD075CPU PAR_1_3_VSS
+ PAR_1_3_VDD075CPU PAR_0_0_VSS

Xpdn
+ PAR_0_0_VDD075CPU PAR_1_0_VSS PAR_1_0_VDD075CPU PAR_2_0_VSS PAR_2_0_VDD075CPU
+ PAR_0_1_VSS PAR_0_1_VDD075CPU PAR_1_1_VSS PAR_1_1_VDD075CPU PAR_2_1_VSS
+ PAR_2_1_VDD075CPU PAR_0_2_VSS PAR_0_2_VDD075CPU PAR_1_2_VSS PAR_1_2_VDD075CPU
+ PAR_2_2_VSS PAR_2_2_VDD075CPU PAR_0_3_VSS PAR_0_3_VDD075CPU PAR_1_3_VSS
+ PAR_1_3_VDD075CPU PAR_0_0_VSS
+ PowerModel

* CPM Port Name | Average current (A) | Max. magnitude of current | Net voltage *
* PAR_0_0_VSS -10.7228 13.2345 0
* PAR_0_0_VDD075CPU 11.6724 14.9064 0.7125
* PAR_1_0_VSS -7.89955 9.51483 0
* PAR_1_0_VDD075CPU 9.37421 11.4853 0.7125
* PAR_2_0_VSS -13.327 15.9542 0
* PAR_2_0_VDD075CPU 14.3522 17.9341 0.7125
* PAR_0_1_VSS -10.2886 12.2976 0
* PAR_0_1_VDD075CPU 9.42101 11.6363 0.7125
* PAR_1_1_VSS -3.30531 4.08406 0
* PAR_1_1_VDD075CPU 3.05699 3.77625 0.7125
* PAR_2_1_VSS -8.94895 10.6534 0
* PAR_2_1_VDD075CPU 8.74906 10.9738 0.7125
* PAR_0_2_VSS -11.9886 22.4206 0
* PAR_0_2_VDD075CPU 13.2151 26.7201 0.7125
* PAR_1_2_VSS -10.9409 21.1102 0
* PAR_1_2_VDD075CPU 13.3245 28.5236 0.7125
* PAR_2_2_VSS -1.7082 2.20828 0
* PAR_2_2_VDD075CPU 1.75099 2.37324 0.7125
* PAR_0_3_VSS -10.3566 16.5106 0
* PAR_0_3_VDD075CPU 10.1596 18.0096 0.7125
* PAR_1_3_VSS -9.76026 18.5026 0
* PAR_1_3_VDD075CPU 10.2365 24.3321 0.7125
* Average power = 75.0353 W.

Icursig1 PAR_0_0_VDD075CPU 0 pwl(
+ 0.000000ps       6.5144899
+ 10.000000ps       6.7206773
+ 20.000000ps         7.26108
+ 29.999999ps       7.9066896
+ 40.000000ps       8.5584098
+ 50.000001ps       9.1465385
+ 59.999998ps       9.6668358
+ 69.999999ps       10.126482
+ 80.000000ps       10.548414
+ 90.000001ps       10.955975
+ 100.000001ps       11.336691
+ 110.000002ps       11.722033
+ 119.999996ps       12.152083
+ 129.999997ps       12.589197
+ 139.999998ps       13.013356
+ 149.999999ps       13.154943
+ 159.999999ps       13.240293
+ 170.000000ps       13.390015
+ 180.000001ps       13.551709
+ 190.000002ps       13.627672
+ 200.000003ps       13.569855
+ 210.000003ps       13.469061
+ 220.000004ps       13.381098
+ 230.000005ps        13.28906
+ 239.999992ps       13.252001
+ 249.999993ps       13.286854
+ 259.999994ps        13.34143
+ 269.999995ps       13.395531
+ 279.999995ps       13.457022
+ 289.999996ps       13.524368
+ 299.999997ps         13.5458
+ 309.999998ps       13.563739
+ 319.999999ps       13.579703
+ 330.000000ps       13.602368
+ 340.000000ps       13.629794
+ 350.000001ps       13.676247
+ 360.000002ps       13.739436
+ 370.000003ps       13.831857
+ 380.000004ps       13.951457
+ 390.000005ps       14.069123
+ 400.000005ps       14.202615
+ 410.000006ps       14.263884
+ 420.000007ps       14.311464
+ 430.000008ps       14.406891
+ 440.000009ps       14.495211
+ 450.000009ps       14.510837
+ 460.000010ps       14.458091
+ 469.999983ps       14.370622
+ 479.999984ps       14.268966
+ 489.999985ps       14.184107
+ 499.999986ps       14.134806
+ 509.999987ps       14.083145
+ 519.999988ps       14.069962
+ 529.999988ps       14.036529
+ 539.999989ps       13.970719
+ 549.999990ps       13.935303
+ 559.999991ps       13.912902
+ 569.999992ps       13.888471
+ 579.999992ps       13.862319
+ 589.999993ps       13.852327
+ 599.999994ps       13.861105
+ 609.999995ps       13.910304
+ 619.999996ps       13.984781
+ 629.999997ps       14.084208
+ 639.999997ps       14.229655
+ 649.999998ps       14.437695
+ 659.999999ps       14.639472
+ 670.000000ps       14.884597
+ 680.000001ps       14.906421
+ 690.000002ps        14.85513
+ 700.000002ps        14.77185
+ 710.000003ps       14.746493
+ 720.000004ps        14.72821
+ 730.000005ps       14.627807
+ 740.000006ps       14.475462
+ 750.000007ps       14.309225
+ 760.000007ps       14.160947
+ 770.000008ps       14.049773
+ 780.000009ps       14.011409
+ 790.000010ps       13.964292
+ 800.000011ps       13.929808
+ 810.000012ps       13.911872
+ 820.000012ps       13.897555
+ 830.000013ps       13.900202
+ 840.000014ps       13.844156
+ 850.000015ps       13.795575
+ 860.000016ps       13.755351
+ 870.000016ps       13.740467
+ 880.000017ps       13.740969
+ 890.000018ps       13.742225
+ 900.000019ps       13.786169
+ 910.000020ps       13.881014
+ 920.000021ps       13.976697
+ 930.000021ps       14.117989
+ 939.999967ps       14.167002
+ 949.999968ps       14.173621
+ 959.999968ps        14.20273
+ 969.999969ps        14.20092
+ 979.999970ps       14.129314
+ 989.999971ps       13.961464
+ 999.999972ps       13.749153
+ 1009.999973ps       13.516317
+ 1019.999973ps       13.306529
+ 1029.999974ps       13.125249
+ 1039.999975ps       12.943785
+ 1049.999976ps       12.793838
+ 1059.999977ps       12.693562
+ 1069.999978ps       12.603144
+ 1079.999978ps       12.522583
+ 1089.999979ps       12.419287
+ 1099.999980ps        12.33775
+ 1109.999981ps       12.235888
+ 1119.999982ps       12.149122
+ 1129.999982ps       12.081466
+ 1139.999983ps       12.057674
+ 1149.999984ps       12.050804
+ 1159.999985ps       12.101925
+ 1169.999986ps       12.212601
+ 1179.999987ps       12.404408
+ 1189.999987ps       12.591117
+ 1199.999988ps       12.808631
+ 1209.999989ps       12.866098
+ 1219.999990ps       12.750045
+ 1229.999991ps       12.618956
+ 1239.999992ps       12.605856
+ 1249.999992ps       12.572454
+ 1259.999993ps       12.455938
+ 1269.999994ps       12.289119
+ 1279.999995ps       12.103784
+ 1289.999996ps       11.901257
+ 1299.999997ps        11.74027
+ 1309.999997ps       11.631539
+ 1319.999998ps       11.589868
+ 1329.999999ps       11.594568
+ 1340.000000ps       11.642431
+ 1350.000001ps       11.701764
+ 1360.000002ps       11.726596
+ 1370.000002ps       11.717823
+ 1380.000003ps       11.658768
+ 1390.000004ps       11.577494
+ 1400.000005ps       11.504099
+ 1410.000006ps       11.466638
+ 1420.000006ps       11.468541
+ 1430.000007ps       11.490023
+ 1440.000008ps       11.561723
+ 1450.000009ps       11.628073
+ 1460.000010ps       11.754762
+ 1470.000011ps       11.802698
+ 1480.000011ps       11.827388
+ 1490.000012ps       11.848112
+ 1500.000013ps       11.853142
+ 1510.000014ps       11.822781
+ 1520.000015ps       11.746529
+ 1530.000016ps         11.6459
+ 1540.000016ps       11.533806
+ 1550.000017ps       11.412162
+ 1560.000018ps       11.310552
+ 1570.000019ps       11.242246
+ 1580.000020ps       11.205411
+ 1590.000021ps       11.204444
+ 1600.000021ps       11.192817
+ 1610.000022ps       11.203201
+ 1620.000023ps       11.212999
+ 1630.000024ps       11.229238
+ 1640.000025ps        11.23603
+ 1650.000025ps       11.239234
+ 1660.000026ps       11.259621
+ 1670.000027ps       11.296774
+ 1680.000028ps       11.329194
+ 1690.000029ps       11.420698
+ 1700.000030ps        11.53433
+ 1710.000030ps       11.734124
+ 1720.000031ps       11.925281
+ 1730.000032ps       12.150754
+ 1740.000033ps       12.317925
+ 1750.000034ps       12.256815
+ 1760.000035ps       12.211015
+ 1770.000035ps       12.244049
+ 1780.000036ps       12.251944
+ 1790.000037ps       12.162804
+ 1800.000038ps       12.016589
+ 1810.000039ps       11.813767
+ 1820.000040ps        11.61446
+ 1830.000040ps       11.472949
+ 1840.000041ps       11.354997
+ 1850.000042ps       11.299816
+ 1860.000043ps       11.263165
+ 1869.999933ps       11.270609
+ 1879.999934ps       11.294007
+ 1889.999934ps        11.26248
+ 1899.999935ps       11.249014
+ 1909.999936ps       11.191618
+ 1919.999937ps       11.134322
+ 1929.999938ps       11.090823
+ 1939.999938ps       11.053197
+ 1949.999939ps       11.055161
+ 1959.999940ps       11.050907
+ 1969.999941ps       11.112645
+ 1979.999942ps        11.18597
+ 1989.999943ps       11.288385
+ 1999.999943ps       11.366657
+ 2009.999944ps       11.409652
+ 2019.999945ps       11.421276
+ 2029.999946ps       11.482396
+ 2039.999947ps       11.515992
+ 2049.999948ps       11.507915
+ 2059.999948ps       11.491065
+ 2069.999949ps       11.416571
+ 2079.999950ps       11.338475
+ 2089.999951ps       11.239899
+ 2099.999952ps       11.159213
+ 2109.999953ps       11.102236
+ 2119.999953ps       11.041539
+ 2129.999954ps       11.005206
+ 2139.999955ps       10.992394
+ 2149.999956ps       10.994153
+ 2159.999957ps       11.038107
+ 2169.999958ps       11.107213
+ 2179.999958ps       11.175548
+ 2189.999959ps       11.209156
+ 2199.999960ps       11.168452
+ 2209.999961ps        11.16785
+ 2219.999962ps       11.227637
+ 2229.999962ps       11.340292
+ 2239.999963ps       11.505826
+ 2249.999964ps       11.696869
+ 2259.999965ps       11.931193
+ 2269.999966ps       12.138346
+ 2279.999967ps       12.081972
+ 2289.999967ps       11.972539
+ 2299.999968ps       11.920701
+ 2309.999969ps       11.923762
+ 2319.999970ps       11.860472
+ 2329.999971ps       11.715703
+ 2339.999972ps       11.538136
+ 2349.999972ps       11.373557
+ 2359.999973ps       11.224674
+ 2369.999974ps        11.13756
+ 2379.999975ps       11.084382
+ 2389.999976ps        11.02409
+ 2399.999977ps       10.986797
+ 2409.999977ps        10.98734
+ 2419.999978ps       11.011426
+ 2429.999979ps       11.019158
+ 2439.999980ps       10.994795
+ 2449.999981ps       10.987107
+ 2459.999982ps       10.964072
+ 2469.999982ps       10.930423
+ 2479.999983ps       10.916077
+ 2489.999984ps       10.921718
+ 2499.999985ps       10.973881
+ 2509.999986ps       11.038207
+ 2519.999986ps       11.135069
+ 2529.999987ps       11.248141
+ 2539.999988ps       11.308453
+ 2549.999989ps        11.36399
+ 2559.999990ps       11.438083
+ 2569.999991ps       11.471419
+ 2579.999991ps       11.474385
+ 2589.999992ps       11.453749
+ 2599.999993ps       11.430958
+ 2609.999994ps        11.38465
+ 2619.999995ps       11.318458
+ 2629.999996ps       11.232471
+ 2639.999996ps       11.118114
+ 2649.999997ps       11.018879
+ 2659.999998ps       10.945097
+ 2669.999999ps       10.886494
+ 2680.000000ps       10.838994
+ 2690.000001ps       10.772128
+ 2700.000001ps       10.726147
+ 2710.000002ps       10.715796
+ 2720.000003ps       10.733563
+ 2730.000004ps       10.766113
+ 2740.000005ps       10.825014
+ 2750.000005ps       10.923409
+ 2760.000006ps       11.057517
+ 2770.000007ps       11.240892
+ 2780.000008ps       11.482346
+ 2790.000009ps       11.760059
+ 2800.000010ps       12.045641
+ 2810.000010ps       12.037435
+ 2820.000011ps       11.979076
+ 2830.000012ps        11.95174
+ 2840.000013ps       11.984883
+ 2850.000014ps       11.995923
+ 2860.000015ps       11.842364
+ 2870.000015ps       11.651162
+ 2880.000016ps       11.474403
+ 2890.000017ps       11.314753
+ 2900.000018ps       11.185881
+ 2910.000019ps       11.076977
+ 2920.000020ps       11.041453
+ 2930.000020ps       11.025146
+ 2940.000021ps       11.004772
+ 2950.000022ps       10.959925
+ 2960.000023ps       10.910618
+ 2970.000024ps       10.858563
+ 2980.000025ps        10.83645
+ 2990.000025ps       10.851837
+ 3000.000026ps       10.904768
+ 3010.000027ps       10.947463
+ 3020.000028ps       11.008904
+ 3030.000029ps       11.058863
+ 3040.000029ps        11.13165
+ 3050.000030ps       11.213534
+ 3060.000031ps       11.347198
+ 3070.000032ps       11.398376
+ 3080.000033ps       11.402345
+ 3090.000034ps       11.430481
+ 3100.000034ps       11.447633
+ 3110.000035ps       11.432079
+ 3120.000036ps       11.373333
+ 3130.000037ps       11.281384
+ 3140.000038ps       11.179793
+ 3150.000039ps       11.065381
+ 3160.000039ps       10.979346
+ 3170.000040ps       10.929193
+ 3180.000041ps        10.85471
+ 3190.000042ps       10.777279
+ 3200.000043ps       10.734015
+ 3210.000044ps       10.732243
+ 3220.000044ps       10.751814
+ 3230.000045ps       10.787999
+ 3240.000046ps       10.827626
+ 3250.000047ps       10.867474
+ 3260.000048ps        10.88881
+ 3270.000049ps       10.927055
+ 3280.000049ps       10.973162
+ 3290.000050ps       11.040319
+ 3300.000051ps       11.155506
+ 3310.000052ps       11.347844
+ 3320.000053ps       11.534654
+ 3330.000053ps       11.768053
+ 3340.000054ps       11.777968
+ 3350.000055ps       11.727579
+ 3360.000056ps       11.680024
+ 3370.000057ps       11.683058
+ 3380.000058ps       11.669864
+ 3390.000058ps       11.581486
+ 3400.000059ps       11.469425
+ 3410.000060ps       11.347895
+ 3420.000061ps       11.181012
+ 3430.000062ps       11.056755
+ 3440.000063ps       10.955902
+ 3450.000063ps       10.882843
+ 3460.000064ps       10.826414
+ 3470.000065ps       10.756437
+ 3480.000066ps       10.723099
+ 3490.000067ps       10.684489
+ 3500.000068ps       10.658064
+ 3510.000068ps       10.642846
+ 3520.000069ps       10.640569
+ 3530.000070ps       10.656221
+ 3540.000071ps       10.670996
+ 3550.000072ps        10.70269
+ 3560.000073ps       10.761241
+ 3570.000073ps       10.881286
+ 3580.000074ps       10.981004
+ 3590.000075ps       11.129113
+ 3600.000076ps       11.193416
+ 3610.000077ps       11.206817
+ 3620.000077ps       11.241221
+ 3630.000078ps       11.244893
+ 3640.000079ps       11.243154
+ 3650.000080ps       11.197404
+ 3660.000081ps       11.143686
+ 3670.000082ps        11.08166
+ 3680.000082ps       10.999378
+ 3690.000083ps       10.933516
+ 3700.000084ps       10.872886
+ 3710.000085ps       10.823814
+ 3720.000086ps       10.768683
+ 3729.999865ps       10.726637
+ 3739.999865ps       10.664668
+ 3749.999866ps       10.618142
+ 3759.999867ps         10.5851
+ 3769.999868ps       10.578948
+ 3779.999869ps       10.579579
+ 3789.999869ps       10.575198
+ 3799.999870ps       10.599986
+ 3809.999871ps       10.619519
+ 3819.999872ps       10.704929
+ 3829.999873ps       10.863293
+ 3839.999874ps       11.089815
+ 3849.999874ps       11.354861
+ 3859.999875ps       11.657667
+ 3869.999876ps       11.758598
+ 3879.999877ps       11.705594
+ 3889.999878ps        11.60288
+ 3899.999879ps        11.59939
+ 3909.999879ps       11.591418
+ 3919.999880ps       11.502409
+ 3929.999881ps       11.338794
+ 3939.999882ps       11.161503
+ 3949.999883ps       10.965405
+ 3959.999884ps       10.801741
+ 3969.999884ps       10.712598
+ 3979.999885ps       10.644802
+ 3989.999886ps       10.653514
+ 3999.999887ps         10.8418
+ 4009.999888ps       11.100972
+ 4019.999889ps       11.251642
+ 4029.999889ps       11.282917
+ 4039.999890ps       11.307334
+ 4049.999891ps       11.327082
+ 4059.999892ps       11.346535
+ 4069.999893ps       11.368165
+ 4079.999893ps       11.415491
+ 4089.999894ps       11.465949
+ 4099.999895ps       11.550211
+ 4109.999896ps       11.640211
+ 4119.999897ps       11.782354
+ 4129.999898ps       11.867215
+ 4139.999898ps       11.904776
+ 4149.999899ps       11.950468
+ 4159.999900ps       12.010051
+ 4169.999901ps       12.057514
+ 4179.999902ps       12.047179
+ 4189.999903ps       11.965915
+ 4199.999903ps       11.845081
+ 4209.999904ps        11.72543
+ 4219.999905ps       11.646458
+ 4229.999906ps         11.6169
+ 4239.999907ps       11.647081
+ 4249.999908ps       11.685833
+ 4259.999908ps       11.727607
+ 4269.999909ps       11.742711
+ 4279.999910ps       11.737184
+ 4289.999911ps       11.726921
+ 4299.999912ps       11.692985
+ 4309.999913ps       11.666957
+ 4319.999913ps       11.655529
+ 4329.999914ps       11.672152
+ 4339.999915ps        11.70506
+ 4349.999916ps       11.796269
+ 4359.999917ps       11.916466
+ 4369.999917ps       12.105775
+ 4379.999918ps       12.295448
+ 4389.999919ps       12.557246
+ 4399.999920ps       12.736741
+ 4409.999921ps       12.699997
+ 4419.999922ps       12.668514
+ 4429.999922ps       12.720086
+ 4439.999923ps       12.775751
+ 4449.999924ps        12.74776
+ 4459.999925ps       12.639849
+ 4469.999926ps       12.473587
+ 4479.999927ps       12.265347
+ 4489.999927ps       12.041704
+ 4499.999928ps       11.858298
+ 4509.999929ps       11.706533
+ 4519.999930ps       11.612675
+ 4529.999931ps       11.547614
+ 4539.999932ps       11.518402
+ 4549.999932ps       11.509602
+ 4559.999933ps       11.502034
+ 4569.999934ps       11.498524
+ 4579.999935ps       11.494313
+ 4589.999936ps       11.501224
+ 4599.999937ps       11.516977
+ 4609.999937ps       11.564967
+ 4619.999938ps       11.634353
+ 4629.999939ps       11.765229
+ 4639.999940ps       11.894154
+ 4649.999941ps       12.031859
+ 4659.999941ps       12.142045
+ 4669.999942ps       12.178209
+ 4679.999943ps       12.192943
+ 4689.999944ps       12.234146
+ 4699.999945ps       12.148148
+ 4709.999946ps       12.032283
+ 4719.999946ps       11.901909
+ 4729.999947ps       11.790212
+ 4739.999948ps       11.698243
+ 4749.999949ps       11.604993
+ 4759.999950ps       11.569314
+ 4769.999951ps       11.580989
+ 4779.999951ps       11.627843
+ 4789.999952ps       11.645743
+ 4799.999953ps       11.654561
+ 4809.999954ps       11.671711
+ 4819.999955ps       11.688107
+ 4829.999956ps       11.703721
+ 4839.999956ps       11.657452
+ 4849.999957ps       11.614888
+ 4859.999958ps       11.590005
+ 4869.999959ps       11.599892
+ 4879.999960ps       11.658228
+ 4889.999961ps       11.734154
+ 4899.999961ps       11.917055
+ 4909.999962ps       12.123189
+ 4919.999963ps       12.380234
+ 4929.999964ps       12.609348
+ 4939.999965ps       12.576672
+ 4949.999965ps       12.547432
+ 4959.999966ps       12.580963
+ 4969.999967ps       12.619453
+ 4979.999968ps        12.58184
+ 4989.999969ps       12.423751
+ 4999.999970ps       12.207252
+ 5009.999970ps       11.973036
+ 5019.999971ps       11.763528
+ 5029.999972ps        11.59633
+ 5039.999973ps       11.461393
+ 5049.999974ps       11.370251
+ 5059.999975ps       11.352241
+ 5069.999975ps       11.343492
+ 5079.999976ps       11.359821
+ 5089.999977ps       11.333384
+ 5099.999978ps       11.344187
+ 5109.999979ps       11.325049
+ 5119.999980ps       11.280153
+ 5129.999980ps       11.248314
+ 5139.999981ps       11.265158
+ 5149.999982ps        11.31229
+ 5159.999983ps       11.413815
+ 5169.999984ps        11.57221
+ 5179.999985ps       11.718512
+ 5189.999985ps       11.814241
+ 5199.999986ps       11.805463
+ 5209.999987ps       11.765795
+ 5219.999988ps       11.742265
+ 5229.999989ps       11.702042
+ 5239.999989ps       11.640185
+ 5249.999990ps       11.544201
+ 5259.999991ps       11.421409
+ 5269.999992ps       11.313508
+ 5279.999993ps       11.229764
+ 5289.999994ps       11.162766
+ 5299.999994ps        11.12845
+ 5309.999995ps       11.108494
+ 5319.999996ps       11.110773
+ 5329.999997ps       11.124697
+ 5339.999998ps       11.173377
+ 5349.999999ps       11.229156
+ 5359.999999ps       11.280595
+ 5370.000000ps       11.336689
+ 5380.000001ps       11.342494
+ 5390.000002ps        11.31815
+ 5400.000003ps       11.295887
+ 5410.000004ps       11.336381
+ 5420.000004ps       11.403856
+ 5430.000005ps       11.555938
+ 5440.000006ps       11.768874
+ 5450.000007ps       12.026308
+ 5460.000008ps       12.296189
+ 5470.000009ps       12.296358
+ 5480.000009ps       12.286851
+ 5490.000010ps       12.322029
+ 5500.000011ps       12.393815
+ 5510.000012ps       12.423779
+ 5520.000013ps       12.354821
+ 5530.000013ps       12.166946
+ 5540.000014ps       11.949971
+ 5550.000015ps        11.71061
+ 5560.000016ps       11.513579
+ 5570.000017ps       11.379644
+ 5580.000018ps       11.292403
+ 5590.000018ps       11.255645
+ 5600.000019ps       11.221524
+ 5610.000020ps       11.227328
+ 5620.000021ps       11.232612
+ 5630.000022ps       11.240276
+ 5640.000023ps         11.2403
+ 5650.000023ps       11.243359
+ 5660.000024ps       11.275684
+ 5670.000025ps       11.306405
+ 5680.000026ps       11.343055
+ 5690.000027ps       11.439859
+ 5700.000028ps       11.560612
+ 5710.000028ps       11.674668
+ 5720.000029ps       11.784518
+ 5730.000030ps       11.783518
+ 5740.000031ps       11.744339
+ 5750.000032ps       11.750999
+ 5760.000033ps       11.756641
+ 5770.000033ps        11.73072
+ 5780.000034ps       11.643571
+ 5790.000035ps       11.531109
+ 5800.000036ps        11.44304
+ 5810.000037ps       11.327614
+ 5820.000037ps       11.251881
+ 5830.000038ps       11.236607
+ 5840.000039ps       11.227556
+ 5850.000040ps       11.233716
+ 5860.000041ps       11.237972
+ 5870.000042ps       11.279885
+ 5880.000042ps       11.326634
+ 5890.000043ps       11.315782
+ 5900.000044ps       11.306424
+ 5910.000045ps       11.275175
+ 5920.000046ps        11.24054
+ 5930.000047ps       11.231153
+ 5940.000047ps       11.240195
+ 5950.000048ps       11.289139
+ 5960.000049ps       11.382583
+ 5970.000050ps       11.572263
+ 5980.000051ps       11.761941
+ 5990.000052ps       12.000062
+ 6000.000052ps        12.02216
+ 6010.000053ps       11.973274
+ 6020.000054ps        11.94027
+ 6030.000055ps       11.999488
+ 6040.000056ps       12.042543
+ 6050.000056ps       11.983797
+ 6060.000057ps       11.901266
+ 6070.000058ps        11.76298
+ 6080.000059ps       11.602649
+ 6090.000060ps        11.41257
+ 6100.000061ps       11.267819
+ 6110.000061ps       11.166382
+ 6120.000062ps       11.092084
+ 6130.000063ps       11.044413
+ 6140.000064ps       11.004795
+ 6150.000065ps       10.964687
+ 6160.000066ps       10.948507
+ 6170.000066ps       10.950758
+ 6180.000067ps       10.971254
+ 6190.000068ps        10.96915
+ 6200.000069ps       10.966273
+ 6210.000070ps       11.004819
+ 6220.000071ps       11.094217
+ 6230.000071ps       11.251628
+ 6240.000072ps       11.358803
+ 6250.000073ps       11.495341
+ 6260.000074ps        11.52129
+ 6270.000075ps       11.522593
+ 6280.000076ps       11.531559
+ 6290.000076ps       11.515232
+ 6300.000077ps       11.462395
+ 6310.000078ps       11.383278
+ 6320.000079ps       11.291434
+ 6330.000080ps       11.227864
+ 6340.000080ps       11.178513
+ 6350.000081ps       11.153729
+ 6360.000082ps       11.137013
+ 6370.000083ps       11.100061
+ 6380.000084ps       11.081378
+ 6390.000085ps       11.043064
+ 6400.000085ps       11.019131
+ 6410.000086ps       11.039401
+ 6420.000087ps        11.08412
+ 6430.000088ps       11.116054
+ 6440.000089ps       11.101043
+ 6450.000090ps       11.092223
+ 6460.000090ps       11.079227
+ 6470.000091ps       11.075066
+ 6480.000092ps       11.122971
+ 6490.000093ps       11.202365
+ 6500.000094ps       11.375351
+ 6510.000095ps        11.55199
+ 6520.000095ps       11.790529
+ 6530.000096ps        11.89349
+ 6540.000097ps       11.881293
+ 6550.000098ps       11.873811
+ 6560.000099ps       11.939642
+ 6570.000100ps       11.976566
+ 6580.000100ps       11.939873
+ 6590.000101ps       11.857179
+ 6600.000102ps       11.752623
+ 6610.000103ps       11.612895
+ 6620.000104ps       11.471873
+ 6630.000104ps       11.341731
+ 6640.000105ps       11.198122
+ 6650.000106ps       11.074175
+ 6660.000107ps       10.989779
+ 6670.000108ps       10.926806
+ 6680.000109ps       10.880379
+ 6690.000109ps       10.822656
+ 6700.000110ps       10.792247
+ 6710.000111ps       10.782372
+ 6720.000112ps       10.815352
+ 6730.000113ps        10.86827
+ 6740.000114ps       10.943663
+ 6750.000114ps        11.05785
+ 6760.000115ps       11.230013
+ 6770.000116ps       11.370292
+ 6780.000117ps       11.521204
+ 6790.000118ps       11.596248
+ 6800.000119ps       11.627327
+ 6810.000119ps        11.63585
+ 6820.000120ps       11.639048
+ 6830.000121ps       11.610266
+ 6840.000122ps         11.5439
+ 6850.000123ps       11.464255
+ 6860.000124ps        11.31615
+ 6870.000124ps       11.201438
+ 6880.000125ps       11.119199
+ 6890.000126ps       11.077247
+ 6900.000127ps       11.047434
+ 6910.000128ps       11.006569
+ 6920.000128ps       11.012718
+ 6930.000129ps        11.03189
+ 6940.000130ps       11.031759
+ 6950.000131ps       11.008286
+ 6960.000132ps       10.967738
+ 6970.000133ps       10.909229
+ 6980.000133ps       10.870869
+ 6990.000134ps       10.870534
+ 7000.000135ps       10.901405
+ 7010.000136ps       10.974202
+ 7020.000137ps       11.079657
+ 7030.000138ps       11.266976
+ 7040.000138ps       11.473743
+ 7050.000139ps        11.75465
+ 7060.000140ps       11.973663
+ 7070.000141ps       11.955473
+ 7080.000142ps       11.912363
+ 7090.000143ps       11.942122
+ 7100.000143ps        11.99773
+ 7110.000144ps       11.970359
+ 7120.000145ps       11.874848
+ 7130.000146ps       11.731357
+ 7140.000147ps       11.548099
+ 7150.000147ps       11.376216
+ 7160.000148ps        11.26742
+ 7170.000149ps       11.214139
+ 7180.000150ps        11.15722
+ 7190.000151ps       11.081479
+ 7200.000152ps       10.996815
+ 7210.000152ps       10.941995
+ 7220.000153ps       10.916827
+ 7230.000154ps       10.925933
+ 7240.000155ps       10.946776
+ 7250.000156ps       10.959007
+ 7260.000157ps       10.964867
+ 7270.000157ps       10.993559
+ 7280.000158ps       11.023293
+ 7290.000159ps       11.075261
+ 7300.000160ps       11.142324
+ 7310.000161ps       11.216192
+ 7320.000162ps       11.274078
+ 7330.000162ps       11.272097
+ 7340.000163ps       11.264668
+ 7350.000164ps       11.260951
+ 7360.000165ps       11.231515
+ 7370.000166ps       11.156849
+ 7380.000167ps       11.053898
+ 7390.000167ps       10.965482
+ 7400.000168ps       10.912246
+ 7410.000169ps        10.86368
+ 7420.000170ps       10.798818
+ 7430.000171ps       10.755292
+ 7440.000171ps       10.728363
+ 7450.000172ps       10.719805
+ 7459.999729ps       10.722643
+ 7469.999730ps       10.699863
+ 7479.999731ps       10.703747
+ 7489.999732ps        10.69401
+ 7499.999732ps       10.675057
+ 7509.999733ps       10.675918
+ 7519.999734ps        10.68713
+ 7529.999735ps       10.727735
+ 7539.999736ps       10.784614
+ 7549.999737ps       10.876771
+ 7559.999737ps        11.05679
+ 7569.999738ps       11.287935
+ 7579.999739ps       11.561801
+ 7589.999740ps       11.810665
+ 7599.999741ps       11.814936
+ 7609.999741ps       11.765705
+ 7619.999742ps       11.772362
+ 7629.999743ps       11.779966
+ 7639.999744ps       11.761351
+ 7649.999745ps       11.687198
+ 7659.999746ps       11.575343
+ 7669.999746ps        11.44774
+ 7679.999747ps       11.283753
+ 7689.999748ps       11.157546
+ 7699.999749ps       11.059277
+ 7709.999750ps        10.99774
+ 7719.999751ps       10.951541
+ 7729.999751ps        10.91568
+ 7739.999752ps       10.844449
+ 7749.999753ps        10.79994
+ 7759.999754ps       10.782971
+ 7769.999755ps        10.78398
+ 7779.999756ps       10.799101
+ 7789.999756ps        10.80171
+ 7799.999757ps       10.797413
+ 7809.999758ps       10.774836
+ 7819.999759ps       10.816612
+ 7829.999760ps       10.892038
+ 7839.999761ps       10.959399
+ 7849.999761ps       11.061828
+ 7859.999762ps       11.103628
+ 7869.999763ps       11.105933
+ 7879.999764ps       11.134957
+ 7889.999765ps       11.101061
+ 7899.999765ps       11.049359
+ 7909.999766ps       10.933453
+ 7919.999767ps       10.819615
+ 7929.999768ps         10.7091
+ 7939.999769ps       10.632452
+ 7949.999770ps       10.577072
+ 7959.999770ps       10.561766
+ 7969.999771ps       10.590522
+ 7979.999772ps       10.619096
+ 7989.999773ps       10.698219
+)

Icursig2 PAR_1_0_VSS 0 pwl(
+ 0.000000ps      -4.9532346
+ 10.000000ps      -5.2710456
+ 20.000000ps      -5.8908776
+ 29.999999ps      -6.4643818
+ 40.000000ps      -6.8802056
+ 50.000001ps      -7.2080749
+ 59.999998ps      -7.4738144
+ 69.999999ps      -7.6346548
+ 80.000000ps      -7.7976506
+ 90.000001ps      -7.9046194
+ 100.000001ps      -7.9979506
+ 110.000002ps      -8.0651049
+ 119.999996ps      -8.0783364
+ 129.999997ps      -8.0934393
+ 139.999998ps      -8.0935116
+ 149.999999ps      -8.0708334
+ 159.999999ps      -8.0408759
+ 170.000000ps      -8.0223703
+ 180.000001ps      -8.0230115
+ 190.000002ps      -8.0532371
+ 200.000003ps      -8.0767877
+ 210.000003ps      -8.1052512
+ 220.000004ps      -8.1540009
+ 230.000005ps      -8.2136687
+ 239.999992ps      -8.2864261
+ 249.999993ps      -8.3453985
+ 259.999994ps      -8.3996523
+ 269.999995ps      -8.4497935
+ 279.999995ps      -8.4743678
+ 289.999996ps      -8.5162616
+ 299.999997ps      -8.5425434
+ 309.999998ps      -8.5491565
+ 319.999999ps      -8.5232511
+ 330.000000ps      -8.4941227
+ 340.000000ps      -8.4834695
+ 350.000001ps      -8.4698046
+ 360.000002ps      -8.4598818
+ 370.000003ps      -8.4623961
+ 380.000004ps      -8.4671674
+ 390.000005ps      -8.4481202
+ 400.000005ps      -8.4347527
+ 410.000006ps      -8.4330078
+ 420.000007ps      -8.4249327
+ 430.000008ps      -8.4263685
+ 440.000009ps       -8.438918
+ 450.000009ps      -8.4542613
+ 460.000010ps      -8.4516942
+ 469.999983ps       -8.475807
+ 479.999984ps      -8.5068129
+ 489.999985ps      -8.5617094
+ 499.999986ps      -8.6062704
+ 509.999987ps      -8.6344738
+ 519.999988ps      -8.6281122
+ 529.999988ps      -8.6152637
+ 539.999989ps      -8.6251611
+ 549.999990ps      -8.6275253
+ 559.999991ps       -8.626279
+ 569.999992ps      -8.6137605
+ 579.999992ps      -8.6070124
+ 589.999993ps      -8.5808575
+ 599.999994ps      -8.5711278
+ 609.999995ps      -8.5607222
+ 619.999996ps      -8.5505724
+ 629.999997ps      -8.5648085
+ 639.999997ps      -8.5705336
+ 649.999998ps      -8.5866378
+ 659.999999ps      -8.5915875
+ 670.000000ps      -8.5746034
+ 680.000001ps       -8.564816
+ 690.000002ps       -8.577111
+ 700.000002ps      -8.6042654
+ 710.000003ps      -8.6378323
+ 720.000004ps       -8.659356
+ 730.000005ps      -8.6532064
+ 740.000006ps      -8.6539734
+ 750.000007ps      -8.6540114
+ 760.000007ps      -8.6620726
+ 770.000008ps       -8.657849
+ 780.000009ps      -8.6500506
+ 790.000010ps      -8.6843627
+ 800.000011ps       -8.681475
+ 810.000012ps      -8.6366284
+ 820.000012ps      -8.6295597
+ 830.000013ps      -8.6243661
+ 840.000014ps      -8.6204065
+ 850.000015ps      -8.6005398
+ 860.000016ps      -8.6060683
+ 870.000016ps      -8.6169866
+ 880.000017ps      -8.6340324
+ 890.000018ps      -8.6772133
+ 900.000019ps      -8.7123943
+ 910.000020ps      -8.7223477
+ 920.000021ps      -8.7330736
+ 930.000021ps      -8.7084636
+ 939.999967ps      -8.7054643
+ 949.999968ps      -8.6943457
+ 959.999968ps      -8.6767445
+ 969.999969ps      -8.6421519
+ 979.999970ps      -8.5761613
+ 989.999971ps      -8.5059091
+ 999.999972ps      -8.4584965
+ 1009.999973ps       -8.419638
+ 1019.999973ps      -8.3937781
+ 1029.999974ps      -8.3898735
+ 1039.999975ps      -8.3647623
+ 1049.999976ps      -8.3484354
+ 1059.999977ps      -8.3357956
+ 1069.999978ps      -8.3234785
+ 1079.999978ps      -8.3231317
+ 1089.999979ps      -8.3070866
+ 1099.999980ps      -8.2866106
+ 1109.999981ps      -8.2741594
+ 1119.999982ps      -8.2515301
+ 1129.999982ps      -8.2417435
+ 1139.999983ps      -8.2058797
+ 1149.999984ps      -8.1739021
+ 1159.999985ps      -8.1389742
+ 1169.999986ps      -8.1108959
+ 1179.999987ps      -8.1002478
+ 1189.999987ps      -8.1160452
+ 1199.999988ps       -8.118705
+ 1209.999989ps      -8.1323004
+ 1219.999990ps      -8.1624845
+ 1229.999991ps      -8.1763712
+ 1239.999992ps      -8.1851901
+ 1249.999992ps      -8.2009022
+ 1259.999993ps       -8.219778
+ 1269.999994ps      -8.2157431
+ 1279.999995ps      -8.2260792
+ 1289.999996ps      -8.2238898
+ 1299.999997ps      -8.2098661
+ 1309.999997ps      -8.1624349
+ 1319.999998ps      -8.1395074
+ 1329.999999ps      -8.1339246
+ 1340.000000ps      -8.1342579
+ 1350.000001ps      -8.1440888
+ 1360.000002ps      -8.1495497
+ 1370.000002ps      -8.1523966
+ 1380.000003ps      -8.1501701
+ 1390.000004ps      -8.1534906
+ 1400.000005ps      -8.1307937
+ 1410.000006ps      -8.1116521
+ 1420.000006ps      -8.0947588
+ 1430.000007ps      -8.0908785
+ 1440.000008ps      -8.0951244
+ 1450.000009ps      -8.0844784
+ 1460.000010ps      -8.0731337
+ 1470.000011ps      -8.0527838
+ 1480.000011ps      -8.0214395
+ 1490.000012ps      -8.0078631
+ 1500.000013ps      -7.9999749
+ 1510.000014ps      -8.0019854
+ 1520.000015ps      -8.0323261
+ 1530.000016ps      -8.0679319
+ 1540.000016ps      -8.0755183
+ 1550.000017ps      -8.0471502
+ 1560.000018ps      -8.0391185
+ 1570.000019ps       -8.030353
+ 1580.000020ps      -8.0467583
+ 1590.000021ps      -8.0534762
+ 1600.000021ps      -8.0577288
+ 1610.000022ps      -8.0526899
+ 1620.000023ps      -8.0620176
+ 1630.000024ps      -8.0691317
+ 1640.000025ps       -8.065283
+ 1650.000025ps      -8.0572918
+ 1660.000026ps      -8.0446988
+ 1670.000027ps      -8.0529969
+ 1680.000028ps      -8.0733806
+ 1690.000029ps      -8.0900031
+ 1700.000030ps       -8.096091
+ 1710.000030ps      -8.0962645
+ 1720.000031ps      -8.1076209
+ 1730.000032ps      -8.1070899
+ 1740.000033ps      -8.1103088
+ 1750.000034ps       -8.112518
+ 1760.000035ps      -8.1217571
+ 1770.000035ps      -8.1278557
+ 1780.000036ps      -8.1445737
+ 1790.000037ps      -8.1585151
+ 1800.000038ps      -8.1869271
+ 1810.000039ps      -8.1593021
+ 1820.000040ps      -8.1039189
+ 1830.000040ps      -8.0507372
+ 1840.000041ps      -8.0043194
+ 1850.000042ps      -7.9932533
+ 1860.000043ps      -7.9574727
+ 1869.999933ps      -7.9323381
+ 1879.999934ps      -7.9218434
+ 1889.999934ps      -7.9145648
+ 1899.999935ps      -7.9246388
+ 1909.999936ps      -7.9314465
+ 1919.999937ps      -7.9278658
+ 1929.999938ps        -7.94495
+ 1939.999938ps      -7.9359202
+ 1949.999939ps       -7.946675
+ 1959.999940ps      -7.9727441
+ 1969.999941ps      -7.9849786
+ 1979.999942ps      -8.0142643
+ 1989.999943ps      -8.0008002
+ 1999.999943ps      -7.9766436
+ 2009.999944ps      -7.9364826
+ 2019.999945ps      -7.8757923
+ 2029.999946ps      -7.8319146
+ 2039.999947ps      -7.7834319
+ 2049.999948ps      -7.7497499
+ 2059.999948ps      -7.7350897
+ 2069.999949ps      -7.7462669
+ 2079.999950ps      -7.7361755
+ 2089.999951ps       -7.760156
+ 2099.999952ps      -7.7713308
+ 2109.999953ps      -7.7901175
+ 2119.999953ps      -7.8431623
+ 2129.999954ps      -7.9024137
+ 2139.999955ps      -7.9522003
+ 2149.999956ps      -7.9697361
+ 2159.999957ps       -7.982556
+ 2169.999958ps       -7.973906
+ 2179.999958ps      -7.9390464
+ 2189.999959ps      -7.9286955
+ 2199.999960ps       -7.896964
+ 2209.999961ps      -7.8751079
+ 2219.999962ps      -7.8583249
+ 2229.999962ps      -7.8593271
+ 2239.999963ps      -7.8785558
+ 2249.999964ps      -7.8836825
+ 2259.999965ps      -7.9011941
+ 2269.999966ps      -7.8933205
+ 2279.999967ps      -7.9095462
+ 2289.999967ps       -7.921437
+ 2299.999968ps      -7.9259905
+ 2309.999969ps      -7.9224663
+ 2319.999970ps      -7.9403557
+ 2329.999971ps      -7.9463107
+ 2339.999972ps      -7.9667444
+ 2349.999972ps      -8.0055188
+ 2359.999973ps      -8.0189831
+ 2369.999974ps      -8.0457892
+ 2379.999975ps       -8.048394
+ 2389.999976ps      -8.0379555
+ 2399.999977ps      -8.0460453
+ 2409.999977ps      -8.0632449
+ 2419.999978ps      -8.1015935
+ 2429.999979ps      -8.1018904
+ 2439.999980ps      -8.0858717
+ 2449.999981ps      -8.0708268
+ 2459.999982ps      -8.0785854
+ 2469.999982ps      -8.0862155
+ 2479.999983ps      -8.1085603
+ 2489.999984ps      -8.1299067
+ 2499.999985ps      -8.1379568
+ 2509.999986ps      -8.1599183
+ 2519.999986ps      -8.1517678
+ 2529.999987ps      -8.1255265
+ 2539.999988ps      -8.1149111
+ 2549.999989ps      -8.0997171
+ 2559.999990ps      -8.1086724
+ 2569.999991ps      -8.1166865
+ 2579.999991ps      -8.1423345
+ 2589.999992ps      -8.1610097
+ 2599.999993ps      -8.1521597
+ 2609.999994ps      -8.1504497
+ 2619.999995ps       -8.120256
+ 2629.999996ps      -8.1080257
+ 2639.999996ps      -8.0975732
+ 2649.999997ps      -8.1175035
+ 2659.999998ps      -8.1348085
+ 2669.999999ps      -8.1125098
+ 2680.000000ps      -8.1144337
+ 2690.000001ps      -8.0976503
+ 2700.000001ps      -8.0799613
+ 2710.000002ps      -8.0707823
+ 2720.000003ps      -8.0381755
+ 2730.000004ps      -8.0115626
+ 2740.000005ps      -7.9658027
+ 2750.000005ps      -7.9657806
+ 2760.000006ps      -8.0022012
+ 2770.000007ps      -8.0037449
+ 2780.000008ps      -8.0036072
+ 2790.000009ps      -8.0049467
+ 2800.000010ps      -7.9993415
+ 2810.000010ps      -7.9977786
+ 2820.000011ps      -8.0184084
+ 2830.000012ps      -8.0546913
+ 2840.000013ps      -8.0611996
+ 2850.000014ps      -8.0865501
+ 2860.000015ps      -8.0703487
+ 2870.000015ps      -8.0423088
+ 2880.000016ps      -7.9879376
+ 2890.000017ps       -7.913787
+ 2900.000018ps      -7.8370994
+ 2910.000019ps      -7.7824481
+ 2920.000020ps      -7.7439233
+ 2930.000020ps      -7.7400803
+ 2940.000021ps      -7.7520484
+ 2950.000022ps      -7.7892052
+ 2960.000023ps      -7.8339818
+ 2970.000024ps      -7.8554161
+ 2980.000025ps      -7.8815104
+ 2990.000025ps      -7.9182933
+ 3000.000026ps      -7.9809037
+ 3010.000027ps      -8.0250659
+ 3020.000028ps      -8.1017747
+ 3030.000029ps      -8.1646068
+ 3040.000029ps      -8.2110146
+ 3050.000030ps      -8.2358851
+ 3060.000031ps      -8.2046932
+ 3070.000032ps      -8.1510048
+ 3080.000033ps      -8.0856751
+ 3090.000034ps       -8.019577
+ 3100.000034ps      -7.9377944
+ 3110.000035ps      -7.8938826
+ 3120.000036ps      -7.8730713
+ 3130.000037ps      -7.8722915
+ 3140.000038ps      -7.8825013
+ 3150.000039ps      -7.9006289
+ 3160.000039ps       -7.912567
+ 3170.000040ps       -7.925241
+ 3180.000041ps      -7.9553666
+ 3190.000042ps      -7.9801369
+ 3200.000043ps      -7.9948554
+ 3210.000044ps      -7.9824544
+ 3220.000044ps      -7.9830193
+ 3230.000045ps      -7.9885071
+ 3240.000046ps      -7.9943067
+ 3250.000047ps      -7.9776841
+ 3260.000048ps       -7.953487
+ 3270.000049ps       -7.953085
+ 3280.000049ps      -7.9452497
+ 3290.000050ps      -7.9424959
+ 3300.000051ps      -7.9424759
+ 3310.000052ps      -7.9467455
+ 3320.000053ps      -7.9723564
+ 3330.000053ps      -7.9660054
+ 3340.000054ps      -7.9736228
+ 3350.000055ps      -7.9719388
+ 3360.000056ps      -7.9674384
+ 3370.000057ps      -7.9790511
+ 3380.000058ps      -7.9873971
+ 3390.000058ps      -8.0009753
+ 3400.000059ps      -7.9866493
+ 3410.000060ps      -7.9797497
+ 3420.000061ps      -7.9560487
+ 3430.000062ps      -7.9297828
+ 3440.000063ps      -7.9216122
+ 3450.000063ps      -7.9036596
+ 3460.000064ps       -7.916133
+ 3470.000065ps      -7.9330029
+ 3480.000066ps      -7.9188263
+ 3490.000067ps      -7.9261581
+ 3500.000068ps      -7.9304558
+ 3510.000068ps      -7.9164041
+ 3520.000069ps      -7.9218163
+ 3530.000070ps      -7.9570308
+ 3540.000071ps      -7.9791579
+ 3550.000072ps      -7.9986546
+ 3560.000073ps      -8.0360802
+ 3570.000073ps      -8.0468451
+ 3580.000074ps      -8.0700494
+ 3590.000075ps      -8.0588663
+ 3600.000076ps      -8.0481028
+ 3610.000077ps      -8.0515353
+ 3620.000077ps       -8.041256
+ 3630.000078ps      -8.0329459
+ 3640.000079ps      -8.0324355
+ 3650.000080ps      -8.0207659
+ 3660.000081ps      -8.0234903
+ 3670.000082ps      -8.0057456
+ 3680.000082ps      -8.0161071
+ 3690.000083ps      -8.0180108
+ 3700.000084ps      -8.0215731
+ 3710.000085ps      -8.0207775
+ 3720.000086ps      -8.0379827
+ 3729.999865ps      -8.0586587
+ 3739.999865ps      -8.0650946
+ 3749.999866ps      -8.0664251
+ 3759.999867ps      -8.0609233
+ 3769.999868ps      -8.0166971
+ 3779.999869ps      -7.9829805
+ 3789.999869ps      -7.9466095
+ 3799.999870ps      -7.9158683
+ 3809.999871ps      -7.9019219
+ 3819.999872ps      -7.8930067
+ 3829.999873ps        -7.89985
+ 3839.999874ps      -7.9070105
+ 3849.999874ps      -7.9121664
+ 3859.999875ps      -7.9113376
+ 3869.999876ps      -7.8935328
+ 3879.999877ps      -7.8821338
+ 3889.999878ps      -7.8880203
+ 3899.999879ps      -7.9187159
+ 3909.999879ps      -7.9375661
+ 3919.999880ps      -7.9666121
+ 3929.999881ps      -7.9954312
+ 3939.999882ps      -7.9915885
+ 3949.999883ps      -7.9775473
+ 3959.999884ps      -7.9586159
+ 3969.999884ps      -7.9532426
+ 3979.999885ps      -7.9215666
+ 3989.999886ps      -7.9226115
+ 3999.999887ps      -7.9987905
+ 4009.999888ps      -8.1430442
+ 4019.999889ps       -8.423768
+ 4029.999889ps      -8.6888785
+ 4039.999890ps      -8.8977171
+ 4049.999891ps      -9.0772086
+ 4059.999892ps      -9.2303005
+ 4069.999893ps      -9.3144387
+ 4079.999893ps      -9.3797582
+ 4089.999894ps      -9.4368586
+ 4099.999895ps      -9.4786511
+ 4109.999896ps       -9.514832
+ 4119.999897ps      -9.4867762
+ 4129.999898ps      -9.4760343
+ 4139.999898ps      -9.4658014
+ 4149.999899ps      -9.4464343
+ 4159.999900ps      -9.4070311
+ 4169.999901ps       -9.349806
+ 4179.999902ps       -9.332046
+ 4189.999903ps      -9.3113553
+ 4199.999903ps      -9.2972838
+ 4209.999904ps      -9.3161607
+ 4219.999905ps       -9.354744
+ 4229.999906ps      -9.3994738
+ 4239.999907ps      -9.4307969
+ 4249.999908ps      -9.4699275
+ 4259.999908ps      -9.4826193
+ 4269.999909ps      -9.4816961
+ 4279.999910ps       -9.429457
+ 4289.999911ps      -9.3864542
+ 4299.999912ps      -9.3271329
+ 4309.999913ps      -9.2984392
+ 4319.999913ps      -9.2346736
+ 4329.999914ps      -9.1721926
+ 4339.999915ps      -9.1583131
+ 4349.999916ps      -9.1244449
+ 4359.999917ps      -9.0942097
+ 4369.999917ps       -9.083014
+ 4379.999918ps      -9.0747555
+ 4389.999919ps       -9.043907
+ 4399.999920ps      -9.0223654
+ 4409.999921ps      -9.0291457
+ 4419.999922ps       -9.021123
+ 4429.999922ps      -8.9966671
+ 4439.999923ps      -8.9992778
+ 4449.999924ps      -9.0114585
+ 4459.999925ps      -9.0049466
+ 4469.999926ps      -8.9983813
+ 4479.999927ps      -9.0110081
+ 4489.999927ps      -9.0341622
+ 4499.999928ps      -9.0787848
+ 4509.999929ps      -9.0895593
+ 4519.999930ps      -9.0889145
+ 4529.999931ps      -9.0805022
+ 4539.999932ps       -9.087975
+ 4549.999932ps      -9.1199412
+ 4559.999933ps      -9.1098799
+ 4569.999934ps      -9.1144463
+ 4579.999935ps      -9.0877141
+ 4589.999936ps      -9.0663396
+ 4599.999937ps      -9.0352368
+ 4609.999937ps      -9.0137201
+ 4619.999938ps      -9.0045926
+ 4629.999939ps      -9.0273244
+ 4639.999940ps      -9.0547632
+ 4649.999941ps      -9.0854847
+ 4659.999941ps      -9.1005274
+ 4669.999942ps      -9.1084756
+ 4679.999943ps      -9.0697731
+ 4689.999944ps      -9.0815891
+ 4699.999945ps      -9.0846473
+ 4709.999946ps      -9.1047782
+ 4719.999946ps      -9.1253981
+ 4729.999947ps      -9.0981821
+ 4739.999948ps      -9.0928021
+ 4749.999949ps      -9.0832083
+ 4759.999950ps      -9.0857585
+ 4769.999951ps      -9.0856886
+ 4779.999951ps       -9.086108
+ 4789.999952ps      -9.0922809
+ 4799.999953ps      -9.0851609
+ 4809.999954ps      -9.0363096
+ 4819.999955ps      -9.0237642
+ 4829.999956ps      -8.9934454
+ 4839.999956ps       -8.988732
+ 4849.999957ps      -8.9632043
+ 4859.999958ps      -8.9641188
+ 4869.999959ps      -8.9518707
+ 4879.999960ps      -8.9672769
+ 4889.999961ps      -8.9878609
+ 4899.999961ps      -8.9735942
+ 4909.999962ps       -8.976863
+ 4919.999963ps      -8.9629402
+ 4929.999964ps      -8.9209949
+ 4939.999965ps      -8.9293801
+ 4949.999965ps      -8.8994208
+ 4959.999966ps      -8.8790999
+ 4969.999967ps       -8.846185
+ 4979.999968ps      -8.7732738
+ 4989.999969ps      -8.6557189
+ 4999.999970ps       -8.547645
+ 5009.999970ps       -8.464888
+ 5019.999971ps      -8.3716033
+ 5029.999972ps      -8.2870406
+ 5039.999973ps      -8.2094604
+ 5049.999974ps      -8.1481755
+ 5059.999975ps      -8.1057753
+ 5069.999975ps      -8.0657103
+ 5079.999976ps      -8.0213932
+ 5089.999977ps      -7.9587678
+ 5099.999978ps      -7.8932986
+ 5109.999979ps      -7.8227325
+ 5119.999980ps      -7.7658553
+ 5129.999980ps      -7.7094862
+ 5139.999981ps       -7.654299
+ 5149.999982ps      -7.5830689
+ 5159.999983ps      -7.5176134
+ 5169.999984ps      -7.4566166
+ 5179.999985ps      -7.4309512
+ 5189.999985ps      -7.4324778
+ 5199.999986ps      -7.4254779
+ 5209.999987ps      -7.4351408
+ 5219.999988ps      -7.4592009
+ 5229.999989ps      -7.4681446
+ 5239.999989ps      -7.4779302
+ 5249.999990ps      -7.4920534
+ 5259.999991ps      -7.4919466
+ 5269.999992ps      -7.4806115
+ 5279.999993ps      -7.4832281
+ 5289.999994ps      -7.4623248
+ 5299.999994ps      -7.4371616
+ 5309.999995ps      -7.3817531
+ 5319.999996ps      -7.3400745
+ 5329.999997ps      -7.3258418
+ 5339.999998ps      -7.3233464
+ 5349.999999ps      -7.3215843
+ 5359.999999ps      -7.3229363
+ 5370.000000ps      -7.3302285
+ 5380.000001ps      -7.3308891
+ 5390.000002ps      -7.3319795
+ 5400.000003ps      -7.3160011
+ 5410.000004ps      -7.3146242
+ 5420.000004ps      -7.2990646
+ 5430.000005ps      -7.2957675
+ 5440.000006ps      -7.2957587
+ 5450.000007ps      -7.2826883
+ 5460.000008ps        -7.25523
+ 5470.000009ps      -7.2417042
+ 5480.000009ps      -7.2223758
+ 5490.000010ps      -7.2010412
+ 5500.000011ps      -7.1946468
+ 5510.000012ps      -7.2037198
+ 5520.000013ps      -7.2288417
+ 5530.000013ps      -7.2555444
+ 5540.000014ps      -7.2619515
+ 5550.000015ps      -7.2488081
+ 5560.000016ps       -7.229562
+ 5570.000017ps      -7.2329142
+ 5580.000018ps      -7.2297068
+ 5590.000018ps      -7.2273495
+ 5600.000019ps       -7.229334
+ 5610.000020ps      -7.2246299
+ 5620.000021ps      -7.2302275
+ 5630.000022ps       -7.244282
+ 5640.000023ps      -7.2245427
+ 5650.000023ps      -7.2021904
+ 5660.000024ps      -7.2045671
+ 5670.000025ps      -7.2257354
+ 5680.000026ps      -7.2635707
+ 5690.000027ps      -7.2589962
+ 5700.000028ps      -7.2650192
+ 5710.000028ps      -7.2567912
+ 5720.000029ps      -7.2513071
+ 5730.000030ps      -7.2297496
+ 5740.000031ps      -7.2115407
+ 5750.000032ps      -7.2005318
+ 5760.000033ps      -7.2181854
+ 5770.000033ps      -7.2360949
+ 5780.000034ps      -7.2716253
+ 5790.000035ps      -7.2841599
+ 5800.000036ps      -7.3058098
+ 5810.000037ps      -7.2928746
+ 5820.000037ps      -7.2399582
+ 5830.000038ps       -7.189831
+ 5840.000039ps      -7.1574552
+ 5850.000040ps      -7.1472378
+ 5860.000041ps      -7.1162576
+ 5870.000042ps      -7.0981477
+ 5880.000042ps      -7.1001285
+ 5890.000043ps      -7.1086408
+ 5900.000044ps      -7.1364491
+ 5910.000045ps      -7.1595213
+ 5920.000046ps      -7.1650261
+ 5930.000047ps      -7.1638446
+ 5940.000047ps      -7.1436059
+ 5950.000048ps      -7.1418256
+ 5960.000049ps      -7.1506937
+ 5970.000050ps      -7.1556485
+ 5980.000051ps      -7.1521498
+ 5990.000052ps      -7.1301223
+ 6000.000052ps      -7.1133191
+ 6010.000053ps      -7.0741831
+ 6020.000054ps      -7.0353395
+ 6030.000055ps      -6.9898794
+ 6040.000056ps      -6.9344171
+ 6050.000056ps      -6.9056719
+ 6060.000057ps      -6.8885226
+ 6070.000058ps       -6.892029
+ 6080.000059ps      -6.8935166
+ 6090.000060ps      -6.9184369
+ 6100.000061ps      -6.9316824
+ 6110.000061ps      -6.9415445
+ 6120.000062ps       -6.986031
+ 6130.000063ps      -7.0321626
+ 6140.000064ps      -7.0735528
+ 6150.000065ps      -7.0891106
+ 6160.000066ps      -7.0938243
+ 6170.000066ps      -7.0653096
+ 6180.000067ps       -7.039202
+ 6190.000068ps      -7.0332205
+ 6200.000069ps      -7.0230928
+ 6210.000070ps      -7.0264124
+ 6220.000071ps      -7.0129693
+ 6230.000071ps      -7.0151988
+ 6240.000072ps      -7.0434982
+ 6250.000073ps      -7.0645356
+ 6260.000074ps      -7.0721839
+ 6270.000075ps      -7.0672424
+ 6280.000076ps      -7.0755659
+ 6290.000076ps      -7.0790524
+ 6300.000077ps      -7.0836045
+ 6310.000078ps      -7.1068839
+ 6320.000079ps       -7.129091
+ 6330.000080ps      -7.1442112
+ 6340.000080ps      -7.1632758
+ 6350.000081ps      -7.1948501
+ 6360.000082ps      -7.2183564
+ 6370.000083ps      -7.2215856
+ 6380.000084ps      -7.2167726
+ 6390.000085ps       -7.219403
+ 6400.000085ps      -7.2221198
+ 6410.000086ps      -7.2420048
+ 6420.000087ps      -7.2523323
+ 6430.000088ps      -7.2522326
+ 6440.000089ps      -7.2345324
+ 6450.000090ps      -7.2171926
+ 6460.000090ps      -7.2323713
+ 6470.000091ps      -7.2571641
+ 6480.000092ps      -7.2651323
+ 6490.000093ps      -7.2826098
+ 6500.000094ps      -7.2929653
+ 6510.000095ps      -7.3121456
+ 6520.000095ps      -7.3039979
+ 6530.000096ps      -7.2784103
+ 6540.000097ps      -7.2423974
+ 6550.000098ps      -7.2297022
+ 6560.000099ps      -7.2195341
+ 6570.000100ps      -7.2239424
+ 6580.000100ps      -7.2496596
+ 6590.000101ps      -7.2516557
+ 6600.000102ps      -7.2546793
+ 6610.000103ps      -7.2607242
+ 6620.000104ps      -7.2574974
+ 6630.000104ps      -7.2562207
+ 6640.000105ps       -7.257855
+ 6650.000106ps      -7.2825638
+ 6660.000107ps      -7.2914882
+ 6670.000108ps      -7.2686857
+ 6680.000109ps      -7.2696651
+ 6690.000109ps      -7.2570097
+ 6700.000110ps      -7.2641913
+ 6710.000111ps      -7.2656268
+ 6720.000112ps      -7.2392068
+ 6730.000113ps       -7.221006
+ 6740.000114ps      -7.1988038
+ 6750.000114ps      -7.2103838
+ 6760.000115ps      -7.2221057
+ 6770.000116ps      -7.2160296
+ 6780.000117ps      -7.2078274
+ 6790.000118ps      -7.2057828
+ 6800.000119ps      -7.1949721
+ 6810.000119ps       -7.197778
+ 6820.000120ps      -7.2066449
+ 6830.000121ps       -7.232085
+ 6840.000122ps      -7.2339859
+ 6850.000123ps      -7.2632748
+ 6860.000124ps      -7.2483958
+ 6870.000124ps      -7.2183797
+ 6880.000125ps      -7.1469587
+ 6890.000126ps      -7.0658532
+ 6900.000127ps       -6.999334
+ 6910.000128ps      -6.9441195
+ 6920.000128ps      -6.9128968
+ 6930.000129ps      -6.9049071
+ 6940.000130ps      -6.9204604
+ 6950.000131ps      -6.9502911
+ 6960.000132ps      -6.9779243
+ 6970.000133ps      -7.0014324
+ 6980.000133ps      -7.0117977
+ 6990.000134ps      -7.0474436
+ 7000.000135ps       -7.097561
+ 7010.000136ps      -7.1526892
+ 7020.000137ps      -7.2279826
+ 7030.000138ps      -7.3006412
+ 7040.000138ps      -7.3491496
+ 7050.000139ps      -7.3694312
+ 7060.000140ps      -7.3625867
+ 7070.000141ps      -7.3194275
+ 7080.000142ps       -7.262965
+ 7090.000143ps       -7.190662
+ 7100.000143ps      -7.1207715
+ 7110.000144ps      -7.0684737
+ 7120.000145ps      -7.0554033
+ 7130.000146ps      -7.0569015
+ 7140.000147ps       -7.072543
+ 7150.000147ps      -7.0935387
+ 7160.000148ps      -7.1129597
+ 7170.000149ps      -7.1227574
+ 7180.000150ps       -7.131254
+ 7190.000151ps      -7.1522243
+ 7200.000152ps      -7.1592535
+ 7210.000152ps      -7.1608324
+ 7220.000153ps      -7.1552242
+ 7230.000154ps      -7.1342052
+ 7240.000155ps      -7.1455107
+ 7250.000156ps      -7.1456152
+ 7260.000157ps      -7.1260862
+ 7270.000157ps      -7.1222047
+ 7280.000158ps      -7.1201385
+ 7290.000159ps      -7.1211483
+ 7300.000160ps      -7.1208656
+ 7310.000161ps      -7.1300222
+ 7320.000162ps      -7.1414354
+ 7330.000162ps      -7.1441691
+ 7340.000163ps      -7.1374134
+ 7350.000164ps      -7.1501511
+ 7360.000165ps      -7.1410071
+ 7370.000166ps      -7.1476976
+ 7380.000167ps      -7.1508006
+ 7390.000167ps      -7.1445761
+ 7400.000168ps      -7.1129084
+ 7410.000169ps      -7.0713589
+ 7420.000170ps       -7.030473
+ 7430.000171ps        -7.01489
+ 7440.000171ps       -7.013624
+ 7450.000172ps      -7.0219083
+ 7459.999729ps      -7.0502394
+ 7469.999730ps      -7.0641803
+ 7479.999731ps      -7.0757079
+ 7489.999732ps      -7.0807419
+ 7499.999732ps       -7.088163
+ 7509.999733ps      -7.0964739
+ 7519.999734ps      -7.0928028
+ 7529.999735ps      -7.1273317
+ 7539.999736ps      -7.1553423
+ 7549.999737ps      -7.1971115
+ 7559.999737ps      -7.2278179
+ 7569.999738ps      -7.2641105
+ 7579.999739ps      -7.3070219
+ 7589.999740ps      -7.2951872
+ 7599.999741ps      -7.2839544
+ 7609.999741ps      -7.2654668
+ 7619.999742ps      -7.2315551
+ 7629.999743ps      -7.2153077
+ 7639.999744ps      -7.2099585
+ 7649.999745ps      -7.2151785
+ 7659.999746ps      -7.2098786
+ 7669.999746ps      -7.1864406
+ 7679.999747ps      -7.1924359
+ 7689.999748ps      -7.1976293
+ 7699.999749ps      -7.2027762
+ 7709.999750ps       -7.189068
+ 7719.999751ps      -7.2142119
+ 7729.999751ps       -7.235782
+ 7739.999752ps      -7.2507772
+ 7749.999753ps      -7.2579377
+ 7759.999754ps      -7.2458838
+ 7769.999755ps      -7.1913385
+ 7779.999756ps      -7.1489981
+ 7789.999756ps      -7.1209221
+ 7799.999757ps      -7.0847332
+ 7809.999758ps      -7.0520242
+ 7819.999759ps      -7.0349393
+ 7829.999760ps      -7.0215004
+ 7839.999761ps      -7.0206069
+ 7849.999761ps      -7.0335622
+ 7859.999762ps      -7.0422054
+ 7869.999763ps       -7.036823
+ 7879.999764ps      -7.0422406
+ 7889.999765ps      -7.0544664
+ 7899.999765ps      -7.0792763
+ 7909.999766ps      -7.1017898
+ 7919.999767ps      -7.1252069
+ 7929.999768ps      -7.1590588
+ 7939.999769ps      -7.1770639
+ 7949.999770ps      -7.1711761
+ 7959.999770ps      -7.1557441
+ 7969.999771ps      -7.1388686
+ 7979.999772ps      -7.1372783
+ 7989.999773ps      -7.2229011
+)

Icursig3 PAR_1_0_VDD075CPU 0 pwl(
+ 0.000000ps       5.5889509
+ 10.000000ps       5.7427575
+ 20.000000ps       6.1527518
+ 29.999999ps       6.6621395
+ 40.000000ps       7.1673122
+ 50.000001ps        7.641559
+ 59.999998ps       8.0928226
+ 69.999999ps       8.4606139
+ 80.000000ps       8.8070198
+ 90.000001ps       9.1001447
+ 100.000001ps         9.34969
+ 110.000002ps       9.5472159
+ 119.999996ps       9.6742597
+ 129.999997ps       9.7688489
+ 139.999998ps       9.8205204
+ 149.999999ps       9.8804942
+ 159.999999ps       9.9298991
+ 170.000000ps       9.9804987
+ 180.000001ps       10.052988
+ 190.000002ps       10.126577
+ 200.000003ps       10.197297
+ 210.000003ps       10.275542
+ 220.000004ps       10.364808
+ 230.000005ps       10.476104
+ 239.999992ps       10.564932
+ 249.999993ps       10.664462
+ 259.999994ps       10.768935
+ 269.999995ps        10.86212
+ 279.999995ps       10.942642
+ 289.999996ps       10.997858
+ 299.999997ps        11.00914
+ 309.999998ps       11.010235
+ 319.999999ps       10.986727
+ 330.000000ps       10.976942
+ 340.000000ps        10.97071
+ 350.000001ps       10.985516
+ 360.000002ps       10.988156
+ 370.000003ps       11.009889
+ 380.000004ps       11.034761
+ 390.000005ps       11.041411
+ 400.000005ps       11.053496
+ 410.000006ps       11.043526
+ 420.000007ps       11.042774
+ 430.000008ps       11.056913
+ 440.000009ps       11.089895
+ 450.000009ps       11.143161
+ 460.000010ps       11.184863
+ 469.999983ps       11.243284
+ 479.999984ps       11.303672
+ 489.999985ps       11.383781
+ 499.999986ps       11.463183
+ 509.999987ps       11.485321
+ 519.999988ps       11.478995
+ 529.999988ps       11.469039
+ 539.999989ps       11.459254
+ 549.999990ps       11.461096
+ 559.999991ps       11.442476
+ 569.999992ps       11.421867
+ 579.999992ps       11.383288
+ 589.999993ps       11.351074
+ 599.999994ps       11.306441
+ 609.999995ps       11.266426
+ 619.999996ps        11.24166
+ 629.999997ps       11.245717
+ 639.999997ps        11.25738
+ 649.999998ps       11.272191
+ 659.999999ps        11.27932
+ 670.000000ps       11.283593
+ 680.000001ps       11.289049
+ 690.000002ps       11.313752
+ 700.000002ps       11.329324
+ 710.000003ps       11.377541
+ 720.000004ps       11.376709
+ 730.000005ps       11.360258
+ 740.000006ps       11.351682
+ 750.000007ps       11.353084
+ 760.000007ps       11.365032
+ 770.000008ps       11.347504
+ 780.000009ps       11.341871
+ 790.000010ps       11.358378
+ 800.000011ps       11.321241
+ 810.000012ps       11.286414
+ 820.000012ps       11.263521
+ 830.000013ps        11.24382
+ 840.000014ps       11.238322
+ 850.000015ps       11.216272
+ 860.000016ps       11.216427
+ 870.000016ps       11.237186
+ 880.000017ps       11.268093
+ 890.000018ps       11.294641
+ 900.000019ps       11.310141
+ 910.000020ps       11.328915
+ 920.000021ps       11.308247
+ 930.000021ps       11.261139
+ 939.999967ps       11.233471
+ 949.999968ps       11.208544
+ 959.999968ps       11.168155
+ 969.999969ps       11.125917
+ 979.999970ps         11.0603
+ 989.999971ps       10.961792
+ 999.999972ps       10.882386
+ 1009.999973ps       10.816729
+ 1019.999973ps       10.750639
+ 1029.999974ps       10.680093
+ 1039.999975ps       10.600691
+ 1049.999976ps       10.535177
+ 1059.999977ps       10.482946
+ 1069.999978ps       10.407941
+ 1079.999978ps       10.328331
+ 1089.999979ps       10.248045
+ 1099.999980ps       10.176387
+ 1109.999981ps       10.104835
+ 1119.999982ps       10.030837
+ 1129.999982ps       9.9525759
+ 1139.999983ps       9.8899991
+ 1149.999984ps       9.7917759
+ 1159.999985ps       9.7079414
+ 1169.999986ps       9.6517407
+ 1179.999987ps       9.6104514
+ 1189.999987ps       9.5951444
+ 1199.999988ps       9.5681468
+ 1209.999989ps        9.567932
+ 1219.999990ps       9.5778429
+ 1229.999991ps       9.5760566
+ 1239.999992ps       9.5744146
+ 1249.999992ps       9.5869302
+ 1259.999993ps       9.5799657
+ 1269.999994ps       9.5659241
+ 1279.999995ps       9.5720969
+ 1289.999996ps       9.5468819
+ 1299.999997ps       9.5319015
+ 1309.999997ps       9.5214387
+ 1319.999998ps       9.5290513
+ 1329.999999ps       9.5519316
+ 1340.000000ps       9.5459956
+ 1350.000001ps       9.5149238
+ 1360.000002ps       9.4818746
+ 1370.000002ps       9.4602925
+ 1380.000003ps       9.4232593
+ 1390.000004ps        9.367712
+ 1400.000005ps       9.3074819
+ 1410.000006ps       9.2713856
+ 1420.000006ps       9.2523689
+ 1430.000007ps       9.2321376
+ 1440.000008ps       9.2000757
+ 1450.000009ps       9.1650714
+ 1460.000010ps       9.1262337
+ 1470.000011ps       9.1118506
+ 1480.000011ps       9.0937091
+ 1490.000012ps       9.0872041
+ 1500.000013ps        9.080376
+ 1510.000014ps       9.0848099
+ 1520.000015ps       9.1047338
+ 1530.000016ps       9.1371666
+ 1540.000016ps       9.1272948
+ 1550.000017ps       9.1012522
+ 1560.000018ps       9.0815749
+ 1570.000019ps       9.0740423
+ 1580.000020ps       9.0677094
+ 1590.000021ps       9.0536407
+ 1600.000021ps        9.048383
+ 1610.000022ps       9.0544602
+ 1620.000023ps       9.0529326
+ 1630.000024ps       9.0635425
+ 1640.000025ps       9.0390389
+ 1650.000025ps       9.0206548
+ 1660.000026ps        9.033626
+ 1670.000027ps        9.048506
+ 1680.000028ps       9.0765317
+ 1690.000029ps       9.0810642
+ 1700.000030ps       9.1017091
+ 1710.000030ps       9.1095889
+ 1720.000031ps       9.1177631
+ 1730.000032ps       9.1179837
+ 1740.000033ps       9.1154715
+ 1750.000034ps        9.107832
+ 1760.000035ps       9.1027719
+ 1770.000035ps       9.1096402
+ 1780.000036ps       9.1234752
+ 1790.000037ps       9.1301883
+ 1800.000038ps        9.125555
+ 1810.000039ps       9.0760313
+ 1820.000040ps       9.0247423
+ 1830.000040ps       8.9886037
+ 1840.000041ps       8.9730191
+ 1850.000042ps       8.9622651
+ 1860.000043ps       8.9224806
+ 1869.999933ps       8.8933123
+ 1879.999934ps       8.8643056
+ 1889.999934ps       8.8558816
+ 1899.999935ps        8.861306
+ 1909.999936ps       8.8619168
+ 1919.999937ps       8.8508085
+ 1929.999938ps       8.8449081
+ 1939.999938ps       8.8481617
+ 1949.999939ps       8.8778895
+ 1959.999940ps       8.9104296
+ 1969.999941ps       8.9229947
+ 1979.999942ps       8.9118931
+ 1989.999943ps       8.8873252
+ 1999.999943ps       8.8568677
+ 2009.999944ps       8.8131227
+ 2019.999945ps        8.773061
+ 2029.999946ps       8.7302605
+ 2039.999947ps       8.6942293
+ 2049.999948ps       8.6662693
+ 2059.999948ps       8.6548889
+ 2069.999949ps       8.6616299
+ 2079.999950ps       8.6759658
+ 2089.999951ps       8.7011805
+ 2099.999952ps       8.7107443
+ 2109.999953ps       8.7400715
+ 2119.999953ps        8.813539
+ 2129.999954ps       8.8916143
+ 2139.999955ps       8.9786253
+ 2149.999956ps       9.0387347
+ 2159.999957ps       9.1032471
+ 2169.999958ps       9.0993989
+ 2179.999958ps       9.0568904
+ 2189.999959ps       9.0021962
+ 2199.999960ps        8.949405
+ 2209.999961ps       8.9273296
+ 2219.999962ps       8.8712914
+ 2229.999962ps        8.854542
+ 2239.999963ps       8.8783443
+ 2249.999964ps       8.8814731
+ 2259.999965ps       8.8821365
+ 2269.999966ps        8.861699
+ 2279.999967ps        8.865519
+ 2289.999967ps       8.8691619
+ 2299.999968ps       8.8524306
+ 2309.999969ps       8.8527847
+ 2319.999970ps       8.8676747
+ 2329.999971ps       8.8800254
+ 2339.999972ps       8.9042038
+ 2349.999972ps       8.9288258
+ 2359.999973ps       8.9562428
+ 2369.999974ps       8.9734086
+ 2379.999975ps       8.9675637
+ 2389.999976ps        8.959876
+ 2399.999977ps       8.9780298
+ 2409.999977ps       9.0073925
+ 2419.999978ps       9.0363442
+ 2429.999979ps         9.03324
+ 2439.999980ps       9.0248135
+ 2449.999981ps       9.0269643
+ 2459.999982ps       9.0469034
+ 2469.999982ps       9.0636608
+ 2479.999983ps       9.0656571
+ 2489.999984ps        9.062404
+ 2499.999985ps       9.0676601
+ 2509.999986ps       9.0715557
+ 2519.999986ps       9.0683167
+ 2529.999987ps       9.0495606
+ 2539.999988ps       9.0371909
+ 2549.999989ps       9.0390858
+ 2559.999990ps       9.0548798
+ 2569.999991ps       9.0929602
+ 2579.999991ps       9.1065555
+ 2589.999992ps       9.1121259
+ 2599.999993ps       9.0959323
+ 2609.999994ps       9.0884901
+ 2619.999995ps       9.0743487
+ 2629.999996ps       9.0859833
+ 2639.999996ps       9.0898072
+ 2649.999997ps       9.0952509
+ 2659.999998ps        9.097982
+ 2669.999999ps       9.0592074
+ 2680.000000ps       9.0435933
+ 2690.000001ps       9.0225168
+ 2700.000001ps       9.0043818
+ 2710.000002ps       8.9955511
+ 2720.000003ps       8.9645239
+ 2730.000004ps       8.9530082
+ 2740.000005ps       8.9337698
+ 2750.000005ps       8.9419974
+ 2760.000006ps       8.9509091
+ 2770.000007ps       8.9474582
+ 2780.000008ps       8.9442769
+ 2790.000009ps       8.9392471
+ 2800.000010ps        8.949107
+ 2810.000010ps       8.9617782
+ 2820.000011ps       8.9740268
+ 2830.000012ps       8.9940205
+ 2840.000013ps       9.0187094
+ 2850.000014ps       9.0370388
+ 2860.000015ps       9.0257194
+ 2870.000015ps       8.9897374
+ 2880.000016ps       8.9121537
+ 2890.000017ps        8.837582
+ 2900.000018ps       8.7658207
+ 2910.000019ps        8.709861
+ 2920.000020ps       8.6986444
+ 2930.000020ps        8.707546
+ 2940.000021ps        8.748813
+ 2950.000022ps       8.7959019
+ 2960.000023ps       8.8576572
+ 2970.000024ps        8.920627
+ 2980.000025ps       8.9935816
+ 2990.000025ps       9.0803477
+ 3000.000026ps       9.1726533
+ 3010.000027ps       9.2368792
+ 3020.000028ps       9.2783542
+ 3030.000029ps       9.3113148
+ 3040.000029ps        9.287891
+ 3050.000030ps       9.2619395
+ 3060.000031ps       9.2018025
+ 3070.000032ps       9.1347745
+ 3080.000033ps       9.0310846
+ 3090.000034ps        8.949812
+ 3100.000034ps       8.8627732
+ 3110.000035ps       8.8204263
+ 3120.000036ps       8.8114159
+ 3130.000037ps       8.8196739
+ 3140.000038ps       8.8363803
+ 3150.000039ps       8.8421057
+ 3160.000039ps       8.8491023
+ 3170.000040ps       8.8589112
+ 3180.000041ps       8.8670575
+ 3190.000042ps       8.8790117
+ 3200.000043ps        8.875965
+ 3210.000044ps       8.8706034
+ 3220.000044ps       8.8647066
+ 3230.000045ps       8.8648063
+ 3240.000046ps       8.8665608
+ 3250.000047ps       8.8714492
+ 3260.000048ps       8.8720171
+ 3270.000049ps       8.8785173
+ 3280.000049ps       8.8783226
+ 3290.000050ps       8.8716901
+ 3300.000051ps       8.8783649
+ 3310.000052ps       8.8759029
+ 3320.000053ps       8.8703488
+ 3330.000053ps       8.8533435
+ 3340.000054ps       8.8610332
+ 3350.000055ps       8.8680342
+ 3360.000056ps        8.864064
+ 3370.000057ps       8.8991312
+ 3380.000058ps       8.9224902
+ 3390.000058ps        8.940042
+ 3400.000059ps       8.9372032
+ 3410.000060ps       8.9034825
+ 3420.000061ps       8.8873987
+ 3430.000062ps       8.8705775
+ 3440.000063ps       8.8659688
+ 3450.000063ps       8.8659285
+ 3460.000064ps       8.8612131
+ 3470.000065ps       8.8482963
+ 3480.000066ps       8.8314973
+ 3490.000067ps          8.8222
+ 3500.000068ps       8.8029988
+ 3510.000068ps       8.7853096
+ 3520.000069ps         8.77108
+ 3530.000070ps       8.8138415
+ 3540.000071ps        8.819705
+ 3550.000072ps       8.8421032
+ 3560.000073ps       8.8804677
+ 3570.000073ps       8.9107985
+ 3580.000074ps       8.9479155
+ 3590.000075ps        8.930786
+ 3600.000076ps       8.9307531
+ 3610.000077ps       8.9337909
+ 3620.000077ps       8.9153837
+ 3630.000078ps       8.9076859
+ 3640.000079ps       8.9043857
+ 3650.000080ps       8.8977147
+ 3660.000081ps       8.8857723
+ 3670.000082ps       8.8649707
+ 3680.000082ps       8.8529684
+ 3690.000083ps       8.8573772
+ 3700.000084ps       8.8685531
+ 3710.000085ps       8.8737031
+ 3720.000086ps       8.8994585
+ 3729.999865ps       8.9245333
+ 3739.999865ps       8.9366446
+ 3749.999866ps       8.9367945
+ 3759.999867ps        8.919501
+ 3769.999868ps       8.8883348
+ 3779.999869ps       8.8700232
+ 3789.999869ps       8.8741713
+ 3799.999870ps       8.8803853
+ 3809.999871ps       8.8890625
+ 3819.999872ps       8.9024041
+ 3829.999873ps          8.9322
+ 3839.999874ps       8.9429272
+ 3849.999874ps       8.9310977
+ 3859.999875ps       8.9116858
+ 3869.999876ps       8.8740966
+ 3879.999877ps       8.8514294
+ 3889.999878ps       8.8276726
+ 3899.999879ps       8.8277846
+ 3909.999879ps       8.8398922
+ 3919.999880ps       8.8544727
+ 3929.999881ps        8.879683
+ 3939.999882ps       8.8905904
+ 3949.999883ps       8.8813628
+ 3959.999884ps        8.848899
+ 3969.999884ps       8.8134375
+ 3979.999885ps        8.773977
+ 3989.999886ps       8.7489763
+ 3999.999887ps       8.8784897
+ 4009.999888ps       9.0910538
+ 4019.999889ps       9.2827698
+ 4029.999889ps       9.4066403
+ 4039.999890ps       9.4912536
+ 4049.999891ps       9.5885571
+ 4059.999892ps       9.6835057
+ 4069.999893ps       9.7205034
+ 4079.999893ps       9.7545539
+ 4089.999894ps       9.7877873
+ 4099.999895ps       9.8144171
+ 4109.999896ps       9.8281342
+ 4119.999897ps       9.8257565
+ 4129.999898ps       9.8397306
+ 4139.999898ps        9.827433
+ 4149.999899ps       9.7979201
+ 4159.999900ps       9.7540465
+ 4169.999901ps       9.6939694
+ 4179.999902ps       9.6551113
+ 4189.999903ps       9.6459277
+ 4199.999903ps       9.6590746
+ 4209.999904ps        9.690121
+ 4219.999905ps        9.731471
+ 4229.999906ps       9.7851853
+ 4239.999907ps       9.8364116
+ 4249.999908ps        9.870748
+ 4259.999908ps       9.8830814
+ 4269.999909ps       9.8616974
+ 4279.999910ps       9.8157925
+ 4289.999911ps       9.7759678
+ 4299.999912ps       9.7222195
+ 4309.999913ps       9.6636737
+ 4319.999913ps         9.59469
+ 4329.999914ps       9.5526295
+ 4339.999915ps         9.51286
+ 4349.999916ps       9.4940796
+ 4359.999917ps       9.4734031
+ 4369.999917ps       9.4762592
+ 4379.999918ps       9.4829347
+ 4389.999919ps       9.4628082
+ 4399.999920ps       9.4457493
+ 4409.999921ps       9.4151553
+ 4419.999922ps       9.3901547
+ 4429.999922ps       9.3883701
+ 4439.999923ps       9.3947785
+ 4449.999924ps       9.4094785
+ 4459.999925ps       9.4117557
+ 4469.999926ps       9.4260134
+ 4479.999927ps        9.434268
+ 4489.999927ps        9.461042
+ 4499.999928ps       9.4999146
+ 4509.999929ps       9.5231786
+ 4519.999930ps       9.5407985
+ 4529.999931ps       9.5447568
+ 4539.999932ps       9.5717683
+ 4549.999932ps       9.6055724
+ 4559.999933ps       9.6151417
+ 4569.999934ps       9.6167848
+ 4579.999935ps       9.6008952
+ 4589.999936ps       9.5883355
+ 4599.999937ps       9.5729222
+ 4609.999937ps       9.5611835
+ 4619.999938ps       9.5674026
+ 4629.999939ps       9.6075218
+ 4639.999940ps       9.6646454
+ 4649.999941ps       9.7278937
+ 4659.999941ps       9.7837573
+ 4669.999942ps       9.7920404
+ 4679.999943ps       9.7873278
+ 4689.999944ps       9.7721415
+ 4699.999945ps       9.7636141
+ 4709.999946ps       9.7798815
+ 4719.999946ps       9.7550001
+ 4729.999947ps       9.7182122
+ 4739.999948ps       9.6907677
+ 4749.999949ps       9.6796694
+ 4759.999950ps       9.6811731
+ 4769.999951ps       9.6578961
+ 4779.999951ps       9.6503346
+ 4789.999952ps       9.6767823
+ 4799.999953ps       9.6561258
+ 4809.999954ps       9.6175201
+ 4819.999955ps       9.6017253
+ 4829.999956ps        9.601144
+ 4839.999956ps       9.6036182
+ 4849.999957ps        9.582595
+ 4859.999958ps       9.5805498
+ 4869.999959ps       9.6015814
+ 4879.999960ps       9.6214132
+ 4889.999961ps       9.6401973
+ 4899.999961ps       9.6589596
+ 4909.999962ps       9.6666577
+ 4919.999963ps       9.6494363
+ 4929.999964ps       9.6184481
+ 4939.999965ps       9.6103651
+ 4949.999965ps        9.626448
+ 4959.999966ps       9.6262644
+ 4969.999967ps       9.6092073
+ 4979.999968ps        9.574262
+ 4989.999969ps       9.5229278
+ 4999.999970ps        9.501859
+ 5009.999970ps       9.4852387
+ 5019.999971ps       9.4909827
+ 5029.999972ps       9.5011341
+ 5039.999973ps       9.5095073
+ 5049.999974ps       9.5215818
+ 5059.999975ps       9.5459711
+ 5069.999975ps       9.5536615
+ 5079.999976ps       9.5594534
+ 5089.999977ps        9.542383
+ 5099.999978ps       9.5196205
+ 5109.999979ps       9.5003883
+ 5119.999980ps       9.4639768
+ 5129.999980ps        9.422444
+ 5139.999981ps       9.3931266
+ 5149.999982ps       9.3338783
+ 5159.999983ps       9.2880006
+ 5169.999984ps       9.2739903
+ 5179.999985ps       9.2642481
+ 5189.999985ps       9.2829523
+ 5199.999986ps       9.2854908
+ 5209.999987ps       9.3096705
+ 5219.999988ps       9.3408794
+ 5229.999989ps         9.36236
+ 5239.999989ps       9.3729234
+ 5249.999990ps       9.4048302
+ 5259.999991ps       9.4152871
+ 5269.999992ps       9.4089099
+ 5279.999993ps       9.4264899
+ 5289.999994ps       9.3943708
+ 5299.999994ps       9.3587885
+ 5309.999995ps       9.3114517
+ 5319.999996ps       9.2856001
+ 5329.999997ps        9.266855
+ 5339.999998ps       9.2574545
+ 5349.999999ps       9.2633534
+ 5359.999999ps       9.2757314
+ 5370.000000ps       9.3031228
+ 5380.000001ps       9.3037043
+ 5390.000002ps        9.295366
+ 5400.000003ps       9.2813298
+ 5410.000004ps       9.2730593
+ 5420.000004ps       9.2813246
+ 5430.000005ps       9.2856787
+ 5440.000006ps       9.2706489
+ 5450.000007ps       9.2620643
+ 5460.000008ps       9.2681394
+ 5470.000009ps        9.307989
+ 5480.000009ps       9.3514858
+ 5490.000010ps        9.402193
+ 5500.000011ps       9.4217929
+ 5510.000012ps       9.4250969
+ 5520.000013ps       9.4225068
+ 5530.000013ps       9.4302581
+ 5540.000014ps       9.3931309
+ 5550.000015ps       9.3231214
+ 5560.000016ps       9.2758687
+ 5570.000017ps       9.2421212
+ 5580.000018ps       9.2199116
+ 5590.000018ps       9.1992309
+ 5600.000019ps       9.1945436
+ 5610.000020ps       9.1992637
+ 5620.000021ps       9.1987756
+ 5630.000022ps       9.2070495
+ 5640.000023ps       9.1887799
+ 5650.000023ps       9.1818678
+ 5660.000024ps       9.1853778
+ 5670.000025ps       9.1977809
+ 5680.000026ps       9.2155239
+ 5690.000027ps       9.2167847
+ 5700.000028ps       9.2325365
+ 5710.000028ps        9.226476
+ 5720.000029ps       9.2164466
+ 5730.000030ps       9.2039609
+ 5740.000031ps       9.1884187
+ 5750.000032ps       9.1763599
+ 5760.000033ps       9.1736771
+ 5770.000033ps       9.1869961
+ 5780.000034ps       9.2106056
+ 5790.000035ps       9.2373527
+ 5800.000036ps       9.2563484
+ 5810.000037ps       9.2204008
+ 5820.000037ps       9.1825645
+ 5830.000038ps       9.1527116
+ 5840.000039ps       9.1398257
+ 5850.000040ps       9.1343526
+ 5860.000041ps       9.1086446
+ 5870.000042ps       9.0903067
+ 5880.000042ps       9.0752921
+ 5890.000043ps       9.0838901
+ 5900.000044ps       9.1032653
+ 5910.000045ps        9.122716
+ 5920.000046ps       9.1227356
+ 5930.000047ps       9.1111288
+ 5940.000047ps        9.111372
+ 5950.000048ps       9.1196044
+ 5960.000049ps       9.1319316
+ 5970.000050ps       9.1349955
+ 5980.000051ps       9.1287861
+ 5990.000052ps       9.1038114
+ 6000.000052ps       9.0687581
+ 6010.000053ps       9.0209133
+ 6020.000054ps       8.9671321
+ 6030.000055ps       8.9237935
+ 6040.000056ps       8.8854352
+ 6050.000056ps       8.8552857
+ 6060.000057ps       8.8443351
+ 6070.000058ps       8.8552129
+ 6080.000059ps       8.8592726
+ 6090.000060ps       8.8821554
+ 6100.000061ps       8.8881147
+ 6110.000061ps       8.9039441
+ 6120.000062ps       8.9565226
+ 6130.000063ps       9.0027634
+ 6140.000064ps       9.0435668
+ 6150.000065ps       9.0498258
+ 6160.000066ps       9.0739075
+ 6170.000066ps       9.0554415
+ 6180.000067ps       9.0192631
+ 6190.000068ps       8.9962618
+ 6200.000069ps       8.9712349
+ 6210.000070ps       8.9765031
+ 6220.000071ps       8.9527164
+ 6230.000071ps        8.962043
+ 6240.000072ps       9.0061714
+ 6250.000073ps       9.0194262
+ 6260.000074ps       9.0366726
+ 6270.000075ps       9.0412288
+ 6280.000076ps        9.069949
+ 6290.000076ps       9.1107378
+ 6300.000077ps       9.1426282
+ 6310.000078ps       9.1957334
+ 6320.000079ps        9.260395
+ 6330.000080ps       9.3100072
+ 6340.000080ps       9.3418258
+ 6350.000081ps       9.3551881
+ 6360.000082ps       9.3515837
+ 6370.000083ps       9.3346531
+ 6380.000084ps        9.287513
+ 6390.000085ps       9.2422726
+ 6400.000085ps       9.2250132
+ 6410.000086ps        9.232043
+ 6420.000087ps       9.2575466
+ 6430.000088ps       9.2493667
+ 6440.000089ps       9.2363447
+ 6450.000090ps       9.2357355
+ 6460.000090ps       9.2470619
+ 6470.000091ps       9.2610246
+ 6480.000092ps        9.266374
+ 6490.000093ps       9.2580239
+ 6500.000094ps       9.2614322
+ 6510.000095ps       9.2554413
+ 6520.000095ps       9.2500639
+ 6530.000096ps       9.2241831
+ 6540.000097ps       9.2075046
+ 6550.000098ps       9.1932211
+ 6560.000099ps       9.1960998
+ 6570.000100ps       9.2106722
+ 6580.000100ps       9.2148886
+ 6590.000101ps       9.2144824
+ 6600.000102ps       9.1991062
+ 6610.000103ps       9.2028398
+ 6620.000104ps       9.2062602
+ 6630.000104ps        9.230876
+ 6640.000105ps       9.2422004
+ 6650.000106ps       9.2560846
+ 6660.000107ps       9.2654034
+ 6670.000108ps       9.2388885
+ 6680.000109ps       9.2235431
+ 6690.000109ps       9.2064105
+ 6700.000110ps       9.1983272
+ 6710.000111ps       9.2022216
+ 6720.000112ps       9.1835688
+ 6730.000113ps       9.1925677
+ 6740.000114ps       9.1876954
+ 6750.000114ps       9.2100558
+ 6760.000115ps       9.2264121
+ 6770.000116ps        9.223456
+ 6780.000117ps       9.2064302
+ 6790.000118ps       9.1785367
+ 6800.000119ps       9.1694612
+ 6810.000119ps       9.1664604
+ 6820.000120ps       9.1765214
+ 6830.000121ps       9.1942553
+ 6840.000122ps        9.216521
+ 6850.000123ps       9.2271365
+ 6860.000124ps       9.2052213
+ 6870.000124ps       9.1599244
+ 6880.000125ps       9.0916698
+ 6890.000126ps        9.025725
+ 6900.000127ps       8.9531992
+ 6910.000128ps       8.8992972
+ 6920.000128ps        8.879112
+ 6930.000129ps       8.8771725
+ 6940.000130ps       8.9025084
+ 6950.000131ps       8.9332496
+ 6960.000132ps       8.9700518
+ 6970.000133ps       8.9876633
+ 6980.000133ps        9.015505
+ 6990.000134ps       9.0443769
+ 7000.000135ps       9.1095124
+ 7010.000136ps       9.1753256
+ 7020.000137ps       9.2395481
+ 7030.000138ps       9.2996664
+ 7040.000138ps       9.3225344
+ 7050.000139ps       9.3376778
+ 7060.000140ps       9.3107031
+ 7070.000141ps       9.2684634
+ 7080.000142ps        9.186506
+ 7090.000143ps       9.1156352
+ 7100.000143ps       9.0385562
+ 7110.000144ps       9.0160154
+ 7120.000145ps       9.0307307
+ 7130.000146ps       9.0760851
+ 7140.000147ps       9.1430462
+ 7150.000147ps       9.2052854
+ 7160.000148ps       9.2689045
+ 7170.000149ps         9.29842
+ 7180.000150ps       9.2993632
+ 7190.000151ps       9.2798472
+ 7200.000152ps       9.2534261
+ 7210.000152ps       9.2053381
+ 7220.000153ps       9.1662489
+ 7230.000154ps       9.1380163
+ 7240.000155ps       9.1130355
+ 7250.000156ps       9.0949362
+ 7260.000157ps       9.0770036
+ 7270.000157ps       9.0752772
+ 7280.000158ps       9.0684142
+ 7290.000159ps       9.0586818
+ 7300.000160ps       9.0581651
+ 7310.000161ps       9.0487569
+ 7320.000162ps       9.0427118
+ 7330.000162ps       9.0217518
+ 7340.000163ps       9.0348324
+ 7350.000164ps       9.0255107
+ 7360.000165ps       9.0147319
+ 7370.000166ps       9.0325484
+ 7380.000167ps       9.0474548
+ 7390.000167ps       9.0587009
+ 7400.000168ps       9.0456802
+ 7410.000169ps       9.0077897
+ 7420.000170ps       8.9863958
+ 7430.000171ps       8.9790562
+ 7440.000171ps       8.9841479
+ 7450.000172ps          8.9899
+ 7459.999729ps       8.9973475
+ 7469.999730ps       9.0024728
+ 7479.999731ps        8.994119
+ 7489.999732ps       8.9959779
+ 7499.999732ps       8.9831289
+ 7509.999733ps       8.9679107
+ 7519.999734ps       8.9698917
+ 7529.999735ps       9.0233307
+ 7539.999736ps       9.0424474
+ 7549.999737ps       9.0806336
+ 7559.999737ps       9.1456489
+ 7569.999738ps        9.199037
+ 7579.999739ps       9.2445605
+ 7589.999740ps        9.218615
+ 7599.999741ps       9.2091397
+ 7609.999741ps       9.2065569
+ 7619.999742ps        9.171456
+ 7629.999743ps       9.1436035
+ 7639.999744ps       9.1287558
+ 7649.999745ps       9.1023754
+ 7659.999746ps       9.0821281
+ 7669.999746ps       9.0602985
+ 7679.999747ps       9.0489994
+ 7689.999748ps       9.0507921
+ 7699.999749ps       9.0584926
+ 7709.999750ps       9.0638381
+ 7719.999751ps       9.0874568
+ 7729.999751ps       9.1127932
+ 7739.999752ps       9.1223269
+ 7749.999753ps       9.1191156
+ 7759.999754ps       9.0977767
+ 7769.999755ps       9.0592011
+ 7779.999756ps       9.0273143
+ 7789.999756ps       8.9951735
+ 7799.999757ps       8.9595562
+ 7809.999758ps       8.9196087
+ 7819.999759ps       8.8862553
+ 7829.999760ps       8.8768101
+ 7839.999761ps       8.8861048
+ 7849.999761ps        8.891637
+ 7859.999762ps       8.8979334
+ 7869.999763ps       8.8950122
+ 7879.999764ps       8.9029883
+ 7889.999765ps       8.9153184
+ 7899.999765ps       8.9426943
+ 7909.999766ps       8.9751562
+ 7919.999767ps       9.0163461
+ 7929.999768ps       9.0644743
+ 7939.999769ps       9.0920128
+ 7949.999770ps       9.1079203
+ 7959.999770ps       9.1203063
+ 7969.999771ps       9.1329349
+ 7979.999772ps       9.1345335
+ 7989.999773ps       9.1570127
+)

Icursig4 PAR_2_0_VSS 0 pwl(
+ 0.000000ps        -8.16882
+ 10.000000ps      -8.7512537
+ 20.000000ps      -9.8389188
+ 29.999999ps      -10.820055
+ 40.000000ps        -11.5717
+ 50.000001ps      -12.090081
+ 59.999998ps      -12.465081
+ 69.999999ps      -12.726736
+ 80.000000ps       -12.93232
+ 90.000001ps      -13.096358
+ 100.000001ps      -13.232937
+ 110.000002ps      -13.351775
+ 119.999996ps       -13.42331
+ 129.999997ps      -13.458599
+ 139.999998ps      -13.490222
+ 149.999999ps      -13.517806
+ 159.999999ps      -13.567775
+ 170.000000ps      -13.611865
+ 180.000001ps      -13.652525
+ 190.000002ps      -13.668201
+ 200.000003ps      -13.709848
+ 210.000003ps       -13.74095
+ 220.000004ps      -13.799182
+ 230.000005ps      -13.877533
+ 239.999992ps       -13.93347
+ 249.999993ps      -14.018962
+ 259.999994ps       -14.10574
+ 269.999995ps      -14.184892
+ 279.999995ps      -14.268178
+ 289.999996ps       -14.29237
+ 299.999997ps      -14.336044
+ 309.999998ps      -14.363193
+ 319.999999ps      -14.372729
+ 330.000000ps      -14.379993
+ 340.000000ps      -14.388878
+ 350.000001ps      -14.390126
+ 360.000002ps       -14.38883
+ 370.000003ps      -14.345331
+ 380.000004ps      -14.304453
+ 390.000005ps       -14.27115
+ 400.000005ps      -14.261556
+ 410.000006ps      -14.284216
+ 420.000007ps      -14.292315
+ 430.000008ps      -14.342495
+ 440.000009ps      -14.359389
+ 450.000009ps      -14.388795
+ 460.000010ps      -14.392561
+ 469.999983ps      -14.423383
+ 479.999984ps      -14.454485
+ 489.999985ps       -14.48014
+ 499.999986ps      -14.476513
+ 509.999987ps      -14.462392
+ 519.999988ps      -14.465952
+ 529.999988ps      -14.440848
+ 539.999989ps      -14.424478
+ 549.999990ps      -14.400471
+ 559.999991ps      -14.401264
+ 569.999992ps      -14.390466
+ 579.999992ps      -14.402021
+ 589.999993ps       -14.42331
+ 599.999994ps      -14.471946
+ 609.999995ps      -14.512824
+ 619.999996ps      -14.536995
+ 629.999997ps      -14.571052
+ 639.999997ps      -14.588118
+ 649.999998ps      -14.622782
+ 659.999999ps      -14.665252
+ 670.000000ps      -14.680573
+ 680.000001ps      -14.718862
+ 690.000002ps      -14.734292
+ 700.000002ps      -14.735585
+ 710.000003ps      -14.722303
+ 720.000004ps      -14.718202
+ 730.000005ps      -14.715171
+ 740.000006ps      -14.684403
+ 750.000007ps      -14.652186
+ 760.000007ps      -14.637178
+ 770.000008ps      -14.604593
+ 780.000009ps      -14.613526
+ 790.000010ps      -14.627397
+ 800.000011ps      -14.642033
+ 810.000012ps      -14.638936
+ 820.000012ps        -14.6002
+ 830.000013ps      -14.601143
+ 840.000014ps      -14.622224
+ 850.000015ps      -14.658153
+ 860.000016ps       -14.66199
+ 870.000016ps      -14.657729
+ 880.000017ps       -14.62348
+ 890.000018ps      -14.589624
+ 900.000019ps      -14.569591
+ 910.000020ps      -14.561906
+ 920.000021ps      -14.532253
+ 930.000021ps      -14.500817
+ 939.999967ps       -14.49374
+ 949.999968ps      -14.498065
+ 959.999968ps      -14.509088
+ 969.999969ps      -14.548952
+ 979.999970ps      -14.590043
+ 989.999971ps      -14.627014
+ 999.999972ps      -14.625007
+ 1009.999973ps      -14.615481
+ 1019.999973ps      -14.638628
+ 1029.999974ps      -14.644048
+ 1039.999975ps      -14.592468
+ 1049.999976ps      -14.558392
+ 1059.999977ps      -14.459724
+ 1069.999978ps      -14.341274
+ 1079.999978ps      -14.209761
+ 1089.999979ps       -14.06822
+ 1099.999980ps      -13.947362
+ 1109.999981ps      -13.861946
+ 1119.999982ps      -13.805276
+ 1129.999982ps      -13.769122
+ 1139.999983ps      -13.759757
+ 1149.999984ps      -13.762262
+ 1159.999985ps      -13.766395
+ 1169.999986ps      -13.754874
+ 1179.999987ps      -13.753468
+ 1189.999987ps      -13.782661
+ 1199.999988ps      -13.815979
+ 1209.999989ps       -13.84694
+ 1219.999990ps      -13.862191
+ 1229.999991ps      -13.837985
+ 1239.999992ps      -13.813482
+ 1249.999992ps      -13.763172
+ 1259.999993ps      -13.705432
+ 1269.999994ps      -13.616214
+ 1279.999995ps      -13.577868
+ 1289.999996ps      -13.579547
+ 1299.999997ps      -13.573805
+ 1309.999997ps      -13.538932
+ 1319.999998ps      -13.522063
+ 1329.999999ps      -13.507107
+ 1340.000000ps      -13.445374
+ 1350.000001ps      -13.367859
+ 1360.000002ps      -13.339637
+ 1370.000002ps       -13.35892
+ 1380.000003ps      -13.380389
+ 1390.000004ps      -13.414754
+ 1400.000005ps      -13.420676
+ 1410.000006ps      -13.421922
+ 1420.000006ps      -13.432955
+ 1430.000007ps      -13.414591
+ 1440.000008ps      -13.409872
+ 1450.000009ps      -13.405535
+ 1460.000010ps      -13.398612
+ 1470.000011ps      -13.403639
+ 1480.000011ps      -13.396477
+ 1490.000012ps      -13.431532
+ 1500.000013ps      -13.420371
+ 1510.000014ps      -13.386148
+ 1520.000015ps      -13.320803
+ 1530.000016ps      -13.307235
+ 1540.000016ps      -13.355856
+ 1550.000017ps      -13.410002
+ 1560.000018ps      -13.465899
+ 1570.000019ps      -13.533895
+ 1580.000020ps      -13.610359
+ 1590.000021ps      -13.664179
+ 1600.000021ps      -13.706344
+ 1610.000022ps      -13.726082
+ 1620.000023ps      -13.699167
+ 1630.000024ps      -13.670199
+ 1640.000025ps      -13.638994
+ 1650.000025ps      -13.576407
+ 1660.000026ps      -13.556559
+ 1670.000027ps      -13.536079
+ 1680.000028ps      -13.497391
+ 1690.000029ps      -13.444939
+ 1700.000030ps      -13.348129
+ 1710.000030ps      -13.269924
+ 1720.000031ps      -13.225678
+ 1730.000032ps      -13.211029
+ 1740.000033ps      -13.212578
+ 1750.000034ps      -13.212948
+ 1760.000035ps      -13.233128
+ 1770.000035ps      -13.246359
+ 1780.000036ps      -13.306058
+ 1790.000037ps      -13.366719
+ 1800.000038ps       -13.39863
+ 1810.000039ps      -13.418437
+ 1820.000040ps      -13.469451
+ 1830.000040ps      -13.513872
+ 1840.000041ps      -13.548628
+ 1850.000042ps      -13.564816
+ 1860.000043ps      -13.571497
+ 1869.999933ps      -13.546096
+ 1879.999934ps      -13.535495
+ 1889.999934ps      -13.520415
+ 1899.999935ps      -13.511806
+ 1909.999936ps       -13.48908
+ 1919.999937ps       -13.46476
+ 1929.999938ps      -13.451219
+ 1939.999938ps      -13.443215
+ 1949.999939ps      -13.410753
+ 1959.999940ps      -13.403274
+ 1969.999941ps      -13.387727
+ 1979.999942ps      -13.389333
+ 1989.999943ps      -13.397256
+ 1999.999943ps      -13.419715
+ 2009.999944ps      -13.406457
+ 2019.999945ps      -13.395165
+ 2029.999946ps       -13.38047
+ 2039.999947ps      -13.377174
+ 2049.999948ps      -13.382484
+ 2059.999948ps      -13.408312
+ 2069.999949ps      -13.437733
+ 2079.999950ps      -13.448341
+ 2089.999951ps      -13.463921
+ 2099.999952ps      -13.499791
+ 2109.999953ps      -13.509797
+ 2119.999953ps      -13.495994
+ 2129.999954ps      -13.463402
+ 2139.999955ps      -13.415009
+ 2149.999956ps      -13.352733
+ 2159.999957ps      -13.283195
+ 2169.999958ps      -13.212494
+ 2179.999958ps      -13.142014
+ 2189.999959ps      -13.061022
+ 2199.999960ps      -12.999517
+ 2209.999961ps       -12.94583
+ 2219.999962ps      -12.904862
+ 2229.999962ps      -12.912224
+ 2239.999963ps      -12.920493
+ 2249.999964ps      -12.977012
+ 2259.999965ps      -13.039797
+ 2269.999966ps      -13.079749
+ 2279.999967ps      -13.146894
+ 2289.999967ps      -13.197455
+ 2299.999968ps      -13.245124
+ 2309.999969ps      -13.261457
+ 2319.999970ps      -13.238013
+ 2329.999971ps      -13.193486
+ 2339.999972ps      -13.153743
+ 2349.999972ps      -13.126261
+ 2359.999973ps      -13.100107
+ 2369.999974ps      -13.082429
+ 2379.999975ps      -13.082466
+ 2389.999976ps      -13.077135
+ 2399.999977ps       -13.08257
+ 2409.999977ps      -13.070038
+ 2419.999978ps      -13.100548
+ 2429.999979ps      -13.152493
+ 2439.999980ps      -13.205432
+ 2449.999981ps       -13.26685
+ 2459.999982ps      -13.329869
+ 2469.999982ps      -13.400089
+ 2479.999983ps      -13.458207
+ 2489.999984ps      -13.483775
+ 2499.999985ps      -13.461637
+ 2509.999986ps       -13.40157
+ 2519.999986ps      -13.308072
+ 2529.999987ps      -13.227157
+ 2539.999988ps      -13.209908
+ 2549.999989ps      -13.171785
+ 2559.999990ps      -13.149405
+ 2569.999991ps      -13.143163
+ 2579.999991ps      -13.154576
+ 2589.999992ps        -13.1468
+ 2599.999993ps      -13.189115
+ 2609.999994ps      -13.203059
+ 2619.999995ps      -13.224677
+ 2629.999996ps      -13.308481
+ 2639.999996ps      -13.368909
+ 2649.999997ps      -13.424691
+ 2659.999998ps      -13.451479
+ 2669.999999ps      -13.482793
+ 2680.000000ps      -13.474679
+ 2690.000001ps      -13.427133
+ 2700.000001ps      -13.340781
+ 2710.000002ps      -13.216204
+ 2720.000003ps      -13.132707
+ 2730.000004ps      -13.062356
+ 2740.000005ps      -13.029429
+ 2750.000005ps      -13.043809
+ 2760.000006ps      -13.084144
+ 2770.000007ps      -13.122277
+ 2780.000008ps      -13.212232
+ 2790.000009ps      -13.239597
+ 2800.000010ps      -13.242335
+ 2810.000010ps      -13.252938
+ 2820.000011ps      -13.294944
+ 2830.000012ps        -13.3472
+ 2840.000013ps      -13.383578
+ 2850.000014ps      -13.437796
+ 2860.000015ps      -13.489307
+ 2870.000015ps       -13.50635
+ 2880.000016ps      -13.488672
+ 2890.000017ps        -13.4231
+ 2900.000018ps      -13.374395
+ 2910.000019ps       -13.29027
+ 2920.000020ps      -13.249461
+ 2930.000020ps      -13.218932
+ 2940.000021ps       -13.18441
+ 2950.000022ps      -13.222408
+ 2960.000023ps      -13.224466
+ 2970.000024ps      -13.225126
+ 2980.000025ps      -13.199854
+ 2990.000025ps      -13.195971
+ 3000.000026ps      -13.203697
+ 3010.000027ps      -13.184726
+ 3020.000028ps      -13.184489
+ 3030.000029ps      -13.203254
+ 3040.000029ps      -13.230508
+ 3050.000030ps      -13.235429
+ 3060.000031ps      -13.233234
+ 3070.000032ps      -13.228709
+ 3080.000033ps      -13.185945
+ 3090.000034ps      -13.175792
+ 3100.000034ps      -13.176801
+ 3110.000035ps      -13.187717
+ 3120.000036ps      -13.195992
+ 3130.000037ps      -13.186617
+ 3140.000038ps      -13.179712
+ 3150.000039ps      -13.176237
+ 3160.000039ps      -13.197256
+ 3170.000040ps      -13.245778
+ 3180.000041ps      -13.276616
+ 3190.000042ps      -13.286962
+ 3200.000043ps      -13.314347
+ 3210.000044ps      -13.350709
+ 3220.000044ps       -13.40589
+ 3230.000045ps       -13.40445
+ 3240.000046ps      -13.394346
+ 3250.000047ps      -13.410902
+ 3260.000048ps      -13.387984
+ 3270.000049ps      -13.375087
+ 3280.000049ps      -13.370533
+ 3290.000050ps      -13.381011
+ 3300.000051ps      -13.423618
+ 3310.000052ps      -13.455438
+ 3320.000053ps      -13.488157
+ 3330.000053ps      -13.550589
+ 3340.000054ps      -13.581564
+ 3350.000055ps      -13.599974
+ 3360.000056ps      -13.610314
+ 3370.000057ps      -13.553893
+ 3380.000058ps       -13.52289
+ 3390.000058ps      -13.473525
+ 3400.000059ps      -13.512979
+ 3410.000060ps      -13.535851
+ 3420.000061ps        -13.5703
+ 3430.000062ps      -13.598633
+ 3440.000063ps      -13.607541
+ 3450.000063ps      -13.602359
+ 3460.000064ps      -13.549737
+ 3470.000065ps      -13.523026
+ 3480.000066ps      -13.514848
+ 3490.000067ps      -13.485797
+ 3500.000068ps      -13.454721
+ 3510.000068ps      -13.448385
+ 3520.000069ps      -13.446415
+ 3530.000070ps      -13.415357
+ 3540.000071ps      -13.333693
+ 3550.000072ps      -13.278866
+ 3560.000073ps      -13.264774
+ 3570.000073ps      -13.239362
+ 3580.000074ps      -13.274982
+ 3590.000075ps      -13.294038
+ 3600.000076ps      -13.308068
+ 3610.000077ps      -13.328865
+ 3620.000077ps      -13.334204
+ 3630.000078ps       -13.35779
+ 3640.000079ps      -13.343367
+ 3650.000080ps      -13.335268
+ 3660.000081ps       -13.32376
+ 3670.000082ps      -13.309414
+ 3680.000082ps      -13.299764
+ 3690.000083ps      -13.275597
+ 3700.000084ps      -13.194368
+ 3710.000085ps      -13.160731
+ 3720.000086ps      -13.085323
+ 3729.999865ps      -13.092106
+ 3739.999865ps      -13.100574
+ 3749.999866ps      -13.162471
+ 3759.999867ps      -13.199408
+ 3769.999868ps      -13.211627
+ 3779.999869ps      -13.222176
+ 3789.999869ps      -13.238157
+ 3799.999870ps      -13.195644
+ 3809.999871ps      -13.155975
+ 3819.999872ps      -13.114744
+ 3829.999873ps      -13.094135
+ 3839.999874ps      -13.100385
+ 3849.999874ps       -13.10185
+ 3859.999875ps      -13.104105
+ 3869.999876ps       -13.09389
+ 3879.999877ps      -13.101906
+ 3889.999878ps      -13.088996
+ 3899.999879ps        -13.0879
+ 3909.999879ps      -13.109469
+ 3919.999880ps      -13.131164
+ 3929.999881ps      -13.168142
+ 3939.999882ps      -13.202915
+ 3949.999883ps       -13.21081
+ 3959.999884ps      -13.206202
+ 3969.999884ps      -13.177043
+ 3979.999885ps      -13.166738
+ 3989.999886ps      -13.205172
+ 3999.999887ps      -13.375903
+ 4009.999888ps      -13.654432
+ 4019.999889ps      -14.143729
+ 4029.999889ps      -14.638081
+ 4039.999890ps        -15.0364
+ 4049.999891ps      -15.322864
+ 4059.999892ps      -15.546624
+ 4069.999893ps      -15.722602
+ 4079.999893ps      -15.818613
+ 4089.999894ps      -15.837504
+ 4099.999895ps      -15.860595
+ 4109.999896ps      -15.881669
+ 4119.999897ps      -15.910355
+ 4129.999898ps      -15.898659
+ 4139.999898ps      -15.891078
+ 4149.999899ps      -15.902996
+ 4159.999900ps      -15.945464
+ 4169.999901ps      -15.954179
+ 4179.999902ps      -15.925285
+ 4189.999903ps      -15.873359
+ 4199.999903ps       -15.82637
+ 4209.999904ps      -15.814772
+ 4219.999905ps      -15.820996
+ 4229.999906ps      -15.836502
+ 4239.999907ps      -15.878824
+ 4249.999908ps      -15.892211
+ 4259.999908ps      -15.910624
+ 4269.999909ps      -15.897158
+ 4279.999910ps      -15.892807
+ 4289.999911ps      -15.825744
+ 4299.999912ps      -15.800267
+ 4309.999913ps      -15.773025
+ 4319.999913ps      -15.766113
+ 4329.999914ps      -15.773295
+ 4339.999915ps      -15.786958
+ 4349.999916ps      -15.782916
+ 4359.999917ps      -15.748729
+ 4369.999917ps      -15.670556
+ 4379.999918ps      -15.594866
+ 4389.999919ps      -15.538185
+ 4399.999920ps      -15.529814
+ 4409.999921ps      -15.512888
+ 4419.999922ps      -15.533883
+ 4429.999922ps      -15.571143
+ 4439.999923ps        -15.5454
+ 4449.999924ps      -15.598211
+ 4459.999925ps      -15.606249
+ 4469.999926ps      -15.643532
+ 4479.999927ps      -15.648932
+ 4489.999927ps      -15.646286
+ 4499.999928ps       -15.63752
+ 4509.999929ps      -15.628393
+ 4519.999930ps      -15.610886
+ 4529.999931ps      -15.584971
+ 4539.999932ps      -15.593298
+ 4549.999932ps      -15.572067
+ 4559.999933ps      -15.541853
+ 4569.999934ps      -15.514634
+ 4579.999935ps      -15.516552
+ 4589.999936ps      -15.516654
+ 4599.999937ps      -15.581474
+ 4609.999937ps      -15.658146
+ 4619.999938ps      -15.665967
+ 4629.999939ps      -15.693226
+ 4639.999940ps      -15.735363
+ 4649.999941ps      -15.748696
+ 4659.999941ps      -15.768328
+ 4669.999942ps      -15.819128
+ 4679.999943ps      -15.865594
+ 4689.999944ps      -15.882106
+ 4699.999945ps      -15.848007
+ 4709.999946ps      -15.825089
+ 4719.999946ps      -15.817502
+ 4729.999947ps      -15.761757
+ 4739.999948ps      -15.724009
+ 4749.999949ps       -15.68999
+ 4759.999950ps      -15.671467
+ 4769.999951ps      -15.663066
+ 4779.999951ps      -15.658285
+ 4789.999952ps      -15.686116
+ 4799.999953ps      -15.663317
+ 4809.999954ps      -15.623297
+ 4819.999955ps      -15.581943
+ 4829.999956ps      -15.611384
+ 4839.999956ps      -15.645457
+ 4849.999957ps      -15.656381
+ 4859.999958ps      -15.647226
+ 4869.999959ps      -15.624043
+ 4879.999960ps      -15.584389
+ 4889.999961ps      -15.537215
+ 4899.999961ps      -15.496366
+ 4909.999962ps      -15.479253
+ 4919.999963ps      -15.429828
+ 4929.999964ps      -15.406857
+ 4939.999965ps      -15.375281
+ 4949.999965ps      -15.357017
+ 4959.999966ps      -15.336436
+ 4969.999967ps      -15.326639
+ 4979.999968ps      -15.308994
+ 4989.999969ps      -15.251826
+ 4999.999970ps      -15.170485
+ 5009.999970ps      -15.043309
+ 5019.999971ps      -14.944567
+ 5029.999972ps      -14.811862
+ 5039.999973ps      -14.671565
+ 5049.999974ps      -14.506407
+ 5059.999975ps      -14.306237
+ 5069.999975ps      -14.081435
+ 5079.999976ps       -13.84911
+ 5089.999977ps      -13.631841
+ 5099.999978ps       -13.44622
+ 5109.999979ps      -13.269954
+ 5119.999980ps      -13.147996
+ 5129.999980ps      -13.049908
+ 5139.999981ps      -12.992145
+ 5149.999982ps      -12.955286
+ 5159.999983ps      -12.943857
+ 5169.999984ps      -12.911472
+ 5179.999985ps      -12.883672
+ 5189.999985ps      -12.876264
+ 5199.999986ps      -12.858581
+ 5209.999987ps      -12.883977
+ 5219.999988ps      -12.883576
+ 5229.999989ps      -12.847629
+ 5239.999989ps      -12.823487
+ 5249.999990ps      -12.739258
+ 5259.999991ps      -12.684179
+ 5269.999992ps      -12.607711
+ 5279.999993ps      -12.547016
+ 5289.999994ps      -12.539528
+ 5299.999994ps      -12.530579
+ 5309.999995ps      -12.481365
+ 5319.999996ps      -12.457129
+ 5329.999997ps      -12.420884
+ 5339.999998ps      -12.362234
+ 5349.999999ps      -12.291082
+ 5359.999999ps      -12.251941
+ 5370.000000ps      -12.240219
+ 5380.000001ps      -12.271798
+ 5390.000002ps      -12.274145
+ 5400.000003ps      -12.284132
+ 5410.000004ps      -12.288404
+ 5420.000004ps       -12.29381
+ 5430.000005ps      -12.281073
+ 5440.000006ps      -12.283731
+ 5450.000007ps      -12.277477
+ 5460.000008ps      -12.259483
+ 5470.000009ps      -12.243133
+ 5480.000009ps       -12.23741
+ 5490.000010ps      -12.273358
+ 5500.000011ps      -12.257556
+ 5510.000012ps      -12.214945
+ 5520.000013ps      -12.157222
+ 5530.000013ps      -12.146816
+ 5540.000014ps      -12.188366
+ 5550.000015ps      -12.237102
+ 5560.000016ps      -12.294222
+ 5570.000017ps      -12.358522
+ 5580.000018ps      -12.401833
+ 5590.000018ps      -12.475049
+ 5600.000019ps      -12.511082
+ 5610.000020ps      -12.545283
+ 5620.000021ps      -12.535222
+ 5630.000022ps      -12.466534
+ 5640.000023ps       -12.43035
+ 5650.000023ps      -12.391083
+ 5660.000024ps      -12.393883
+ 5670.000025ps      -12.362689
+ 5680.000026ps      -12.305773
+ 5690.000027ps      -12.239388
+ 5700.000028ps      -12.167619
+ 5710.000028ps       -12.08701
+ 5720.000029ps      -12.035036
+ 5730.000030ps       -12.00756
+ 5740.000031ps      -12.016263
+ 5750.000032ps      -12.026674
+ 5760.000033ps      -12.028574
+ 5770.000033ps      -12.079092
+ 5780.000034ps      -12.124949
+ 5790.000035ps      -12.193899
+ 5800.000036ps      -12.228334
+ 5810.000037ps      -12.263373
+ 5820.000037ps      -12.283425
+ 5830.000038ps      -12.323689
+ 5840.000039ps      -12.362479
+ 5850.000040ps      -12.383808
+ 5860.000041ps      -12.384161
+ 5870.000042ps      -12.359053
+ 5880.000042ps      -12.338735
+ 5890.000043ps      -12.320617
+ 5900.000044ps      -12.311217
+ 5910.000045ps      -12.296644
+ 5920.000046ps      -12.255861
+ 5930.000047ps      -12.240398
+ 5940.000047ps      -12.234842
+ 5950.000048ps      -12.221583
+ 5960.000049ps      -12.198883
+ 5970.000050ps      -12.188716
+ 5980.000051ps      -12.199041
+ 5990.000052ps      -12.195331
+ 6000.000052ps      -12.201481
+ 6010.000053ps      -12.214662
+ 6020.000054ps      -12.211284
+ 6030.000055ps      -12.198821
+ 6040.000056ps      -12.189099
+ 6050.000056ps      -12.184787
+ 6060.000057ps      -12.200479
+ 6070.000058ps       -12.20676
+ 6080.000059ps      -12.219095
+ 6090.000060ps      -12.240854
+ 6100.000061ps      -12.267537
+ 6110.000061ps      -12.286014
+ 6120.000062ps       -12.27246
+ 6130.000063ps       -12.23273
+ 6140.000064ps      -12.198572
+ 6150.000065ps       -12.16151
+ 6160.000066ps      -12.089311
+ 6170.000066ps      -12.016582
+ 6180.000067ps      -11.939164
+ 6190.000068ps      -11.854333
+ 6200.000069ps      -11.777814
+ 6210.000070ps      -11.730471
+ 6220.000071ps      -11.710376
+ 6230.000071ps      -11.716764
+ 6240.000072ps      -11.723825
+ 6250.000073ps      -11.770991
+ 6260.000074ps       -11.82064
+ 6270.000075ps      -11.881611
+ 6280.000076ps      -11.931477
+ 6290.000076ps      -11.986741
+ 6300.000077ps      -12.034277
+ 6310.000078ps      -12.063147
+ 6320.000079ps      -12.033269
+ 6330.000080ps      -12.007714
+ 6340.000080ps      -11.963792
+ 6350.000081ps      -11.940261
+ 6360.000082ps      -11.918375
+ 6370.000083ps      -11.903048
+ 6380.000084ps       -11.88851
+ 6390.000085ps       -11.89891
+ 6400.000085ps      -11.878942
+ 6410.000086ps      -11.861486
+ 6420.000087ps      -11.873238
+ 6430.000088ps      -11.909092
+ 6440.000089ps       -11.98268
+ 6450.000090ps       -12.05129
+ 6460.000090ps      -12.120198
+ 6470.000091ps      -12.202365
+ 6480.000092ps      -12.253167
+ 6490.000093ps      -12.278496
+ 6500.000094ps      -12.239988
+ 6510.000095ps      -12.169634
+ 6520.000095ps      -12.091143
+ 6530.000096ps      -12.034726
+ 6540.000097ps      -11.989027
+ 6550.000098ps      -11.956733
+ 6560.000099ps      -11.931296
+ 6570.000100ps      -11.923519
+ 6580.000100ps      -11.935252
+ 6590.000101ps      -11.943161
+ 6600.000102ps      -11.974101
+ 6610.000103ps       -12.00694
+ 6620.000104ps      -12.049362
+ 6630.000104ps      -12.107367
+ 6640.000105ps       -12.15461
+ 6650.000106ps      -12.208756
+ 6660.000107ps      -12.242072
+ 6670.000108ps      -12.280052
+ 6680.000109ps      -12.268072
+ 6690.000109ps      -12.230463
+ 6700.000110ps      -12.150709
+ 6710.000111ps      -12.041958
+ 6720.000112ps      -11.945546
+ 6730.000113ps      -11.885812
+ 6740.000114ps       -11.83435
+ 6750.000114ps      -11.861131
+ 6760.000115ps      -11.896714
+ 6770.000116ps      -11.928511
+ 6780.000117ps      -11.991735
+ 6790.000118ps      -11.999224
+ 6800.000119ps      -12.010366
+ 6810.000119ps      -12.031678
+ 6820.000120ps      -12.081217
+ 6830.000121ps      -12.139213
+ 6840.000122ps      -12.194511
+ 6850.000123ps      -12.246964
+ 6860.000124ps      -12.270212
+ 6870.000124ps      -12.291486
+ 6880.000125ps        -12.2645
+ 6890.000126ps      -12.195948
+ 6900.000127ps      -12.136554
+ 6910.000128ps      -12.074124
+ 6920.000128ps      -12.037435
+ 6930.000129ps      -12.016071
+ 6940.000130ps      -12.005489
+ 6950.000131ps      -12.035343
+ 6960.000132ps      -12.029898
+ 6970.000133ps      -12.018705
+ 6980.000133ps      -11.982291
+ 6990.000134ps      -11.980314
+ 7000.000135ps      -11.985198
+ 7010.000136ps      -11.986642
+ 7020.000137ps      -11.977308
+ 7030.000138ps      -11.971576
+ 7040.000138ps      -12.007171
+ 7050.000139ps       -12.02051
+ 7060.000140ps       -12.04322
+ 7070.000141ps      -12.022876
+ 7080.000142ps      -11.983632
+ 7090.000143ps      -11.967775
+ 7100.000143ps      -11.986308
+ 7110.000144ps      -12.006853
+ 7120.000145ps       -12.01327
+ 7130.000146ps      -12.019024
+ 7140.000147ps      -12.010573
+ 7150.000147ps      -12.016095
+ 7160.000148ps      -12.038562
+ 7170.000149ps      -12.076514
+ 7180.000150ps      -12.100776
+ 7190.000151ps      -12.115521
+ 7200.000152ps      -12.122637
+ 7210.000152ps      -12.156356
+ 7220.000153ps      -12.225772
+ 7230.000154ps      -12.214164
+ 7240.000155ps      -12.193981
+ 7250.000156ps       -12.19922
+ 7260.000157ps      -12.190632
+ 7270.000157ps      -12.164424
+ 7280.000158ps      -12.153485
+ 7290.000159ps      -12.162122
+ 7300.000160ps      -12.179377
+ 7310.000161ps      -12.213727
+ 7320.000162ps      -12.277058
+ 7330.000162ps      -12.344229
+ 7340.000163ps      -12.386289
+ 7350.000164ps      -12.414579
+ 7360.000165ps      -12.396996
+ 7370.000166ps      -12.377106
+ 7380.000167ps      -12.327979
+ 7390.000167ps      -12.295814
+ 7400.000168ps      -12.323966
+ 7410.000169ps      -12.339803
+ 7420.000170ps      -12.371576
+ 7430.000171ps      -12.397981
+ 7440.000171ps       -12.41099
+ 7450.000172ps      -12.399448
+ 7459.999729ps      -12.380391
+ 7469.999730ps      -12.344174
+ 7479.999731ps      -12.305483
+ 7489.999732ps       -12.27613
+ 7499.999732ps        -12.2599
+ 7509.999733ps       -12.25254
+ 7519.999734ps      -12.267929
+ 7529.999735ps      -12.218657
+ 7539.999736ps      -12.135699
+ 7549.999737ps      -12.061111
+ 7559.999737ps      -12.046388
+ 7569.999738ps      -12.044488
+ 7579.999739ps      -12.079734
+ 7589.999740ps      -12.110556
+ 7599.999741ps      -12.139566
+ 7609.999741ps      -12.137815
+ 7619.999742ps      -12.134528
+ 7629.999743ps      -12.159241
+ 7639.999744ps      -12.154637
+ 7649.999745ps      -12.149296
+ 7659.999746ps      -12.128346
+ 7669.999746ps      -12.118668
+ 7679.999747ps      -12.097284
+ 7689.999748ps      -12.074167
+ 7699.999749ps      -11.991125
+ 7709.999750ps      -11.968876
+ 7719.999751ps      -11.927448
+ 7729.999751ps      -11.919992
+ 7739.999752ps      -11.911927
+ 7749.999753ps      -11.946096
+ 7759.999754ps      -12.004965
+ 7769.999755ps      -12.029976
+ 7779.999756ps      -12.026159
+ 7789.999756ps      -12.028695
+ 7799.999757ps      -12.001956
+ 7809.999758ps      -11.976073
+ 7819.999759ps      -11.932818
+ 7829.999760ps      -11.905181
+ 7839.999761ps      -11.897476
+ 7849.999761ps      -11.900586
+ 7859.999762ps      -11.911775
+ 7869.999763ps      -11.918486
+ 7879.999764ps      -11.914626
+ 7889.999765ps      -11.909382
+ 7899.999765ps      -11.920864
+ 7909.999766ps      -11.953515
+ 7919.999767ps      -11.969753
+ 7929.999768ps      -11.995803
+ 7939.999769ps      -12.029208
+ 7949.999770ps      -12.057186
+ 7959.999770ps      -12.037618
+ 7969.999771ps      -12.008505
+ 7979.999772ps      -12.000586
+ 7989.999773ps      -12.182051
+)

Icursig5 PAR_2_0_VDD075CPU 0 pwl(
+ 0.000000ps       8.3818197
+ 10.000000ps       8.6404198
+ 20.000000ps       9.3242942
+ 29.999999ps       10.148297
+ 40.000000ps       10.960302
+ 50.000001ps       11.685352
+ 59.999998ps       12.331488
+ 69.999999ps       12.914801
+ 80.000000ps       13.415119
+ 90.000001ps       13.813253
+ 100.000001ps       14.159576
+ 110.000002ps       14.459443
+ 119.999996ps       14.735806
+ 129.999997ps       14.950291
+ 139.999998ps       15.103188
+ 149.999999ps       15.262988
+ 159.999999ps       15.434645
+ 170.000000ps       15.596811
+ 180.000001ps       15.744455
+ 190.000002ps       15.834044
+ 200.000003ps       15.933254
+ 210.000003ps       16.043528
+ 220.000004ps       16.161811
+ 230.000005ps       16.305586
+ 239.999992ps       16.456393
+ 249.999993ps       16.606678
+ 259.999994ps       16.752551
+ 269.999995ps       16.876873
+ 279.999995ps       16.993162
+ 289.999996ps       17.068076
+ 299.999997ps       17.125317
+ 309.999998ps       17.142532
+ 319.999999ps        17.16978
+ 330.000000ps       17.217779
+ 340.000000ps       17.268281
+ 350.000001ps        17.31109
+ 360.000002ps       17.313394
+ 370.000003ps       17.302608
+ 380.000004ps        17.25748
+ 390.000005ps       17.251344
+ 400.000005ps       17.278122
+ 410.000006ps       17.304072
+ 420.000007ps       17.338541
+ 430.000008ps       17.399086
+ 440.000009ps       17.447105
+ 450.000009ps        17.51013
+ 460.000010ps       17.535265
+ 469.999983ps       17.581862
+ 479.999984ps       17.604113
+ 489.999985ps       17.593084
+ 499.999986ps       17.587285
+ 509.999987ps       17.595308
+ 519.999988ps       17.595595
+ 529.999988ps       17.590996
+ 539.999989ps       17.591073
+ 549.999990ps       17.578727
+ 559.999991ps        17.57328
+ 569.999992ps       17.565235
+ 579.999992ps       17.572437
+ 589.999993ps       17.585443
+ 599.999994ps       17.625201
+ 609.999995ps       17.674011
+ 619.999996ps       17.721457
+ 629.999997ps       17.760444
+ 639.999997ps       17.788326
+ 649.999998ps       17.812613
+ 659.999999ps       17.826867
+ 670.000000ps       17.851743
+ 680.000001ps       17.895099
+ 690.000002ps       17.909104
+ 700.000002ps       17.916094
+ 710.000003ps        17.92492
+ 720.000004ps       17.934098
+ 730.000005ps       17.905528
+ 740.000006ps       17.851657
+ 750.000007ps       17.797717
+ 760.000007ps       17.758899
+ 770.000008ps       17.756016
+ 780.000009ps       17.761335
+ 790.000010ps       17.788172
+ 800.000011ps       17.769566
+ 810.000012ps        17.74324
+ 820.000012ps       17.708738
+ 830.000013ps       17.709664
+ 840.000014ps       17.732636
+ 850.000015ps       17.739545
+ 860.000016ps       17.749708
+ 870.000016ps       17.743628
+ 880.000017ps       17.734051
+ 890.000018ps       17.707799
+ 900.000019ps       17.698792
+ 910.000020ps        17.64963
+ 920.000021ps       17.602946
+ 930.000021ps         17.5694
+ 939.999967ps       17.567563
+ 949.999968ps       17.554431
+ 959.999968ps       17.512723
+ 969.999969ps       17.516851
+ 979.999970ps       17.519471
+ 989.999971ps       17.525315
+ 999.999972ps       17.485795
+ 1009.999973ps       17.420396
+ 1019.999973ps       17.367956
+ 1029.999974ps       17.281136
+ 1039.999975ps        17.16257
+ 1049.999976ps       17.042972
+ 1059.999977ps       16.840524
+ 1069.999978ps       16.618123
+ 1079.999978ps       16.375758
+ 1089.999979ps       16.159314
+ 1099.999980ps       15.966157
+ 1109.999981ps        15.77874
+ 1119.999982ps       15.631051
+ 1129.999982ps       15.534509
+ 1139.999983ps       15.463281
+ 1149.999984ps       15.387914
+ 1159.999985ps       15.319048
+ 1169.999986ps        15.24318
+ 1179.999987ps       15.176632
+ 1189.999987ps       15.161001
+ 1199.999988ps       15.126272
+ 1209.999989ps       15.111515
+ 1219.999990ps       15.102205
+ 1229.999991ps       15.071746
+ 1239.999992ps       15.015657
+ 1249.999992ps        14.91346
+ 1259.999993ps       14.798152
+ 1269.999994ps       14.707682
+ 1279.999995ps       14.630143
+ 1289.999996ps        14.58384
+ 1299.999997ps       14.552746
+ 1309.999997ps       14.518074
+ 1319.999998ps        14.48522
+ 1329.999999ps       14.439037
+ 1340.000000ps       14.373649
+ 1350.000001ps        14.29506
+ 1360.000002ps       14.228804
+ 1370.000002ps       14.202015
+ 1380.000003ps       14.203704
+ 1390.000004ps       14.198904
+ 1400.000005ps       14.191085
+ 1410.000006ps       14.184338
+ 1420.000006ps       14.169074
+ 1430.000007ps       14.150024
+ 1440.000008ps       14.140628
+ 1450.000009ps       14.132446
+ 1460.000010ps        14.12751
+ 1470.000011ps       14.096025
+ 1480.000011ps        14.09019
+ 1490.000012ps       14.098771
+ 1500.000013ps       14.080499
+ 1510.000014ps       14.050623
+ 1520.000015ps       14.002929
+ 1530.000016ps       13.981771
+ 1540.000016ps       14.021125
+ 1550.000017ps       14.056055
+ 1560.000018ps       14.105892
+ 1570.000019ps       14.178943
+ 1580.000020ps       14.212113
+ 1590.000021ps        14.25093
+ 1600.000021ps       14.256522
+ 1610.000022ps       14.256501
+ 1620.000023ps       14.232319
+ 1630.000024ps       14.169123
+ 1640.000025ps       14.131881
+ 1650.000025ps       14.088166
+ 1660.000026ps       14.064305
+ 1670.000027ps       14.035756
+ 1680.000028ps       13.998056
+ 1690.000029ps       13.945717
+ 1700.000030ps       13.866424
+ 1710.000030ps       13.799876
+ 1720.000031ps       13.753378
+ 1730.000032ps       13.749369
+ 1740.000033ps       13.759632
+ 1750.000034ps        13.78429
+ 1760.000035ps        13.78408
+ 1770.000035ps        13.81355
+ 1780.000036ps       13.864462
+ 1790.000037ps       13.942696
+ 1800.000038ps       13.977087
+ 1810.000039ps       13.991749
+ 1820.000040ps       13.996183
+ 1830.000040ps       14.017112
+ 1840.000041ps       14.035268
+ 1850.000042ps       14.057283
+ 1860.000043ps       14.056142
+ 1869.999933ps       14.038595
+ 1879.999934ps        14.04177
+ 1889.999934ps       14.035353
+ 1899.999935ps       14.032683
+ 1909.999936ps       14.019931
+ 1919.999937ps       13.975256
+ 1929.999938ps       13.952967
+ 1939.999938ps       13.950067
+ 1949.999939ps       13.935578
+ 1959.999940ps       13.921347
+ 1969.999941ps       13.896657
+ 1979.999942ps       13.904961
+ 1989.999943ps       13.918025
+ 1999.999943ps       13.927555
+ 2009.999944ps       13.924194
+ 2019.999945ps       13.916833
+ 2029.999946ps       13.903253
+ 2039.999947ps         13.8961
+ 2049.999948ps       13.879018
+ 2059.999948ps       13.881554
+ 2069.999949ps       13.899899
+ 2079.999950ps       13.922318
+ 2089.999951ps       13.952968
+ 2099.999952ps       13.975625
+ 2109.999953ps       13.979549
+ 2119.999953ps        13.96379
+ 2129.999954ps        13.92063
+ 2139.999955ps       13.872151
+ 2149.999956ps       13.828624
+ 2159.999957ps        13.75365
+ 2169.999958ps       13.676351
+ 2179.999958ps       13.597849
+ 2189.999959ps       13.535559
+ 2199.999960ps       13.485785
+ 2209.999961ps        13.45186
+ 2219.999962ps       13.447043
+ 2229.999962ps       13.448564
+ 2239.999963ps       13.452404
+ 2249.999964ps       13.488177
+ 2259.999965ps       13.549662
+ 2269.999966ps       13.596859
+ 2279.999967ps       13.643641
+ 2289.999967ps       13.675948
+ 2299.999968ps       13.719733
+ 2309.999969ps       13.761403
+ 2319.999970ps       13.748997
+ 2329.999971ps       13.728742
+ 2339.999972ps       13.667673
+ 2349.999972ps       13.644319
+ 2359.999973ps       13.629896
+ 2369.999974ps       13.625545
+ 2379.999975ps       13.615985
+ 2389.999976ps       13.597286
+ 2399.999977ps        13.59299
+ 2409.999977ps       13.588037
+ 2419.999978ps       13.603291
+ 2429.999979ps        13.64479
+ 2439.999980ps       13.698219
+ 2449.999981ps       13.755037
+ 2459.999982ps       13.822287
+ 2469.999982ps       13.869214
+ 2479.999983ps       13.903637
+ 2489.999984ps       13.908405
+ 2499.999985ps       13.881274
+ 2509.999986ps       13.807525
+ 2519.999986ps       13.731772
+ 2529.999987ps       13.684689
+ 2539.999988ps       13.663219
+ 2549.999989ps       13.653256
+ 2559.999990ps       13.644946
+ 2569.999991ps       13.637378
+ 2579.999991ps       13.629286
+ 2589.999992ps        13.62883
+ 2599.999993ps       13.654369
+ 2609.999994ps       13.683365
+ 2619.999995ps       13.725294
+ 2629.999996ps       13.790955
+ 2639.999996ps       13.841243
+ 2649.999997ps       13.902856
+ 2659.999998ps       13.923384
+ 2669.999999ps       13.935343
+ 2680.000000ps       13.918425
+ 2690.000001ps       13.885772
+ 2700.000001ps       13.803846
+ 2710.000002ps       13.705839
+ 2720.000003ps       13.623706
+ 2730.000004ps        13.56827
+ 2740.000005ps       13.542713
+ 2750.000005ps       13.554114
+ 2760.000006ps       13.580741
+ 2770.000007ps       13.609777
+ 2780.000008ps       13.648256
+ 2790.000009ps       13.677547
+ 2800.000010ps       13.704989
+ 2810.000010ps        13.72741
+ 2820.000011ps       13.762453
+ 2830.000012ps       13.802582
+ 2840.000013ps       13.855067
+ 2850.000014ps       13.898915
+ 2860.000015ps        13.92391
+ 2870.000015ps       13.934627
+ 2880.000016ps       13.900147
+ 2890.000017ps       13.840857
+ 2900.000018ps       13.769262
+ 2910.000019ps       13.694244
+ 2920.000020ps        13.65566
+ 2930.000020ps       13.649029
+ 2940.000021ps       13.661931
+ 2950.000022ps       13.676762
+ 2960.000023ps       13.695099
+ 2970.000024ps       13.673664
+ 2980.000025ps       13.666348
+ 2990.000025ps        13.65013
+ 3000.000026ps       13.649127
+ 3010.000027ps       13.631481
+ 3020.000028ps       13.619496
+ 3030.000029ps       13.643148
+ 3040.000029ps        13.66117
+ 3050.000030ps       13.670053
+ 3060.000031ps       13.669466
+ 3070.000032ps       13.656741
+ 3080.000033ps       13.638959
+ 3090.000034ps       13.623569
+ 3100.000034ps       13.632137
+ 3110.000035ps       13.658123
+ 3120.000036ps       13.640928
+ 3130.000037ps       13.642576
+ 3140.000038ps       13.638948
+ 3150.000039ps       13.652781
+ 3160.000039ps       13.675572
+ 3170.000040ps         13.7179
+ 3180.000041ps       13.728787
+ 3190.000042ps       13.739337
+ 3200.000043ps       13.750714
+ 3210.000044ps       13.778444
+ 3220.000044ps       13.818808
+ 3230.000045ps       13.818036
+ 3240.000046ps       13.825292
+ 3250.000047ps       13.824583
+ 3260.000048ps       13.819653
+ 3270.000049ps       13.807813
+ 3280.000049ps       13.816521
+ 3290.000050ps       13.810536
+ 3300.000051ps       13.818485
+ 3310.000052ps       13.847906
+ 3320.000053ps        13.89172
+ 3330.000053ps       13.943699
+ 3340.000054ps       13.955186
+ 3350.000055ps       13.978764
+ 3360.000056ps       13.961063
+ 3370.000057ps       13.936044
+ 3380.000058ps       13.922819
+ 3390.000058ps       13.925482
+ 3400.000059ps       13.966688
+ 3410.000060ps       13.979287
+ 3420.000061ps       14.017503
+ 3430.000062ps       14.046497
+ 3440.000063ps       14.051889
+ 3450.000063ps       14.026618
+ 3460.000064ps       13.994912
+ 3470.000065ps       13.959204
+ 3480.000066ps       13.922705
+ 3490.000067ps       13.875182
+ 3500.000068ps       13.842509
+ 3510.000068ps       13.839691
+ 3520.000069ps       13.827317
+ 3530.000070ps       13.791014
+ 3540.000071ps       13.722986
+ 3550.000072ps       13.663242
+ 3560.000073ps       13.656546
+ 3570.000073ps       13.656204
+ 3580.000074ps       13.699679
+ 3590.000075ps       13.706999
+ 3600.000076ps       13.718192
+ 3610.000077ps       13.721462
+ 3620.000077ps       13.710242
+ 3630.000078ps       13.724069
+ 3640.000079ps       13.718017
+ 3650.000080ps       13.704963
+ 3660.000081ps       13.692605
+ 3670.000082ps       13.686601
+ 3680.000082ps       13.650443
+ 3690.000083ps       13.608708
+ 3700.000084ps       13.524079
+ 3710.000085ps       13.501083
+ 3720.000086ps       13.457815
+ 3729.999865ps       13.453733
+ 3739.999865ps       13.507615
+ 3749.999866ps       13.559722
+ 3759.999867ps       13.614895
+ 3769.999868ps       13.615754
+ 3779.999869ps       13.605587
+ 3789.999869ps       13.587359
+ 3799.999870ps       13.536749
+ 3809.999871ps       13.493427
+ 3819.999872ps        13.45061
+ 3829.999873ps       13.434664
+ 3839.999874ps       13.429957
+ 3849.999874ps       13.439531
+ 3859.999875ps       13.448468
+ 3869.999876ps       13.442837
+ 3879.999877ps       13.433894
+ 3889.999878ps       13.433642
+ 3899.999879ps       13.440715
+ 3909.999879ps       13.469904
+ 3919.999880ps       13.493067
+ 3929.999881ps       13.523599
+ 3939.999882ps       13.564652
+ 3949.999883ps       13.573648
+ 3959.999884ps       13.562325
+ 3969.999884ps       13.523565
+ 3979.999885ps       13.498177
+ 3989.999886ps       13.512263
+ 3999.999887ps       13.746194
+ 4009.999888ps       14.056873
+ 4019.999889ps       14.232182
+ 4029.999889ps       14.338471
+ 4039.999890ps       14.438647
+ 4049.999891ps       14.533435
+ 4059.999892ps        14.61457
+ 4069.999893ps       14.665221
+ 4079.999893ps       14.697084
+ 4089.999894ps       14.682839
+ 4099.999895ps       14.689712
+ 4109.999896ps       14.690087
+ 4119.999897ps       14.692455
+ 4129.999898ps        14.69303
+ 4139.999898ps       14.676525
+ 4149.999899ps       14.666911
+ 4159.999900ps       14.672731
+ 4169.999901ps       14.674366
+ 4179.999902ps       14.665486
+ 4189.999903ps       14.604925
+ 4199.999903ps       14.587182
+ 4209.999904ps       14.571612
+ 4219.999905ps       14.597283
+ 4229.999906ps       14.640052
+ 4239.999907ps       14.672929
+ 4249.999908ps       14.705456
+ 4259.999908ps       14.705633
+ 4269.999909ps       14.709416
+ 4279.999910ps       14.704008
+ 4289.999911ps       14.689967
+ 4299.999912ps       14.668133
+ 4309.999913ps       14.630582
+ 4319.999913ps       14.604478
+ 4329.999914ps          14.595
+ 4339.999915ps        14.57709
+ 4349.999916ps       14.562792
+ 4359.999917ps       14.531211
+ 4369.999917ps       14.487486
+ 4379.999918ps       14.426229
+ 4389.999919ps       14.390469
+ 4399.999920ps       14.387515
+ 4409.999921ps       14.404028
+ 4419.999922ps       14.419029
+ 4429.999922ps       14.465967
+ 4439.999923ps       14.504348
+ 4449.999924ps       14.540631
+ 4459.999925ps       14.549102
+ 4469.999926ps       14.571689
+ 4479.999927ps       14.581096
+ 4489.999927ps       14.574795
+ 4499.999928ps       14.564605
+ 4509.999929ps       14.557924
+ 4519.999930ps       14.552055
+ 4529.999931ps       14.538958
+ 4539.999932ps       14.522655
+ 4549.999932ps       14.497428
+ 4559.999933ps       14.494691
+ 4569.999934ps       14.499154
+ 4579.999935ps        14.50292
+ 4589.999936ps       14.529958
+ 4599.999937ps       14.570928
+ 4609.999937ps       14.611965
+ 4619.999938ps       14.646717
+ 4629.999939ps       14.683578
+ 4639.999940ps       14.708618
+ 4649.999941ps       14.734532
+ 4659.999941ps       14.750929
+ 4669.999942ps        14.78212
+ 4679.999943ps       14.811019
+ 4689.999944ps       14.820816
+ 4699.999945ps       14.829054
+ 4709.999946ps       14.833854
+ 4719.999946ps       14.841177
+ 4729.999947ps       14.833665
+ 4739.999948ps        14.79839
+ 4749.999949ps       14.753644
+ 4759.999950ps       14.713084
+ 4769.999951ps       14.704334
+ 4779.999951ps        14.72476
+ 4789.999952ps       14.760031
+ 4799.999953ps       14.759653
+ 4809.999954ps       14.754931
+ 4819.999955ps       14.730159
+ 4829.999956ps       14.720869
+ 4839.999956ps       14.740309
+ 4849.999957ps       14.765772
+ 4859.999958ps       14.789302
+ 4869.999959ps       14.802882
+ 4879.999960ps       14.797246
+ 4889.999961ps       14.778716
+ 4899.999961ps       14.783612
+ 4909.999962ps       14.754957
+ 4919.999963ps        14.72179
+ 4929.999964ps       14.689319
+ 4939.999965ps       14.701237
+ 4949.999965ps       14.704206
+ 4959.999966ps       14.700079
+ 4969.999967ps       14.745231
+ 4979.999968ps       14.799884
+ 4989.999969ps        14.86158
+ 4999.999970ps       14.893523
+ 5009.999970ps       14.919024
+ 5019.999971ps       14.966301
+ 5029.999972ps       14.978657
+ 5039.999973ps       14.971174
+ 5049.999974ps       14.973475
+ 5059.999975ps       14.896337
+ 5069.999975ps       14.785873
+ 5079.999976ps       14.653534
+ 5089.999977ps       14.537395
+ 5099.999978ps       14.441568
+ 5109.999979ps       14.352203
+ 5119.999980ps       14.294575
+ 5129.999980ps       14.289798
+ 5139.999981ps       14.291577
+ 5149.999982ps       14.289814
+ 5159.999983ps       14.283762
+ 5169.999984ps        14.26744
+ 5179.999985ps       14.254918
+ 5189.999985ps       14.296913
+ 5199.999986ps       14.321862
+ 5209.999987ps       14.361365
+ 5219.999988ps       14.399559
+ 5229.999989ps        14.40885
+ 5239.999989ps       14.386702
+ 5249.999990ps       14.328099
+ 5259.999991ps       14.234633
+ 5269.999992ps       14.166283
+ 5279.999993ps       14.120136
+ 5289.999994ps        14.09929
+ 5299.999994ps       14.089559
+ 5309.999995ps        14.07123
+ 5319.999996ps        14.06476
+ 5329.999997ps       14.045267
+ 5339.999998ps       13.994425
+ 5349.999999ps       13.928558
+ 5359.999999ps       13.886917
+ 5370.000000ps        13.88424
+ 5380.000001ps       13.897688
+ 5390.000002ps       13.919429
+ 5400.000003ps       13.920993
+ 5410.000004ps        13.92934
+ 5420.000004ps       13.931982
+ 5430.000005ps       13.921283
+ 5440.000006ps       13.916753
+ 5450.000007ps       13.912114
+ 5460.000008ps        13.92362
+ 5470.000009ps       13.906052
+ 5480.000009ps       13.908706
+ 5490.000010ps       13.926354
+ 5500.000011ps       13.917015
+ 5510.000012ps       13.899397
+ 5520.000013ps       13.857193
+ 5530.000013ps       13.841045
+ 5540.000014ps       13.875041
+ 5550.000015ps       13.917444
+ 5560.000016ps       13.970778
+ 5570.000017ps       14.043404
+ 5580.000018ps       14.099289
+ 5590.000018ps       14.154345
+ 5600.000019ps         14.1675
+ 5610.000020ps       14.172768
+ 5620.000021ps       14.145006
+ 5630.000022ps       14.096479
+ 5640.000023ps       14.070618
+ 5650.000023ps       14.023933
+ 5660.000024ps       14.000054
+ 5670.000025ps       13.971599
+ 5680.000026ps       13.940499
+ 5690.000027ps       13.884297
+ 5700.000028ps       13.797151
+ 5710.000028ps       13.733646
+ 5720.000029ps       13.691505
+ 5730.000030ps       13.695095
+ 5740.000031ps       13.710211
+ 5750.000032ps       13.732004
+ 5760.000033ps       13.734843
+ 5770.000033ps       13.751353
+ 5780.000034ps        13.80655
+ 5790.000035ps       13.883294
+ 5800.000036ps       13.918261
+ 5810.000037ps        13.92943
+ 5820.000037ps       13.952169
+ 5830.000038ps       13.980347
+ 5840.000039ps       14.005974
+ 5850.000040ps       14.026682
+ 5860.000041ps       14.039354
+ 5870.000042ps       14.024974
+ 5880.000042ps       14.026693
+ 5890.000043ps         14.0235
+ 5900.000044ps       14.021676
+ 5910.000045ps       14.000962
+ 5920.000046ps       13.969825
+ 5930.000047ps       13.950006
+ 5940.000047ps       13.943267
+ 5950.000048ps       13.922071
+ 5960.000049ps       13.908728
+ 5970.000050ps       13.879089
+ 5980.000051ps       13.887946
+ 5990.000052ps       13.901844
+ 6000.000052ps       13.921395
+ 6010.000053ps         13.9165
+ 6020.000054ps       13.897579
+ 6030.000055ps       13.879897
+ 6040.000056ps       13.877501
+ 6050.000056ps        13.86632
+ 6060.000057ps       13.881824
+ 6070.000058ps       13.912786
+ 6080.000059ps       13.945808
+ 6090.000060ps       13.975899
+ 6100.000061ps       13.999937
+ 6110.000061ps       14.002404
+ 6120.000062ps        13.98631
+ 6130.000063ps       13.944301
+ 6140.000064ps       13.890181
+ 6150.000065ps        13.83051
+ 6160.000066ps       13.742859
+ 6170.000066ps       13.671152
+ 6180.000067ps       13.592535
+ 6190.000068ps       13.535373
+ 6200.000069ps       13.484077
+ 6210.000070ps       13.447415
+ 6220.000071ps       13.437001
+ 6230.000071ps       13.440407
+ 6240.000072ps       13.445949
+ 6250.000073ps       13.487401
+ 6260.000074ps       13.559269
+ 6270.000075ps       13.595426
+ 6280.000076ps       13.648091
+ 6290.000076ps       13.678172
+ 6300.000077ps       13.717283
+ 6310.000078ps       13.753513
+ 6320.000079ps        13.73488
+ 6330.000080ps       13.708761
+ 6340.000080ps       13.641448
+ 6350.000081ps       13.616756
+ 6360.000082ps       13.601477
+ 6370.000083ps       13.598204
+ 6380.000084ps       13.582209
+ 6390.000085ps       13.566517
+ 6400.000085ps       13.570184
+ 6410.000086ps       13.565322
+ 6420.000087ps       13.596897
+ 6430.000088ps       13.651886
+ 6440.000089ps       13.705885
+ 6450.000090ps       13.761787
+ 6460.000090ps       13.828204
+ 6470.000091ps       13.877668
+ 6480.000092ps       13.922731
+ 6490.000093ps       13.924913
+ 6500.000094ps       13.906156
+ 6510.000095ps        13.83726
+ 6520.000095ps       13.762724
+ 6530.000096ps       13.710147
+ 6540.000097ps       13.685558
+ 6550.000098ps       13.670275
+ 6560.000099ps        13.66766
+ 6570.000100ps       13.653833
+ 6580.000100ps       13.644072
+ 6590.000101ps       13.638514
+ 6600.000102ps        13.67326
+ 6610.000103ps         13.6892
+ 6620.000104ps       13.726551
+ 6630.000104ps       13.793217
+ 6640.000105ps       13.845745
+ 6650.000106ps       13.912986
+ 6660.000107ps       13.930808
+ 6670.000108ps       13.942075
+ 6680.000109ps       13.919167
+ 6690.000109ps       13.883568
+ 6700.000110ps       13.793006
+ 6710.000111ps       13.695632
+ 6720.000112ps       13.609012
+ 6730.000113ps        13.54767
+ 6740.000114ps       13.527494
+ 6750.000114ps       13.541946
+ 6760.000115ps       13.569721
+ 6770.000116ps       13.606474
+ 6780.000117ps       13.661711
+ 6790.000118ps       13.699381
+ 6800.000119ps       13.730264
+ 6810.000119ps       13.744848
+ 6820.000120ps       13.780838
+ 6830.000121ps       13.818991
+ 6840.000122ps       13.868132
+ 6850.000123ps       13.912803
+ 6860.000124ps       13.945191
+ 6870.000124ps       13.960699
+ 6880.000125ps       13.932849
+ 6890.000126ps       13.879027
+ 6900.000127ps       13.812691
+ 6910.000128ps       13.725912
+ 6920.000128ps       13.680984
+ 6930.000129ps       13.670719
+ 6940.000130ps       13.677386
+ 6950.000131ps       13.697767
+ 6960.000132ps       13.711473
+ 6970.000133ps       13.696783
+ 6980.000133ps       13.689942
+ 6990.000134ps       13.682275
+ 7000.000135ps       13.675277
+ 7010.000136ps       13.649127
+ 7020.000137ps       13.642047
+ 7030.000138ps       13.667249
+ 7040.000138ps       13.685108
+ 7050.000139ps       13.696877
+ 7060.000140ps       13.680401
+ 7070.000141ps       13.667947
+ 7080.000142ps       13.645866
+ 7090.000143ps       13.624372
+ 7100.000143ps       13.628569
+ 7110.000144ps       13.652883
+ 7120.000145ps       13.631024
+ 7130.000146ps       13.619141
+ 7140.000147ps       13.613637
+ 7150.000147ps        13.62401
+ 7160.000148ps       13.646861
+ 7170.000149ps       13.686586
+ 7180.000150ps       13.696245
+ 7190.000151ps       13.707737
+ 7200.000152ps       13.732422
+ 7210.000152ps       13.764693
+ 7220.000153ps       13.801343
+ 7230.000154ps       13.815374
+ 7240.000155ps       13.821261
+ 7250.000156ps       13.830556
+ 7260.000157ps       13.818653
+ 7270.000157ps       13.808426
+ 7280.000158ps       13.822855
+ 7290.000159ps       13.823102
+ 7300.000160ps       13.834832
+ 7310.000161ps       13.864965
+ 7320.000162ps        13.90537
+ 7330.000162ps       13.962572
+ 7340.000163ps       13.963903
+ 7350.000164ps       13.982657
+ 7360.000165ps       13.966969
+ 7370.000166ps       13.941186
+ 7380.000167ps       13.926628
+ 7390.000167ps         13.9222
+ 7400.000168ps       13.965734
+ 7410.000169ps       13.979911
+ 7420.000170ps       14.019797
+ 7430.000171ps       14.049162
+ 7440.000171ps       14.055979
+ 7450.000172ps       14.027876
+ 7459.999729ps       13.985079
+ 7469.999730ps       13.953037
+ 7479.999731ps       13.930628
+ 7489.999732ps       13.880066
+ 7499.999732ps       13.845265
+ 7509.999733ps       13.837327
+ 7519.999734ps       13.819786
+ 7529.999735ps       13.782354
+ 7539.999736ps       13.720129
+ 7549.999737ps       13.669071
+ 7559.999737ps       13.673478
+ 7569.999738ps       13.671015
+ 7579.999739ps       13.713074
+ 7589.999740ps       13.707478
+ 7599.999741ps       13.710235
+ 7609.999741ps       13.719382
+ 7619.999742ps       13.707352
+ 7629.999743ps       13.719145
+ 7639.999744ps       13.713443
+ 7649.999745ps       13.698296
+ 7659.999746ps       13.693047
+ 7669.999746ps       13.685572
+ 7679.999747ps       13.650716
+ 7689.999748ps       13.616702
+ 7699.999749ps       13.538426
+ 7709.999750ps       13.513499
+ 7719.999751ps       13.458756
+ 7729.999751ps       13.458213
+ 7739.999752ps       13.504416
+ 7749.999753ps       13.567759
+ 7759.999754ps       13.620141
+ 7769.999755ps       13.611946
+ 7779.999756ps       13.613293
+ 7789.999756ps       13.600785
+ 7799.999757ps       13.549679
+ 7809.999758ps       13.498922
+ 7819.999759ps       13.455828
+ 7829.999760ps       13.435767
+ 7839.999761ps       13.432058
+ 7849.999761ps       13.439044
+ 7859.999762ps       13.443477
+ 7869.999763ps       13.439032
+ 7879.999764ps       13.425114
+ 7889.999765ps       13.431166
+ 7899.999765ps       13.429361
+ 7909.999766ps       13.443798
+ 7919.999767ps       13.464312
+ 7929.999768ps       13.502383
+ 7939.999769ps       13.540878
+ 7949.999770ps        13.54723
+ 7959.999770ps       13.539651
+ 7969.999771ps       13.507939
+ 7979.999772ps       13.471287
+ 7989.999773ps       13.463718
+)

Icursig6 PAR_0_1_VSS 0 pwl(
+ 0.000000ps      -6.2181877
+ 10.000000ps       -6.655805
+ 20.000000ps      -7.5109935
+ 29.999999ps      -8.2607921
+ 40.000000ps      -8.8258791
+ 50.000001ps         -9.2483
+ 59.999998ps      -9.5424482
+ 69.999999ps      -9.7460276
+ 80.000000ps      -9.9184519
+ 90.000001ps      -10.054074
+ 100.000001ps      -10.166003
+ 110.000002ps      -10.226779
+ 119.999996ps      -10.282321
+ 129.999997ps      -10.348613
+ 139.999998ps      -10.401586
+ 149.999999ps      -10.471964
+ 159.999999ps      -10.505891
+ 170.000000ps      -10.549577
+ 180.000001ps      -10.556901
+ 190.000002ps      -10.589631
+ 200.000003ps      -10.601491
+ 210.000003ps       -10.62608
+ 220.000004ps      -10.639833
+ 230.000005ps      -10.659243
+ 239.999992ps      -10.693402
+ 249.999993ps      -10.757493
+ 259.999994ps      -10.829208
+ 269.999995ps      -10.886985
+ 279.999995ps      -10.931124
+ 289.999996ps      -10.983664
+ 299.999997ps      -11.037091
+ 309.999998ps      -11.067819
+ 319.999999ps      -11.092063
+ 330.000000ps      -11.108951
+ 340.000000ps      -11.161723
+ 350.000001ps      -11.197649
+ 360.000002ps      -11.195521
+ 370.000003ps      -11.233682
+ 380.000004ps      -11.268045
+ 390.000005ps      -11.293731
+ 400.000005ps      -11.287024
+ 410.000006ps      -11.250588
+ 420.000007ps      -11.224201
+ 430.000008ps      -11.220579
+ 440.000009ps      -11.180215
+ 450.000009ps      -11.171487
+ 460.000010ps      -11.154118
+ 469.999983ps       -11.16095
+ 479.999984ps       -11.18004
+ 489.999985ps      -11.214038
+ 499.999986ps      -11.187158
+ 509.999987ps      -11.186382
+ 519.999988ps      -11.183378
+ 529.999988ps      -11.179684
+ 539.999989ps      -11.210636
+ 549.999990ps      -11.226099
+ 559.999991ps      -11.245446
+ 569.999992ps      -11.248375
+ 579.999992ps      -11.245319
+ 589.999993ps       -11.24948
+ 599.999994ps      -11.233082
+ 609.999995ps      -11.206401
+ 619.999996ps      -11.201295
+ 629.999997ps      -11.173965
+ 639.999997ps      -11.194897
+ 649.999998ps      -11.199273
+ 659.999999ps       -11.18646
+ 670.000000ps      -11.183647
+ 680.000001ps      -11.207164
+ 690.000002ps      -11.228367
+ 700.000002ps      -11.239168
+ 710.000003ps      -11.250607
+ 720.000004ps      -11.263704
+ 730.000005ps      -11.261302
+ 740.000006ps      -11.244289
+ 750.000007ps      -11.237751
+ 760.000007ps      -11.240387
+ 770.000008ps      -11.218717
+ 780.000009ps      -11.207858
+ 790.000010ps       -11.20172
+ 800.000011ps       -11.20056
+ 810.000012ps       -11.21194
+ 820.000012ps      -11.198482
+ 830.000013ps      -11.201594
+ 840.000014ps      -11.206012
+ 850.000015ps      -11.204083
+ 860.000016ps      -11.209981
+ 870.000016ps      -11.225211
+ 880.000017ps      -11.246291
+ 890.000018ps      -11.264146
+ 900.000019ps      -11.290382
+ 910.000020ps      -11.268299
+ 920.000021ps      -11.265693
+ 930.000021ps      -11.252822
+ 939.999967ps      -11.213147
+ 949.999968ps      -11.159251
+ 959.999968ps      -11.066908
+ 969.999969ps      -11.003909
+ 979.999970ps      -10.953153
+ 989.999971ps      -10.888211
+ 999.999972ps      -10.831599
+ 1009.999973ps      -10.790438
+ 1019.999973ps      -10.737828
+ 1029.999974ps      -10.706605
+ 1039.999975ps       -10.65933
+ 1049.999976ps      -10.599475
+ 1059.999977ps      -10.574294
+ 1069.999978ps      -10.554892
+ 1079.999978ps      -10.553204
+ 1089.999979ps      -10.544836
+ 1099.999980ps      -10.525579
+ 1109.999981ps      -10.490877
+ 1119.999982ps      -10.475802
+ 1129.999982ps      -10.465806
+ 1139.999983ps       -10.45097
+ 1149.999984ps      -10.431513
+ 1159.999985ps      -10.404032
+ 1169.999986ps      -10.367926
+ 1179.999987ps      -10.354301
+ 1189.999987ps      -10.339084
+ 1199.999988ps      -10.336922
+ 1209.999989ps      -10.344974
+ 1219.999990ps      -10.323185
+ 1229.999991ps      -10.332481
+ 1239.999992ps      -10.325605
+ 1249.999992ps      -10.304656
+ 1259.999993ps      -10.299526
+ 1269.999994ps      -10.324758
+ 1279.999995ps      -10.344391
+ 1289.999996ps      -10.372343
+ 1299.999997ps      -10.387223
+ 1309.999997ps      -10.402032
+ 1319.999998ps       -10.45131
+ 1329.999999ps      -10.485761
+ 1340.000000ps      -10.543559
+ 1350.000001ps      -10.571015
+ 1360.000002ps      -10.625623
+ 1370.000002ps      -10.653334
+ 1380.000003ps      -10.699523
+ 1390.000004ps      -10.712648
+ 1400.000005ps       -10.73497
+ 1410.000006ps       -10.73082
+ 1420.000006ps      -10.712747
+ 1430.000007ps      -10.683207
+ 1440.000008ps      -10.657304
+ 1450.000009ps      -10.630697
+ 1460.000010ps      -10.605493
+ 1470.000011ps      -10.590058
+ 1480.000011ps        -10.5562
+ 1490.000012ps      -10.551144
+ 1500.000013ps      -10.556916
+ 1510.000014ps      -10.602997
+ 1520.000015ps      -10.642299
+ 1530.000016ps      -10.638741
+ 1540.000016ps      -10.668308
+ 1550.000017ps      -10.720332
+ 1560.000018ps      -10.732346
+ 1570.000019ps      -10.719566
+ 1580.000020ps      -10.729729
+ 1590.000021ps      -10.751331
+ 1600.000021ps      -10.747131
+ 1610.000022ps      -10.699045
+ 1620.000023ps       -10.66021
+ 1630.000024ps      -10.602539
+ 1640.000025ps      -10.554158
+ 1650.000025ps      -10.492839
+ 1660.000026ps      -10.455538
+ 1670.000027ps      -10.476141
+ 1680.000028ps       -10.52024
+ 1690.000029ps      -10.551187
+ 1700.000030ps      -10.561521
+ 1710.000030ps       -10.57325
+ 1720.000031ps      -10.588665
+ 1730.000032ps      -10.628141
+ 1740.000033ps      -10.640917
+ 1750.000034ps      -10.622563
+ 1760.000035ps      -10.610276
+ 1770.000035ps      -10.552499
+ 1780.000036ps      -10.475458
+ 1790.000037ps      -10.422263
+ 1800.000038ps      -10.383923
+ 1810.000039ps      -10.357139
+ 1820.000040ps      -10.307487
+ 1830.000040ps      -10.286567
+ 1840.000041ps      -10.282998
+ 1850.000042ps      -10.301092
+ 1860.000043ps      -10.305936
+ 1869.999933ps      -10.302084
+ 1879.999934ps      -10.315698
+ 1889.999934ps      -10.333907
+ 1899.999935ps      -10.351664
+ 1909.999936ps      -10.381508
+ 1919.999937ps      -10.379138
+ 1929.999938ps      -10.384044
+ 1939.999938ps      -10.397142
+ 1949.999939ps      -10.391946
+ 1959.999940ps      -10.367906
+ 1969.999941ps      -10.338841
+ 1979.999942ps      -10.293697
+ 1989.999943ps      -10.251226
+ 1999.999943ps      -10.209759
+ 2009.999944ps      -10.200211
+ 2019.999945ps      -10.209074
+ 2029.999946ps      -10.239364
+ 2039.999947ps      -10.283159
+ 2049.999948ps      -10.339513
+ 2059.999948ps      -10.352833
+ 2069.999949ps      -10.364595
+ 2079.999950ps      -10.336299
+ 2089.999951ps      -10.321103
+ 2099.999952ps      -10.261224
+ 2109.999953ps      -10.222299
+ 2119.999953ps      -10.164053
+ 2129.999954ps      -10.163232
+ 2139.999955ps      -10.176362
+ 2149.999956ps      -10.203452
+ 2159.999957ps      -10.224755
+ 2169.999958ps      -10.260499
+ 2179.999958ps       -10.27898
+ 2189.999959ps      -10.274643
+ 2199.999960ps       -10.28189
+ 2209.999961ps       -10.29015
+ 2219.999962ps        -10.3332
+ 2229.999962ps      -10.360052
+ 2239.999963ps      -10.385224
+ 2249.999964ps      -10.411638
+ 2259.999965ps      -10.438152
+ 2269.999966ps       -10.44741
+ 2279.999967ps      -10.438057
+ 2289.999967ps      -10.403748
+ 2299.999968ps      -10.377447
+ 2309.999969ps      -10.341631
+ 2319.999970ps      -10.306329
+ 2329.999971ps      -10.302744
+ 2339.999972ps      -10.332809
+ 2349.999972ps      -10.390091
+ 2359.999973ps      -10.407132
+ 2369.999974ps      -10.414813
+ 2379.999975ps      -10.420771
+ 2389.999976ps      -10.431364
+ 2399.999977ps      -10.442364
+ 2409.999977ps      -10.462453
+ 2419.999978ps      -10.482185
+ 2429.999979ps      -10.488692
+ 2439.999980ps      -10.510033
+ 2449.999981ps      -10.527821
+ 2459.999982ps      -10.523997
+ 2469.999982ps      -10.503145
+ 2479.999983ps      -10.481472
+ 2489.999984ps      -10.447363
+ 2499.999985ps      -10.442402
+ 2509.999986ps      -10.453629
+ 2519.999986ps      -10.433497
+ 2529.999987ps      -10.419104
+ 2539.999988ps      -10.427635
+ 2549.999989ps       -10.43396
+ 2559.999990ps      -10.458816
+ 2569.999991ps      -10.410829
+ 2579.999991ps      -10.407693
+ 2589.999992ps      -10.418116
+ 2599.999993ps      -10.430108
+ 2609.999994ps      -10.396177
+ 2619.999995ps      -10.357783
+ 2629.999996ps      -10.348121
+ 2639.999996ps      -10.313786
+ 2649.999997ps      -10.271395
+ 2659.999998ps      -10.251504
+ 2669.999999ps      -10.235018
+ 2680.000000ps       -10.22536
+ 2690.000001ps      -10.157786
+ 2700.000001ps      -10.123165
+ 2710.000002ps      -10.109337
+ 2720.000003ps      -10.115753
+ 2730.000004ps      -10.120885
+ 2740.000005ps      -10.139513
+ 2750.000005ps      -10.178634
+ 2760.000006ps      -10.190451
+ 2770.000007ps      -10.190271
+ 2780.000008ps      -10.161191
+ 2790.000009ps      -10.111892
+ 2800.000010ps      -10.102676
+ 2810.000010ps      -10.088673
+ 2820.000011ps      -10.055021
+ 2830.000012ps      -10.046973
+ 2840.000013ps      -10.038702
+ 2850.000014ps      -10.034515
+ 2860.000015ps      -10.041531
+ 2870.000015ps      -10.054003
+ 2880.000016ps       -10.04097
+ 2890.000017ps      -10.058278
+ 2900.000018ps       -10.05263
+ 2910.000019ps      -10.062515
+ 2920.000020ps      -10.106616
+ 2930.000020ps      -10.136825
+ 2940.000021ps      -10.141729
+ 2950.000022ps      -10.102114
+ 2960.000023ps      -10.048623
+ 2970.000024ps      -10.006543
+ 2980.000025ps      -9.9601964
+ 2990.000025ps      -9.9580088
+ 3000.000026ps      -9.9673454
+ 3010.000027ps      -9.9976532
+ 3020.000028ps      -10.031431
+ 3030.000029ps      -10.039599
+ 3040.000029ps      -10.048335
+ 3050.000030ps      -10.053755
+ 3060.000031ps      -10.086037
+ 3070.000032ps      -10.088203
+ 3080.000033ps      -10.097837
+ 3090.000034ps      -10.103782
+ 3100.000034ps        -10.1166
+ 3110.000035ps      -10.135462
+ 3120.000036ps      -10.137389
+ 3130.000037ps      -10.147769
+ 3140.000038ps      -10.145243
+ 3150.000039ps      -10.130089
+ 3160.000039ps      -10.111696
+ 3170.000040ps      -10.111292
+ 3180.000041ps      -10.105826
+ 3190.000042ps      -10.091221
+ 3200.000043ps      -10.098149
+ 3210.000044ps      -10.119699
+ 3220.000044ps      -10.160387
+ 3230.000045ps      -10.174437
+ 3240.000046ps      -10.194283
+ 3250.000047ps      -10.187701
+ 3260.000048ps      -10.191475
+ 3270.000049ps      -10.171187
+ 3280.000049ps      -10.186532
+ 3290.000050ps      -10.208485
+ 3300.000051ps      -10.244683
+ 3310.000052ps       -10.23841
+ 3320.000053ps      -10.199196
+ 3330.000053ps      -10.200592
+ 3340.000054ps      -10.171087
+ 3350.000055ps       -10.17115
+ 3360.000056ps      -10.173266
+ 3370.000057ps      -10.171363
+ 3380.000058ps      -10.188066
+ 3390.000058ps      -10.207604
+ 3400.000059ps      -10.206771
+ 3410.000060ps      -10.218781
+ 3420.000061ps       -10.24753
+ 3430.000062ps      -10.227406
+ 3440.000063ps       -10.23266
+ 3450.000063ps      -10.267134
+ 3460.000064ps      -10.323125
+ 3470.000065ps      -10.341546
+ 3480.000066ps      -10.322183
+ 3490.000067ps      -10.319038
+ 3500.000068ps      -10.303318
+ 3510.000068ps      -10.279235
+ 3520.000069ps      -10.227085
+ 3530.000070ps      -10.145303
+ 3540.000071ps      -10.109752
+ 3550.000072ps      -10.105483
+ 3560.000073ps       -10.11992
+ 3570.000073ps      -10.080051
+ 3580.000074ps      -10.068749
+ 3590.000075ps      -10.071209
+ 3600.000076ps      -10.045226
+ 3610.000077ps      -10.032732
+ 3620.000077ps      -10.050709
+ 3630.000078ps      -10.084329
+ 3640.000079ps      -10.098597
+ 3650.000080ps      -10.128902
+ 3660.000081ps       -10.11274
+ 3670.000082ps      -10.134276
+ 3680.000082ps      -10.150463
+ 3690.000083ps      -10.169381
+ 3700.000084ps      -10.175312
+ 3710.000085ps      -10.151022
+ 3720.000086ps      -10.139679
+ 3729.999865ps      -10.165308
+ 3739.999865ps       -10.15852
+ 3749.999866ps      -10.143662
+ 3759.999867ps      -10.135585
+ 3769.999868ps      -10.135204
+ 3779.999869ps      -10.140802
+ 3789.999869ps      -10.154149
+ 3799.999870ps      -10.174999
+ 3809.999871ps      -10.196851
+ 3819.999872ps      -10.180558
+ 3829.999873ps      -10.165015
+ 3839.999874ps      -10.140571
+ 3849.999874ps      -10.131489
+ 3859.999875ps      -10.134645
+ 3869.999876ps      -10.129278
+ 3879.999877ps      -10.135506
+ 3889.999878ps      -10.150357
+ 3899.999879ps      -10.139245
+ 3909.999879ps      -10.094162
+ 3919.999880ps      -10.071254
+ 3929.999881ps      -10.064544
+ 3939.999882ps      -10.092176
+ 3949.999883ps       -10.07267
+ 3959.999884ps      -10.055333
+ 3969.999884ps      -10.040316
+ 3979.999885ps      -10.022613
+ 3989.999886ps       -10.05395
+ 3999.999887ps      -10.200927
+ 4009.999888ps      -10.443055
+ 4019.999889ps      -10.812087
+ 4029.999889ps      -11.157329
+ 4039.999890ps      -11.412585
+ 4049.999891ps      -11.649937
+ 4059.999892ps      -11.780902
+ 4069.999893ps      -11.879478
+ 4079.999893ps      -11.907681
+ 4089.999894ps      -11.968309
+ 4099.999895ps      -11.999195
+ 4109.999896ps      -12.037883
+ 4119.999897ps      -12.101533
+ 4129.999898ps       -12.16753
+ 4139.999898ps      -12.228163
+ 4149.999899ps      -12.288397
+ 4159.999900ps      -12.276492
+ 4169.999901ps      -12.245778
+ 4179.999902ps      -12.229764
+ 4189.999903ps      -12.230799
+ 4199.999903ps      -12.240936
+ 4209.999904ps      -12.242469
+ 4219.999905ps      -12.240784
+ 4229.999906ps      -12.229144
+ 4239.999907ps      -12.239599
+ 4249.999908ps      -12.235627
+ 4259.999908ps      -12.216835
+ 4269.999909ps      -12.198395
+ 4279.999910ps      -12.179561
+ 4289.999911ps       -12.17882
+ 4299.999912ps      -12.180605
+ 4309.999913ps      -12.174493
+ 4319.999913ps      -12.153663
+ 4329.999914ps      -12.141819
+ 4339.999915ps      -12.170354
+ 4349.999916ps      -12.212088
+ 4359.999917ps      -12.182479
+ 4369.999917ps      -12.257076
+ 4379.999918ps      -12.253275
+ 4389.999919ps      -12.297589
+ 4399.999920ps      -12.284212
+ 4409.999921ps      -12.237682
+ 4419.999922ps      -12.185125
+ 4429.999922ps      -12.153344
+ 4439.999923ps        -12.1046
+ 4449.999924ps      -12.075503
+ 4459.999925ps       -12.07672
+ 4469.999926ps      -12.080308
+ 4479.999927ps      -12.082651
+ 4489.999927ps      -12.100853
+ 4499.999928ps      -12.088334
+ 4509.999929ps      -12.094541
+ 4519.999930ps      -12.080382
+ 4529.999931ps      -12.082465
+ 4539.999932ps      -12.115081
+ 4549.999932ps      -12.124137
+ 4559.999933ps      -12.163413
+ 4569.999934ps      -12.154757
+ 4579.999935ps      -12.140575
+ 4589.999936ps      -12.160082
+ 4599.999937ps      -12.127708
+ 4609.999937ps      -12.093527
+ 4619.999938ps      -12.080815
+ 4629.999939ps      -12.043465
+ 4639.999940ps       -12.07189
+ 4649.999941ps      -12.079021
+ 4659.999941ps      -12.059447
+ 4669.999942ps      -12.058438
+ 4679.999943ps      -12.092369
+ 4689.999944ps      -12.105559
+ 4699.999945ps      -12.110871
+ 4709.999946ps      -12.117731
+ 4719.999946ps      -12.129643
+ 4729.999947ps      -12.125071
+ 4739.999948ps      -12.095554
+ 4749.999949ps      -12.082682
+ 4759.999950ps      -12.075136
+ 4769.999951ps      -12.043418
+ 4779.999951ps      -12.020278
+ 4789.999952ps      -11.977992
+ 4799.999953ps      -11.969189
+ 4809.999954ps      -11.953793
+ 4819.999955ps      -11.979395
+ 4829.999956ps      -11.977374
+ 4839.999956ps      -11.956456
+ 4849.999957ps      -11.923946
+ 4859.999958ps       -11.91858
+ 4869.999959ps       -11.92468
+ 4879.999960ps      -11.936736
+ 4889.999961ps      -11.950945
+ 4899.999961ps      -11.954959
+ 4909.999962ps      -11.940357
+ 4919.999963ps       -11.93516
+ 4929.999964ps      -11.892734
+ 4939.999965ps      -11.871807
+ 4949.999965ps      -11.800696
+ 4959.999966ps      -11.707522
+ 4969.999967ps      -11.594328
+ 4979.999968ps      -11.502273
+ 4989.999969ps      -11.381055
+ 4999.999970ps      -11.246214
+ 5009.999970ps      -11.116328
+ 5019.999971ps      -10.979356
+ 5029.999972ps      -10.838956
+ 5039.999973ps      -10.684052
+ 5049.999974ps      -10.548505
+ 5059.999975ps      -10.440104
+ 5069.999975ps      -10.354463
+ 5079.999976ps       -10.28606
+ 5089.999977ps      -10.230794
+ 5099.999978ps      -10.174428
+ 5109.999979ps      -10.096013
+ 5119.999980ps      -10.035522
+ 5129.999980ps       -9.980839
+ 5139.999981ps      -9.9440304
+ 5149.999982ps      -9.8814543
+ 5159.999983ps      -9.8111616
+ 5169.999984ps      -9.7555869
+ 5179.999985ps      -9.7196853
+ 5189.999985ps      -9.7006057
+ 5199.999986ps      -9.6880202
+ 5209.999987ps       -9.672817
+ 5219.999988ps      -9.6603013
+ 5229.999989ps      -9.6429695
+ 5239.999989ps      -9.6372238
+ 5249.999990ps      -9.6016097
+ 5259.999991ps      -9.5752722
+ 5269.999992ps       -9.591561
+ 5279.999993ps      -9.5854125
+ 5289.999994ps      -9.6118863
+ 5299.999994ps      -9.6140257
+ 5309.999995ps      -9.6094549
+ 5319.999996ps      -9.6522922
+ 5329.999997ps      -9.6870821
+ 5339.999998ps      -9.7362518
+ 5349.999999ps      -9.7552913
+ 5359.999999ps      -9.7933749
+ 5370.000000ps      -9.8298753
+ 5380.000001ps      -9.8656069
+ 5390.000002ps      -9.8990356
+ 5400.000003ps      -9.9232222
+ 5410.000004ps      -9.9190663
+ 5420.000004ps      -9.8888582
+ 5430.000005ps      -9.8444725
+ 5440.000006ps       -9.821723
+ 5450.000007ps      -9.8054086
+ 5460.000008ps      -9.7646334
+ 5470.000009ps      -9.7557767
+ 5480.000009ps      -9.7232806
+ 5490.000010ps      -9.7283712
+ 5500.000011ps      -9.7334289
+ 5510.000012ps      -9.8096432
+ 5520.000013ps      -9.8414602
+ 5530.000013ps      -9.8572894
+ 5540.000014ps      -9.8634261
+ 5550.000015ps      -9.8937387
+ 5560.000016ps      -9.9137853
+ 5570.000017ps      -9.9024086
+ 5580.000018ps      -9.9209312
+ 5590.000018ps      -9.9276175
+ 5600.000019ps      -9.9130077
+ 5610.000020ps      -9.8762758
+ 5620.000021ps      -9.8137634
+ 5630.000022ps      -9.7726262
+ 5640.000023ps      -9.7205214
+ 5650.000023ps      -9.6445114
+ 5660.000024ps      -9.6172035
+ 5670.000025ps      -9.6318318
+ 5680.000026ps      -9.6650195
+ 5690.000027ps      -9.7023973
+ 5700.000028ps      -9.7235118
+ 5710.000028ps      -9.7328523
+ 5720.000029ps      -9.7500909
+ 5730.000030ps      -9.7714937
+ 5740.000031ps      -9.7765979
+ 5750.000032ps      -9.7703891
+ 5760.000033ps      -9.7469371
+ 5770.000033ps      -9.6915653
+ 5780.000034ps      -9.6269604
+ 5790.000035ps      -9.5924668
+ 5800.000036ps      -9.5613632
+ 5810.000037ps      -9.5366614
+ 5820.000037ps      -9.4748385
+ 5830.000038ps      -9.4179601
+ 5840.000039ps      -9.4155246
+ 5850.000040ps      -9.4257799
+ 5860.000041ps      -9.4413144
+ 5870.000042ps      -9.4554103
+ 5880.000042ps      -9.4725167
+ 5890.000043ps      -9.5108214
+ 5900.000044ps      -9.5472289
+ 5910.000045ps      -9.5708001
+ 5920.000046ps      -9.5914263
+ 5930.000047ps        -9.60574
+ 5940.000047ps      -9.6020594
+ 5950.000048ps      -9.5750394
+ 5960.000049ps      -9.5349235
+ 5970.000050ps      -9.4993873
+ 5980.000051ps      -9.4561296
+ 5990.000052ps       -9.414914
+ 6000.000052ps      -9.3743125
+ 6010.000053ps      -9.3621331
+ 6020.000054ps      -9.3739335
+ 6030.000055ps      -9.3928582
+ 6040.000056ps      -9.4261487
+ 6050.000056ps       -9.464233
+ 6060.000057ps       -9.480493
+ 6070.000058ps      -9.4693237
+ 6080.000059ps      -9.4518267
+ 6090.000060ps       -9.426102
+ 6100.000061ps      -9.3884199
+ 6110.000061ps      -9.3433253
+ 6120.000062ps      -9.3033945
+ 6130.000063ps      -9.3021668
+ 6140.000064ps       -9.307238
+ 6150.000065ps      -9.3298084
+ 6160.000066ps      -9.3703681
+ 6170.000066ps      -9.3970723
+ 6180.000067ps      -9.4151038
+ 6190.000068ps       -9.397795
+ 6200.000069ps      -9.3972522
+ 6210.000070ps      -9.3975495
+ 6220.000071ps      -9.4366259
+ 6230.000071ps      -9.4667736
+ 6240.000072ps      -9.5098396
+ 6250.000073ps      -9.5720185
+ 6260.000074ps      -9.6038446
+ 6270.000075ps      -9.6123477
+ 6280.000076ps      -9.5950208
+ 6290.000076ps       -9.556723
+ 6300.000077ps      -9.5384322
+ 6310.000078ps      -9.4925397
+ 6320.000079ps      -9.4631447
+ 6330.000080ps      -9.4651397
+ 6340.000080ps      -9.4799551
+ 6350.000081ps      -9.5503009
+ 6360.000082ps      -9.5578907
+ 6370.000083ps       -9.568704
+ 6380.000084ps      -9.5606663
+ 6390.000085ps      -9.5748319
+ 6400.000085ps      -9.5841506
+ 6410.000086ps      -9.5853679
+ 6420.000087ps      -9.5943138
+ 6430.000088ps      -9.6315328
+ 6440.000089ps       -9.670028
+ 6450.000090ps      -9.6519381
+ 6460.000090ps      -9.6549525
+ 6470.000091ps       -9.638561
+ 6480.000092ps      -9.6147685
+ 6490.000093ps      -9.5912318
+ 6500.000094ps      -9.5853343
+ 6510.000095ps       -9.602621
+ 6520.000095ps       -9.583803
+ 6530.000096ps      -9.5549442
+ 6540.000097ps      -9.5602569
+ 6550.000098ps      -9.5901044
+ 6560.000099ps      -9.6037218
+ 6570.000100ps      -9.5579479
+ 6580.000100ps      -9.5457009
+ 6590.000101ps      -9.5374017
+ 6600.000102ps      -9.5265591
+ 6610.000103ps      -9.4935168
+ 6620.000104ps      -9.4671743
+ 6630.000104ps      -9.4498943
+ 6640.000105ps      -9.4329712
+ 6650.000106ps      -9.4019376
+ 6660.000107ps      -9.3866551
+ 6670.000108ps      -9.3970717
+ 6680.000109ps      -9.3699144
+ 6690.000109ps      -9.3278384
+ 6700.000110ps      -9.3002501
+ 6710.000111ps      -9.2990963
+ 6720.000112ps      -9.2981499
+ 6730.000113ps      -9.2920333
+ 6740.000114ps      -9.3329762
+ 6750.000114ps      -9.3577869
+ 6760.000115ps       -9.362787
+ 6770.000116ps      -9.3755028
+ 6780.000117ps      -9.3398238
+ 6790.000118ps      -9.2910506
+ 6800.000119ps      -9.2558122
+ 6810.000119ps      -9.2297603
+ 6820.000120ps      -9.2027671
+ 6830.000121ps      -9.1845991
+ 6840.000122ps      -9.1853924
+ 6850.000123ps      -9.1858463
+ 6860.000124ps      -9.1965315
+ 6870.000124ps      -9.2075224
+ 6880.000125ps      -9.1916183
+ 6890.000126ps      -9.2038851
+ 6900.000127ps      -9.2212199
+ 6910.000128ps      -9.2353034
+ 6920.000128ps      -9.2932316
+ 6930.000129ps      -9.3127214
+ 6940.000130ps      -9.3034161
+ 6950.000131ps      -9.2723606
+ 6960.000132ps      -9.2344935
+ 6970.000133ps      -9.1825405
+ 6980.000133ps       -9.131265
+ 6990.000134ps       -9.118396
+ 7000.000135ps      -9.1287986
+ 7010.000136ps      -9.1394329
+ 7020.000137ps      -9.1732436
+ 7030.000138ps      -9.1833881
+ 7040.000138ps      -9.2011255
+ 7050.000139ps      -9.2122675
+ 7060.000140ps      -9.2393482
+ 7070.000141ps      -9.2364904
+ 7080.000142ps      -9.2438261
+ 7090.000143ps      -9.2524597
+ 7100.000143ps      -9.2727021
+ 7110.000144ps      -9.2846476
+ 7120.000145ps      -9.3083043
+ 7130.000146ps      -9.3122541
+ 7140.000147ps       -9.311919
+ 7150.000147ps      -9.2964641
+ 7160.000148ps      -9.3024771
+ 7170.000149ps      -9.2908172
+ 7180.000150ps      -9.2726878
+ 7190.000151ps      -9.2681508
+ 7200.000152ps      -9.2672344
+ 7210.000152ps      -9.2917117
+ 7220.000153ps      -9.3137769
+ 7230.000154ps      -9.3257246
+ 7240.000155ps      -9.3291682
+ 7250.000156ps      -9.3331842
+ 7260.000157ps       -9.345144
+ 7270.000157ps      -9.3281059
+ 7280.000158ps      -9.3431417
+ 7290.000159ps      -9.3654066
+ 7300.000160ps      -9.4079449
+ 7310.000161ps      -9.4097326
+ 7320.000162ps      -9.3896097
+ 7330.000162ps      -9.3717187
+ 7340.000163ps      -9.3491565
+ 7350.000164ps      -9.3292097
+ 7360.000165ps      -9.3343955
+ 7370.000166ps      -9.3453923
+ 7380.000167ps      -9.3567454
+ 7390.000167ps      -9.3705606
+ 7400.000168ps      -9.3601213
+ 7410.000169ps       -9.363433
+ 7420.000170ps      -9.3740313
+ 7430.000171ps      -9.3615152
+ 7440.000171ps      -9.3679689
+ 7450.000172ps      -9.3966484
+ 7459.999729ps      -9.4564431
+ 7469.999730ps      -9.4859999
+ 7479.999731ps      -9.4601391
+ 7489.999732ps      -9.4665405
+ 7499.999732ps      -9.4550679
+ 7509.999733ps      -9.4409546
+ 7519.999734ps      -9.3772351
+ 7529.999735ps      -9.3220869
+ 7539.999736ps      -9.2863726
+ 7549.999737ps      -9.2734531
+ 7559.999737ps      -9.2839934
+ 7569.999738ps      -9.2551973
+ 7579.999739ps      -9.2485873
+ 7589.999740ps      -9.2447593
+ 7599.999741ps      -9.2309833
+ 7609.999741ps      -9.2256144
+ 7619.999742ps      -9.2264057
+ 7629.999743ps      -9.2362922
+ 7639.999744ps      -9.2475385
+ 7649.999745ps      -9.2948218
+ 7659.999746ps      -9.2922379
+ 7669.999746ps       -9.293503
+ 7679.999747ps      -9.3045654
+ 7689.999748ps      -9.3179898
+ 7699.999749ps      -9.3285687
+ 7709.999750ps      -9.3182154
+ 7719.999751ps      -9.3074463
+ 7729.999751ps      -9.3210525
+ 7739.999752ps      -9.3049312
+ 7749.999753ps      -9.3026484
+ 7759.999754ps      -9.2811971
+ 7769.999755ps      -9.2920096
+ 7779.999756ps      -9.3186873
+ 7789.999756ps      -9.3304926
+ 7799.999757ps      -9.3465628
+ 7809.999758ps      -9.3709511
+ 7819.999759ps      -9.3506362
+ 7829.999760ps      -9.3123801
+ 7839.999761ps      -9.2951492
+ 7849.999761ps      -9.2874011
+ 7859.999762ps      -9.2880809
+ 7869.999763ps      -9.2861939
+ 7879.999764ps       -9.299545
+ 7889.999765ps      -9.3264723
+ 7899.999765ps      -9.3254495
+ 7909.999766ps      -9.2643047
+ 7919.999767ps       -9.231131
+ 7929.999768ps      -9.2292854
+ 7939.999769ps       -9.256509
+ 7949.999770ps      -9.2527778
+ 7959.999770ps      -9.2404118
+ 7969.999771ps      -9.2332454
+ 7979.999772ps      -9.2242331
+ 7989.999773ps      -9.3653916
+)

Icursig7 PAR_0_1_VDD075CPU 0 pwl(
+ 0.000000ps       5.3806801
+ 10.000000ps       5.5477786
+ 20.000000ps       5.9866112
+ 29.999999ps       6.5087647
+ 40.000000ps       7.0300976
+ 50.000001ps       7.4991271
+ 59.999998ps        7.912944
+ 69.999999ps       8.2790421
+ 80.000000ps       8.6030356
+ 90.000001ps       8.8915591
+ 100.000001ps       9.1466695
+ 110.000002ps       9.3311483
+ 119.999996ps       9.5162201
+ 129.999997ps       9.6774452
+ 139.999998ps       9.8336795
+ 149.999999ps       9.9856848
+ 159.999999ps        10.07867
+ 170.000000ps       10.180934
+ 180.000001ps       10.259973
+ 190.000002ps       10.337474
+ 200.000003ps       10.403225
+ 210.000003ps        10.46445
+ 220.000004ps       10.523217
+ 230.000005ps       10.586374
+ 239.999992ps       10.655304
+ 249.999993ps       10.726992
+ 259.999994ps       10.813606
+ 269.999995ps       10.898306
+ 279.999995ps       10.975861
+ 289.999996ps       11.030913
+ 299.999997ps       11.074663
+ 309.999998ps        11.11974
+ 319.999999ps       11.132821
+ 330.000000ps        11.17537
+ 340.000000ps       11.240979
+ 350.000001ps        11.28657
+ 360.000002ps       11.321213
+ 370.000003ps       11.380045
+ 380.000004ps        11.42158
+ 390.000005ps       11.446483
+ 400.000005ps       11.429056
+ 410.000006ps       11.411228
+ 420.000007ps        11.40192
+ 430.000008ps       11.406915
+ 440.000009ps       11.383914
+ 450.000009ps       11.374951
+ 460.000010ps       11.401723
+ 469.999983ps       11.426561
+ 479.999984ps        11.44346
+ 489.999985ps       11.430152
+ 499.999986ps       11.434498
+ 509.999987ps       11.455529
+ 519.999988ps       11.476359
+ 529.999988ps       11.479256
+ 539.999989ps       11.529059
+ 549.999990ps       11.561982
+ 559.999991ps       11.594361
+ 569.999992ps       11.607998
+ 579.999992ps       11.584078
+ 589.999993ps       11.594252
+ 599.999994ps       11.556158
+ 609.999995ps       11.544886
+ 619.999996ps       11.539855
+ 629.999997ps       11.536071
+ 639.999997ps       11.551617
+ 649.999998ps        11.55034
+ 659.999999ps       11.541039
+ 670.000000ps       11.566551
+ 680.000001ps       11.603787
+ 690.000002ps       11.616138
+ 700.000002ps       11.609342
+ 710.000003ps       11.618592
+ 720.000004ps       11.636305
+ 730.000005ps       11.635341
+ 740.000006ps        11.60133
+ 750.000007ps       11.582673
+ 760.000007ps       11.556365
+ 770.000008ps       11.540357
+ 780.000009ps       11.531848
+ 790.000010ps       11.512279
+ 800.000011ps       11.503353
+ 810.000012ps       11.506681
+ 820.000012ps        11.52205
+ 830.000013ps       11.520881
+ 840.000014ps       11.520519
+ 850.000015ps       11.507485
+ 860.000016ps       11.495181
+ 870.000016ps       11.495102
+ 880.000017ps       11.507513
+ 890.000018ps       11.530096
+ 900.000019ps       11.539042
+ 910.000020ps       11.525038
+ 920.000021ps       11.497533
+ 930.000021ps       11.463327
+ 939.999967ps         11.4111
+ 949.999968ps       11.347323
+ 959.999968ps       11.269914
+ 969.999969ps       11.212706
+ 979.999970ps       11.168634
+ 989.999971ps       11.094468
+ 999.999972ps       11.036651
+ 1009.999973ps       10.959051
+ 1019.999973ps       10.883564
+ 1029.999974ps       10.793293
+ 1039.999975ps       10.684897
+ 1049.999976ps        10.58248
+ 1059.999977ps       10.506992
+ 1069.999978ps       10.434895
+ 1079.999978ps        10.36564
+ 1089.999979ps       10.297164
+ 1099.999980ps       10.220077
+ 1109.999981ps       10.126702
+ 1119.999982ps        10.05275
+ 1129.999982ps       9.9836538
+ 1139.999983ps       9.9260847
+ 1149.999984ps       9.8524036
+ 1159.999985ps       9.7804547
+ 1169.999986ps       9.7197677
+ 1179.999987ps       9.6670338
+ 1189.999987ps        9.628324
+ 1199.999988ps       9.5857612
+ 1209.999989ps       9.5597413
+ 1219.999990ps       9.5475529
+ 1229.999991ps       9.5300547
+ 1239.999992ps       9.5090094
+ 1249.999992ps       9.4646366
+ 1259.999993ps       9.4514957
+ 1269.999994ps       9.4353593
+ 1279.999995ps       9.4246175
+ 1289.999996ps       9.4316822
+ 1299.999997ps        9.418207
+ 1309.999997ps        9.421943
+ 1319.999998ps       9.4292633
+ 1329.999999ps       9.4432645
+ 1340.000000ps        9.473318
+ 1350.000001ps       9.4750186
+ 1360.000002ps       9.5037073
+ 1370.000002ps       9.5385831
+ 1380.000003ps       9.5652029
+ 1390.000004ps        9.572539
+ 1400.000005ps       9.5597724
+ 1410.000006ps       9.5386254
+ 1420.000006ps       9.5134073
+ 1430.000007ps       9.4886501
+ 1440.000008ps       9.4635847
+ 1450.000009ps       9.4491945
+ 1460.000010ps       9.4099181
+ 1470.000011ps       9.3885513
+ 1480.000011ps       9.3634763
+ 1490.000012ps        9.353045
+ 1500.000013ps       9.3560851
+ 1510.000014ps       9.3982479
+ 1520.000015ps       9.4250334
+ 1530.000016ps       9.4439564
+ 1540.000016ps       9.4647838
+ 1550.000017ps       9.5015537
+ 1560.000018ps       9.5128212
+ 1570.000019ps       9.4953619
+ 1580.000020ps        9.499884
+ 1590.000021ps       9.4933172
+ 1600.000021ps       9.4780099
+ 1610.000022ps       9.4317709
+ 1620.000023ps       9.3902677
+ 1630.000024ps       9.3298465
+ 1640.000025ps       9.2883836
+ 1650.000025ps       9.2379601
+ 1660.000026ps       9.2189294
+ 1670.000027ps       9.2454631
+ 1680.000028ps       9.2687745
+ 1690.000029ps       9.3032481
+ 1700.000030ps       9.3065076
+ 1710.000030ps       9.3307324
+ 1720.000031ps       9.3472948
+ 1730.000032ps        9.353585
+ 1740.000033ps       9.3440919
+ 1750.000034ps       9.3316558
+ 1760.000035ps       9.3187223
+ 1770.000035ps        9.274189
+ 1780.000036ps       9.2320398
+ 1790.000037ps       9.2050585
+ 1800.000038ps       9.1705656
+ 1810.000039ps       9.1369043
+ 1820.000040ps       9.0842222
+ 1830.000040ps       9.0640918
+ 1840.000041ps        9.057697
+ 1850.000042ps       9.0739316
+ 1860.000043ps       9.0927197
+ 1869.999933ps       9.1054404
+ 1879.999934ps       9.1163309
+ 1889.999934ps       9.1291182
+ 1899.999935ps       9.1571966
+ 1909.999936ps       9.1836608
+ 1919.999937ps       9.1947346
+ 1929.999938ps       9.2018237
+ 1939.999938ps       9.1849878
+ 1949.999939ps       9.1618819
+ 1959.999940ps       9.1365609
+ 1969.999941ps       9.1086499
+ 1979.999942ps       9.0853333
+ 1989.999943ps       9.0447241
+ 1999.999943ps       9.0151521
+ 2009.999944ps       9.0094594
+ 2019.999945ps       9.0137463
+ 2029.999946ps       9.0328339
+ 2039.999947ps        9.045124
+ 2049.999948ps       9.0656421
+ 2059.999948ps       9.0698883
+ 2069.999949ps       9.0607757
+ 2079.999950ps         9.03694
+ 2089.999951ps       9.0104215
+ 2099.999952ps       8.9730014
+ 2109.999953ps       8.9469074
+ 2119.999953ps       8.9028906
+ 2129.999954ps       8.9148874
+ 2139.999955ps       8.9269084
+ 2149.999956ps       8.9425405
+ 2159.999957ps       8.9839314
+ 2169.999958ps       9.0070684
+ 2179.999958ps       9.0132808
+ 2189.999959ps       8.9966186
+ 2199.999960ps       9.0057407
+ 2209.999961ps       9.0176354
+ 2219.999962ps       9.0454502
+ 2229.999962ps       9.0611172
+ 2239.999963ps       9.0893824
+ 2249.999964ps       9.1227488
+ 2259.999965ps       9.1460625
+ 2269.999966ps       9.1397531
+ 2279.999967ps       9.1153535
+ 2289.999967ps       9.0867127
+ 2299.999968ps       9.0892433
+ 2309.999969ps       9.0641317
+ 2319.999970ps        9.049082
+ 2329.999971ps       9.0642828
+ 2339.999972ps       9.0956409
+ 2349.999972ps       9.1362714
+ 2359.999973ps        9.136614
+ 2369.999974ps       9.1373862
+ 2379.999975ps       9.1289595
+ 2389.999976ps       9.1644614
+ 2399.999977ps       9.1509064
+ 2409.999977ps       9.1434537
+ 2419.999978ps        9.157505
+ 2429.999979ps       9.1778402
+ 2439.999980ps       9.2064837
+ 2449.999981ps       9.1880647
+ 2459.999982ps       9.1976844
+ 2469.999982ps       9.1951735
+ 2479.999983ps        9.183128
+ 2489.999984ps       9.1643719
+ 2499.999985ps       9.1526005
+ 2509.999986ps       9.1891081
+ 2519.999986ps       9.1762793
+ 2529.999987ps       9.1680501
+ 2539.999988ps       9.1759385
+ 2549.999989ps       9.1938343
+ 2559.999990ps       9.1894425
+ 2569.999991ps       9.1390734
+ 2579.999991ps        9.136449
+ 2589.999992ps        9.128048
+ 2599.999993ps        9.131012
+ 2609.999994ps       9.0983812
+ 2619.999995ps        9.068789
+ 2629.999996ps       9.0481572
+ 2639.999996ps       9.0135465
+ 2649.999997ps       8.9862707
+ 2659.999998ps       8.9832424
+ 2669.999999ps       8.9812753
+ 2680.000000ps       8.9829222
+ 2690.000001ps        8.946372
+ 2700.000001ps       8.9317673
+ 2710.000002ps       8.9334333
+ 2720.000003ps        8.937916
+ 2730.000004ps       8.9427464
+ 2740.000005ps       8.9508803
+ 2750.000005ps        8.959875
+ 2760.000006ps       8.9653188
+ 2770.000007ps         8.95815
+ 2780.000008ps       8.9384262
+ 2790.000009ps       8.8949101
+ 2800.000010ps       8.8636018
+ 2810.000010ps       8.8367473
+ 2820.000011ps       8.8210397
+ 2830.000012ps       8.7918675
+ 2840.000013ps       8.7732775
+ 2850.000014ps       8.7612494
+ 2860.000015ps       8.7558637
+ 2870.000015ps       8.7674043
+ 2880.000016ps       8.7748661
+ 2890.000017ps       8.8105035
+ 2900.000018ps       8.8297322
+ 2910.000019ps       8.8476792
+ 2920.000020ps        8.882385
+ 2930.000020ps       8.8960465
+ 2940.000021ps       8.8954367
+ 2950.000022ps       8.8533074
+ 2960.000023ps       8.8201944
+ 2970.000024ps       8.7942854
+ 2980.000025ps       8.7519452
+ 2990.000025ps       8.7407891
+ 3000.000026ps       8.7629281
+ 3010.000027ps       8.7890903
+ 3020.000028ps       8.8240432
+ 3030.000029ps       8.8275714
+ 3040.000029ps       8.8495664
+ 3050.000030ps       8.8628808
+ 3060.000031ps       8.8897154
+ 3070.000032ps       8.8723348
+ 3080.000033ps       8.8705555
+ 3090.000034ps       8.8782088
+ 3100.000034ps         8.88984
+ 3110.000035ps       8.9108027
+ 3120.000036ps       8.9172426
+ 3130.000037ps       8.9119813
+ 3140.000038ps       8.9059254
+ 3150.000039ps       8.8798237
+ 3160.000039ps       8.8729536
+ 3170.000040ps       8.8671253
+ 3180.000041ps       8.8543978
+ 3190.000042ps       8.8613117
+ 3200.000043ps       8.8699849
+ 3210.000044ps       8.8972345
+ 3220.000044ps       8.9256673
+ 3230.000045ps        8.938315
+ 3240.000046ps       8.9456405
+ 3250.000047ps        8.932493
+ 3260.000048ps       8.9328386
+ 3270.000049ps       8.9245515
+ 3280.000049ps       8.9370178
+ 3290.000050ps       8.9569297
+ 3300.000051ps       8.9758206
+ 3310.000052ps       8.9806075
+ 3320.000053ps       8.9804922
+ 3330.000053ps       8.9736495
+ 3340.000054ps       8.9535765
+ 3350.000055ps       8.9354018
+ 3360.000056ps       8.9429164
+ 3370.000057ps       8.9377725
+ 3380.000058ps        8.959649
+ 3390.000058ps       8.9724996
+ 3400.000059ps       8.9714311
+ 3410.000060ps       8.9717294
+ 3420.000061ps       8.9799882
+ 3430.000062ps       8.9598381
+ 3440.000063ps       8.9402477
+ 3450.000063ps       8.9698446
+ 3460.000064ps       9.0207616
+ 3470.000065ps       9.0496456
+ 3480.000066ps       9.0044037
+ 3490.000067ps       9.0102196
+ 3500.000068ps       9.0034007
+ 3510.000068ps       9.0148457
+ 3520.000069ps        8.956797
+ 3530.000070ps       8.9263591
+ 3540.000071ps       8.9143032
+ 3550.000072ps       8.9095689
+ 3560.000073ps       8.9068002
+ 3570.000073ps       8.8807251
+ 3580.000074ps       8.8698548
+ 3590.000075ps       8.8481657
+ 3600.000076ps       8.8104261
+ 3610.000077ps       8.7835997
+ 3620.000077ps       8.7690609
+ 3630.000078ps       8.7717871
+ 3640.000079ps       8.7765768
+ 3650.000080ps        8.810027
+ 3660.000081ps       8.8026489
+ 3670.000082ps       8.8027419
+ 3680.000082ps       8.8223055
+ 3690.000083ps       8.8377881
+ 3700.000084ps       8.8550223
+ 3710.000085ps        8.842742
+ 3720.000086ps       8.8465301
+ 3729.999865ps       8.8624902
+ 3739.999865ps       8.8715648
+ 3749.999866ps       8.8695485
+ 3759.999867ps       8.8776564
+ 3769.999868ps       8.8836991
+ 3779.999869ps       8.8896503
+ 3789.999869ps       8.8957395
+ 3799.999870ps       8.8895954
+ 3809.999871ps       8.9061163
+ 3819.999872ps       8.8821803
+ 3829.999873ps       8.8455145
+ 3839.999874ps       8.8397796
+ 3849.999874ps        8.825882
+ 3859.999875ps       8.8078831
+ 3869.999876ps       8.7988282
+ 3879.999877ps       8.8251364
+ 3889.999878ps       8.8674501
+ 3899.999879ps       8.8376511
+ 3909.999879ps       8.7956598
+ 3919.999880ps       8.7861489
+ 3929.999881ps       8.7874253
+ 3939.999882ps       8.8016574
+ 3949.999883ps       8.7850656
+ 3959.999884ps       8.7726423
+ 3969.999884ps       8.7531527
+ 3979.999885ps       8.7280976
+ 3989.999886ps       8.7512209
+ 3999.999887ps       8.9434527
+ 4009.999888ps       9.1818677
+ 4019.999889ps       9.3508601
+ 4029.999889ps       9.4520268
+ 4039.999890ps       9.5307215
+ 4049.999891ps       9.5962494
+ 4059.999892ps       9.6260573
+ 4069.999893ps       9.6263103
+ 4079.999893ps       9.6079549
+ 4089.999894ps       9.6099896
+ 4099.999895ps       9.6392615
+ 4109.999896ps       9.6518613
+ 4119.999897ps         9.67853
+ 4129.999898ps       9.7023209
+ 4139.999898ps       9.7332637
+ 4149.999899ps       9.7626842
+ 4159.999900ps       9.7643717
+ 4169.999901ps        9.779084
+ 4179.999902ps       9.7694791
+ 4189.999903ps       9.7770679
+ 4199.999903ps       9.7922991
+ 4209.999904ps       9.7982802
+ 4219.999905ps       9.7916634
+ 4229.999906ps       9.7779031
+ 4239.999907ps        9.763462
+ 4249.999908ps       9.7327737
+ 4259.999908ps        9.709071
+ 4269.999909ps       9.6751627
+ 4279.999910ps       9.6725915
+ 4289.999911ps        9.665175
+ 4299.999912ps       9.6626755
+ 4309.999913ps       9.6646217
+ 4319.999913ps       9.6587891
+ 4329.999914ps       9.6711322
+ 4339.999915ps         9.70756
+ 4349.999916ps       9.7194116
+ 4359.999917ps       9.7368298
+ 4369.999917ps       9.7626367
+ 4379.999918ps       9.7832605
+ 4389.999919ps       9.7821348
+ 4399.999920ps       9.7416394
+ 4409.999921ps       9.7127589
+ 4419.999922ps       9.6926934
+ 4429.999922ps       9.6882115
+ 4439.999923ps       9.6532667
+ 4449.999924ps       9.6330282
+ 4459.999925ps        9.639839
+ 4469.999926ps       9.6526963
+ 4479.999927ps       9.6606612
+ 4489.999927ps       9.6430872
+ 4499.999928ps       9.6372999
+ 4509.999929ps       9.6399839
+ 4519.999930ps       9.6532957
+ 4529.999931ps       9.6522536
+ 4539.999932ps       9.6908099
+ 4549.999932ps       9.7180837
+ 4559.999933ps       9.7383648
+ 4569.999934ps       9.7554821
+ 4579.999935ps       9.7364208
+ 4589.999936ps       9.7437073
+ 4599.999937ps       9.7164201
+ 4609.999937ps       9.7013444
+ 4619.999938ps       9.7084598
+ 4629.999939ps       9.7069236
+ 4639.999940ps       9.7248141
+ 4649.999941ps       9.7204997
+ 4659.999941ps       9.7135092
+ 4669.999942ps       9.7297899
+ 4679.999943ps       9.7710062
+ 4689.999944ps       9.7849249
+ 4699.999945ps       9.7785106
+ 4709.999946ps       9.7904753
+ 4719.999946ps       9.8051622
+ 4729.999947ps       9.8036337
+ 4739.999948ps       9.7755586
+ 4749.999949ps       9.7573139
+ 4759.999950ps       9.7394655
+ 4769.999951ps       9.7268492
+ 4779.999951ps       9.7176994
+ 4789.999952ps       9.7089143
+ 4799.999953ps       9.7142824
+ 4809.999954ps       9.7312285
+ 4819.999955ps       9.7409559
+ 4829.999956ps       9.7486622
+ 4839.999956ps       9.7655504
+ 4849.999957ps        9.766018
+ 4859.999958ps        9.760026
+ 4869.999959ps       9.7773609
+ 4879.999960ps       9.7981801
+ 4889.999961ps       9.8256029
+ 4899.999961ps       9.8438281
+ 4909.999962ps       9.8286909
+ 4919.999963ps       9.8079344
+ 4929.999964ps       9.7891678
+ 4939.999965ps       9.7242023
+ 4949.999965ps       9.6681096
+ 4959.999966ps       9.6038877
+ 4969.999967ps       9.5734935
+ 4979.999968ps       9.5599615
+ 4989.999969ps       9.5240489
+ 4999.999970ps       9.5117474
+ 5009.999970ps       9.4974457
+ 5019.999971ps       9.4883884
+ 5029.999972ps        9.467381
+ 5039.999973ps       9.4451691
+ 5049.999974ps       9.4143072
+ 5059.999975ps        9.416531
+ 5069.999975ps       9.4226455
+ 5079.999976ps       9.4334188
+ 5089.999977ps       9.4269868
+ 5099.999978ps       9.4057467
+ 5109.999979ps       9.3708591
+ 5119.999980ps       9.3481429
+ 5129.999980ps       9.3302906
+ 5139.999981ps       9.3171667
+ 5149.999982ps       9.2822765
+ 5159.999983ps       9.2580002
+ 5169.999984ps       9.2346244
+ 5179.999985ps        9.221603
+ 5189.999985ps       9.2122499
+ 5199.999986ps       9.1919877
+ 5209.999987ps       9.1968245
+ 5219.999988ps       9.2078057
+ 5229.999989ps       9.2140665
+ 5239.999989ps       9.2077972
+ 5249.999990ps       9.1901379
+ 5259.999991ps       9.1972454
+ 5269.999992ps       9.1966531
+ 5279.999993ps       9.2092716
+ 5289.999994ps       9.2422636
+ 5299.999994ps       9.2413535
+ 5309.999995ps       9.2598894
+ 5319.999996ps       9.2883998
+ 5329.999997ps       9.3149266
+ 5339.999998ps         9.35711
+ 5349.999999ps       9.3708412
+ 5359.999999ps       9.4168969
+ 5370.000000ps       9.4555086
+ 5380.000001ps       9.4918986
+ 5390.000002ps        9.506078
+ 5400.000003ps        9.506122
+ 5410.000004ps       9.4907802
+ 5420.000004ps       9.4747871
+ 5430.000005ps       9.4601379
+ 5440.000006ps       9.4423506
+ 5450.000007ps        9.432115
+ 5460.000008ps       9.4136683
+ 5470.000009ps       9.3983619
+ 5480.000009ps       9.3819087
+ 5490.000010ps       9.3767769
+ 5500.000011ps       9.3925906
+ 5510.000012ps       9.4379646
+ 5520.000013ps       9.4671896
+ 5530.000013ps       9.4751686
+ 5540.000014ps       9.4951338
+ 5550.000015ps       9.5338511
+ 5560.000016ps       9.5400927
+ 5570.000017ps       9.5190537
+ 5580.000018ps       9.5215302
+ 5590.000018ps       9.5161051
+ 5600.000019ps       9.5080945
+ 5610.000020ps       9.4608301
+ 5620.000021ps       9.4277658
+ 5630.000022ps       9.3667331
+ 5640.000023ps       9.3253547
+ 5650.000023ps       9.2832801
+ 5660.000024ps       9.2702621
+ 5670.000025ps       9.3017226
+ 5680.000026ps       9.3282641
+ 5690.000027ps       9.3652951
+ 5700.000028ps       9.3676318
+ 5710.000028ps       9.3913551
+ 5720.000029ps        9.409666
+ 5730.000030ps       9.4226192
+ 5740.000031ps       9.4179111
+ 5750.000032ps       9.3995274
+ 5760.000033ps       9.3859764
+ 5770.000033ps       9.3436645
+ 5780.000034ps       9.3020073
+ 5790.000035ps       9.2664233
+ 5800.000036ps        9.230525
+ 5810.000037ps       9.1964429
+ 5820.000037ps        9.148829
+ 5830.000038ps       9.1360842
+ 5840.000039ps       9.1323583
+ 5850.000040ps       9.1535081
+ 5860.000041ps       9.1793606
+ 5870.000042ps       9.1858064
+ 5880.000042ps       9.1932211
+ 5890.000043ps       9.2017544
+ 5900.000044ps       9.2290946
+ 5910.000045ps       9.2533297
+ 5920.000046ps       9.2583687
+ 5930.000047ps       9.2587179
+ 5940.000047ps       9.2450388
+ 5950.000048ps       9.2308927
+ 5960.000049ps       9.2082912
+ 5970.000050ps       9.1812348
+ 5980.000051ps       9.1519538
+ 5990.000052ps       9.1160475
+ 6000.000052ps       9.0792385
+ 6010.000053ps       9.0781821
+ 6020.000054ps       9.0859837
+ 6030.000055ps       9.1020893
+ 6040.000056ps       9.1282682
+ 6050.000056ps       9.1601921
+ 6060.000057ps        9.172032
+ 6070.000058ps       9.1758604
+ 6080.000059ps       9.1528142
+ 6090.000060ps       9.1303627
+ 6100.000061ps       9.0858724
+ 6110.000061ps       9.0559162
+ 6120.000062ps       9.0166482
+ 6130.000063ps       9.0229441
+ 6140.000064ps       9.0367063
+ 6150.000065ps       9.0514272
+ 6160.000066ps       9.0907141
+ 6170.000066ps       9.1153418
+ 6180.000067ps       9.1217705
+ 6190.000068ps       9.1068521
+ 6200.000069ps       9.1205405
+ 6210.000070ps       9.1296951
+ 6220.000071ps       9.1634607
+ 6230.000071ps        9.183793
+ 6240.000072ps       9.2060132
+ 6250.000073ps       9.2301255
+ 6260.000074ps        9.246348
+ 6270.000075ps       9.2426605
+ 6280.000076ps       9.2227312
+ 6290.000076ps        9.201236
+ 6300.000077ps       9.2024313
+ 6310.000078ps       9.1858708
+ 6320.000079ps       9.1700612
+ 6330.000080ps        9.185802
+ 6340.000080ps       9.2206946
+ 6350.000081ps       9.2608766
+ 6360.000082ps       9.2568483
+ 6370.000083ps       9.2594003
+ 6380.000084ps       9.2524927
+ 6390.000085ps       9.2785114
+ 6400.000085ps       9.2696852
+ 6410.000086ps        9.270963
+ 6420.000087ps       9.2864718
+ 6430.000088ps       9.3012315
+ 6440.000089ps       9.3204357
+ 6450.000090ps       9.3043438
+ 6460.000090ps       9.3102671
+ 6470.000091ps       9.3021371
+ 6480.000092ps       9.2935491
+ 6490.000093ps       9.2755393
+ 6500.000094ps       9.2630667
+ 6510.000095ps       9.2920542
+ 6520.000095ps       9.2788699
+ 6530.000096ps       9.2834357
+ 6540.000097ps       9.2959468
+ 6550.000098ps       9.3105003
+ 6560.000099ps        9.304189
+ 6570.000100ps       9.2481253
+ 6580.000100ps       9.2416544
+ 6590.000101ps       9.2319647
+ 6600.000102ps       9.2387805
+ 6610.000103ps       9.2045272
+ 6620.000104ps       9.1752996
+ 6630.000104ps       9.1609784
+ 6640.000105ps       9.1317566
+ 6650.000106ps       9.1080935
+ 6660.000107ps        9.105515
+ 6670.000108ps        9.090191
+ 6680.000109ps       9.0919169
+ 6690.000109ps       9.0404248
+ 6700.000110ps       9.0193074
+ 6710.000111ps       9.0211785
+ 6720.000112ps       9.0237088
+ 6730.000113ps       9.0338227
+ 6740.000114ps        9.039788
+ 6750.000114ps       9.0501291
+ 6760.000115ps       9.0590426
+ 6770.000116ps       9.0483934
+ 6780.000117ps       9.0253581
+ 6790.000118ps       8.9848072
+ 6800.000119ps       8.9563218
+ 6810.000119ps       8.9406835
+ 6820.000120ps       8.9264499
+ 6830.000121ps       8.8976925
+ 6840.000122ps       8.8821441
+ 6850.000123ps       8.8728208
+ 6860.000124ps       8.8665838
+ 6870.000124ps       8.8671303
+ 6880.000125ps       8.8768707
+ 6890.000126ps       8.9108383
+ 6900.000127ps       8.9194154
+ 6910.000128ps       8.9384299
+ 6920.000128ps        8.963343
+ 6930.000129ps       8.9818293
+ 6940.000130ps       8.9861168
+ 6950.000131ps       8.9386169
+ 6960.000132ps       8.8990835
+ 6970.000133ps       8.8713314
+ 6980.000133ps       8.8335039
+ 6990.000134ps       8.8282118
+ 7000.000135ps       8.8468516
+ 7010.000136ps       8.8744262
+ 7020.000137ps       8.9026458
+ 7030.000138ps       8.9062903
+ 7040.000138ps       8.9304792
+ 7050.000139ps       8.9435251
+ 7060.000140ps       8.9731824
+ 7070.000141ps       8.9619995
+ 7080.000142ps        8.956423
+ 7090.000143ps        8.968258
+ 7100.000143ps       8.9837216
+ 7110.000144ps       9.0019995
+ 7120.000145ps       9.0050906
+ 7130.000146ps       9.0130593
+ 7140.000147ps       9.0044337
+ 7150.000147ps       8.9780771
+ 7160.000148ps       8.9629804
+ 7170.000149ps       8.9581725
+ 7180.000150ps       8.9514268
+ 7190.000151ps       8.9608192
+ 7200.000152ps         8.97159
+ 7210.000152ps       9.0062104
+ 7220.000153ps       9.0453123
+ 7230.000154ps       9.0499945
+ 7240.000155ps       9.0588238
+ 7250.000156ps       9.0419089
+ 7260.000157ps       9.0394348
+ 7270.000157ps       9.0246281
+ 7280.000158ps       9.0358127
+ 7290.000159ps       9.0540986
+ 7300.000160ps       9.0710074
+ 7310.000161ps       9.0704642
+ 7320.000162ps       9.0609931
+ 7330.000162ps       9.0550719
+ 7340.000163ps       9.0345336
+ 7350.000164ps       9.0235343
+ 7360.000165ps       9.0297911
+ 7370.000166ps       9.0169813
+ 7380.000167ps           9.043
+ 7390.000167ps       9.0529713
+ 7400.000168ps       9.0566576
+ 7410.000169ps       9.0615864
+ 7420.000170ps       9.0708245
+ 7430.000171ps       9.0457788
+ 7440.000171ps       9.0212267
+ 7450.000172ps       9.0602426
+ 7459.999729ps       9.1033197
+ 7469.999730ps       9.1366068
+ 7479.999731ps       9.0970402
+ 7489.999732ps       9.1050557
+ 7499.999732ps       9.0947557
+ 7509.999733ps       9.0973631
+ 7519.999734ps       9.0455596
+ 7529.999735ps       9.0117406
+ 7539.999736ps       8.9976623
+ 7549.999737ps       9.0013719
+ 7559.999737ps       9.0134843
+ 7569.999738ps       8.9938653
+ 7579.999739ps       8.9812357
+ 7589.999740ps       8.9627573
+ 7599.999741ps       8.9303967
+ 7609.999741ps       8.8966806
+ 7619.999742ps       8.8775208
+ 7629.999743ps       8.8877274
+ 7639.999744ps       8.8935404
+ 7649.999745ps       8.9172161
+ 7659.999746ps       8.9010405
+ 7669.999746ps       8.9079659
+ 7679.999747ps       8.9233452
+ 7689.999748ps       8.9416328
+ 7699.999749ps       8.9617575
+ 7709.999750ps       8.9459901
+ 7719.999751ps       8.9506296
+ 7729.999751ps        8.969575
+ 7739.999752ps       8.9816105
+ 7749.999753ps       8.9785101
+ 7759.999754ps       8.9869798
+ 7769.999755ps       8.9918248
+ 7779.999756ps       8.9947064
+ 7789.999756ps       8.9911458
+ 7799.999757ps       8.9838938
+ 7809.999758ps         8.99841
+ 7819.999759ps       8.9807826
+ 7829.999760ps       8.9484587
+ 7839.999761ps       8.9363048
+ 7849.999761ps       8.9212514
+ 7859.999762ps       8.9045316
+ 7869.999763ps       8.8948314
+ 7879.999764ps       8.9152421
+ 7889.999765ps        8.956384
+ 7899.999765ps       8.9299244
+ 7909.999766ps       8.8945075
+ 7919.999767ps       8.8853604
+ 7929.999768ps       8.8897011
+ 7939.999769ps       8.9061897
+ 7949.999770ps       8.8877695
+ 7959.999770ps       8.8718535
+ 7969.999771ps       8.8482873
+ 7979.999772ps       8.8233719
+ 7989.999773ps        8.837916
+)

Icursig8 PAR_1_1_VSS 0 pwl(
+ 0.000000ps      -2.2112659
+ 10.000000ps      -2.3206604
+ 20.000000ps      -2.5336384
+ 29.999999ps      -2.7573126
+ 40.000000ps       -2.945401
+ 50.000001ps      -3.1146541
+ 59.999998ps      -3.2788854
+ 69.999999ps      -3.4146844
+ 80.000000ps      -3.5280487
+ 90.000001ps      -3.5490719
+ 100.000001ps      -3.5088093
+ 110.000002ps      -3.4589153
+ 119.999996ps      -3.4016517
+ 129.999997ps      -3.3647579
+ 139.999998ps       -3.345731
+ 149.999999ps      -3.3410332
+ 159.999999ps      -3.3396166
+ 170.000000ps      -3.3391002
+ 180.000001ps      -3.3423883
+ 190.000002ps      -3.3424478
+ 200.000003ps      -3.3360304
+ 210.000003ps      -3.3524362
+ 220.000004ps       -3.349186
+ 230.000005ps      -3.3495815
+ 239.999992ps      -3.3586021
+ 249.999993ps      -3.3780253
+ 259.999994ps      -3.4009051
+ 269.999995ps      -3.4004987
+ 279.999995ps      -3.3877177
+ 289.999996ps      -3.3845374
+ 299.999997ps      -3.3848741
+ 309.999998ps      -3.3964235
+ 319.999999ps      -3.3960897
+ 330.000000ps       -3.416204
+ 340.000000ps      -3.4409586
+ 350.000001ps      -3.4453759
+ 360.000002ps      -3.4266675
+ 370.000003ps      -3.4358199
+ 380.000004ps      -3.4204137
+ 390.000005ps      -3.4318427
+ 400.000005ps      -3.4247573
+ 410.000006ps      -3.4164399
+ 420.000007ps      -3.4178836
+ 430.000008ps      -3.4194578
+ 440.000009ps      -3.4407875
+ 450.000009ps      -3.4596784
+ 460.000010ps      -3.4832329
+ 469.999983ps      -3.5272943
+ 479.999984ps      -3.5755997
+ 489.999985ps      -3.6233281
+ 499.999986ps      -3.6300727
+ 509.999987ps      -3.6098273
+ 519.999988ps      -3.5802893
+ 529.999988ps      -3.5427999
+ 539.999989ps      -3.5095368
+ 549.999990ps      -3.4726359
+ 559.999991ps      -3.4641749
+ 569.999992ps      -3.4494065
+ 579.999992ps      -3.4335104
+ 589.999993ps      -3.4305246
+ 599.999994ps      -3.4225744
+ 609.999995ps      -3.4162031
+ 619.999996ps      -3.4123448
+ 629.999997ps      -3.4192285
+ 639.999997ps      -3.4178068
+ 649.999998ps      -3.4315899
+ 659.999999ps      -3.4415315
+ 670.000000ps       -3.440686
+ 680.000001ps      -3.4368059
+ 690.000002ps      -3.4323036
+ 700.000002ps      -3.4359361
+ 710.000003ps      -3.4208561
+ 720.000004ps      -3.4001867
+ 730.000005ps      -3.3956424
+ 740.000006ps      -3.4048667
+ 750.000007ps      -3.3985068
+ 760.000007ps      -3.3964494
+ 770.000008ps      -3.4195766
+ 780.000009ps      -3.4250218
+ 790.000010ps      -3.4258692
+ 800.000011ps      -3.4136807
+ 810.000012ps      -3.4301124
+ 820.000012ps      -3.4301101
+ 830.000013ps       -3.409656
+ 840.000014ps      -3.4006485
+ 850.000015ps      -3.4096815
+ 860.000016ps      -3.4305677
+ 870.000016ps      -3.4751934
+ 880.000017ps      -3.5303289
+ 890.000018ps      -3.5878213
+ 900.000019ps      -3.6616046
+ 910.000020ps      -3.7228028
+ 920.000021ps      -3.7626395
+ 930.000021ps      -3.7214795
+ 939.999967ps      -3.6571396
+ 949.999968ps       -3.611426
+ 959.999968ps       -3.546842
+ 969.999969ps      -3.4948351
+ 979.999970ps      -3.4478785
+ 989.999971ps       -3.418607
+ 999.999972ps       -3.380127
+ 1009.999973ps      -3.3381637
+ 1019.999973ps      -3.3041988
+ 1029.999974ps      -3.2768471
+ 1039.999975ps      -3.2597674
+ 1049.999976ps      -3.2480492
+ 1059.999977ps      -3.2356748
+ 1069.999978ps      -3.2260506
+ 1079.999978ps      -3.2153603
+ 1089.999979ps      -3.2028986
+ 1099.999980ps      -3.1870674
+ 1109.999981ps      -3.1763488
+ 1119.999982ps      -3.1688955
+ 1129.999982ps      -3.1707966
+ 1139.999983ps       -3.175116
+ 1149.999984ps      -3.1999796
+ 1159.999985ps      -3.2142084
+ 1169.999986ps      -3.2024896
+ 1179.999987ps      -3.2026181
+ 1189.999987ps      -3.2128992
+ 1199.999988ps      -3.2139238
+ 1209.999989ps      -3.2009738
+ 1219.999990ps      -3.1859952
+ 1229.999991ps      -3.1813097
+ 1239.999992ps      -3.1885621
+ 1249.999992ps      -3.1855979
+ 1259.999993ps      -3.1955154
+ 1269.999994ps      -3.2075778
+ 1279.999995ps      -3.2271985
+ 1289.999996ps      -3.2498542
+ 1299.999997ps      -3.2815068
+ 1309.999997ps      -3.3309172
+ 1319.999998ps      -3.3826632
+ 1329.999999ps      -3.4272031
+ 1340.000000ps      -3.4398652
+ 1350.000001ps      -3.4392793
+ 1360.000002ps      -3.4279537
+ 1370.000002ps      -3.3998384
+ 1380.000003ps      -3.3740452
+ 1390.000004ps      -3.3427241
+ 1400.000005ps      -3.3091809
+ 1410.000006ps      -3.2742531
+ 1420.000006ps      -3.2533879
+ 1430.000007ps       -3.255205
+ 1440.000008ps      -3.2532241
+ 1450.000009ps       -3.267144
+ 1460.000010ps      -3.2808214
+ 1470.000011ps      -3.2860987
+ 1480.000011ps       -3.284841
+ 1490.000012ps      -3.2894063
+ 1500.000013ps      -3.3002707
+ 1510.000014ps      -3.3009021
+ 1520.000015ps      -3.2928654
+ 1530.000016ps      -3.2935169
+ 1540.000016ps       -3.291047
+ 1550.000017ps      -3.2977663
+ 1560.000018ps      -3.2938105
+ 1570.000019ps      -3.2893082
+ 1580.000020ps      -3.2778005
+ 1590.000021ps       -3.292046
+ 1600.000021ps      -3.3071717
+ 1610.000022ps      -3.3107419
+ 1620.000023ps      -3.3165034
+ 1630.000024ps       -3.315529
+ 1640.000025ps      -3.3112168
+ 1650.000025ps       -3.304705
+ 1660.000026ps      -3.2975914
+ 1670.000027ps      -3.2864763
+ 1680.000028ps      -3.2842089
+ 1690.000029ps      -3.3090374
+ 1700.000030ps      -3.3589971
+ 1710.000030ps      -3.4018734
+ 1720.000031ps      -3.4524363
+ 1730.000032ps      -3.5151817
+ 1740.000033ps      -3.5879103
+ 1750.000034ps      -3.6285735
+ 1760.000035ps      -3.5867326
+ 1770.000035ps      -3.5285743
+ 1780.000036ps      -3.4578025
+ 1790.000037ps      -3.4013157
+ 1800.000038ps      -3.3574841
+ 1810.000039ps      -3.3327939
+ 1820.000040ps      -3.3136628
+ 1830.000040ps      -3.3082575
+ 1840.000041ps      -3.3014489
+ 1850.000042ps      -3.3105428
+ 1860.000043ps      -3.2950051
+ 1869.999933ps      -3.2881387
+ 1879.999934ps       -3.285439
+ 1889.999934ps      -3.2782994
+ 1899.999935ps      -3.2914622
+ 1909.999936ps      -3.2565226
+ 1919.999937ps      -3.2275169
+ 1929.999938ps      -3.2057207
+ 1939.999938ps       -3.196869
+ 1949.999939ps      -3.1939955
+ 1959.999940ps      -3.1806327
+ 1969.999941ps      -3.1925995
+ 1979.999942ps      -3.2072248
+ 1989.999943ps        -3.20442
+ 1999.999943ps      -3.2083249
+ 2009.999944ps      -3.2206237
+ 2019.999945ps      -3.2246147
+ 2029.999946ps      -3.2270945
+ 2039.999947ps      -3.2356025
+ 2049.999948ps      -3.2315698
+ 2059.999948ps      -3.2351473
+ 2069.999949ps      -3.2388961
+ 2079.999950ps      -3.2377254
+ 2089.999951ps       -3.237699
+ 2099.999952ps      -3.2612205
+ 2109.999953ps      -3.2733232
+ 2119.999953ps      -3.2944157
+ 2129.999954ps      -3.3159657
+ 2139.999955ps      -3.3623856
+ 2149.999956ps      -3.4043426
+ 2159.999957ps      -3.4429858
+ 2169.999958ps        -3.45993
+ 2179.999958ps      -3.4417269
+ 2189.999959ps      -3.4155035
+ 2199.999960ps       -3.390413
+ 2209.999961ps      -3.3634276
+ 2219.999962ps      -3.3370007
+ 2229.999962ps      -3.3044528
+ 2239.999963ps      -3.2883244
+ 2249.999964ps      -3.2772586
+ 2259.999965ps      -3.2749534
+ 2269.999966ps      -3.2697376
+ 2279.999967ps      -3.2695036
+ 2289.999967ps      -3.2698787
+ 2299.999968ps      -3.2697624
+ 2309.999969ps      -3.2735135
+ 2319.999970ps      -3.2749018
+ 2329.999971ps      -3.2636861
+ 2339.999972ps      -3.2649042
+ 2349.999972ps      -3.2713517
+ 2359.999973ps        -3.26793
+ 2369.999974ps      -3.2647993
+ 2379.999975ps      -3.2731954
+ 2389.999976ps      -3.2741844
+ 2399.999977ps      -3.2753565
+ 2409.999977ps      -3.2703725
+ 2419.999978ps      -3.2599074
+ 2429.999979ps      -3.2486034
+ 2439.999980ps      -3.2362387
+ 2449.999981ps      -3.2304328
+ 2459.999982ps      -3.2185399
+ 2469.999982ps      -3.2127887
+ 2479.999983ps      -3.1961977
+ 2489.999984ps      -3.1950011
+ 2499.999985ps      -3.1927508
+ 2509.999986ps      -3.2044557
+ 2519.999986ps      -3.2265497
+ 2529.999987ps      -3.2546041
+ 2539.999988ps      -3.3262239
+ 2549.999989ps      -3.3805284
+ 2559.999990ps      -3.4612179
+ 2569.999991ps      -3.5509049
+ 2579.999991ps      -3.6222665
+ 2589.999992ps      -3.6242963
+ 2599.999993ps      -3.5530052
+ 2609.999994ps      -3.4602955
+ 2619.999995ps      -3.3750258
+ 2629.999996ps      -3.3213183
+ 2639.999996ps      -3.2729008
+ 2649.999997ps      -3.2510317
+ 2659.999998ps      -3.2255501
+ 2669.999999ps      -3.2157887
+ 2680.000000ps      -3.2004796
+ 2690.000001ps      -3.1909243
+ 2700.000001ps      -3.1915469
+ 2710.000002ps      -3.1937426
+ 2720.000003ps      -3.1976002
+ 2730.000004ps      -3.2050898
+ 2740.000005ps      -3.2069726
+ 2750.000005ps      -3.2106531
+ 2760.000006ps      -3.2098683
+ 2770.000007ps      -3.1998969
+ 2780.000008ps      -3.1936247
+ 2790.000009ps      -3.1801737
+ 2800.000010ps      -3.1633163
+ 2810.000010ps      -3.1407743
+ 2820.000011ps      -3.1322688
+ 2830.000012ps      -3.1310931
+ 2840.000013ps      -3.1163082
+ 2850.000014ps      -3.1154436
+ 2860.000015ps      -3.1293484
+ 2870.000015ps        -3.15555
+ 2880.000016ps      -3.1791796
+ 2890.000017ps      -3.1831908
+ 2900.000018ps      -3.2107995
+ 2910.000019ps      -3.2542558
+ 2920.000020ps      -3.2697421
+ 2930.000020ps      -3.2984172
+ 2940.000021ps      -3.3347354
+ 2950.000022ps      -3.3723764
+ 2960.000023ps      -3.4045654
+ 2970.000024ps      -3.3846117
+ 2980.000025ps      -3.3817602
+ 2990.000025ps       -3.400982
+ 3000.000026ps      -3.4083592
+ 3010.000027ps      -3.3925343
+ 3020.000028ps      -3.3728025
+ 3030.000029ps      -3.3369965
+ 3040.000029ps      -3.3212576
+ 3050.000030ps      -3.3095473
+ 3060.000031ps      -3.3164649
+ 3070.000032ps      -3.3264581
+ 3080.000033ps      -3.3277138
+ 3090.000034ps      -3.3379907
+ 3100.000034ps      -3.3624266
+ 3110.000035ps      -3.3667268
+ 3120.000036ps      -3.3605539
+ 3130.000037ps      -3.3413403
+ 3140.000038ps      -3.3188851
+ 3150.000039ps      -3.2983809
+ 3160.000039ps      -3.2852487
+ 3170.000040ps      -3.2721313
+ 3180.000041ps      -3.2634013
+ 3190.000042ps      -3.2677552
+ 3200.000043ps      -3.2667657
+ 3210.000044ps      -3.2636118
+ 3220.000044ps       -3.263518
+ 3230.000045ps      -3.2676432
+ 3240.000046ps       -3.279004
+ 3250.000047ps      -3.2938435
+ 3260.000048ps      -3.3042848
+ 3270.000049ps      -3.3160948
+ 3280.000049ps      -3.3169282
+ 3290.000050ps      -3.3191438
+ 3300.000051ps      -3.3065936
+ 3310.000052ps      -3.2948079
+ 3320.000053ps      -3.2880015
+ 3330.000053ps      -3.2774794
+ 3340.000054ps      -3.2738599
+ 3350.000055ps      -3.2792258
+ 3360.000056ps      -3.2952204
+ 3370.000057ps      -3.3441964
+ 3380.000058ps      -3.3981049
+ 3390.000058ps      -3.4847587
+ 3400.000059ps      -3.5800696
+ 3410.000060ps      -3.6653948
+ 3420.000061ps      -3.6865288
+ 3430.000062ps      -3.6444973
+ 3440.000063ps      -3.5746178
+ 3450.000063ps      -3.5072856
+ 3460.000064ps      -3.4398209
+ 3470.000065ps      -3.4011929
+ 3480.000066ps      -3.3689782
+ 3490.000067ps      -3.3506975
+ 3500.000068ps      -3.3221474
+ 3510.000068ps       -3.310358
+ 3520.000069ps      -3.2797947
+ 3530.000070ps      -3.2596454
+ 3540.000071ps      -3.2515638
+ 3550.000072ps      -3.2612304
+ 3560.000073ps      -3.2552296
+ 3570.000073ps      -3.2648233
+ 3580.000074ps      -3.2596646
+ 3590.000075ps       -3.249625
+ 3600.000076ps      -3.2551223
+ 3610.000077ps      -3.2322489
+ 3620.000077ps       -3.209229
+ 3630.000078ps      -3.1931458
+ 3640.000079ps      -3.1989506
+ 3650.000080ps      -3.2011834
+ 3660.000081ps      -3.1954772
+ 3670.000082ps      -3.1989743
+ 3680.000082ps      -3.1958298
+ 3690.000083ps      -3.2084527
+ 3700.000084ps      -3.2196325
+ 3710.000085ps      -3.2208167
+ 3720.000086ps      -3.2284567
+ 3729.999865ps      -3.2283857
+ 3739.999865ps      -3.2314168
+ 3749.999866ps      -3.2426759
+ 3759.999867ps      -3.2555316
+ 3769.999868ps      -3.2621777
+ 3779.999869ps      -3.2570059
+ 3789.999869ps       -3.265585
+ 3799.999870ps       -3.279389
+ 3809.999871ps      -3.3150415
+ 3819.999872ps      -3.3511064
+ 3829.999873ps      -3.3782767
+ 3839.999874ps       -3.362384
+ 3849.999874ps      -3.3502302
+ 3859.999875ps      -3.3277185
+ 3869.999876ps      -3.2921043
+ 3879.999877ps      -3.2444789
+ 3889.999878ps      -3.2138259
+ 3899.999879ps      -3.1916143
+ 3909.999879ps      -3.1738789
+ 3919.999880ps      -3.1687536
+ 3929.999881ps       -3.180529
+ 3939.999882ps      -3.1916609
+ 3949.999883ps      -3.2121188
+ 3959.999884ps      -3.2432862
+ 3969.999884ps      -3.2575339
+ 3979.999885ps      -3.2789871
+ 3989.999886ps      -3.2982137
+ 3999.999887ps      -3.3428934
+ 4009.999888ps      -3.4164879
+ 4019.999889ps      -3.4656483
+ 4029.999889ps      -3.5308933
+ 4039.999890ps      -3.5661526
+ 4049.999891ps      -3.5858139
+ 4059.999892ps      -3.6102432
+ 4069.999893ps      -3.6017713
+ 4079.999893ps      -3.6140476
+ 4089.999894ps       -3.627134
+ 4099.999895ps      -3.6588824
+ 4109.999896ps      -3.6797915
+ 4119.999897ps      -3.6965722
+ 4129.999898ps      -3.7293541
+ 4139.999898ps       -3.749887
+ 4149.999899ps      -3.7685554
+ 4159.999900ps      -3.7633088
+ 4169.999901ps      -3.7881465
+ 4179.999902ps      -3.8114996
+ 4189.999903ps      -3.8174861
+ 4199.999903ps       -3.843709
+ 4209.999904ps      -3.8763051
+ 4219.999905ps      -3.9049545
+ 4229.999906ps      -3.9487349
+ 4239.999907ps      -4.0343844
+ 4249.999908ps      -4.0840639
+ 4259.999908ps      -4.0429803
+ 4269.999909ps      -3.9661359
+ 4279.999910ps      -3.8834278
+ 4289.999911ps      -3.8262041
+ 4299.999912ps      -3.7765845
+ 4309.999913ps      -3.7480474
+ 4319.999913ps      -3.7247094
+ 4329.999914ps      -3.7287327
+ 4339.999915ps      -3.7386897
+ 4349.999916ps      -3.7352976
+ 4359.999917ps      -3.7124043
+ 4369.999917ps      -3.6963888
+ 4379.999918ps      -3.6841239
+ 4389.999919ps      -3.6911535
+ 4399.999920ps      -3.6736517
+ 4409.999921ps      -3.6611761
+ 4419.999922ps      -3.6561705
+ 4429.999922ps      -3.6485413
+ 4439.999923ps      -3.6632027
+ 4449.999924ps      -3.6566072
+ 4459.999925ps      -3.6645164
+ 4469.999926ps      -3.6662117
+ 4479.999927ps        -3.68449
+ 4489.999927ps      -3.6972634
+ 4499.999928ps      -3.6877614
+ 4509.999929ps      -3.6634763
+ 4519.999930ps      -3.6436622
+ 4529.999931ps      -3.6262079
+ 4539.999932ps      -3.6229761
+ 4549.999932ps      -3.6270717
+ 4559.999933ps      -3.6388215
+ 4569.999934ps      -3.6472431
+ 4579.999935ps      -3.6386495
+ 4589.999936ps      -3.6370643
+ 4599.999937ps      -3.6527632
+ 4609.999937ps      -3.6650617
+ 4619.999938ps       -3.680056
+ 4629.999939ps      -3.7081899
+ 4639.999940ps      -3.7436706
+ 4649.999941ps      -3.8160567
+ 4659.999941ps       -3.876129
+ 4669.999942ps      -3.8810321
+ 4679.999943ps       -3.848316
+ 4689.999944ps      -3.8286795
+ 4699.999945ps      -3.7901724
+ 4709.999946ps      -3.7520412
+ 4719.999946ps       -3.702936
+ 4729.999947ps      -3.6678952
+ 4739.999948ps      -3.6661108
+ 4749.999949ps      -3.6518958
+ 4759.999950ps      -3.6303864
+ 4769.999951ps      -3.6474947
+ 4779.999951ps      -3.6450133
+ 4789.999952ps      -3.6416958
+ 4799.999953ps      -3.6273452
+ 4809.999954ps      -3.6397375
+ 4819.999955ps      -3.6446312
+ 4829.999956ps      -3.6275648
+ 4839.999956ps      -3.6148618
+ 4849.999957ps      -3.6119625
+ 4859.999958ps      -3.6064577
+ 4869.999959ps      -3.5988844
+ 4879.999960ps      -3.6030715
+ 4889.999961ps      -3.5944828
+ 4899.999961ps      -3.5751361
+ 4909.999962ps      -3.5598208
+ 4919.999963ps      -3.5674665
+ 4929.999964ps      -3.5746659
+ 4939.999965ps      -3.5869024
+ 4949.999965ps       -3.607743
+ 4959.999966ps      -3.6080664
+ 4969.999967ps      -3.5953121
+ 4979.999968ps      -3.5672266
+ 4989.999969ps      -3.5262002
+ 4999.999970ps      -3.4770346
+ 5009.999970ps      -3.4251799
+ 5019.999971ps      -3.3952158
+ 5029.999972ps      -3.3690641
+ 5039.999973ps      -3.3890409
+ 5049.999974ps      -3.4219631
+ 5059.999975ps      -3.4765013
+ 5069.999975ps       -3.538901
+ 5079.999976ps      -3.5784095
+ 5089.999977ps       -3.527326
+ 5099.999978ps       -3.433255
+ 5109.999979ps      -3.3464003
+ 5119.999980ps      -3.2656973
+ 5129.999980ps       -3.205424
+ 5139.999981ps      -3.1694374
+ 5149.999982ps      -3.1607735
+ 5159.999983ps      -3.1533763
+ 5169.999984ps      -3.1326625
+ 5179.999985ps       -3.116374
+ 5189.999985ps      -3.1163175
+ 5199.999986ps      -3.1124646
+ 5209.999987ps      -3.0924022
+ 5219.999988ps      -3.0667524
+ 5229.999989ps      -3.0569389
+ 5239.999989ps      -3.0500159
+ 5249.999990ps       -3.050191
+ 5259.999991ps       -3.053394
+ 5269.999992ps      -3.0541421
+ 5279.999993ps      -3.0604667
+ 5289.999994ps      -3.0603327
+ 5299.999994ps      -3.0643327
+ 5309.999995ps      -3.0790097
+ 5319.999996ps      -3.0959385
+ 5329.999997ps      -3.1007772
+ 5339.999998ps      -3.1111709
+ 5349.999999ps      -3.1264738
+ 5359.999999ps      -3.1403584
+ 5370.000000ps      -3.1445297
+ 5380.000001ps      -3.1488543
+ 5390.000002ps      -3.1472129
+ 5400.000003ps      -3.1314221
+ 5410.000004ps      -3.1192984
+ 5420.000004ps      -3.1030224
+ 5430.000005ps      -3.1107699
+ 5440.000006ps       -3.128029
+ 5450.000007ps       -3.161455
+ 5460.000008ps      -3.1915372
+ 5470.000009ps      -3.2306601
+ 5480.000009ps      -3.2731656
+ 5490.000010ps      -3.3100572
+ 5500.000011ps      -3.3451098
+ 5510.000012ps      -3.3336341
+ 5520.000013ps      -3.3060114
+ 5530.000013ps      -3.2882213
+ 5540.000014ps        -3.25779
+ 5550.000015ps      -3.2326444
+ 5560.000016ps      -3.2023933
+ 5570.000017ps      -3.1740377
+ 5580.000018ps      -3.1489907
+ 5590.000018ps      -3.1542503
+ 5600.000019ps      -3.1587351
+ 5610.000020ps      -3.1557281
+ 5620.000021ps      -3.1615212
+ 5630.000022ps      -3.1564512
+ 5640.000023ps      -3.1573878
+ 5650.000023ps      -3.1580203
+ 5660.000024ps      -3.1498592
+ 5670.000025ps      -3.1406988
+ 5680.000026ps      -3.1269714
+ 5690.000027ps      -3.1342499
+ 5700.000028ps      -3.1452761
+ 5710.000028ps      -3.1413084
+ 5720.000029ps      -3.1246388
+ 5730.000030ps      -3.1103173
+ 5740.000031ps      -3.0946991
+ 5750.000032ps      -3.0761796
+ 5760.000033ps       -3.073424
+ 5770.000033ps      -3.0775627
+ 5780.000034ps       -3.086491
+ 5790.000035ps      -3.0931067
+ 5800.000036ps      -3.1045616
+ 5810.000037ps      -3.1145616
+ 5820.000037ps      -3.1185679
+ 5830.000038ps      -3.1254703
+ 5840.000039ps      -3.1299313
+ 5850.000040ps      -3.1582747
+ 5860.000041ps      -3.1778433
+ 5870.000042ps      -3.2106621
+ 5880.000042ps      -3.2587788
+ 5890.000043ps      -3.3345711
+ 5900.000044ps      -3.4337151
+ 5910.000045ps      -3.4691382
+ 5920.000046ps      -3.4470032
+ 5930.000047ps      -3.3838066
+ 5940.000047ps      -3.2986927
+ 5950.000048ps      -3.2263438
+ 5960.000049ps      -3.1566354
+ 5970.000050ps      -3.1217267
+ 5980.000051ps      -3.1041564
+ 5990.000052ps       -3.091093
+ 6000.000052ps      -3.0835101
+ 6010.000053ps      -3.0844909
+ 6020.000054ps      -3.0874176
+ 6030.000055ps      -3.0823824
+ 6040.000056ps      -3.0863636
+ 6050.000056ps      -3.0865264
+ 6060.000057ps      -3.0828503
+ 6070.000058ps      -3.0854426
+ 6080.000059ps      -3.0865109
+ 6090.000060ps      -3.0879807
+ 6100.000061ps      -3.1029196
+ 6110.000061ps      -3.1005475
+ 6120.000062ps      -3.1044237
+ 6130.000063ps      -3.1049689
+ 6140.000064ps      -3.1061332
+ 6150.000065ps      -3.1152904
+ 6160.000066ps      -3.1136419
+ 6170.000066ps      -3.1155829
+ 6180.000067ps      -3.1135683
+ 6190.000068ps      -3.1075128
+ 6200.000069ps      -3.1171632
+ 6210.000070ps      -3.1272666
+ 6220.000071ps      -3.1164748
+ 6230.000071ps      -3.1093004
+ 6240.000072ps      -3.0981902
+ 6250.000073ps      -3.0909667
+ 6260.000074ps      -3.0958506
+ 6270.000075ps      -3.1185383
+ 6280.000076ps      -3.1392934
+ 6290.000076ps      -3.1714095
+ 6300.000077ps      -3.1953646
+ 6310.000078ps      -3.2363058
+ 6320.000079ps      -3.2842795
+ 6330.000080ps      -3.3015347
+ 6340.000080ps      -3.2993029
+ 6350.000081ps      -3.2768722
+ 6360.000082ps      -3.2577775
+ 6370.000083ps      -3.2177195
+ 6380.000084ps      -3.1927436
+ 6390.000085ps      -3.1736802
+ 6400.000085ps      -3.1644557
+ 6410.000086ps      -3.1465531
+ 6420.000087ps      -3.1198911
+ 6430.000088ps      -3.1065009
+ 6440.000089ps      -3.0904169
+ 6450.000090ps      -3.0891302
+ 6460.000090ps       -3.082793
+ 6470.000091ps      -3.0761018
+ 6480.000092ps      -3.0625475
+ 6490.000093ps      -3.0586279
+ 6500.000094ps      -3.0560969
+ 6510.000095ps      -3.0598135
+ 6520.000095ps      -3.0604383
+ 6530.000096ps       -3.063348
+ 6540.000097ps       -3.080566
+ 6550.000098ps      -3.0839044
+ 6560.000099ps      -3.0861097
+ 6570.000100ps      -3.0837864
+ 6580.000100ps      -3.0783127
+ 6590.000101ps      -3.0856381
+ 6600.000102ps       -3.082904
+ 6610.000103ps      -3.0638807
+ 6620.000104ps      -3.0534457
+ 6630.000104ps       -3.050106
+ 6640.000105ps       -3.044622
+ 6650.000106ps      -3.0497338
+ 6660.000107ps       -3.035358
+ 6670.000108ps      -3.0362807
+ 6680.000109ps       -3.042928
+ 6690.000109ps      -3.0566564
+ 6700.000110ps      -3.1047685
+ 6710.000111ps      -3.1497472
+ 6720.000112ps      -3.2223395
+ 6730.000113ps      -3.3227262
+ 6740.000114ps      -3.4098499
+ 6750.000114ps      -3.4595509
+ 6760.000115ps      -3.4070207
+ 6770.000116ps      -3.3489646
+ 6780.000117ps      -3.2681241
+ 6790.000118ps      -3.1897505
+ 6800.000119ps      -3.1233963
+ 6810.000119ps      -3.0643157
+ 6820.000120ps      -3.0323325
+ 6830.000121ps      -3.0197862
+ 6840.000122ps       -2.998378
+ 6850.000123ps       -2.991657
+ 6860.000124ps       -2.999784
+ 6870.000124ps      -3.0237264
+ 6880.000125ps      -3.0481947
+ 6890.000126ps      -3.0566379
+ 6900.000127ps      -3.0790772
+ 6910.000128ps      -3.1317046
+ 6920.000128ps      -3.1386633
+ 6930.000129ps      -3.1556477
+ 6940.000130ps      -3.1756964
+ 6950.000131ps      -3.1843139
+ 6960.000132ps      -3.1896246
+ 6970.000133ps      -3.1404684
+ 6980.000133ps       -3.099219
+ 6990.000134ps      -3.0715185
+ 7000.000135ps      -3.0574746
+ 7010.000136ps      -3.0565552
+ 7020.000137ps      -3.0537886
+ 7030.000138ps      -3.0487691
+ 7040.000138ps      -3.0591378
+ 7050.000139ps      -3.0752257
+ 7060.000140ps      -3.1062006
+ 7070.000141ps      -3.1324913
+ 7080.000142ps      -3.1467198
+ 7090.000143ps      -3.1707834
+ 7100.000143ps      -3.2051056
+ 7110.000144ps       -3.234853
+ 7120.000145ps      -3.2580849
+ 7130.000146ps      -3.2677404
+ 7140.000147ps      -3.2848038
+ 7150.000147ps      -3.3064056
+ 7160.000148ps      -3.3203134
+ 7170.000149ps      -3.3037748
+ 7180.000150ps      -3.2785134
+ 7190.000151ps      -3.2561973
+ 7200.000152ps      -3.2278918
+ 7210.000152ps      -3.1986056
+ 7220.000153ps      -3.1749977
+ 7230.000154ps      -3.1537049
+ 7240.000155ps      -3.1553955
+ 7250.000156ps      -3.1535005
+ 7260.000157ps      -3.1579916
+ 7270.000157ps      -3.1702893
+ 7280.000158ps      -3.1721276
+ 7290.000159ps       -3.171164
+ 7300.000160ps      -3.1545398
+ 7310.000161ps      -3.1475106
+ 7320.000162ps      -3.1340499
+ 7330.000162ps      -3.1292864
+ 7340.000163ps      -3.1210185
+ 7350.000164ps       -3.122974
+ 7360.000165ps      -3.1157391
+ 7370.000166ps      -3.1107242
+ 7380.000167ps      -3.1158964
+ 7390.000167ps      -3.1272148
+ 7400.000168ps      -3.1396854
+ 7410.000169ps      -3.1433477
+ 7420.000170ps      -3.1537957
+ 7430.000171ps      -3.1622743
+ 7440.000171ps      -3.1671867
+ 7450.000172ps      -3.1608632
+ 7459.999729ps      -3.1573614
+ 7469.999730ps      -3.1524798
+ 7479.999731ps      -3.1498176
+ 7489.999732ps      -3.1506854
+ 7499.999732ps      -3.1387109
+ 7509.999733ps      -3.1352691
+ 7519.999734ps      -3.1340782
+ 7529.999735ps      -3.1553057
+ 7539.999736ps      -3.1956496
+ 7549.999737ps      -3.2700088
+ 7559.999737ps      -3.3505062
+ 7569.999738ps       -3.443209
+ 7579.999739ps      -3.4953043
+ 7589.999740ps      -3.4680601
+ 7599.999741ps      -3.4027822
+ 7609.999741ps      -3.3061034
+ 7619.999742ps      -3.2104125
+ 7629.999743ps       -3.152691
+ 7639.999744ps      -3.1252843
+ 7649.999745ps      -3.1097064
+ 7659.999746ps      -3.0868138
+ 7669.999746ps      -3.0797075
+ 7679.999747ps      -3.0788488
+ 7689.999748ps       -3.085916
+ 7699.999749ps       -3.088082
+ 7709.999750ps      -3.0854217
+ 7719.999751ps      -3.0928811
+ 7729.999751ps      -3.0912946
+ 7739.999752ps      -3.0916572
+ 7749.999753ps      -3.0936786
+ 7759.999754ps      -3.0964831
+ 7769.999755ps      -3.1022009
+ 7779.999756ps      -3.0842765
+ 7789.999756ps      -3.0620948
+ 7799.999757ps      -3.0481214
+ 7809.999758ps      -3.0466178
+ 7819.999759ps      -3.0489412
+ 7829.999760ps       -3.025258
+ 7839.999761ps      -3.0211642
+ 7849.999761ps      -3.0222189
+ 7859.999762ps      -3.0213539
+ 7869.999763ps      -3.0079419
+ 7879.999764ps      -2.9979499
+ 7889.999765ps      -2.9940166
+ 7899.999765ps      -2.9910809
+ 7909.999766ps      -2.9864217
+ 7919.999767ps      -2.9933412
+ 7929.999768ps        -3.01809
+ 7939.999769ps      -3.0587855
+ 7949.999770ps      -3.1064176
+ 7959.999770ps      -3.1519431
+ 7969.999771ps      -3.2115657
+ 7979.999772ps      -3.2679389
+ 7989.999773ps      -3.3540431
+)

Icursig9 PAR_1_1_VDD075CPU 0 pwl(
+ 0.000000ps       1.9835573
+ 10.000000ps       2.0321732
+ 20.000000ps       2.1542004
+ 29.999999ps       2.2994906
+ 40.000000ps       2.4514053
+ 50.000001ps       2.5861509
+ 59.999998ps       2.7103415
+ 69.999999ps       2.8204527
+ 80.000000ps        2.920495
+ 90.000001ps       2.9745044
+ 100.000001ps       3.0201483
+ 110.000002ps       3.0573254
+ 119.999996ps       3.0911922
+ 129.999997ps       3.1187903
+ 139.999998ps       3.1455373
+ 149.999999ps       3.1782833
+ 159.999999ps       3.1991269
+ 170.000000ps       3.2271864
+ 180.000001ps       3.2484791
+ 190.000002ps       3.2611141
+ 200.000003ps       3.2708093
+ 210.000003ps       3.2981087
+ 220.000004ps       3.3008886
+ 230.000005ps       3.3105709
+ 239.999992ps       3.3419517
+ 249.999993ps       3.3704266
+ 259.999994ps       3.4054119
+ 269.999995ps       3.3919193
+ 279.999995ps       3.3890689
+ 289.999996ps       3.3978917
+ 299.999997ps       3.4112045
+ 309.999998ps       3.4234628
+ 319.999999ps       3.4202688
+ 330.000000ps       3.4354708
+ 340.000000ps       3.4606665
+ 350.000001ps       3.4600394
+ 360.000002ps        3.455265
+ 370.000003ps       3.4584677
+ 380.000004ps       3.4568784
+ 390.000005ps       3.4617988
+ 400.000005ps       3.4438784
+ 410.000006ps        3.443311
+ 420.000007ps       3.4422483
+ 430.000008ps       3.4488151
+ 440.000009ps       3.4795027
+ 450.000009ps       3.4999495
+ 460.000010ps         3.53955
+ 469.999983ps       3.6030919
+ 479.999984ps       3.6733916
+ 489.999985ps       3.7499396
+ 499.999986ps       3.7762505
+ 509.999987ps        3.755674
+ 519.999988ps       3.7082068
+ 529.999988ps       3.6685677
+ 539.999989ps       3.6268106
+ 549.999990ps       3.5917654
+ 559.999991ps       3.5656661
+ 569.999992ps       3.5372773
+ 579.999992ps       3.5197995
+ 589.999993ps       3.4961218
+ 599.999994ps       3.4847194
+ 609.999995ps       3.4738544
+ 619.999996ps       3.4682994
+ 629.999997ps        3.471544
+ 639.999997ps       3.4727417
+ 649.999998ps       3.4903963
+ 659.999999ps       3.5076644
+ 670.000000ps       3.5140288
+ 680.000001ps       3.5102073
+ 690.000002ps       3.5074814
+ 700.000002ps        3.501074
+ 710.000003ps       3.4851829
+ 720.000004ps       3.4723662
+ 730.000005ps       3.4638007
+ 740.000006ps       3.4750658
+ 750.000007ps       3.4616663
+ 760.000007ps       3.4557718
+ 770.000008ps       3.4729213
+ 780.000009ps       3.4643916
+ 790.000010ps       3.4618621
+ 800.000011ps       3.4471226
+ 810.000012ps       3.4591587
+ 820.000012ps       3.4527743
+ 830.000013ps       3.4334567
+ 840.000014ps       3.4319796
+ 850.000015ps       3.4393863
+ 860.000016ps       3.4546187
+ 870.000016ps       3.4610108
+ 880.000017ps       3.4762108
+ 890.000018ps       3.4831857
+ 900.000019ps       3.4911852
+ 910.000020ps       3.5018306
+ 920.000021ps       3.5084029
+ 930.000021ps       3.5099661
+ 939.999967ps       3.5100433
+ 949.999968ps       3.5020391
+ 959.999968ps       3.4827736
+ 969.999969ps       3.4490961
+ 979.999970ps       3.4182308
+ 989.999971ps       3.3833727
+ 999.999972ps       3.3539969
+ 1009.999973ps        3.322187
+ 1019.999973ps       3.2896322
+ 1029.999974ps       3.2537836
+ 1039.999975ps        3.231034
+ 1049.999976ps       3.2078074
+ 1059.999977ps       3.1940431
+ 1069.999978ps       3.1746505
+ 1079.999978ps       3.1619476
+ 1089.999979ps       3.1382193
+ 1099.999980ps       3.1185758
+ 1109.999981ps       3.1051608
+ 1119.999982ps       3.0977226
+ 1129.999982ps       3.0870811
+ 1139.999983ps       3.0782784
+ 1149.999984ps       3.0858767
+ 1159.999985ps       3.0688601
+ 1169.999986ps       3.0558684
+ 1179.999987ps       3.0521186
+ 1189.999987ps       3.0528651
+ 1199.999988ps        3.051024
+ 1209.999989ps       3.0247089
+ 1219.999990ps       3.0024023
+ 1229.999991ps       2.9875077
+ 1239.999992ps       2.9763796
+ 1249.999992ps       2.9740837
+ 1259.999993ps       2.9791666
+ 1269.999994ps       2.9955068
+ 1279.999995ps       3.0187098
+ 1289.999996ps       3.0578903
+ 1299.999997ps       3.0958937
+ 1309.999997ps       3.1611166
+ 1319.999998ps       3.2319406
+ 1329.999999ps       3.2904721
+ 1340.000000ps        3.292581
+ 1350.000001ps       3.2609668
+ 1360.000002ps       3.2273617
+ 1370.000002ps       3.2001549
+ 1380.000003ps       3.1658016
+ 1390.000004ps        3.130611
+ 1400.000005ps       3.0966091
+ 1410.000006ps       3.0608919
+ 1420.000006ps       3.0351755
+ 1430.000007ps       3.0282172
+ 1440.000008ps        3.020436
+ 1450.000009ps       3.0227921
+ 1460.000010ps       3.0250617
+ 1470.000011ps       3.0277346
+ 1480.000011ps       3.0236904
+ 1490.000012ps        3.016412
+ 1500.000013ps       3.0195612
+ 1510.000014ps       3.0204378
+ 1520.000015ps        3.021749
+ 1530.000016ps       3.0297587
+ 1540.000016ps       3.0361518
+ 1550.000017ps       3.0333727
+ 1560.000018ps       3.0221883
+ 1570.000019ps       3.0133246
+ 1580.000020ps       3.0067918
+ 1590.000021ps       3.0080336
+ 1600.000021ps       3.0143946
+ 1610.000022ps       3.0173234
+ 1620.000023ps        3.018015
+ 1630.000024ps       3.0080177
+ 1640.000025ps        3.005668
+ 1650.000025ps       3.0028237
+ 1660.000026ps       2.9937706
+ 1670.000027ps       2.9815818
+ 1680.000028ps        2.981799
+ 1690.000029ps       2.9941788
+ 1700.000030ps       3.0150043
+ 1710.000030ps       3.0257734
+ 1720.000031ps       3.0345118
+ 1730.000032ps        3.036053
+ 1740.000033ps       3.0399039
+ 1750.000034ps       3.0366785
+ 1760.000035ps       3.0222529
+ 1770.000035ps       3.0100541
+ 1780.000036ps       2.9961558
+ 1790.000037ps       2.9820725
+ 1800.000038ps       2.9688549
+ 1810.000039ps       2.9611751
+ 1820.000040ps       2.9600016
+ 1830.000040ps       2.9596428
+ 1840.000041ps       2.9601067
+ 1850.000042ps       2.9797762
+ 1860.000043ps       2.9769064
+ 1869.999933ps       2.9704889
+ 1879.999934ps       2.9702016
+ 1889.999934ps       2.9755517
+ 1899.999935ps       2.9860809
+ 1909.999936ps       2.9427612
+ 1919.999937ps       2.9116566
+ 1929.999938ps       2.9022526
+ 1939.999938ps        2.895851
+ 1949.999939ps       2.8986419
+ 1959.999940ps       2.8870774
+ 1969.999941ps       2.8937489
+ 1979.999942ps       2.9009186
+ 1989.999943ps       2.9111378
+ 1999.999943ps       2.9163201
+ 2009.999944ps       2.9261488
+ 2019.999945ps       2.9308081
+ 2029.999946ps       2.9340939
+ 2039.999947ps       2.9329567
+ 2049.999948ps       2.9333655
+ 2059.999948ps       2.9359874
+ 2069.999949ps       2.9309961
+ 2079.999950ps       2.9301074
+ 2089.999951ps        2.938476
+ 2099.999952ps       2.9594436
+ 2109.999953ps       2.9816587
+ 2119.999953ps       3.0154226
+ 2129.999954ps       3.0591801
+ 2139.999955ps       3.1092805
+ 2149.999956ps       3.1746344
+ 2159.999957ps       3.2263903
+ 2169.999958ps       3.2432098
+ 2179.999958ps       3.2067086
+ 2189.999959ps       3.1594103
+ 2199.999960ps       3.1358536
+ 2209.999961ps       3.1025742
+ 2219.999962ps       3.0599677
+ 2229.999962ps       3.0203042
+ 2239.999963ps       2.9935542
+ 2249.999964ps       2.9790617
+ 2259.999965ps       2.9764502
+ 2269.999966ps       2.9776898
+ 2279.999967ps       2.9856108
+ 2289.999967ps        2.996134
+ 2299.999968ps       2.9963203
+ 2309.999969ps       3.0017652
+ 2319.999970ps       3.0050469
+ 2329.999971ps       3.0055055
+ 2339.999972ps       3.0078571
+ 2349.999972ps        3.000711
+ 2359.999973ps       2.9915235
+ 2369.999974ps       2.9797525
+ 2379.999975ps       2.9727215
+ 2389.999976ps        2.969704
+ 2399.999977ps       2.9639617
+ 2409.999977ps       2.9630597
+ 2419.999978ps       2.9556936
+ 2429.999979ps       2.9479994
+ 2439.999980ps       2.9393063
+ 2449.999981ps       2.9334059
+ 2459.999982ps       2.9306933
+ 2469.999982ps       2.9255606
+ 2479.999983ps       2.9261212
+ 2489.999984ps        2.927463
+ 2499.999985ps       2.9322322
+ 2509.999986ps       2.9493104
+ 2519.999986ps       2.9540663
+ 2529.999987ps       2.9584991
+ 2539.999988ps       3.0018469
+ 2549.999989ps        3.008484
+ 2559.999990ps       3.0238838
+ 2569.999991ps       3.0396462
+ 2579.999991ps       3.0609641
+ 2589.999992ps        3.068469
+ 2599.999993ps        3.052608
+ 2609.999994ps       3.0245418
+ 2619.999995ps       2.9886073
+ 2629.999996ps       2.9679554
+ 2639.999996ps       2.9534103
+ 2649.999997ps       2.9469622
+ 2659.999998ps       2.9261467
+ 2669.999999ps       2.9243413
+ 2680.000000ps       2.9197778
+ 2690.000001ps       2.9115941
+ 2700.000001ps       2.9055405
+ 2710.000002ps       2.9096613
+ 2720.000003ps       2.9144202
+ 2730.000004ps        2.925488
+ 2740.000005ps       2.9347173
+ 2750.000005ps       2.9387902
+ 2760.000006ps       2.9415801
+ 2770.000007ps       2.9451726
+ 2780.000008ps       2.9412565
+ 2790.000009ps       2.9307435
+ 2800.000010ps       2.9143371
+ 2810.000010ps       2.8918876
+ 2820.000011ps       2.8769831
+ 2830.000012ps       2.8881496
+ 2840.000013ps       2.8745339
+ 2850.000014ps        2.871613
+ 2860.000015ps       2.8806342
+ 2870.000015ps       2.8948405
+ 2880.000016ps       2.9154687
+ 2890.000017ps       2.9159477
+ 2900.000018ps        2.932717
+ 2910.000019ps       2.9853059
+ 2920.000020ps       2.9881891
+ 2930.000020ps       3.0067694
+ 2940.000021ps       3.0488348
+ 2950.000022ps       3.0886931
+ 2960.000023ps       3.1310979
+ 2970.000024ps       3.1208333
+ 2980.000025ps       3.1461167
+ 2990.000025ps       3.1807545
+ 3000.000026ps       3.2154023
+ 3010.000027ps       3.1895958
+ 3020.000028ps       3.1532958
+ 3030.000029ps       3.1235106
+ 3040.000029ps       3.0846499
+ 3050.000030ps       3.0619502
+ 3060.000031ps       3.0501835
+ 3070.000032ps       3.0430099
+ 3080.000033ps       3.0425621
+ 3090.000034ps       3.0454388
+ 3100.000034ps       3.0442902
+ 3110.000035ps       3.0423668
+ 3120.000036ps        3.038111
+ 3130.000037ps       3.0325996
+ 3140.000038ps       3.0152869
+ 3150.000039ps       3.0035479
+ 3160.000039ps       2.9940392
+ 3170.000040ps        2.989646
+ 3180.000041ps       2.9795059
+ 3190.000042ps       2.9713862
+ 3200.000043ps       2.9720406
+ 3210.000044ps       2.9664836
+ 3220.000044ps        2.964081
+ 3230.000045ps       2.9659518
+ 3240.000046ps       2.9780635
+ 3250.000047ps        2.987201
+ 3260.000048ps       3.0021701
+ 3270.000049ps       3.0113818
+ 3280.000049ps         3.01535
+ 3290.000050ps        3.011007
+ 3300.000051ps       3.0019909
+ 3310.000052ps       2.9935122
+ 3320.000053ps       2.9868665
+ 3330.000053ps       2.9814944
+ 3340.000054ps        2.975846
+ 3350.000055ps       2.9776139
+ 3360.000056ps       2.9769179
+ 3370.000057ps       2.9823106
+ 3380.000058ps       2.9943166
+ 3390.000058ps       3.0236919
+ 3400.000059ps       3.0532824
+ 3410.000060ps       3.0872871
+ 3420.000061ps       3.0953798
+ 3430.000062ps        3.087565
+ 3440.000063ps       3.0897868
+ 3450.000063ps        3.062589
+ 3460.000064ps       3.0332778
+ 3470.000065ps       3.0183547
+ 3480.000066ps       3.0069086
+ 3490.000067ps       3.0092746
+ 3500.000068ps       2.9866517
+ 3510.000068ps       2.9711494
+ 3520.000069ps        2.948084
+ 3530.000070ps       2.9323036
+ 3540.000071ps       2.9217605
+ 3550.000072ps       2.9300997
+ 3560.000073ps       2.9241284
+ 3570.000073ps       2.9260286
+ 3580.000074ps       2.9307115
+ 3590.000075ps       2.9406528
+ 3600.000076ps       2.9422809
+ 3610.000077ps       2.9182954
+ 3620.000077ps       2.9083848
+ 3630.000078ps       2.9082022
+ 3640.000079ps       2.9051526
+ 3650.000080ps       2.9048108
+ 3660.000081ps       2.9036111
+ 3670.000082ps       2.9040237
+ 3680.000082ps       2.9061229
+ 3690.000083ps       2.9133174
+ 3700.000084ps       2.9140706
+ 3710.000085ps       2.9086343
+ 3720.000086ps       2.9053049
+ 3729.999865ps       2.9041945
+ 3739.999865ps       2.9098706
+ 3749.999866ps       2.9122765
+ 3759.999867ps       2.9193354
+ 3769.999868ps       2.9471281
+ 3779.999869ps       2.9478942
+ 3789.999869ps       2.9679627
+ 3799.999870ps       3.0051785
+ 3809.999871ps       3.0627305
+ 3819.999872ps       3.1284647
+ 3829.999873ps       3.1622211
+ 3839.999874ps       3.1604561
+ 3849.999874ps       3.1255591
+ 3859.999875ps       3.0863536
+ 3869.999876ps       3.0400854
+ 3879.999877ps       2.9890857
+ 3889.999878ps       2.9474325
+ 3899.999879ps       2.9130365
+ 3909.999879ps       2.8973776
+ 3919.999880ps       2.8923034
+ 3929.999881ps       2.8941645
+ 3939.999882ps       2.9075222
+ 3949.999883ps       2.9254909
+ 3959.999884ps       2.9413044
+ 3969.999884ps       2.9560958
+ 3979.999885ps       2.9693293
+ 3989.999886ps       2.9847902
+ 3999.999887ps       3.0382145
+ 4009.999888ps       3.0965483
+ 4019.999889ps       3.1099238
+ 4029.999889ps       3.1176687
+ 4039.999890ps       3.1111157
+ 4049.999891ps       3.1012941
+ 4059.999892ps       3.0816348
+ 4069.999893ps       3.0523464
+ 4079.999893ps       3.0567601
+ 4089.999894ps       3.0585897
+ 4099.999895ps       3.0657942
+ 4109.999896ps       3.0700685
+ 4119.999897ps        3.075845
+ 4129.999898ps       3.0863905
+ 4139.999898ps        3.099413
+ 4149.999899ps       3.1230068
+ 4159.999900ps       3.1366994
+ 4169.999901ps       3.1529189
+ 4179.999902ps       3.1597976
+ 4189.999903ps        3.158494
+ 4199.999903ps       3.1467445
+ 4209.999904ps        3.148858
+ 4219.999905ps       3.1334282
+ 4229.999906ps       3.1384653
+ 4239.999907ps       3.1610586
+ 4249.999908ps       3.1797968
+ 4259.999908ps       3.1934692
+ 4269.999909ps        3.164313
+ 4279.999910ps       3.1328043
+ 4289.999911ps       3.1106156
+ 4299.999912ps       3.0974323
+ 4309.999913ps       3.0914132
+ 4319.999913ps       3.0767271
+ 4329.999914ps       3.0794062
+ 4339.999915ps        3.095749
+ 4349.999916ps       3.0900081
+ 4359.999917ps       3.0788954
+ 4369.999917ps       3.0793623
+ 4379.999918ps       3.0767273
+ 4389.999919ps       3.0747399
+ 4399.999920ps       3.0570424
+ 4409.999921ps       3.0544375
+ 4419.999922ps       3.0490592
+ 4429.999922ps       3.0516601
+ 4439.999923ps       3.0642841
+ 4449.999924ps       3.0582987
+ 4459.999925ps       3.0610639
+ 4469.999926ps       3.0802139
+ 4479.999927ps       3.0866386
+ 4489.999927ps       3.0936768
+ 4499.999928ps       3.0677023
+ 4509.999929ps       3.0581095
+ 4519.999930ps       3.0500965
+ 4529.999931ps       3.0455484
+ 4539.999932ps       3.0441221
+ 4549.999932ps        3.041782
+ 4559.999933ps       3.0452043
+ 4569.999934ps       3.0441804
+ 4579.999935ps       3.0474224
+ 4589.999936ps       3.0465307
+ 4599.999937ps       3.0492309
+ 4609.999937ps       3.0587083
+ 4619.999938ps        3.090968
+ 4629.999939ps        3.136631
+ 4639.999940ps       3.1881083
+ 4649.999941ps       3.2630124
+ 4659.999941ps       3.3287646
+ 4669.999942ps       3.3434672
+ 4679.999943ps       3.3055281
+ 4689.999944ps       3.2660381
+ 4699.999945ps       3.2275149
+ 4709.999946ps       3.1788421
+ 4719.999946ps       3.1337485
+ 4729.999947ps       3.0986471
+ 4739.999948ps       3.0885714
+ 4749.999949ps       3.0587109
+ 4759.999950ps       3.0473852
+ 4769.999951ps       3.0608481
+ 4779.999951ps       3.0503498
+ 4789.999952ps       3.0506796
+ 4799.999953ps        3.038074
+ 4809.999954ps       3.0546253
+ 4819.999955ps       3.0527849
+ 4829.999956ps       3.0330686
+ 4839.999956ps       3.0276034
+ 4849.999957ps        3.029287
+ 4859.999958ps         3.03786
+ 4869.999959ps         3.03543
+ 4879.999960ps       3.0420332
+ 4889.999961ps       3.0339347
+ 4899.999961ps       3.0238169
+ 4909.999962ps       3.0133679
+ 4919.999963ps       3.0183471
+ 4929.999964ps       3.0226265
+ 4939.999965ps       3.0292944
+ 4949.999965ps       3.0380477
+ 4959.999966ps       3.0343408
+ 4969.999967ps       3.0203574
+ 4979.999968ps        3.008408
+ 4989.999969ps       2.9974369
+ 4999.999970ps       2.9888853
+ 5009.999970ps       2.9810795
+ 5019.999971ps        2.977735
+ 5029.999972ps       2.9706349
+ 5039.999973ps       2.9821462
+ 5049.999974ps       2.9857437
+ 5059.999975ps       3.0073468
+ 5069.999975ps       3.0223236
+ 5079.999976ps       3.0356332
+ 5089.999977ps       3.0273054
+ 5099.999978ps         3.01535
+ 5109.999979ps       3.0054105
+ 5119.999980ps       2.9923974
+ 5129.999980ps       2.9741728
+ 5139.999981ps       2.9613024
+ 5149.999982ps       2.9697663
+ 5159.999983ps       2.9579768
+ 5169.999984ps       2.9512178
+ 5179.999985ps       2.9518754
+ 5189.999985ps       2.9576158
+ 5199.999986ps       2.9604479
+ 5209.999987ps       2.9367013
+ 5219.999988ps       2.9225421
+ 5229.999989ps       2.9207843
+ 5239.999989ps       2.9175402
+ 5249.999990ps       2.9243888
+ 5259.999991ps       2.9299608
+ 5269.999992ps       2.9355871
+ 5279.999993ps       2.9457787
+ 5289.999994ps       2.9488104
+ 5299.999994ps       2.9527335
+ 5309.999995ps        2.962716
+ 5319.999996ps       2.9680686
+ 5329.999997ps       2.9749036
+ 5339.999998ps        2.981733
+ 5349.999999ps       2.9938741
+ 5359.999999ps        2.998368
+ 5370.000000ps       3.0048674
+ 5380.000001ps       3.0069919
+ 5390.000002ps       3.0086883
+ 5400.000003ps       2.9991267
+ 5410.000004ps        2.983424
+ 5420.000004ps       2.9785524
+ 5430.000005ps       2.9938749
+ 5440.000006ps       3.0112547
+ 5450.000007ps        3.046707
+ 5460.000008ps       3.0906629
+ 5470.000009ps       3.1389521
+ 5480.000009ps       3.1985591
+ 5490.000010ps       3.2465238
+ 5500.000011ps       3.2906883
+ 5510.000012ps       3.2594724
+ 5520.000013ps       3.2256143
+ 5530.000013ps       3.2042065
+ 5540.000014ps       3.1727458
+ 5550.000015ps       3.1321213
+ 5560.000016ps        3.095171
+ 5570.000017ps       3.0648151
+ 5580.000018ps       3.0430998
+ 5590.000018ps       3.0365938
+ 5600.000019ps       3.0404575
+ 5610.000020ps       3.0401651
+ 5620.000021ps       3.0348643
+ 5630.000022ps       3.0244542
+ 5640.000023ps       3.0220061
+ 5650.000023ps       3.0197666
+ 5660.000024ps       3.0153816
+ 5670.000025ps       3.0003958
+ 5680.000026ps       2.9874459
+ 5690.000027ps       2.9895399
+ 5700.000028ps       2.9985486
+ 5710.000028ps       2.9993943
+ 5720.000029ps       2.9943566
+ 5730.000030ps        2.976504
+ 5740.000031ps       2.9619461
+ 5750.000032ps       2.9441428
+ 5760.000033ps       2.9406105
+ 5770.000033ps        2.940302
+ 5780.000034ps       2.9388145
+ 5790.000035ps       2.9398984
+ 5800.000036ps       2.9423407
+ 5810.000037ps       2.9471313
+ 5820.000037ps        2.955389
+ 5830.000038ps       2.9602884
+ 5840.000039ps       2.9659472
+ 5850.000040ps        2.994376
+ 5860.000041ps       3.0020348
+ 5870.000042ps       3.0128803
+ 5880.000042ps       3.0265459
+ 5890.000043ps        3.047854
+ 5900.000044ps        3.076874
+ 5910.000045ps       3.0576005
+ 5920.000046ps       3.0304185
+ 5930.000047ps       3.0116038
+ 5940.000047ps       2.9909071
+ 5950.000048ps        2.976339
+ 5960.000049ps       2.9465762
+ 5970.000050ps       2.9378715
+ 5980.000051ps        2.933577
+ 5990.000052ps       2.9321996
+ 6000.000052ps       2.9360657
+ 6010.000053ps       2.9454693
+ 6020.000054ps       2.9475883
+ 6030.000055ps       2.9493055
+ 6040.000056ps       2.9521633
+ 6050.000056ps        2.950894
+ 6060.000057ps       2.9551448
+ 6070.000058ps       2.9479754
+ 6080.000059ps       2.9474896
+ 6090.000060ps       2.9521296
+ 6100.000061ps       2.9570902
+ 6110.000061ps       2.9671012
+ 6120.000062ps       2.9667155
+ 6130.000063ps       2.9709828
+ 6140.000064ps       2.9718375
+ 6150.000065ps       2.9691739
+ 6160.000066ps       2.9674732
+ 6170.000066ps       2.9620376
+ 6180.000067ps       2.9609727
+ 6190.000068ps       2.9544364
+ 6200.000069ps        2.954909
+ 6210.000070ps       2.9610147
+ 6220.000071ps       2.9588213
+ 6230.000071ps       2.9516753
+ 6240.000072ps       2.9481675
+ 6250.000073ps       2.9540545
+ 6260.000074ps       2.9666437
+ 6270.000075ps       2.9813442
+ 6280.000076ps       3.0146968
+ 6290.000076ps       3.0628469
+ 6300.000077ps        3.111872
+ 6310.000078ps       3.1757212
+ 6320.000079ps       3.2400757
+ 6330.000080ps       3.2828429
+ 6340.000080ps       3.2756125
+ 6350.000081ps       3.2346847
+ 6360.000082ps       3.1914317
+ 6370.000083ps       3.1457249
+ 6380.000084ps       3.1014074
+ 6390.000085ps       3.0662625
+ 6400.000085ps       3.0347761
+ 6410.000086ps       3.0083269
+ 6420.000087ps       2.9896906
+ 6430.000088ps       2.9742534
+ 6440.000089ps       2.9576787
+ 6450.000090ps       2.9421414
+ 6460.000090ps       2.9366491
+ 6470.000091ps       2.9325559
+ 6480.000092ps       2.9332277
+ 6490.000093ps       2.9372771
+ 6500.000094ps       2.9418783
+ 6510.000095ps        2.951244
+ 6520.000095ps       2.9495554
+ 6530.000096ps       2.9512119
+ 6540.000097ps       2.9813488
+ 6550.000098ps       2.9752593
+ 6560.000099ps       2.9747416
+ 6570.000100ps       2.9746367
+ 6580.000100ps       2.9760201
+ 6590.000101ps       2.9854713
+ 6600.000102ps       2.9851915
+ 6610.000103ps       2.9656512
+ 6620.000104ps       2.9447407
+ 6630.000104ps       2.9451314
+ 6640.000105ps       2.9378458
+ 6650.000106ps       2.9413022
+ 6660.000107ps        2.929481
+ 6670.000108ps       2.9330851
+ 6680.000109ps       2.9344661
+ 6690.000109ps       2.9370817
+ 6700.000110ps       2.9477796
+ 6710.000111ps       2.9643045
+ 6720.000112ps       2.9837464
+ 6730.000113ps       3.0111173
+ 6740.000114ps       3.0420601
+ 6750.000114ps        3.053372
+ 6760.000115ps       3.0423284
+ 6770.000116ps        3.029227
+ 6780.000117ps       3.0091332
+ 6790.000118ps       2.9758878
+ 6800.000119ps       2.9457022
+ 6810.000119ps       2.9159727
+ 6820.000120ps       2.8979128
+ 6830.000121ps       2.9038709
+ 6840.000122ps       2.8865493
+ 6850.000123ps       2.8843812
+ 6860.000124ps       2.8949703
+ 6870.000124ps       2.9064217
+ 6880.000125ps       2.9268266
+ 6890.000126ps       2.9227483
+ 6900.000127ps       2.9412042
+ 6910.000128ps       2.9881822
+ 6920.000128ps       2.9897221
+ 6930.000129ps       3.0004513
+ 6940.000130ps       3.0324379
+ 6950.000131ps       3.0529546
+ 6960.000132ps       3.0616283
+ 6970.000133ps       3.0080241
+ 6980.000133ps       2.9750752
+ 6990.000134ps       2.9486505
+ 7000.000135ps       2.9375127
+ 7010.000136ps       2.9287575
+ 7020.000137ps       2.9360302
+ 7030.000138ps        2.934846
+ 7040.000138ps       2.9353612
+ 7050.000139ps       2.9482114
+ 7060.000140ps       2.9682253
+ 7070.000141ps       2.9858194
+ 7080.000142ps       3.0004227
+ 7090.000143ps       3.0202033
+ 7100.000143ps       3.0396582
+ 7110.000144ps       3.0556726
+ 7120.000145ps        3.087652
+ 7130.000146ps       3.1181538
+ 7140.000147ps       3.1599284
+ 7150.000147ps       3.2150533
+ 7160.000148ps       3.2646517
+ 7170.000149ps       3.2676627
+ 7180.000150ps       3.2256119
+ 7190.000151ps       3.1839545
+ 7200.000152ps       3.1491735
+ 7210.000152ps       3.1088588
+ 7220.000153ps       3.0734775
+ 7230.000154ps       3.0499951
+ 7240.000155ps       3.0386826
+ 7250.000156ps       3.0299303
+ 7260.000157ps       3.0349608
+ 7270.000157ps       3.0375345
+ 7280.000158ps       3.0341849
+ 7290.000159ps       3.0338716
+ 7300.000160ps       3.0200072
+ 7310.000161ps       3.0102767
+ 7320.000162ps        3.007548
+ 7330.000162ps       3.0088122
+ 7340.000163ps       2.9999805
+ 7350.000164ps       2.9874074
+ 7360.000165ps       2.9754499
+ 7370.000166ps       2.9660673
+ 7380.000167ps         2.96516
+ 7390.000167ps       2.9726676
+ 7400.000168ps       2.9847412
+ 7410.000169ps       3.0014632
+ 7420.000170ps       3.0070142
+ 7430.000171ps        3.008779
+ 7440.000171ps       3.0247935
+ 7450.000172ps       3.0097348
+ 7459.999729ps       3.0021559
+ 7469.999730ps       3.0043673
+ 7479.999731ps       3.0077326
+ 7489.999732ps       3.0173188
+ 7499.999732ps       2.9954577
+ 7509.999733ps       2.9863531
+ 7519.999734ps       2.9710633
+ 7529.999735ps       2.9621991
+ 7539.999736ps       2.9644158
+ 7549.999737ps       2.9926136
+ 7559.999737ps       3.0047012
+ 7569.999738ps       3.0260259
+ 7579.999739ps       3.0456489
+ 7589.999740ps       3.0432151
+ 7599.999741ps       3.0364624
+ 7609.999741ps         3.00479
+ 7619.999742ps       2.9767408
+ 7629.999743ps       2.9583238
+ 7639.999744ps       2.9416027
+ 7649.999745ps       2.9330081
+ 7659.999746ps       2.9269696
+ 7669.999746ps       2.9293689
+ 7679.999747ps        2.922055
+ 7689.999748ps       2.9241632
+ 7699.999749ps       2.9276976
+ 7709.999750ps       2.9209785
+ 7719.999751ps       2.9188899
+ 7729.999751ps       2.9209099
+ 7739.999752ps       2.9253928
+ 7749.999753ps       2.9298688
+ 7759.999754ps       2.9326822
+ 7769.999755ps        2.942802
+ 7779.999756ps        2.923851
+ 7789.999756ps       2.9068631
+ 7799.999757ps       2.9037897
+ 7809.999758ps       2.9050022
+ 7819.999759ps       2.9081429
+ 7829.999760ps       2.8901479
+ 7839.999761ps        2.890202
+ 7849.999761ps       2.8969496
+ 7859.999762ps       2.8936081
+ 7869.999763ps       2.8860421
+ 7879.999764ps       2.8718771
+ 7889.999765ps       2.8636143
+ 7899.999765ps        2.856627
+ 7909.999766ps       2.8608799
+ 7919.999767ps        2.869171
+ 7929.999768ps       2.8912763
+ 7939.999769ps       2.9223437
+ 7949.999770ps       2.9772367
+ 7959.999770ps       3.0337112
+ 7969.999771ps       3.0909827
+ 7979.999772ps        3.165908
+ 7989.999773ps       3.2432279
+)

Icursig10 PAR_2_1_VSS 0 pwl(
+ 0.000000ps      -5.4142896
+ 10.000000ps      -5.8117279
+ 20.000000ps      -6.5621981
+ 29.999999ps      -7.2254674
+ 40.000000ps      -7.7279693
+ 50.000001ps      -8.0780125
+ 59.999998ps      -8.3179024
+ 69.999999ps      -8.5199594
+ 80.000000ps      -8.6462832
+ 90.000001ps      -8.7690488
+ 100.000001ps       -8.855755
+ 110.000002ps      -8.9257221
+ 119.999996ps      -8.9847063
+ 129.999997ps      -9.0217088
+ 139.999998ps      -9.0533571
+ 149.999999ps      -9.0790898
+ 159.999999ps      -9.1102836
+ 170.000000ps        -9.10535
+ 180.000001ps      -9.1194049
+ 190.000002ps      -9.1222214
+ 200.000003ps      -9.1553399
+ 210.000003ps      -9.2008269
+ 220.000004ps      -9.2497579
+ 230.000005ps      -9.3108985
+ 239.999992ps      -9.3885081
+ 249.999993ps      -9.4433172
+ 259.999994ps      -9.5137375
+ 269.999995ps      -9.5667068
+ 279.999995ps      -9.6126912
+ 289.999996ps      -9.6389356
+ 299.999997ps      -9.6314731
+ 309.999998ps      -9.6406811
+ 319.999999ps      -9.6662874
+ 330.000000ps      -9.7004357
+ 340.000000ps       -9.700332
+ 350.000001ps      -9.7260931
+ 360.000002ps      -9.7287568
+ 370.000003ps      -9.7295687
+ 380.000004ps      -9.7299611
+ 390.000005ps      -9.7484047
+ 400.000005ps      -9.7425229
+ 410.000006ps      -9.7638695
+ 420.000007ps      -9.7619631
+ 430.000008ps      -9.7939918
+ 440.000009ps      -9.8092143
+ 450.000009ps      -9.7925896
+ 460.000010ps      -9.7832257
+ 469.999983ps      -9.7873799
+ 479.999984ps      -9.7473022
+ 489.999985ps      -9.7641135
+ 499.999986ps       -9.735432
+ 509.999987ps      -9.7583644
+ 519.999988ps      -9.8021882
+ 529.999988ps       -9.864587
+ 539.999989ps      -9.9190018
+ 549.999990ps      -9.9362742
+ 559.999991ps      -9.9474274
+ 569.999992ps      -9.9588109
+ 579.999992ps      -9.9834628
+ 589.999993ps      -9.9566517
+ 599.999994ps        -9.95338
+ 609.999995ps      -9.9239564
+ 619.999996ps      -9.8745473
+ 629.999997ps      -9.8275942
+ 639.999997ps      -9.7809863
+ 649.999998ps      -9.7670358
+ 659.999999ps      -9.7919234
+ 670.000000ps      -9.8270017
+ 680.000001ps      -9.8870203
+ 690.000002ps      -9.9353045
+ 700.000002ps      -9.9668115
+ 710.000003ps      -9.9993953
+ 720.000004ps      -10.017221
+ 730.000005ps       -10.04686
+ 740.000006ps      -10.050344
+ 750.000007ps       -10.07039
+ 760.000007ps      -10.059433
+ 770.000008ps      -10.015778
+ 780.000009ps      -10.005212
+ 790.000010ps      -10.008871
+ 800.000011ps      -9.9778629
+ 810.000012ps      -9.9240482
+ 820.000012ps      -9.8798638
+ 830.000013ps      -9.8659712
+ 840.000014ps      -9.8854399
+ 850.000015ps      -9.8998005
+ 860.000016ps      -9.8947239
+ 870.000016ps      -9.9386184
+ 880.000017ps      -9.9573547
+ 890.000018ps      -9.9573916
+ 900.000019ps      -9.9646333
+ 910.000020ps      -9.9835857
+ 920.000021ps      -9.9829541
+ 930.000021ps      -9.9798633
+ 939.999967ps       -9.961455
+ 949.999968ps       -9.945248
+ 959.999968ps      -9.9403364
+ 969.999969ps      -9.8922003
+ 979.999970ps      -9.8490008
+ 989.999971ps       -9.753593
+ 999.999972ps      -9.6399186
+ 1009.999973ps      -9.5787957
+ 1019.999973ps      -9.5572865
+ 1029.999974ps      -9.5549453
+ 1039.999975ps      -9.5368639
+ 1049.999976ps      -9.5433591
+ 1059.999977ps      -9.5259962
+ 1069.999978ps      -9.5380736
+ 1079.999978ps      -9.5002017
+ 1089.999979ps      -9.4187905
+ 1099.999980ps      -9.3627189
+ 1109.999981ps      -9.3476848
+ 1119.999982ps      -9.3437816
+ 1129.999982ps      -9.3563553
+ 1139.999983ps      -9.3360737
+ 1149.999984ps      -9.2936662
+ 1159.999985ps      -9.2333014
+ 1169.999986ps      -9.1790992
+ 1179.999987ps      -9.1293818
+ 1189.999987ps      -9.1215778
+ 1199.999988ps       -9.129056
+ 1209.999989ps      -9.1295434
+ 1219.999990ps      -9.1508147
+ 1229.999991ps      -9.1843209
+ 1239.999992ps      -9.1833554
+ 1249.999992ps      -9.2175029
+ 1259.999993ps      -9.2606626
+ 1269.999994ps      -9.2754445
+ 1279.999995ps      -9.2862547
+ 1289.999996ps      -9.2789844
+ 1299.999997ps      -9.2877621
+ 1309.999997ps      -9.3057155
+ 1319.999998ps      -9.3267247
+ 1329.999999ps      -9.3431552
+ 1340.000000ps      -9.3359552
+ 1350.000001ps      -9.3136694
+ 1360.000002ps      -9.2643056
+ 1370.000002ps      -9.2321072
+ 1380.000003ps      -9.2249743
+ 1390.000004ps      -9.2196546
+ 1400.000005ps      -9.1927014
+ 1410.000006ps       -9.162822
+ 1420.000006ps      -9.1189184
+ 1430.000007ps      -9.0886408
+ 1440.000008ps      -9.0896275
+ 1450.000009ps      -9.0767607
+ 1460.000010ps      -9.0689417
+ 1470.000011ps      -9.0582659
+ 1480.000011ps      -9.0651784
+ 1490.000012ps      -9.0607912
+ 1500.000013ps      -9.0549195
+ 1510.000014ps      -9.0487541
+ 1520.000015ps      -9.0438077
+ 1530.000016ps      -9.0347837
+ 1540.000016ps      -9.0268443
+ 1550.000017ps      -9.0103278
+ 1560.000018ps      -9.0138841
+ 1570.000019ps      -9.0300385
+ 1580.000020ps      -9.0118223
+ 1590.000021ps      -8.9907432
+ 1600.000021ps       -8.970129
+ 1610.000022ps      -8.9799828
+ 1620.000023ps      -8.9665894
+ 1630.000024ps      -8.9443514
+ 1640.000025ps       -8.925396
+ 1650.000025ps      -8.9207323
+ 1660.000026ps      -8.9274808
+ 1670.000027ps      -8.9219494
+ 1680.000028ps      -8.9296502
+ 1690.000029ps      -8.9650978
+ 1700.000030ps      -8.9735675
+ 1710.000030ps      -8.9891375
+ 1720.000031ps      -9.0123789
+ 1730.000032ps      -9.0132223
+ 1740.000033ps      -9.0174304
+ 1750.000034ps      -8.9945049
+ 1760.000035ps      -8.9927535
+ 1770.000035ps      -8.9826146
+ 1780.000036ps      -8.9439701
+ 1790.000037ps      -8.9095386
+ 1800.000038ps      -8.8887281
+ 1810.000039ps      -8.8717322
+ 1820.000040ps      -8.8777422
+ 1830.000040ps      -8.8926297
+ 1840.000041ps      -8.9112896
+ 1850.000042ps      -8.9605463
+ 1860.000043ps      -9.0173668
+ 1869.999933ps      -9.0632788
+ 1879.999934ps      -9.1203275
+ 1889.999934ps       -9.159672
+ 1899.999935ps      -9.1821709
+ 1909.999936ps      -9.1818539
+ 1919.999937ps      -9.1640314
+ 1929.999938ps      -9.1664521
+ 1939.999938ps      -9.1400322
+ 1949.999939ps      -9.1321014
+ 1959.999940ps      -9.1002964
+ 1969.999941ps      -9.0499888
+ 1979.999942ps      -9.0105083
+ 1989.999943ps      -9.0102664
+ 1999.999943ps      -9.0238869
+ 2009.999944ps      -9.0379294
+ 2019.999945ps      -9.0775268
+ 2029.999946ps      -9.1186841
+ 2039.999947ps      -9.1774646
+ 2049.999948ps      -9.1922335
+ 2059.999948ps      -9.2020217
+ 2069.999949ps      -9.2018792
+ 2079.999950ps      -9.2017118
+ 2089.999951ps      -9.2159834
+ 2099.999952ps      -9.2174145
+ 2109.999953ps      -9.2005734
+ 2119.999953ps      -9.1949387
+ 2129.999954ps      -9.1448433
+ 2139.999955ps      -9.0957439
+ 2149.999956ps      -9.0634646
+ 2159.999957ps      -9.0410477
+ 2169.999958ps      -9.0692523
+ 2179.999958ps      -9.0949032
+ 2189.999959ps      -9.1321526
+ 2199.999960ps      -9.1875545
+ 2209.999961ps      -9.2244907
+ 2219.999962ps      -9.2718247
+ 2229.999962ps      -9.3076548
+ 2239.999963ps      -9.2970002
+ 2249.999964ps      -9.2815593
+ 2259.999965ps      -9.2798442
+ 2269.999966ps       -9.281357
+ 2279.999967ps      -9.2533939
+ 2289.999967ps      -9.2271389
+ 2299.999968ps      -9.1817543
+ 2309.999969ps      -9.1197392
+ 2319.999970ps      -9.0827112
+ 2329.999971ps      -9.0667151
+ 2339.999972ps      -9.0652411
+ 2349.999972ps      -9.0972586
+ 2359.999973ps      -9.1129478
+ 2369.999974ps      -9.1240273
+ 2379.999975ps      -9.1424212
+ 2389.999976ps      -9.1542466
+ 2399.999977ps      -9.1575717
+ 2409.999977ps      -9.1652962
+ 2419.999978ps      -9.1735038
+ 2429.999979ps      -9.1856169
+ 2439.999980ps      -9.1706778
+ 2449.999981ps      -9.1897545
+ 2459.999982ps       -9.194683
+ 2469.999982ps      -9.1922705
+ 2479.999983ps      -9.1632658
+ 2489.999984ps      -9.1699373
+ 2499.999985ps      -9.1638695
+ 2509.999986ps      -9.1276688
+ 2519.999986ps      -9.1152919
+ 2529.999987ps      -9.0877495
+ 2539.999988ps      -9.0760057
+ 2549.999989ps      -9.0911299
+ 2559.999990ps      -9.1134525
+ 2569.999991ps      -9.1353351
+ 2579.999991ps      -9.1100161
+ 2589.999992ps      -9.1496576
+ 2599.999993ps      -9.1913079
+ 2609.999994ps      -9.2068175
+ 2619.999995ps      -9.2359877
+ 2629.999996ps      -9.2611871
+ 2639.999996ps      -9.2801847
+ 2649.999997ps      -9.2582949
+ 2659.999998ps       -9.204295
+ 2669.999999ps      -9.1593927
+ 2680.000000ps      -9.1216933
+ 2690.000001ps      -9.1017682
+ 2700.000001ps       -9.063472
+ 2710.000002ps       -9.020165
+ 2720.000003ps      -8.9841006
+ 2730.000004ps      -8.9352531
+ 2740.000005ps      -8.8932266
+ 2750.000005ps      -8.8872992
+ 2760.000006ps      -8.8980424
+ 2770.000007ps      -8.9350382
+ 2780.000008ps      -8.9580655
+ 2790.000009ps      -8.9999453
+ 2800.000010ps       -9.021118
+ 2810.000010ps      -9.0176037
+ 2820.000011ps      -8.9780277
+ 2830.000012ps      -8.9389381
+ 2840.000013ps       -8.918701
+ 2850.000014ps      -8.9077587
+ 2860.000015ps      -8.8786779
+ 2870.000015ps      -8.8324168
+ 2880.000016ps      -8.8000901
+ 2890.000017ps      -8.7348842
+ 2900.000018ps      -8.6825392
+ 2910.000019ps      -8.6576509
+ 2920.000020ps      -8.6695842
+ 2930.000020ps       -8.708565
+ 2940.000021ps      -8.7553342
+ 2950.000022ps      -8.8046285
+ 2960.000023ps      -8.8142372
+ 2970.000024ps      -8.8419362
+ 2980.000025ps       -8.814743
+ 2990.000025ps      -8.8215723
+ 3000.000026ps      -8.8209848
+ 3010.000027ps      -8.7720583
+ 3020.000028ps      -8.7607394
+ 3030.000029ps      -8.7611503
+ 3040.000029ps      -8.7808642
+ 3050.000030ps      -8.7689825
+ 3060.000031ps      -8.7869495
+ 3070.000032ps      -8.7540127
+ 3080.000033ps       -8.729514
+ 3090.000034ps       -8.721613
+ 3100.000034ps      -8.7600906
+ 3110.000035ps      -8.7946417
+ 3120.000036ps      -8.7785495
+ 3130.000037ps      -8.7850283
+ 3140.000038ps      -8.8012566
+ 3150.000039ps      -8.8144433
+ 3160.000039ps      -8.7990687
+ 3170.000040ps      -8.7843263
+ 3180.000041ps      -8.7712828
+ 3190.000042ps      -8.7604524
+ 3200.000043ps      -8.7519883
+ 3210.000044ps      -8.7563998
+ 3220.000044ps      -8.7763305
+ 3230.000045ps       -8.809458
+ 3240.000046ps      -8.8407102
+ 3250.000047ps       -8.845632
+ 3260.000048ps      -8.8722042
+ 3270.000049ps      -8.9124412
+ 3280.000049ps      -8.9251308
+ 3290.000050ps      -8.9628389
+ 3300.000051ps      -8.9796019
+ 3310.000052ps      -9.0283619
+ 3320.000053ps      -9.0324002
+ 3330.000053ps       -9.042434
+ 3340.000054ps       -9.044788
+ 3350.000055ps      -9.0384636
+ 3360.000056ps      -9.0622892
+ 3370.000057ps      -9.0175123
+ 3380.000058ps       -8.960154
+ 3390.000058ps      -8.9483544
+ 3400.000059ps      -8.9418273
+ 3410.000060ps      -8.9504137
+ 3420.000061ps       -8.931951
+ 3430.000062ps      -8.9383787
+ 3440.000063ps      -8.9639117
+ 3450.000063ps       -8.992892
+ 3460.000064ps       -9.016249
+ 3470.000065ps      -9.0235353
+ 3480.000066ps      -9.0296716
+ 3490.000067ps      -9.0612336
+ 3500.000068ps      -9.0908873
+ 3510.000068ps      -9.1039649
+ 3520.000069ps       -9.114658
+ 3530.000070ps      -9.1481383
+ 3540.000071ps      -9.0991954
+ 3550.000072ps      -9.0688125
+ 3560.000073ps      -9.0289713
+ 3570.000073ps       -8.986799
+ 3580.000074ps      -8.9656544
+ 3590.000075ps      -8.9257004
+ 3600.000076ps      -8.9450534
+ 3610.000077ps      -8.9660126
+ 3620.000077ps       -8.980079
+ 3630.000078ps      -9.0092255
+ 3640.000079ps      -9.0029653
+ 3650.000080ps      -8.9848792
+ 3660.000081ps      -8.9958652
+ 3670.000082ps      -9.0212398
+ 3680.000082ps      -9.0423482
+ 3690.000083ps      -9.0389822
+ 3700.000084ps      -9.0624455
+ 3710.000085ps      -9.0887167
+ 3720.000086ps      -9.0768908
+ 3729.999865ps       -9.010925
+ 3739.999865ps      -8.9339873
+ 3749.999866ps      -8.8981071
+ 3759.999867ps      -8.8738811
+ 3769.999868ps      -8.8597731
+ 3779.999869ps      -8.8657342
+ 3789.999869ps      -8.8893014
+ 3799.999870ps      -8.9351944
+ 3809.999871ps      -8.9573231
+ 3819.999872ps       -8.992518
+ 3829.999873ps      -9.0376713
+ 3839.999874ps      -9.0524522
+ 3849.999874ps      -9.0659955
+ 3859.999875ps      -9.0922607
+ 3869.999876ps       -9.110528
+ 3879.999877ps      -9.1258547
+ 3889.999878ps      -9.0983204
+ 3899.999879ps      -9.0672635
+ 3909.999879ps      -9.0143884
+ 3919.999880ps      -8.9657987
+ 3929.999881ps      -8.9234857
+ 3939.999882ps      -8.8729627
+ 3949.999883ps      -8.8884193
+ 3959.999884ps      -8.9004299
+ 3969.999884ps      -8.9582739
+ 3979.999885ps      -8.9692864
+ 3989.999886ps      -8.9818074
+ 3999.999887ps      -9.0952097
+ 4009.999888ps      -9.2766057
+ 4019.999889ps      -9.5690154
+ 4029.999889ps      -9.8437542
+ 4039.999890ps      -10.056735
+ 4049.999891ps       -10.18514
+ 4059.999892ps      -10.304048
+ 4069.999893ps      -10.385432
+ 4079.999893ps      -10.438398
+ 4089.999894ps       -10.46499
+ 4099.999895ps      -10.484317
+ 4109.999896ps      -10.517028
+ 4119.999897ps      -10.553487
+ 4129.999898ps      -10.590165
+ 4139.999898ps      -10.602296
+ 4149.999899ps      -10.634876
+ 4159.999900ps      -10.646299
+ 4169.999901ps       -10.62709
+ 4179.999902ps      -10.603801
+ 4189.999903ps      -10.543964
+ 4199.999903ps      -10.546013
+ 4209.999904ps      -10.567036
+ 4219.999905ps      -10.556161
+ 4229.999906ps      -10.523742
+ 4239.999907ps      -10.558873
+ 4249.999908ps      -10.546191
+ 4259.999908ps      -10.558102
+ 4269.999909ps      -10.553481
+ 4279.999910ps      -10.553617
+ 4289.999911ps       -10.52224
+ 4299.999912ps      -10.466998
+ 4309.999913ps      -10.461583
+ 4319.999913ps      -10.471047
+ 4329.999914ps        -10.4918
+ 4339.999915ps      -10.513621
+ 4349.999916ps       -10.50747
+ 4359.999917ps        -10.5136
+ 4369.999917ps       -10.49824
+ 4379.999918ps      -10.477669
+ 4389.999919ps      -10.464771
+ 4399.999920ps      -10.465317
+ 4409.999921ps      -10.474422
+ 4419.999922ps      -10.476683
+ 4429.999922ps      -10.486672
+ 4439.999923ps      -10.483847
+ 4449.999924ps      -10.456308
+ 4459.999925ps      -10.454181
+ 4469.999926ps      -10.447079
+ 4479.999927ps      -10.414872
+ 4489.999927ps      -10.454428
+ 4499.999928ps       -10.41876
+ 4509.999929ps      -10.428198
+ 4519.999930ps      -10.457992
+ 4529.999931ps      -10.505197
+ 4539.999932ps      -10.546381
+ 4549.999932ps      -10.546989
+ 4559.999933ps      -10.551165
+ 4569.999934ps      -10.573565
+ 4579.999935ps      -10.602918
+ 4589.999936ps      -10.591555
+ 4599.999937ps      -10.567389
+ 4609.999937ps      -10.515848
+ 4619.999938ps      -10.466174
+ 4629.999939ps      -10.425517
+ 4639.999940ps      -10.381387
+ 4649.999941ps      -10.372269
+ 4659.999941ps      -10.389654
+ 4669.999942ps      -10.422028
+ 4679.999943ps      -10.506605
+ 4689.999944ps      -10.544847
+ 4699.999945ps      -10.592201
+ 4709.999946ps      -10.627177
+ 4719.999946ps      -10.633683
+ 4729.999947ps      -10.653372
+ 4739.999948ps      -10.644287
+ 4749.999949ps      -10.625463
+ 4759.999950ps      -10.615508
+ 4769.999951ps      -10.555942
+ 4779.999951ps      -10.543779
+ 4789.999952ps      -10.515604
+ 4799.999953ps      -10.508575
+ 4809.999954ps      -10.435208
+ 4819.999955ps      -10.381729
+ 4829.999956ps      -10.382513
+ 4839.999956ps       -10.41225
+ 4849.999957ps      -10.421738
+ 4859.999958ps      -10.423099
+ 4869.999959ps      -10.426913
+ 4879.999960ps      -10.430663
+ 4889.999961ps      -10.440048
+ 4899.999961ps      -10.450056
+ 4909.999962ps      -10.448085
+ 4919.999963ps      -10.452705
+ 4929.999964ps        -10.4647
+ 4939.999965ps      -10.436554
+ 4949.999965ps      -10.403632
+ 4959.999966ps      -10.380026
+ 4969.999967ps      -10.325613
+ 4979.999968ps      -10.213378
+ 4989.999969ps      -10.070054
+ 4999.999970ps      -9.8498992
+ 5009.999970ps      -9.6831617
+ 5019.999971ps      -9.5498027
+ 5029.999972ps      -9.4696211
+ 5039.999973ps      -9.3991934
+ 5049.999974ps      -9.3089289
+ 5059.999975ps      -9.2209396
+ 5069.999975ps      -9.1494268
+ 5079.999976ps      -9.0543427
+ 5089.999977ps      -8.9334717
+ 5099.999978ps      -8.8301356
+ 5109.999979ps      -8.7666927
+ 5119.999980ps      -8.7221086
+ 5129.999980ps       -8.698974
+ 5139.999981ps      -8.6478314
+ 5149.999982ps      -8.6038876
+ 5159.999983ps       -8.517158
+ 5169.999984ps      -8.4522161
+ 5179.999985ps      -8.4057343
+ 5189.999985ps      -8.3704981
+ 5199.999986ps      -8.3481504
+ 5209.999987ps       -8.321628
+ 5219.999988ps      -8.3359941
+ 5229.999989ps      -8.3532584
+ 5239.999989ps      -8.3464082
+ 5249.999990ps      -8.3606388
+ 5259.999991ps      -8.4114345
+ 5269.999992ps      -8.4282893
+ 5279.999993ps      -8.4390054
+ 5289.999994ps       -8.438689
+ 5299.999994ps      -8.4390755
+ 5309.999995ps      -8.4715354
+ 5319.999996ps       -8.462183
+ 5329.999997ps      -8.4646334
+ 5339.999998ps       -8.437215
+ 5349.999999ps      -8.4129572
+ 5359.999999ps       -8.355945
+ 5370.000000ps      -8.3159605
+ 5380.000001ps      -8.3027469
+ 5390.000002ps        -8.28922
+ 5400.000003ps      -8.2656758
+ 5410.000004ps      -8.2505726
+ 5420.000004ps      -8.2198653
+ 5430.000005ps       -8.197948
+ 5440.000006ps      -8.1775277
+ 5450.000007ps      -8.1741673
+ 5460.000008ps      -8.1516855
+ 5470.000009ps      -8.1452234
+ 5480.000009ps      -8.1384634
+ 5490.000010ps      -8.1319468
+ 5500.000011ps      -8.1279757
+ 5510.000012ps      -8.1221394
+ 5520.000013ps        -8.12864
+ 5530.000013ps      -8.1187341
+ 5540.000014ps      -8.0770485
+ 5550.000015ps      -8.0629293
+ 5560.000016ps      -8.0650631
+ 5570.000017ps      -8.0746823
+ 5580.000018ps      -8.0610314
+ 5590.000018ps      -8.0510255
+ 5600.000019ps      -8.0458043
+ 5610.000020ps      -8.0415494
+ 5620.000021ps      -8.0324127
+ 5630.000022ps      -8.0107002
+ 5640.000023ps      -7.9904649
+ 5650.000023ps       -7.989874
+ 5660.000024ps      -7.9698875
+ 5670.000025ps      -7.9657775
+ 5680.000026ps      -7.9786227
+ 5690.000027ps      -8.0068662
+ 5700.000028ps      -8.0356661
+ 5710.000028ps      -8.0620149
+ 5720.000029ps      -8.0648807
+ 5730.000030ps      -8.0671216
+ 5740.000031ps      -8.0723832
+ 5750.000032ps      -8.0664173
+ 5760.000033ps      -8.0659314
+ 5770.000033ps      -8.0213864
+ 5780.000034ps      -7.9853677
+ 5790.000035ps      -7.9604895
+ 5800.000036ps      -7.9306689
+ 5810.000037ps      -7.9298305
+ 5820.000037ps       -7.927544
+ 5830.000038ps      -7.9498406
+ 5840.000039ps      -7.9610827
+ 5850.000040ps      -8.0069431
+ 5860.000041ps       -8.061952
+ 5870.000042ps      -8.1237982
+ 5880.000042ps      -8.1731448
+ 5890.000043ps      -8.2100771
+ 5900.000044ps      -8.2255974
+ 5910.000045ps      -8.2471164
+ 5920.000046ps      -8.2347508
+ 5930.000047ps      -8.2219193
+ 5940.000047ps      -8.2000429
+ 5950.000048ps      -8.1831137
+ 5960.000049ps      -8.1561403
+ 5970.000050ps      -8.1184662
+ 5980.000051ps      -8.0891791
+ 5990.000052ps      -8.0822314
+ 6000.000052ps      -8.0873482
+ 6010.000053ps      -8.1002421
+ 6020.000054ps      -8.1338441
+ 6030.000055ps      -8.1788173
+ 6040.000056ps       -8.221881
+ 6050.000056ps      -8.2409951
+ 6060.000057ps      -8.2512032
+ 6070.000058ps      -8.2626216
+ 6080.000059ps      -8.2597867
+ 6090.000060ps      -8.2716141
+ 6100.000061ps      -8.2652633
+ 6110.000061ps      -8.2673506
+ 6120.000062ps       -8.237972
+ 6130.000063ps      -8.2006777
+ 6140.000064ps      -8.1507066
+ 6150.000065ps      -8.1017428
+ 6160.000066ps      -8.0822679
+ 6170.000066ps      -8.0960493
+ 6180.000067ps      -8.1367551
+ 6190.000068ps      -8.1818487
+ 6200.000069ps      -8.2289187
+ 6210.000070ps      -8.2813375
+ 6220.000071ps      -8.3265665
+ 6230.000071ps      -8.3556355
+ 6240.000072ps      -8.3550096
+ 6250.000073ps      -8.3423454
+ 6260.000074ps      -8.3319243
+ 6270.000075ps      -8.3322187
+ 6280.000076ps      -8.3252923
+ 6290.000076ps      -8.2934487
+ 6300.000077ps      -8.2385019
+ 6310.000078ps      -8.1900245
+ 6320.000079ps      -8.1705677
+ 6330.000080ps      -8.1423127
+ 6340.000080ps      -8.1398716
+ 6350.000081ps      -8.1603772
+ 6360.000082ps      -8.1730539
+ 6370.000083ps      -8.1970306
+ 6380.000084ps      -8.2117274
+ 6390.000085ps      -8.2268172
+ 6400.000085ps      -8.2256839
+ 6410.000086ps      -8.2333113
+ 6420.000087ps      -8.2460295
+ 6430.000088ps      -8.2519345
+ 6440.000089ps      -8.2509827
+ 6450.000090ps      -8.2613656
+ 6460.000090ps       -8.272675
+ 6470.000091ps      -8.2587124
+ 6480.000092ps      -8.2442879
+ 6490.000093ps      -8.2457826
+ 6500.000094ps      -8.2365081
+ 6510.000095ps      -8.2019611
+ 6520.000095ps      -8.1882575
+ 6530.000096ps      -8.1696771
+ 6540.000097ps      -8.1502216
+ 6550.000098ps      -8.1656517
+ 6560.000099ps      -8.1807325
+ 6570.000100ps      -8.2057098
+ 6580.000100ps      -8.1766071
+ 6590.000101ps       -8.218276
+ 6600.000102ps      -8.2581496
+ 6610.000103ps      -8.2700428
+ 6620.000104ps      -8.2944711
+ 6630.000104ps      -8.3223149
+ 6640.000105ps      -8.3431784
+ 6650.000106ps      -8.3120526
+ 6660.000107ps      -8.2583588
+ 6670.000108ps      -8.2135297
+ 6680.000109ps      -8.1885792
+ 6690.000109ps       -8.158944
+ 6700.000110ps      -8.1202355
+ 6710.000111ps      -8.0803947
+ 6720.000112ps      -8.0221359
+ 6730.000113ps      -7.9741355
+ 6740.000114ps      -7.9416798
+ 6750.000114ps      -7.9351904
+ 6760.000115ps      -7.9716936
+ 6770.000116ps      -7.9933044
+ 6780.000117ps      -8.0153523
+ 6790.000118ps      -8.0499759
+ 6800.000119ps      -8.0610769
+ 6810.000119ps      -8.0606692
+ 6820.000120ps      -8.0138102
+ 6830.000121ps      -7.9967995
+ 6840.000122ps      -7.9875479
+ 6850.000123ps      -7.9791351
+ 6860.000124ps      -7.9538517
+ 6870.000124ps      -7.8895642
+ 6880.000125ps      -7.8439951
+ 6890.000126ps      -7.7741827
+ 6900.000127ps      -7.7377341
+ 6910.000128ps      -7.7177823
+ 6920.000128ps      -7.7326722
+ 6930.000129ps      -7.7616033
+ 6940.000130ps      -7.7944312
+ 6950.000131ps      -7.8441867
+ 6960.000132ps      -7.8723908
+ 6970.000133ps      -7.8837614
+ 6980.000133ps      -7.8700436
+ 6990.000134ps      -7.8736511
+ 7000.000135ps      -7.8773843
+ 7010.000136ps      -7.8417588
+ 7020.000137ps      -7.8307916
+ 7030.000138ps      -7.8280905
+ 7040.000138ps       -7.832663
+ 7050.000139ps      -7.8203102
+ 7060.000140ps      -7.8394496
+ 7070.000141ps      -7.8094246
+ 7080.000142ps       -7.782335
+ 7090.000143ps      -7.7783654
+ 7100.000143ps      -7.7935799
+ 7110.000144ps      -7.8400079
+ 7120.000145ps       -7.832943
+ 7130.000146ps      -7.8318698
+ 7140.000147ps       -7.856589
+ 7150.000147ps      -7.8731466
+ 7160.000148ps      -7.8670456
+ 7170.000149ps      -7.8423286
+ 7180.000150ps      -7.8377169
+ 7190.000151ps      -7.8273539
+ 7200.000152ps      -7.8005353
+ 7210.000152ps      -7.8140851
+ 7220.000153ps      -7.8281223
+ 7230.000154ps      -7.8623186
+ 7240.000155ps      -7.9036097
+ 7250.000156ps      -7.9083082
+ 7260.000157ps      -7.9432103
+ 7270.000157ps      -7.9757447
+ 7280.000158ps       -8.008119
+ 7290.000159ps      -8.0354463
+ 7300.000160ps       -8.064458
+ 7310.000161ps      -8.0935562
+ 7320.000162ps      -8.1122544
+ 7330.000162ps      -8.1246372
+ 7340.000163ps      -8.1090552
+ 7350.000164ps      -8.1035668
+ 7360.000165ps      -8.1213609
+ 7370.000166ps      -8.0682125
+ 7380.000167ps      -8.0262974
+ 7390.000167ps      -8.0126321
+ 7400.000168ps      -8.0157202
+ 7410.000169ps      -8.0255891
+ 7420.000170ps      -8.0113233
+ 7430.000171ps      -8.0052774
+ 7440.000171ps      -8.0186324
+ 7450.000172ps      -8.0462302
+ 7459.999729ps      -8.0714468
+ 7469.999730ps      -8.0744767
+ 7479.999731ps      -8.0944227
+ 7489.999732ps       -8.107137
+ 7499.999732ps      -8.1363695
+ 7509.999733ps      -8.1566031
+ 7519.999734ps       -8.169938
+ 7529.999735ps      -8.1767515
+ 7539.999736ps      -8.1312721
+ 7549.999737ps      -8.0986959
+ 7559.999737ps      -8.0577265
+ 7569.999738ps      -8.0281241
+ 7579.999739ps      -8.0012178
+ 7589.999740ps      -7.9862537
+ 7599.999741ps      -8.0037459
+ 7609.999741ps      -8.0244197
+ 7619.999742ps      -8.0422843
+ 7629.999743ps      -8.0713693
+ 7639.999744ps      -8.0690624
+ 7649.999745ps      -8.0514395
+ 7659.999746ps      -8.0691558
+ 7669.999746ps      -8.0874174
+ 7679.999747ps      -8.1037327
+ 7689.999748ps      -8.1111072
+ 7699.999749ps      -8.1403739
+ 7709.999750ps      -8.1344387
+ 7719.999751ps      -8.1211115
+ 7729.999751ps      -8.0486725
+ 7739.999752ps      -7.9898126
+ 7749.999753ps      -7.9545006
+ 7759.999754ps      -7.9241657
+ 7769.999755ps      -7.9207205
+ 7779.999756ps      -7.9355636
+ 7789.999756ps      -7.9637291
+ 7799.999757ps      -8.0006474
+ 7809.999758ps      -8.0267642
+ 7819.999759ps      -8.0718413
+ 7829.999760ps      -8.1002516
+ 7839.999761ps      -8.1132819
+ 7849.999761ps      -8.1208241
+ 7859.999762ps      -8.1681903
+ 7869.999763ps      -8.1847958
+ 7879.999764ps       -8.196134
+ 7889.999765ps      -8.1877935
+ 7899.999765ps      -8.1588112
+ 7909.999766ps      -8.0931765
+ 7919.999767ps      -8.0369369
+ 7929.999768ps      -7.9731038
+ 7939.999769ps      -7.9476954
+ 7949.999770ps       -7.960828
+ 7959.999770ps      -7.9961763
+ 7969.999771ps      -8.0181717
+ 7979.999772ps      -8.0323927
+ 7989.999773ps      -8.1617519
+)

Icursig11 PAR_2_1_VDD075CPU 0 pwl(
+ 0.000000ps       5.0081995
+ 10.000000ps       5.1649024
+ 20.000000ps       5.5739354
+ 29.999999ps       6.0673673
+ 40.000000ps       6.5489844
+ 50.000001ps       6.9819362
+ 59.999998ps       7.3595526
+ 69.999999ps       7.6936038
+ 80.000000ps       7.9863008
+ 90.000001ps       8.2328383
+ 100.000001ps       8.4505507
+ 110.000002ps       8.6338825
+ 119.999996ps        8.798178
+ 129.999997ps       8.9389834
+ 139.999998ps       9.0571396
+ 149.999999ps       9.1516933
+ 159.999999ps       9.2351879
+ 170.000000ps       9.3083869
+ 180.000001ps        9.374906
+ 190.000002ps       9.4443706
+ 200.000003ps       9.5242146
+ 210.000003ps       9.6079321
+ 220.000004ps        9.697179
+ 230.000005ps       9.7980695
+ 239.999992ps       9.8927685
+ 249.999993ps       9.9696958
+ 259.999994ps       10.042097
+ 269.999995ps       10.104303
+ 279.999995ps       10.169747
+ 289.999996ps       10.192977
+ 299.999997ps       10.216017
+ 309.999998ps       10.256146
+ 319.999999ps       10.310085
+ 330.000000ps       10.367757
+ 340.000000ps       10.410846
+ 350.000001ps       10.439681
+ 360.000002ps       10.483139
+ 370.000003ps       10.514696
+ 380.000004ps       10.534852
+ 390.000005ps       10.552228
+ 400.000005ps       10.566839
+ 410.000006ps        10.58855
+ 420.000007ps       10.600145
+ 430.000008ps       10.614373
+ 440.000009ps       10.608092
+ 450.000009ps       10.594151
+ 460.000010ps       10.582723
+ 469.999983ps       10.588394
+ 479.999984ps       10.583839
+ 489.999985ps       10.640729
+ 499.999986ps       10.629435
+ 509.999987ps       10.638258
+ 519.999988ps       10.686769
+ 529.999988ps       10.738429
+ 539.999989ps       10.798932
+ 549.999990ps       10.799219
+ 559.999991ps        10.81247
+ 569.999992ps       10.819571
+ 579.999992ps       10.821542
+ 589.999993ps       10.805151
+ 599.999994ps       10.782354
+ 609.999995ps       10.734489
+ 619.999996ps       10.692922
+ 629.999997ps       10.658908
+ 639.999997ps       10.635738
+ 649.999998ps       10.650902
+ 659.999999ps       10.670687
+ 670.000000ps       10.711806
+ 680.000001ps       10.788817
+ 690.000002ps       10.814458
+ 700.000002ps       10.875201
+ 710.000003ps       10.921862
+ 720.000004ps       10.954705
+ 730.000005ps       10.973817
+ 740.000006ps       10.961896
+ 750.000007ps       10.959558
+ 760.000007ps       10.936393
+ 770.000008ps       10.862363
+ 780.000009ps       10.818077
+ 790.000010ps        10.78545
+ 800.000011ps       10.768708
+ 810.000012ps       10.718845
+ 820.000012ps       10.677587
+ 830.000013ps       10.686495
+ 840.000014ps       10.717559
+ 850.000015ps       10.742246
+ 860.000016ps       10.761433
+ 870.000016ps       10.776986
+ 880.000017ps       10.779022
+ 890.000018ps       10.770834
+ 900.000019ps       10.769775
+ 910.000020ps       10.753595
+ 920.000021ps       10.754078
+ 930.000021ps       10.742732
+ 939.999967ps       10.739669
+ 949.999968ps       10.729728
+ 959.999968ps       10.716706
+ 969.999969ps       10.668375
+ 979.999970ps       10.587363
+ 989.999971ps       10.481803
+ 999.999972ps       10.346366
+ 1009.999973ps       10.244384
+ 1019.999973ps       10.165304
+ 1029.999974ps       10.121788
+ 1039.999975ps       10.046714
+ 1049.999976ps        9.967909
+ 1059.999977ps       9.8902166
+ 1069.999978ps        9.808739
+ 1079.999978ps       9.7222623
+ 1089.999979ps       9.5895725
+ 1099.999980ps       9.4846948
+ 1109.999981ps       9.4053988
+ 1119.999982ps       9.3340996
+ 1129.999982ps        9.276698
+ 1139.999983ps        9.215458
+ 1149.999984ps       9.1605174
+ 1159.999985ps       9.0932032
+ 1169.999986ps       9.0191423
+ 1179.999987ps       8.9621052
+ 1189.999987ps       8.9079732
+ 1199.999988ps       8.8667565
+ 1209.999989ps       8.8400185
+ 1219.999990ps       8.8271079
+ 1229.999991ps        8.831995
+ 1239.999992ps       8.8101474
+ 1249.999992ps       8.8049926
+ 1259.999993ps       8.8392079
+ 1269.999994ps       8.8385255
+ 1279.999995ps       8.8356267
+ 1289.999996ps       8.8268314
+ 1299.999997ps       8.8313275
+ 1309.999997ps       8.8480566
+ 1319.999998ps        8.826444
+ 1329.999999ps       8.8213255
+ 1340.000000ps       8.7973291
+ 1350.000001ps       8.7610117
+ 1360.000002ps       8.7005826
+ 1370.000002ps       8.6541085
+ 1380.000003ps        8.629165
+ 1390.000004ps       8.6038144
+ 1400.000005ps       8.5839711
+ 1410.000006ps       8.5544409
+ 1420.000006ps       8.5337211
+ 1430.000007ps        8.517714
+ 1440.000008ps        8.497527
+ 1450.000009ps       8.4816404
+ 1460.000010ps       8.4615939
+ 1470.000011ps       8.4601016
+ 1480.000011ps       8.4620606
+ 1490.000012ps       8.4693117
+ 1500.000013ps       8.4730768
+ 1510.000014ps       8.4675274
+ 1520.000015ps       8.4440912
+ 1530.000016ps       8.4241766
+ 1540.000016ps       8.3933196
+ 1550.000017ps       8.3777839
+ 1560.000018ps       8.3705673
+ 1570.000019ps       8.3778847
+ 1580.000020ps       8.3609732
+ 1590.000021ps       8.3438733
+ 1600.000021ps       8.3451679
+ 1610.000022ps       8.3346558
+ 1620.000023ps       8.3472896
+ 1630.000024ps       8.3238569
+ 1640.000025ps       8.3191013
+ 1650.000025ps        8.313276
+ 1660.000026ps       8.3051312
+ 1670.000027ps       8.2995757
+ 1680.000028ps       8.3031452
+ 1690.000029ps       8.3198291
+ 1700.000030ps       8.3398915
+ 1710.000030ps       8.3577516
+ 1720.000031ps       8.3624809
+ 1730.000032ps       8.3582197
+ 1740.000033ps       8.3465765
+ 1750.000034ps       8.3444455
+ 1760.000035ps       8.3316234
+ 1770.000035ps       8.2907432
+ 1780.000036ps       8.2566432
+ 1790.000037ps       8.2285594
+ 1800.000038ps       8.2116207
+ 1810.000039ps       8.2072528
+ 1820.000040ps       8.2050931
+ 1830.000040ps       8.2130588
+ 1840.000041ps       8.2195125
+ 1850.000042ps       8.2426459
+ 1860.000043ps       8.2910282
+ 1869.999933ps       8.3515054
+ 1879.999934ps       8.3846989
+ 1889.999934ps       8.4159234
+ 1899.999935ps       8.4414249
+ 1909.999936ps       8.4598548
+ 1919.999937ps       8.4570099
+ 1929.999938ps       8.4332104
+ 1939.999938ps       8.4140739
+ 1949.999939ps        8.407443
+ 1959.999940ps       8.3829053
+ 1969.999941ps       8.3488689
+ 1979.999942ps        8.339926
+ 1989.999943ps       8.3278551
+ 1999.999943ps       8.3428846
+ 2009.999944ps       8.3462754
+ 2019.999945ps       8.3625807
+ 2029.999946ps       8.3979749
+ 2039.999947ps       8.4287732
+ 2049.999948ps       8.4575773
+ 2059.999948ps       8.4746312
+ 2069.999949ps       8.4843826
+ 2079.999950ps       8.4869125
+ 2089.999951ps       8.4952943
+ 2099.999952ps       8.4943322
+ 2109.999953ps       8.4918405
+ 2119.999953ps       8.4754702
+ 2129.999954ps       8.4408598
+ 2139.999955ps       8.4091909
+ 2149.999956ps       8.3798006
+ 2159.999957ps       8.3915178
+ 2169.999958ps       8.4206454
+ 2179.999958ps       8.4721629
+ 2189.999959ps       8.5115969
+ 2199.999960ps       8.5381727
+ 2209.999961ps       8.5690736
+ 2219.999962ps        8.580288
+ 2229.999962ps       8.5972976
+ 2239.999963ps       8.5961343
+ 2249.999964ps       8.5843304
+ 2259.999965ps       8.5745757
+ 2269.999966ps       8.5539551
+ 2279.999967ps       8.5339242
+ 2289.999967ps       8.5031204
+ 2299.999968ps       8.4381734
+ 2309.999969ps       8.3823033
+ 2319.999970ps        8.356318
+ 2329.999971ps       8.3551959
+ 2339.999972ps       8.3688257
+ 2349.999972ps       8.3961323
+ 2359.999973ps       8.4277787
+ 2369.999974ps       8.4554735
+ 2379.999975ps       8.4892474
+ 2389.999976ps       8.4932377
+ 2399.999977ps       8.4894239
+ 2409.999977ps       8.4936657
+ 2419.999978ps       8.4909487
+ 2429.999979ps       8.4963696
+ 2439.999980ps       8.4672072
+ 2449.999981ps       8.4697589
+ 2459.999982ps       8.4774606
+ 2469.999982ps        8.439118
+ 2479.999983ps       8.4186294
+ 2489.999984ps       8.4029163
+ 2499.999985ps       8.3914274
+ 2509.999986ps        8.393681
+ 2519.999986ps       8.4116074
+ 2529.999987ps       8.3987116
+ 2539.999988ps       8.3953302
+ 2549.999989ps        8.434143
+ 2559.999990ps       8.4530062
+ 2569.999991ps       8.4797601
+ 2579.999991ps       8.4392472
+ 2589.999992ps        8.472229
+ 2599.999993ps        8.511369
+ 2609.999994ps       8.5140236
+ 2619.999995ps       8.5198167
+ 2629.999996ps       8.5339997
+ 2639.999996ps       8.5379646
+ 2649.999997ps        8.513588
+ 2659.999998ps       8.4599019
+ 2669.999999ps       8.4214844
+ 2680.000000ps       8.3846743
+ 2690.000001ps       8.3528289
+ 2700.000001ps       8.3247943
+ 2710.000002ps       8.2946371
+ 2720.000003ps       8.2541484
+ 2730.000004ps       8.2188845
+ 2740.000005ps       8.1998326
+ 2750.000005ps       8.2104206
+ 2760.000006ps       8.2319955
+ 2770.000007ps       8.2630249
+ 2780.000008ps        8.284156
+ 2790.000009ps       8.3029851
+ 2800.000010ps       8.2987394
+ 2810.000010ps       8.2871998
+ 2820.000011ps       8.2470583
+ 2830.000012ps       8.2230352
+ 2840.000013ps       8.2079389
+ 2850.000014ps       8.1927908
+ 2860.000015ps       8.1623193
+ 2870.000015ps        8.109198
+ 2880.000016ps       8.0622922
+ 2890.000017ps       8.0086692
+ 2900.000018ps       7.9804051
+ 2910.000019ps       7.9738415
+ 2920.000020ps        7.999393
+ 2930.000020ps       8.0361792
+ 2940.000021ps       8.0742975
+ 2950.000022ps       8.1140603
+ 2960.000023ps       8.1333415
+ 2970.000024ps       8.1280052
+ 2980.000025ps       8.1223635
+ 2990.000025ps       8.1305812
+ 3000.000026ps       8.1148732
+ 3010.000027ps       8.0716817
+ 3020.000028ps       8.0620288
+ 3030.000029ps       8.0645672
+ 3040.000029ps       8.0714115
+ 3050.000030ps       8.0522311
+ 3060.000031ps       8.0740309
+ 3070.000032ps       8.0321847
+ 3080.000033ps          8.0084
+ 3090.000034ps       8.0307198
+ 3100.000034ps       8.0558719
+ 3110.000035ps        8.108189
+ 3120.000036ps       8.0869846
+ 3130.000037ps       8.1108261
+ 3140.000038ps       8.1183981
+ 3150.000039ps       8.1196651
+ 3160.000039ps       8.1110708
+ 3170.000040ps       8.0861479
+ 3180.000041ps       8.0651812
+ 3190.000042ps       8.0629892
+ 3200.000043ps       8.0436022
+ 3210.000044ps       8.0432504
+ 3220.000044ps       8.0764669
+ 3230.000045ps       8.1198634
+ 3240.000046ps       8.1522772
+ 3250.000047ps       8.1368108
+ 3260.000048ps       8.1621598
+ 3270.000049ps       8.1933148
+ 3280.000049ps       8.2285964
+ 3290.000050ps       8.2581015
+ 3300.000051ps       8.2950057
+ 3310.000052ps       8.3198323
+ 3320.000053ps       8.3362747
+ 3330.000053ps       8.3221647
+ 3340.000054ps        8.307415
+ 3350.000055ps       8.3072676
+ 3360.000056ps       8.3296819
+ 3370.000057ps       8.2717863
+ 3380.000058ps       8.2147286
+ 3390.000058ps       8.2013774
+ 3400.000059ps       8.2048833
+ 3410.000060ps       8.2246956
+ 3420.000061ps       8.1940208
+ 3430.000062ps       8.1925345
+ 3440.000063ps       8.2011329
+ 3450.000063ps       8.2174771
+ 3460.000064ps       8.2443706
+ 3470.000065ps       8.2509554
+ 3480.000066ps       8.2670311
+ 3490.000067ps       8.2821739
+ 3500.000068ps       8.3192872
+ 3510.000068ps       8.3466799
+ 3520.000069ps        8.361958
+ 3530.000070ps       8.3602942
+ 3540.000071ps       8.3035932
+ 3550.000072ps       8.2607728
+ 3560.000073ps       8.2185121
+ 3570.000073ps       8.1852812
+ 3580.000074ps       8.1678448
+ 3590.000075ps       8.1460204
+ 3600.000076ps       8.1574669
+ 3610.000077ps       8.1801351
+ 3620.000077ps       8.2049379
+ 3630.000078ps        8.241632
+ 3640.000079ps       8.2448042
+ 3650.000080ps       8.2355934
+ 3660.000081ps       8.2442187
+ 3670.000082ps       8.2556835
+ 3680.000082ps       8.2737143
+ 3690.000083ps       8.2793568
+ 3700.000084ps       8.2855228
+ 3710.000085ps       8.2707377
+ 3720.000086ps       8.2581459
+ 3729.999865ps       8.1927923
+ 3739.999865ps       8.1520548
+ 3749.999866ps        8.133299
+ 3759.999867ps       8.1141745
+ 3769.999868ps       8.1261757
+ 3779.999869ps       8.1202397
+ 3789.999869ps       8.1546316
+ 3799.999870ps       8.1920463
+ 3809.999871ps       8.2234138
+ 3819.999872ps       8.2538915
+ 3829.999873ps       8.2755364
+ 3839.999874ps       8.2822467
+ 3849.999874ps       8.2805125
+ 3859.999875ps       8.2890576
+ 3869.999876ps       8.2979782
+ 3879.999877ps       8.3108536
+ 3889.999878ps       8.2850722
+ 3899.999879ps        8.244727
+ 3909.999879ps       8.1964717
+ 3919.999880ps       8.1426734
+ 3929.999881ps       8.1020846
+ 3939.999882ps       8.0839079
+ 3949.999883ps       8.0892877
+ 3959.999884ps        8.107709
+ 3969.999884ps       8.1108896
+ 3979.999885ps       8.1148526
+ 3989.999886ps       8.1400999
+ 3999.999887ps       8.2869437
+ 4009.999888ps       8.4994159
+ 4019.999889ps       8.6342391
+ 4029.999889ps       8.7289262
+ 4039.999890ps       8.7960678
+ 4049.999891ps       8.8433068
+ 4059.999892ps       8.8673023
+ 4069.999893ps       8.8964978
+ 4079.999893ps       8.8975247
+ 4089.999894ps       8.9014764
+ 4099.999895ps       8.9113195
+ 4109.999896ps       8.9363004
+ 4119.999897ps       8.9699125
+ 4129.999898ps       9.0033601
+ 4139.999898ps       9.0455141
+ 4149.999899ps       9.0665326
+ 4159.999900ps       9.0673191
+ 4169.999901ps        9.051024
+ 4179.999902ps       9.0266294
+ 4189.999903ps       9.0070304
+ 4199.999903ps       9.0088291
+ 4209.999904ps       9.0099685
+ 4219.999905ps       9.0244935
+ 4229.999906ps        9.047191
+ 4239.999907ps       9.0482027
+ 4249.999908ps       9.0446175
+ 4259.999908ps       9.0316399
+ 4269.999909ps       9.0031064
+ 4279.999910ps       8.9858916
+ 4289.999911ps       8.9464604
+ 4299.999912ps       8.9258417
+ 4309.999913ps       8.9307324
+ 4319.999913ps       8.9454502
+ 4329.999914ps        8.964493
+ 4339.999915ps       8.9663415
+ 4349.999916ps       8.9713884
+ 4359.999917ps       8.9843563
+ 4369.999917ps       8.9973052
+ 4379.999918ps       9.0041237
+ 4389.999919ps       9.0065046
+ 4399.999920ps       9.0004314
+ 4409.999921ps       9.0092112
+ 4419.999922ps       9.0060179
+ 4429.999922ps       9.0124987
+ 4439.999923ps       9.0067989
+ 4449.999924ps        8.987497
+ 4459.999925ps       8.9724742
+ 4469.999926ps       8.9690713
+ 4479.999927ps       8.9516158
+ 4489.999927ps       8.9852524
+ 4499.999928ps       8.9725609
+ 4509.999929ps        8.975953
+ 4519.999930ps       9.0249633
+ 4529.999931ps       9.0841632
+ 4539.999932ps       9.1485364
+ 4549.999932ps       9.1509209
+ 4559.999933ps       9.1655055
+ 4569.999934ps       9.1725265
+ 4579.999935ps       9.1651076
+ 4589.999936ps       9.1487728
+ 4599.999937ps       9.1168266
+ 4609.999937ps       9.0710633
+ 4619.999938ps       9.0292013
+ 4629.999939ps       9.0004337
+ 4639.999940ps       8.9747777
+ 4649.999941ps       8.9933403
+ 4659.999941ps       9.0095641
+ 4669.999942ps       9.0461069
+ 4679.999943ps       9.1196296
+ 4689.999944ps       9.1461753
+ 4699.999945ps       9.1997073
+ 4709.999946ps       9.2451943
+ 4719.999946ps       9.2830756
+ 4729.999947ps       9.3067952
+ 4739.999948ps       9.3058249
+ 4749.999949ps        9.307132
+ 4759.999950ps       9.2931843
+ 4769.999951ps       9.2350649
+ 4779.999951ps       9.2045546
+ 4789.999952ps       9.1821972
+ 4799.999953ps       9.1648378
+ 4809.999954ps       9.1182428
+ 4819.999955ps       9.0934263
+ 4829.999956ps       9.1033401
+ 4839.999956ps       9.1357263
+ 4849.999957ps       9.1663822
+ 4859.999958ps       9.1794494
+ 4869.999959ps       9.2049085
+ 4879.999960ps       9.2252553
+ 4889.999961ps       9.2242562
+ 4899.999961ps       9.2180067
+ 4909.999962ps       9.2135055
+ 4919.999963ps        9.212053
+ 4929.999964ps       9.2094783
+ 4939.999965ps       9.2095012
+ 4949.999965ps       9.2093966
+ 4959.999966ps       9.2109423
+ 4969.999967ps       9.1673556
+ 4979.999968ps       9.1129965
+ 4989.999969ps       9.0441696
+ 4999.999970ps        8.972181
+ 5009.999970ps       8.9396709
+ 5019.999971ps       8.9418786
+ 5029.999972ps        8.969431
+ 5039.999973ps       8.9626387
+ 5049.999974ps       8.9627264
+ 5059.999975ps       8.9680437
+ 5069.999975ps       8.9648946
+ 5079.999976ps       8.9501868
+ 5089.999977ps       8.8776725
+ 5099.999978ps       8.8334698
+ 5109.999979ps       8.8168875
+ 5119.999980ps       8.7988909
+ 5129.999980ps       8.7978572
+ 5139.999981ps       8.7820942
+ 5149.999982ps       8.7653444
+ 5159.999983ps       8.7385781
+ 5169.999984ps       8.6981595
+ 5179.999985ps       8.6599536
+ 5189.999985ps       8.6331232
+ 5199.999986ps       8.6219363
+ 5209.999987ps       8.6291076
+ 5219.999988ps       8.6421185
+ 5229.999989ps       8.6756427
+ 5239.999989ps       8.6772589
+ 5249.999990ps       8.6935217
+ 5259.999991ps       8.7390385
+ 5269.999992ps       8.7524773
+ 5279.999993ps       8.7678671
+ 5289.999994ps       8.7656527
+ 5299.999994ps       8.7814395
+ 5309.999995ps       8.8048619
+ 5319.999996ps       8.7950348
+ 5329.999997ps       8.8068937
+ 5339.999998ps       8.7982632
+ 5349.999999ps       8.7844892
+ 5359.999999ps       8.7403047
+ 5370.000000ps       8.7059701
+ 5380.000001ps       8.6935885
+ 5390.000002ps       8.6740095
+ 5400.000003ps       8.6581016
+ 5410.000004ps       8.6339407
+ 5420.000004ps       8.6104302
+ 5430.000005ps        8.594954
+ 5440.000006ps       8.5841943
+ 5450.000007ps       8.5649167
+ 5460.000008ps       8.5470952
+ 5470.000009ps       8.5500541
+ 5480.000009ps       8.5576127
+ 5490.000010ps       8.5711952
+ 5500.000011ps       8.5848236
+ 5510.000012ps       8.5840664
+ 5520.000013ps       8.5606812
+ 5530.000013ps       8.5457627
+ 5540.000014ps       8.5257075
+ 5550.000015ps       8.5162969
+ 5560.000016ps       8.5158411
+ 5570.000017ps       8.5343628
+ 5580.000018ps        8.517807
+ 5590.000018ps       8.4959094
+ 5600.000019ps       8.4974917
+ 5610.000020ps       8.4959766
+ 5620.000021ps       8.5070144
+ 5630.000022ps       8.4779909
+ 5640.000023ps       8.4770291
+ 5650.000023ps       8.4704266
+ 5660.000024ps       8.4765582
+ 5670.000025ps       8.4843915
+ 5680.000026ps       8.4897944
+ 5690.000027ps        8.512631
+ 5700.000028ps        8.527481
+ 5710.000028ps       8.5383693
+ 5720.000029ps       8.5498265
+ 5730.000030ps       8.5479562
+ 5740.000031ps       8.5348246
+ 5750.000032ps       8.5244623
+ 5760.000033ps       8.5151419
+ 5770.000033ps       8.4888444
+ 5780.000034ps       8.4575142
+ 5790.000035ps       8.4252759
+ 5800.000036ps       8.4067109
+ 5810.000037ps       8.4067246
+ 5820.000037ps       8.4037188
+ 5830.000038ps       8.4099922
+ 5840.000039ps        8.421071
+ 5850.000040ps       8.4522387
+ 5860.000041ps       8.5029393
+ 5870.000042ps       8.5570337
+ 5880.000042ps       8.5894157
+ 5890.000043ps        8.624482
+ 5900.000044ps       8.6467121
+ 5910.000045ps       8.6557331
+ 5920.000046ps       8.6426162
+ 5930.000047ps       8.6243893
+ 5940.000047ps       8.6065811
+ 5950.000048ps       8.5999518
+ 5960.000049ps       8.5738065
+ 5970.000050ps       8.5363596
+ 5980.000051ps       8.5217723
+ 5990.000052ps       8.5152924
+ 6000.000052ps       8.5315027
+ 6010.000053ps       8.5367487
+ 6020.000054ps         8.55769
+ 6030.000055ps       8.5945623
+ 6040.000056ps       8.6332338
+ 6050.000056ps       8.6635804
+ 6060.000057ps       8.6813328
+ 6070.000058ps       8.6906176
+ 6080.000059ps       8.6998524
+ 6090.000060ps       8.7081092
+ 6100.000061ps       8.7104403
+ 6110.000061ps       8.7071518
+ 6120.000062ps       8.6933963
+ 6130.000063ps       8.6520855
+ 6140.000064ps       8.6192606
+ 6150.000065ps       8.5940467
+ 6160.000066ps       8.6051315
+ 6170.000066ps        8.639244
+ 6180.000067ps       8.6846069
+ 6190.000068ps        8.716721
+ 6200.000069ps       8.7464203
+ 6210.000070ps       8.7726557
+ 6220.000071ps        8.782203
+ 6230.000071ps       8.7966798
+ 6240.000072ps       8.7950044
+ 6250.000073ps       8.7772175
+ 6260.000074ps       8.7714633
+ 6270.000075ps       8.7588749
+ 6280.000076ps       8.7334732
+ 6290.000076ps       8.6987626
+ 6300.000077ps       8.6339653
+ 6310.000078ps       8.5734792
+ 6320.000079ps       8.5403223
+ 6330.000080ps       8.5424318
+ 6340.000080ps       8.5574239
+ 6350.000081ps       8.5867737
+ 6360.000082ps       8.6211304
+ 6370.000083ps       8.6507976
+ 6380.000084ps       8.6844374
+ 6390.000085ps       8.6909242
+ 6400.000085ps       8.6856755
+ 6410.000086ps       8.6903108
+ 6420.000087ps       8.6824529
+ 6430.000088ps       8.6855261
+ 6440.000089ps       8.6578917
+ 6450.000090ps         8.66222
+ 6460.000090ps       8.6627577
+ 6470.000091ps       8.6262802
+ 6480.000092ps        8.606877
+ 6490.000093ps       8.5897378
+ 6500.000094ps       8.5772805
+ 6510.000095ps       8.5781679
+ 6520.000095ps       8.5969679
+ 6530.000096ps       8.5889176
+ 6540.000097ps       8.5790183
+ 6550.000098ps       8.6196617
+ 6560.000099ps       8.6409762
+ 6570.000100ps       8.6644744
+ 6580.000100ps       8.6292628
+ 6590.000101ps       8.6629668
+ 6600.000102ps       8.6983772
+ 6610.000103ps       8.7074595
+ 6620.000104ps       8.7114933
+ 6630.000104ps       8.7275017
+ 6640.000105ps       8.7298733
+ 6650.000106ps       8.7105549
+ 6660.000107ps       8.6591244
+ 6670.000108ps       8.6229616
+ 6680.000109ps       8.5842649
+ 6690.000109ps        8.555026
+ 6700.000110ps       8.5308309
+ 6710.000111ps       8.5081362
+ 6720.000112ps       8.4697463
+ 6730.000113ps       8.4361516
+ 6740.000114ps       8.4145023
+ 6750.000114ps       8.4250148
+ 6760.000115ps       8.4421472
+ 6770.000116ps       8.4714506
+ 6780.000117ps       8.4917283
+ 6790.000118ps       8.5113994
+ 6800.000119ps       8.5190232
+ 6810.000119ps       8.5077382
+ 6820.000120ps       8.4704527
+ 6830.000121ps       8.4357842
+ 6840.000122ps        8.415874
+ 6850.000123ps       8.3955106
+ 6860.000124ps       8.3630216
+ 6870.000124ps       8.3118139
+ 6880.000125ps       8.2812917
+ 6890.000126ps       8.2323839
+ 6900.000127ps       8.2049427
+ 6910.000128ps       8.1960741
+ 6920.000128ps       8.2189765
+ 6930.000129ps       8.2598697
+ 6940.000130ps       8.3064566
+ 6950.000131ps       8.3488224
+ 6960.000132ps       8.3582775
+ 6970.000133ps       8.3571414
+ 6980.000133ps        8.345174
+ 6990.000134ps       8.3547239
+ 7000.000135ps       8.3408196
+ 7010.000136ps       8.2837719
+ 7020.000137ps       8.2731591
+ 7030.000138ps       8.2797301
+ 7040.000138ps       8.2916116
+ 7050.000139ps       8.2724877
+ 7060.000140ps       8.2964518
+ 7070.000141ps       8.2572588
+ 7080.000142ps        8.241908
+ 7090.000143ps       8.2677582
+ 7100.000143ps       8.2987864
+ 7110.000144ps       8.3478845
+ 7120.000145ps       8.3231627
+ 7130.000146ps       8.3449912
+ 7140.000147ps       8.3492122
+ 7150.000147ps       8.3506846
+ 7160.000148ps       8.3296059
+ 7170.000149ps       8.3060049
+ 7180.000150ps       8.2829523
+ 7190.000151ps       8.2822332
+ 7200.000152ps        8.265174
+ 7210.000152ps       8.2694266
+ 7220.000153ps       8.3049808
+ 7230.000154ps       8.3443175
+ 7240.000155ps       8.3777949
+ 7250.000156ps       8.3665493
+ 7260.000157ps       8.3894284
+ 7270.000157ps       8.4266528
+ 7280.000158ps       8.4550611
+ 7290.000159ps       8.4817872
+ 7300.000160ps       8.5091256
+ 7310.000161ps       8.5430086
+ 7320.000162ps       8.5505428
+ 7330.000162ps       8.5342097
+ 7340.000163ps       8.5292021
+ 7350.000164ps       8.5278726
+ 7360.000165ps       8.5522497
+ 7370.000166ps        8.497563
+ 7380.000167ps        8.433279
+ 7390.000167ps       8.4195512
+ 7400.000168ps       8.4211274
+ 7410.000169ps       8.4402689
+ 7420.000170ps       8.4062769
+ 7430.000171ps       8.4067043
+ 7440.000171ps       8.4202173
+ 7450.000172ps       8.4365578
+ 7459.999729ps       8.4624711
+ 7469.999730ps       8.4682001
+ 7479.999731ps       8.4802712
+ 7489.999732ps        8.503165
+ 7499.999732ps       8.5361275
+ 7509.999733ps       8.5633656
+ 7519.999734ps       8.5798038
+ 7529.999735ps       8.5862989
+ 7539.999736ps       8.5336437
+ 7549.999737ps       8.4890272
+ 7559.999737ps       8.4527166
+ 7569.999738ps       8.4174284
+ 7579.999739ps       8.4017293
+ 7589.999740ps       8.3770993
+ 7599.999741ps       8.3931034
+ 7609.999741ps       8.4093039
+ 7619.999742ps       8.4287881
+ 7629.999743ps       8.4635591
+ 7639.999744ps       8.4652897
+ 7649.999745ps       8.4515567
+ 7659.999746ps        8.461642
+ 7669.999746ps       8.4788861
+ 7679.999747ps       8.5033733
+ 7689.999748ps       8.5062449
+ 7699.999749ps       8.5107896
+ 7709.999750ps       8.5034926
+ 7719.999751ps       8.4936651
+ 7729.999751ps       8.4344173
+ 7739.999752ps       8.3870322
+ 7749.999753ps        8.359665
+ 7759.999754ps        8.341594
+ 7769.999755ps       8.3507274
+ 7779.999756ps       8.3420926
+ 7789.999756ps       8.3669062
+ 7799.999757ps        8.409703
+ 7809.999758ps       8.4376587
+ 7819.999759ps        8.461525
+ 7829.999760ps       8.4865794
+ 7839.999761ps       8.4940454
+ 7849.999761ps        8.488687
+ 7859.999762ps       8.4971277
+ 7869.999763ps       8.5096022
+ 7879.999764ps       8.5281212
+ 7889.999765ps       8.5033888
+ 7899.999765ps       8.4612273
+ 7909.999766ps       8.4153487
+ 7919.999767ps       8.3613426
+ 7929.999768ps       8.3280365
+ 7939.999769ps       8.3027493
+ 7949.999770ps       8.3091736
+ 7959.999770ps       8.3232238
+ 7969.999771ps       8.3358863
+ 7979.999772ps       8.3412522
+ 7989.999773ps        8.350163
+)

Icursig12 PAR_0_2_VSS 0 pwl(
+ 0.000000ps      -5.3903966
+ 10.000000ps      -6.3583822
+ 20.000000ps      -8.5529007
+ 29.999999ps      -10.814348
+ 40.000000ps      -11.619148
+ 50.000001ps      -11.660674
+ 59.999998ps      -12.706773
+ 69.999999ps      -15.073606
+ 80.000000ps      -18.281274
+ 90.000001ps      -20.665205
+ 100.000001ps      -20.446847
+ 110.000002ps       -19.24483
+ 119.999996ps      -19.309417
+ 129.999997ps      -19.721616
+ 139.999998ps      -20.022988
+ 149.999999ps      -19.550772
+ 159.999999ps      -17.912414
+ 170.000000ps      -16.295028
+ 180.000001ps       -15.27537
+ 190.000002ps      -14.225406
+ 200.000003ps      -13.237193
+ 210.000003ps      -12.391102
+ 220.000004ps      -11.737741
+ 230.000005ps      -11.191189
+ 239.999992ps      -10.712611
+ 249.999993ps      -10.309193
+ 259.999994ps      -9.9914576
+ 269.999995ps      -9.7681106
+ 279.999995ps      -9.5917829
+ 289.999996ps      -9.4588588
+ 299.999997ps      -9.3596505
+ 309.999998ps      -9.3131583
+ 319.999999ps       -9.274623
+ 330.000000ps      -9.2460898
+ 340.000000ps      -9.2680724
+ 350.000001ps      -9.3799173
+ 360.000002ps      -9.5802404
+ 370.000003ps      -9.8821364
+ 380.000004ps      -10.379251
+ 390.000005ps      -11.151647
+ 400.000005ps      -11.999574
+ 410.000006ps       -12.84065
+ 420.000007ps      -13.701153
+ 430.000008ps      -14.314207
+ 440.000009ps      -14.732645
+ 450.000009ps      -14.917548
+ 460.000010ps      -14.883002
+ 469.999983ps      -14.679137
+ 479.999984ps      -14.199608
+ 489.999985ps      -13.599188
+ 499.999986ps      -12.928404
+ 509.999987ps      -12.204169
+ 519.999988ps      -11.496989
+ 529.999988ps      -10.876184
+ 539.999989ps      -10.357292
+ 549.999990ps      -9.9020389
+ 559.999991ps      -9.5493781
+ 569.999992ps       -9.247169
+ 579.999992ps      -9.0036663
+ 589.999993ps      -8.8064503
+ 599.999994ps      -8.6673714
+ 609.999995ps      -8.5938482
+ 619.999996ps       -8.525105
+ 629.999997ps       -8.497944
+ 639.999997ps      -8.5011347
+ 649.999998ps      -8.5217661
+ 659.999999ps      -8.6334199
+ 670.000000ps      -9.1174238
+ 680.000001ps      -10.439676
+ 690.000002ps       -12.37308
+ 700.000002ps       -13.55616
+ 710.000003ps      -13.534609
+ 720.000004ps      -13.662481
+ 730.000005ps      -15.185935
+ 740.000006ps      -17.980461
+ 750.000007ps      -20.898072
+ 760.000007ps      -21.887619
+ 770.000008ps      -20.767519
+ 780.000009ps      -20.106908
+ 790.000010ps      -20.214252
+ 800.000011ps      -20.634492
+ 810.000012ps      -20.643131
+ 820.000012ps      -19.520423
+ 830.000013ps      -17.768633
+ 840.000014ps      -16.478831
+ 850.000015ps      -15.447884
+ 860.000016ps      -14.306954
+ 870.000016ps      -13.331987
+ 880.000017ps      -12.621681
+ 890.000018ps       -11.97116
+ 900.000019ps      -11.429055
+ 910.000020ps      -10.928321
+ 920.000021ps      -10.507326
+ 930.000021ps      -10.135941
+ 939.999967ps        -9.85203
+ 949.999968ps      -9.6305137
+ 959.999968ps      -9.4626908
+ 969.999969ps      -9.3341533
+ 979.999970ps      -9.2566627
+ 989.999971ps      -9.1878798
+ 999.999972ps      -9.1718266
+ 1009.999973ps      -9.1987766
+ 1019.999973ps      -9.3364341
+ 1029.999974ps      -9.5653711
+ 1039.999975ps      -9.9263367
+ 1049.999976ps      -10.504894
+ 1059.999977ps      -11.269578
+ 1069.999978ps       -12.10328
+ 1079.999978ps      -12.980224
+ 1089.999979ps      -13.694852
+ 1099.999980ps      -14.160742
+ 1109.999981ps       -14.46241
+ 1119.999982ps      -14.474101
+ 1129.999982ps       -14.31284
+ 1139.999983ps      -13.993043
+ 1149.999984ps      -13.472888
+ 1159.999985ps      -12.835934
+ 1169.999986ps      -12.160281
+ 1179.999987ps      -11.498865
+ 1189.999987ps      -10.840508
+ 1199.999988ps       -10.24465
+ 1209.999989ps      -9.7224397
+ 1219.999990ps      -9.2241799
+ 1229.999991ps      -8.8281232
+ 1239.999992ps      -8.5045944
+ 1249.999992ps      -8.2694298
+ 1259.999993ps      -8.0895456
+ 1269.999994ps      -7.9517849
+ 1279.999995ps      -7.8424795
+ 1289.999996ps      -7.7745889
+ 1299.999997ps       -7.758996
+ 1309.999997ps      -7.7718123
+ 1319.999998ps      -7.8576692
+ 1329.999999ps      -8.0942381
+ 1340.000000ps      -8.8419595
+ 1350.000001ps      -10.471831
+ 1360.000002ps      -12.422686
+ 1370.000002ps      -13.233588
+ 1380.000003ps      -13.004549
+ 1390.000004ps      -13.608676
+ 1400.000005ps      -15.623095
+ 1410.000006ps      -18.572289
+ 1420.000006ps      -21.031748
+ 1430.000007ps      -21.127731
+ 1440.000008ps      -19.864984
+ 1450.000009ps      -19.548829
+ 1460.000010ps      -19.709968
+ 1470.000011ps      -20.191629
+ 1480.000011ps        -19.7829
+ 1490.000012ps      -18.279037
+ 1500.000013ps      -16.620084
+ 1510.000014ps       -15.53393
+ 1520.000015ps      -14.493868
+ 1530.000016ps      -13.414808
+ 1540.000016ps      -12.550656
+ 1550.000017ps      -11.916627
+ 1560.000018ps      -11.360129
+ 1570.000019ps      -10.886025
+ 1580.000020ps      -10.428359
+ 1590.000021ps      -10.025365
+ 1600.000021ps      -9.7069878
+ 1610.000022ps      -9.4904796
+ 1620.000023ps      -9.3376896
+ 1630.000024ps      -9.2028603
+ 1640.000025ps      -9.0624721
+ 1650.000025ps      -8.9658582
+ 1660.000026ps      -8.9007778
+ 1670.000027ps      -8.8869363
+ 1680.000028ps      -8.9712111
+ 1690.000029ps      -9.1196185
+ 1700.000030ps      -9.3641773
+ 1710.000030ps        -9.78563
+ 1720.000031ps      -10.467631
+ 1730.000032ps      -11.272212
+ 1740.000033ps      -12.120346
+ 1750.000034ps      -12.966936
+ 1760.000035ps      -13.601586
+ 1770.000035ps      -13.949916
+ 1780.000036ps      -14.175544
+ 1790.000037ps      -14.159114
+ 1800.000038ps      -14.008923
+ 1810.000039ps      -13.601365
+ 1820.000040ps      -13.023001
+ 1830.000040ps      -12.349228
+ 1840.000041ps      -11.636406
+ 1850.000042ps      -10.949893
+ 1860.000043ps      -10.322441
+ 1869.999933ps      -9.7797222
+ 1879.999934ps      -9.3068217
+ 1889.999934ps      -8.9186378
+ 1899.999935ps      -8.6008921
+ 1909.999936ps      -8.3507097
+ 1919.999937ps      -8.1429337
+ 1929.999938ps      -7.9935454
+ 1939.999938ps      -7.8840455
+ 1949.999939ps      -7.8036029
+ 1959.999940ps      -7.7630208
+ 1969.999941ps      -7.7450708
+ 1979.999942ps      -7.7600374
+ 1989.999943ps      -7.8439397
+ 1999.999943ps      -8.2071197
+ 2009.999944ps      -9.3058814
+ 2019.999945ps      -11.216517
+ 2029.999946ps      -12.671778
+ 2039.999947ps      -12.948711
+ 2049.999948ps      -12.883528
+ 2059.999948ps      -14.169134
+ 2069.999949ps      -16.768994
+ 2079.999950ps        -19.7669
+ 2089.999951ps      -21.345688
+ 2099.999952ps      -20.574123
+ 2109.999953ps      -19.558973
+ 2119.999953ps      -19.736079
+ 2129.999954ps      -20.077004
+ 2139.999955ps      -20.187818
+ 2149.999956ps      -19.342329
+ 2159.999957ps      -17.558923
+ 2169.999958ps      -16.140081
+ 2179.999958ps      -15.112951
+ 2189.999959ps      -13.996961
+ 2199.999960ps       -12.97786
+ 2209.999961ps      -12.248801
+ 2219.999962ps      -11.577979
+ 2229.999962ps      -11.014203
+ 2239.999963ps      -10.458698
+ 2249.999964ps      -9.9811169
+ 2259.999965ps      -9.5732349
+ 2269.999966ps      -9.2613792
+ 2279.999967ps      -9.0555149
+ 2289.999967ps      -8.8716523
+ 2299.999968ps      -8.7452119
+ 2309.999969ps      -8.6597469
+ 2319.999970ps      -8.6072324
+ 2329.999971ps      -8.5990755
+ 2339.999972ps       -8.638388
+ 2349.999972ps      -8.7850959
+ 2359.999973ps      -8.9993624
+ 2369.999974ps      -9.3401754
+ 2379.999975ps      -9.8689127
+ 2389.999976ps      -10.643512
+ 2399.999977ps      -11.513672
+ 2409.999977ps      -12.379044
+ 2419.999978ps      -13.167188
+ 2429.999979ps      -13.679225
+ 2439.999980ps      -14.006407
+ 2449.999981ps      -14.089926
+ 2459.999982ps      -14.014792
+ 2469.999982ps       -13.76529
+ 2479.999983ps      -13.264887
+ 2489.999984ps      -12.660585
+ 2499.999985ps      -12.020578
+ 2509.999986ps      -11.364004
+ 2519.999986ps      -10.701877
+ 2529.999987ps      -10.117691
+ 2539.999988ps      -9.5723751
+ 2549.999989ps      -9.0962448
+ 2559.999990ps      -8.7172437
+ 2569.999991ps      -8.3931388
+ 2579.999991ps      -8.1506679
+ 2589.999992ps      -7.9597544
+ 2599.999993ps      -7.8524253
+ 2609.999994ps      -7.7477828
+ 2619.999995ps      -7.6865972
+ 2629.999996ps      -7.6656479
+ 2639.999996ps      -7.6524673
+ 2649.999997ps      -7.6970975
+ 2659.999998ps      -7.8338608
+ 2669.999999ps      -8.3986249
+ 2680.000000ps      -9.8699839
+ 2690.000001ps      -11.817654
+ 2700.000001ps      -12.766935
+ 2710.000002ps      -12.685644
+ 2720.000003ps      -12.958764
+ 2730.000004ps      -14.635873
+ 2740.000005ps       -17.62056
+ 2750.000005ps      -20.477916
+ 2760.000006ps      -21.089082
+ 2770.000007ps      -19.852843
+ 2780.000008ps      -19.374718
+ 2790.000009ps      -19.491605
+ 2800.000010ps      -19.941558
+ 2810.000010ps      -19.832349
+ 2820.000011ps      -18.488661
+ 2830.000012ps      -16.770687
+ 2840.000013ps      -15.588816
+ 2850.000014ps      -14.512911
+ 2860.000015ps      -13.323993
+ 2870.000015ps      -12.347673
+ 2880.000016ps      -11.642921
+ 2890.000017ps      -11.005423
+ 2900.000018ps      -10.515333
+ 2910.000019ps      -10.038237
+ 2920.000020ps      -9.6666572
+ 2930.000020ps      -9.3948988
+ 2940.000021ps      -9.2009583
+ 2950.000022ps      -9.0808692
+ 2960.000023ps      -9.0173812
+ 2970.000024ps      -8.9639798
+ 2980.000025ps      -8.9306152
+ 2990.000025ps      -8.8646908
+ 3000.000026ps      -8.8298524
+ 3010.000027ps       -8.850817
+ 3020.000028ps      -8.9892841
+ 3030.000029ps      -9.1800345
+ 3040.000029ps       -9.517658
+ 3050.000030ps      -10.110735
+ 3060.000031ps      -10.901645
+ 3070.000032ps      -11.778768
+ 3080.000033ps      -12.676777
+ 3090.000034ps      -13.383462
+ 3100.000034ps       -13.83422
+ 3110.000035ps       -14.16425
+ 3120.000036ps      -14.200119
+ 3130.000037ps      -14.076886
+ 3140.000038ps      -13.762595
+ 3150.000039ps      -13.232775
+ 3160.000039ps      -12.582894
+ 3170.000040ps      -11.879254
+ 3180.000041ps      -11.168282
+ 3190.000042ps      -10.474881
+ 3200.000043ps      -9.8534071
+ 3210.000044ps      -9.3610898
+ 3220.000044ps      -8.9618944
+ 3230.000045ps      -8.6295814
+ 3240.000046ps      -8.3689552
+ 3250.000047ps      -8.1606868
+ 3260.000048ps      -8.0127739
+ 3270.000049ps      -7.9154058
+ 3280.000049ps      -7.8311597
+ 3290.000050ps       -7.775796
+ 3300.000051ps      -7.7438002
+ 3310.000052ps       -7.733956
+ 3320.000053ps      -7.7671318
+ 3330.000053ps      -8.0251906
+ 3340.000054ps      -8.9404823
+ 3350.000055ps      -10.717729
+ 3360.000056ps      -12.453799
+ 3370.000057ps      -12.886305
+ 3380.000058ps      -12.719663
+ 3390.000058ps      -13.652809
+ 3400.000059ps       -16.01349
+ 3410.000060ps      -19.054986
+ 3420.000061ps      -21.229656
+ 3430.000062ps      -20.853564
+ 3440.000063ps      -19.514463
+ 3450.000063ps      -19.488595
+ 3460.000064ps      -19.848107
+ 3470.000065ps      -20.097246
+ 3480.000066ps      -19.550683
+ 3490.000067ps      -17.829366
+ 3500.000068ps      -16.141805
+ 3510.000068ps       -15.09541
+ 3520.000069ps      -14.020884
+ 3530.000070ps      -12.988183
+ 3540.000071ps      -12.155119
+ 3550.000072ps      -11.504501
+ 3560.000073ps      -10.949722
+ 3570.000073ps      -10.458808
+ 3580.000074ps      -10.021105
+ 3590.000075ps      -9.6264301
+ 3600.000076ps      -9.3429045
+ 3610.000077ps      -9.1314868
+ 3620.000077ps      -8.9531045
+ 3630.000078ps      -8.8154428
+ 3640.000079ps      -8.7333337
+ 3650.000080ps      -8.6668828
+ 3660.000081ps      -8.6269278
+ 3670.000082ps      -8.6365556
+ 3680.000082ps      -8.7717743
+ 3690.000083ps      -8.9790099
+ 3700.000084ps      -9.2744184
+ 3710.000085ps      -9.7535859
+ 3720.000086ps      -10.510164
+ 3729.999865ps      -11.355941
+ 3739.999865ps      -12.215389
+ 3749.999866ps      -13.076483
+ 3759.999867ps       -13.69007
+ 3769.999868ps      -14.034709
+ 3779.999869ps      -14.154002
+ 3789.999869ps      -14.089045
+ 3799.999870ps      -13.863005
+ 3809.999871ps       -13.37618
+ 3819.999872ps      -12.746419
+ 3829.999873ps      -12.081525
+ 3839.999874ps      -11.375165
+ 3849.999874ps       -10.70392
+ 3859.999875ps      -10.098424
+ 3869.999876ps      -9.5840297
+ 3879.999877ps      -9.1511292
+ 3889.999878ps      -8.7878852
+ 3899.999879ps      -8.5289812
+ 3909.999879ps      -8.3363314
+ 3919.999880ps      -8.1604294
+ 3929.999881ps      -7.9912524
+ 3939.999882ps      -7.8498511
+ 3949.999883ps      -7.7580149
+ 3959.999884ps      -7.6978058
+ 3969.999884ps      -7.6686399
+ 3979.999885ps      -7.6928748
+ 3989.999886ps      -7.8279345
+ 3999.999887ps        -8.39298
+ 4009.999888ps      -9.8333265
+ 4019.999889ps       -12.02179
+ 4029.999889ps      -13.407234
+ 4039.999890ps      -13.563345
+ 4049.999891ps       -13.81998
+ 4059.999892ps      -15.437678
+ 4069.999893ps      -18.319464
+ 4079.999893ps      -21.345348
+ 4089.999894ps      -22.420624
+ 4099.999895ps      -21.336648
+ 4109.999896ps      -20.678844
+ 4119.999897ps      -20.769865
+ 4129.999898ps      -21.169152
+ 4139.999898ps      -21.170401
+ 4149.999899ps      -20.057521
+ 4159.999900ps      -18.315382
+ 4169.999901ps      -17.025729
+ 4179.999902ps      -15.996697
+ 4189.999903ps      -14.835803
+ 4199.999903ps      -13.865501
+ 4209.999904ps      -13.137658
+ 4219.999905ps      -12.470335
+ 4229.999906ps      -11.925316
+ 4239.999907ps      -11.427574
+ 4249.999908ps      -11.053327
+ 4259.999908ps      -10.736118
+ 4269.999909ps      -10.484157
+ 4279.999910ps      -10.289565
+ 4289.999911ps      -10.123537
+ 4299.999912ps      -10.021971
+ 4309.999913ps      -9.9744951
+ 4319.999913ps       -9.932514
+ 4329.999914ps      -9.9214552
+ 4339.999915ps      -9.9418938
+ 4349.999916ps      -10.078599
+ 4359.999917ps      -10.315627
+ 4369.999917ps      -10.663268
+ 4379.999918ps      -11.236424
+ 4389.999919ps      -12.017291
+ 4399.999920ps      -12.890175
+ 4409.999921ps      -13.757535
+ 4419.999922ps      -14.508396
+ 4429.999922ps      -15.014787
+ 4439.999923ps      -15.366185
+ 4449.999924ps      -15.428774
+ 4459.999925ps      -15.304483
+ 4469.999926ps      -15.008732
+ 4479.999927ps      -14.494226
+ 4489.999927ps      -13.873502
+ 4499.999928ps       -13.14805
+ 4509.999929ps       -12.44871
+ 4519.999930ps       -11.76455
+ 4529.999931ps      -11.181955
+ 4539.999932ps      -10.682442
+ 4549.999932ps      -10.249217
+ 4559.999933ps      -9.9105963
+ 4569.999934ps      -9.6478953
+ 4579.999935ps      -9.4220996
+ 4589.999936ps      -9.2647893
+ 4599.999937ps      -9.1555498
+ 4609.999937ps      -9.0782565
+ 4619.999938ps      -9.0245453
+ 4629.999939ps      -8.9933285
+ 4639.999940ps       -8.988886
+ 4649.999941ps      -9.0544076
+ 4659.999941ps      -9.2494891
+ 4669.999942ps      -9.9769781
+ 4679.999943ps      -11.562645
+ 4689.999944ps       -13.45688
+ 4699.999945ps      -14.206631
+ 4709.999946ps       -13.94949
+ 4719.999946ps      -14.545609
+ 4729.999947ps      -16.616079
+ 4739.999948ps      -19.623216
+ 4749.999949ps      -22.097612
+ 4759.999950ps      -22.181792
+ 4769.999951ps      -20.900919
+ 4779.999951ps      -20.557113
+ 4789.999952ps      -20.724989
+ 4799.999953ps      -21.196742
+ 4809.999954ps      -20.805052
+ 4819.999955ps      -19.281109
+ 4829.999956ps      -17.576415
+ 4839.999956ps      -16.464741
+ 4849.999957ps      -15.346494
+ 4859.999958ps      -14.256831
+ 4869.999959ps      -13.385185
+ 4879.999960ps       -12.71529
+ 4889.999961ps      -12.125074
+ 4899.999961ps      -11.631438
+ 4909.999962ps      -11.146574
+ 4919.999963ps      -10.734298
+ 4929.999964ps      -10.394126
+ 4939.999965ps      -10.132321
+ 4949.999965ps      -9.9270436
+ 4959.999966ps      -9.7831615
+ 4969.999967ps       -9.655065
+ 4979.999968ps      -9.5505179
+ 4989.999969ps      -9.4530683
+ 4999.999970ps      -9.4034801
+ 5009.999970ps      -9.4168169
+ 5019.999971ps      -9.5228111
+ 5029.999972ps      -9.7381533
+ 5039.999973ps      -10.138609
+ 5049.999974ps      -10.780082
+ 5059.999975ps      -11.539989
+ 5069.999975ps      -12.319376
+ 5079.999976ps      -13.126106
+ 5089.999977ps      -13.734547
+ 5099.999978ps      -14.062846
+ 5109.999979ps       -14.24113
+ 5119.999980ps      -14.163438
+ 5129.999980ps      -13.939803
+ 5139.999981ps      -13.480107
+ 5149.999982ps      -12.879212
+ 5159.999983ps       -12.19946
+ 5169.999984ps      -11.493657
+ 5179.999985ps        -10.8244
+ 5189.999985ps      -10.191341
+ 5199.999986ps      -9.6278077
+ 5209.999987ps      -9.1144047
+ 5219.999988ps      -8.6530396
+ 5229.999989ps      -8.2674473
+ 5239.999989ps      -7.9822735
+ 5249.999990ps      -7.7533607
+ 5259.999991ps      -7.5809978
+ 5269.999992ps      -7.4515031
+ 5279.999993ps      -7.3497066
+ 5289.999994ps      -7.2930262
+ 5299.999994ps      -7.2774064
+ 5309.999995ps      -7.2988886
+ 5319.999996ps      -7.4030395
+ 5329.999997ps      -7.7927176
+ 5339.999998ps      -8.9070688
+ 5349.999999ps      -10.844013
+ 5359.999999ps      -12.333963
+ 5370.000000ps      -12.622215
+ 5380.000001ps      -12.534564
+ 5390.000002ps      -13.790279
+ 5400.000003ps       -16.34239
+ 5410.000004ps      -19.282755
+ 5420.000004ps      -20.823135
+ 5430.000005ps      -20.030786
+ 5440.000006ps      -19.032908
+ 5450.000007ps      -19.177152
+ 5460.000008ps      -19.506299
+ 5470.000009ps      -19.628174
+ 5480.000009ps      -18.764233
+ 5490.000010ps      -17.014441
+ 5500.000011ps      -15.620371
+ 5510.000012ps      -14.600814
+ 5520.000013ps      -13.519483
+ 5530.000013ps      -12.520556
+ 5540.000014ps      -11.780883
+ 5550.000015ps      -11.129272
+ 5560.000016ps      -10.604993
+ 5570.000017ps      -10.108549
+ 5580.000018ps      -9.7043758
+ 5590.000018ps      -9.3201961
+ 5600.000019ps      -9.0459714
+ 5610.000020ps      -8.8670997
+ 5620.000021ps      -8.7429934
+ 5630.000022ps      -8.6259756
+ 5640.000023ps      -8.5104025
+ 5650.000023ps      -8.4055447
+ 5660.000024ps      -8.3416407
+ 5670.000025ps      -8.3634421
+ 5680.000026ps      -8.4807609
+ 5690.000027ps      -8.6826658
+ 5700.000028ps      -8.9923214
+ 5710.000028ps      -9.4714696
+ 5720.000029ps      -10.243416
+ 5730.000030ps      -11.094066
+ 5740.000031ps      -11.916412
+ 5750.000032ps      -12.715919
+ 5760.000033ps      -13.219845
+ 5770.000033ps       -13.54935
+ 5780.000034ps      -13.618243
+ 5790.000035ps      -13.542939
+ 5800.000036ps      -13.308797
+ 5810.000037ps      -12.823787
+ 5820.000037ps      -12.209387
+ 5830.000038ps      -11.528091
+ 5840.000039ps      -10.835759
+ 5850.000040ps      -10.171511
+ 5860.000041ps      -9.5650077
+ 5870.000042ps      -9.0539407
+ 5880.000042ps      -8.6093426
+ 5890.000043ps      -8.2456804
+ 5900.000044ps      -7.9705923
+ 5910.000045ps      -7.7212286
+ 5920.000046ps      -7.5223771
+ 5930.000047ps      -7.3881998
+ 5940.000047ps      -7.2937324
+ 5950.000048ps      -7.2222034
+ 5960.000049ps      -7.1839606
+ 5970.000050ps      -7.1873739
+ 5980.000051ps      -7.2143208
+ 5990.000052ps      -7.3529911
+ 6000.000052ps      -7.9363308
+ 6010.000053ps      -9.4618276
+ 6020.000054ps      -11.442892
+ 6030.000055ps      -12.399279
+ 6040.000056ps      -12.340689
+ 6050.000056ps      -12.668113
+ 6060.000057ps      -14.401991
+ 6070.000058ps      -17.382215
+ 6080.000059ps      -20.220095
+ 6090.000060ps      -20.828816
+ 6100.000061ps      -19.570666
+ 6110.000061ps       -19.07906
+ 6120.000062ps      -19.203044
+ 6130.000063ps      -19.613485
+ 6140.000064ps      -19.470875
+ 6150.000065ps      -18.122534
+ 6160.000066ps      -16.396983
+ 6170.000066ps      -15.227014
+ 6180.000067ps      -14.174162
+ 6190.000068ps      -13.029825
+ 6200.000069ps       -12.09543
+ 6210.000070ps      -11.429886
+ 6220.000071ps      -10.820257
+ 6230.000071ps       -10.29734
+ 6240.000072ps      -9.7587334
+ 6250.000073ps      -9.3100921
+ 6260.000074ps      -8.9195123
+ 6270.000075ps      -8.6386272
+ 6280.000076ps      -8.4345755
+ 6290.000076ps      -8.2911846
+ 6300.000077ps      -8.1637518
+ 6310.000078ps      -8.0866949
+ 6320.000079ps      -8.0496493
+ 6330.000080ps      -8.0607837
+ 6340.000080ps      -8.1407915
+ 6350.000081ps      -8.3172062
+ 6360.000082ps      -8.5719094
+ 6370.000083ps      -8.9682789
+ 6380.000084ps      -9.5985586
+ 6390.000085ps      -10.414036
+ 6400.000085ps      -11.288001
+ 6410.000086ps      -12.185196
+ 6420.000087ps      -12.854289
+ 6430.000088ps      -13.257834
+ 6440.000089ps      -13.546547
+ 6450.000090ps      -13.547093
+ 6460.000090ps      -13.401922
+ 6470.000091ps      -13.033603
+ 6480.000092ps      -12.504676
+ 6490.000093ps      -11.865694
+ 6500.000094ps      -11.192771
+ 6510.000095ps       -10.55333
+ 6520.000095ps      -9.9312398
+ 6530.000096ps      -9.3665081
+ 6540.000097ps      -8.8479897
+ 6550.000098ps      -8.4106165
+ 6560.000099ps      -8.0430907
+ 6570.000100ps       -7.742227
+ 6580.000100ps      -7.5301152
+ 6590.000101ps      -7.3724774
+ 6600.000102ps      -7.2715711
+ 6610.000103ps      -7.1799692
+ 6620.000104ps      -7.1206873
+ 6630.000104ps      -7.0943024
+ 6640.000105ps      -7.1149877
+ 6650.000106ps       -7.193515
+ 6660.000107ps      -7.4578203
+ 6670.000108ps      -8.3395104
+ 6680.000109ps      -10.088523
+ 6690.000109ps      -11.797187
+ 6700.000110ps      -12.229729
+ 6710.000111ps      -12.059966
+ 6720.000112ps      -12.961787
+ 6730.000113ps      -15.279959
+ 6740.000114ps      -18.318358
+ 6750.000114ps      -20.500221
+ 6760.000115ps       -20.11844
+ 6770.000116ps      -18.820904
+ 6780.000117ps      -18.809461
+ 6790.000118ps      -19.190206
+ 6800.000119ps      -19.509265
+ 6810.000119ps      -19.011678
+ 6820.000120ps      -17.338005
+ 6830.000121ps      -15.664946
+ 6840.000122ps      -14.603749
+ 6850.000123ps      -13.484012
+ 6860.000124ps      -12.416381
+ 6870.000124ps      -11.513394
+ 6880.000125ps      -10.847287
+ 6890.000126ps      -10.264867
+ 6900.000127ps      -9.7613784
+ 6910.000128ps      -9.3119907
+ 6920.000128ps       -8.959658
+ 6930.000129ps      -8.7372702
+ 6940.000130ps      -8.5905489
+ 6950.000131ps      -8.4948858
+ 6960.000132ps      -8.4457441
+ 6970.000133ps      -8.3969864
+ 6980.000133ps      -8.3428663
+ 6990.000134ps      -8.3145732
+ 7000.000135ps      -8.3080533
+ 7010.000136ps      -8.3787378
+ 7020.000137ps      -8.5371794
+ 7030.000138ps      -8.7860213
+ 7040.000138ps      -9.2080274
+ 7050.000139ps      -9.9272618
+ 7060.000140ps      -10.755156
+ 7070.000141ps      -11.618017
+ 7080.000142ps      -12.467444
+ 7090.000143ps      -13.075644
+ 7100.000143ps      -13.468702
+ 7110.000144ps      -13.636176
+ 7120.000145ps      -13.608401
+ 7130.000146ps      -13.434359
+ 7140.000147ps      -12.990951
+ 7150.000147ps      -12.401471
+ 7160.000148ps      -11.760516
+ 7170.000149ps      -11.053653
+ 7180.000150ps      -10.328373
+ 7190.000151ps      -9.6775046
+ 7200.000152ps      -9.0999895
+ 7210.000152ps      -8.6179195
+ 7220.000153ps      -8.2436398
+ 7230.000154ps      -7.9509267
+ 7240.000155ps      -7.7244453
+ 7250.000156ps      -7.5426875
+ 7260.000157ps      -7.4050941
+ 7270.000157ps      -7.3135551
+ 7280.000158ps      -7.2579384
+ 7290.000159ps      -7.2166021
+ 7300.000160ps      -7.1905476
+ 7310.000161ps      -7.1929007
+ 7320.000162ps      -7.2857268
+ 7330.000162ps      -7.7462139
+ 7340.000163ps      -9.0744127
+ 7350.000164ps      -11.053389
+ 7360.000165ps      -12.242912
+ 7370.000166ps      -12.236464
+ 7380.000167ps      -12.380326
+ 7390.000167ps      -13.934726
+ 7400.000168ps      -16.742719
+ 7410.000169ps      -19.710533
+ 7420.000170ps      -20.714705
+ 7430.000171ps      -19.617501
+ 7440.000171ps      -18.945431
+ 7450.000172ps      -19.049601
+ 7459.999729ps       -19.46087
+ 7469.999730ps      -19.423581
+ 7479.999731ps      -18.270024
+ 7489.999732ps      -16.486307
+ 7499.999732ps      -15.193246
+ 7509.999733ps      -14.156712
+ 7519.999734ps      -13.008755
+ 7529.999735ps      -12.048349
+ 7539.999736ps      -11.359417
+ 7549.999737ps      -10.726964
+ 7559.999737ps      -10.206984
+ 7569.999738ps      -9.7084315
+ 7579.999739ps      -9.3221398
+ 7589.999740ps      -8.9862089
+ 7599.999741ps      -8.7402325
+ 7609.999741ps      -8.5403001
+ 7619.999742ps      -8.3830612
+ 7629.999743ps      -8.2596591
+ 7639.999744ps      -8.1678866
+ 7649.999745ps      -8.1018946
+ 7659.999746ps      -8.0932607
+ 7669.999746ps       -8.139573
+ 7679.999747ps       -8.302389
+ 7689.999748ps      -8.5431081
+ 7699.999749ps      -8.9056076
+ 7709.999750ps       -9.497003
+ 7719.999751ps       -10.28511
+ 7729.999751ps      -11.158646
+ 7739.999752ps      -12.067953
+ 7749.999753ps      -12.818222
+ 7759.999754ps      -13.300608
+ 7769.999755ps      -13.591155
+ 7779.999756ps      -13.591316
+ 7789.999756ps      -13.445096
+ 7799.999757ps      -13.145641
+ 7809.999758ps      -12.618758
+ 7819.999759ps       -11.95683
+ 7829.999760ps      -11.238901
+ 7839.999761ps      -10.549674
+ 7849.999761ps       -9.890412
+ 7859.999762ps       -9.320197
+ 7869.999763ps      -8.8332257
+ 7879.999764ps      -8.4373392
+ 7889.999765ps      -8.1127411
+ 7899.999765ps      -7.8819083
+ 7909.999766ps      -7.7004201
+ 7919.999767ps       -7.547174
+ 7929.999768ps      -7.4035734
+ 7939.999769ps      -7.2777365
+ 7949.999770ps      -7.1927707
+ 7959.999770ps      -7.1406157
+ 7969.999771ps      -7.1285565
+ 7979.999772ps      -7.2032665
+ 7989.999773ps      -7.4821881
+)

Icursig13 PAR_0_2_VDD075CPU 0 pwl(
+ 0.000000ps       5.6264234
+ 10.000000ps       6.4278931
+ 20.000000ps       8.5764313
+ 29.999999ps       11.065865
+ 40.000000ps       12.330726
+ 50.000001ps        12.96527
+ 59.999998ps       14.670818
+ 69.999999ps       17.688974
+ 80.000000ps       21.369529
+ 90.000001ps       24.197523
+ 100.000001ps       24.391973
+ 110.000002ps       23.530657
+ 119.999996ps       23.732243
+ 129.999997ps       24.239406
+ 139.999998ps       24.644518
+ 149.999999ps        24.16319
+ 159.999999ps       22.523298
+ 170.000000ps       20.832561
+ 180.000001ps       19.664087
+ 190.000002ps       18.527689
+ 200.000003ps       17.437469
+ 210.000003ps       16.434241
+ 220.000004ps       15.512622
+ 230.000005ps       14.657073
+ 239.999992ps       13.848958
+ 249.999993ps       13.126089
+ 259.999994ps       12.507317
+ 269.999995ps       12.035193
+ 279.999995ps       11.691119
+ 289.999996ps       11.422523
+ 299.999997ps       11.219262
+ 309.999998ps       11.067235
+ 319.999999ps       10.947023
+ 330.000000ps        10.84633
+ 340.000000ps       10.795012
+ 350.000001ps       10.821207
+ 360.000002ps       10.901437
+ 370.000003ps       11.075303
+ 380.000004ps       11.214093
+ 390.000005ps        11.56806
+ 400.000005ps       11.902292
+ 410.000006ps       12.169672
+ 420.000007ps       12.608414
+ 430.000008ps       12.976356
+ 440.000009ps       13.443001
+ 450.000009ps       13.634963
+ 460.000010ps       13.696625
+ 469.999983ps       13.687783
+ 479.999984ps       13.589202
+ 489.999985ps       13.415253
+ 499.999986ps       13.148311
+ 509.999987ps       12.813846
+ 519.999988ps       12.432984
+ 529.999988ps       12.079387
+ 539.999989ps       11.735961
+ 549.999990ps       11.414091
+ 559.999991ps       11.124628
+ 569.999992ps       10.866317
+ 579.999992ps        10.66021
+ 589.999993ps       10.512797
+ 599.999994ps       10.412258
+ 609.999995ps       10.352574
+ 619.999996ps       10.327808
+ 629.999997ps       10.327536
+ 639.999997ps       10.346088
+ 649.999998ps       10.454409
+ 659.999999ps       10.664547
+ 670.000000ps       11.184852
+ 680.000001ps       12.572663
+ 690.000002ps       14.755451
+ 700.000002ps       16.218117
+ 710.000003ps        16.60516
+ 720.000004ps       17.175079
+ 730.000005ps       19.061966
+ 740.000006ps       22.214799
+ 750.000007ps       25.458443
+ 760.000007ps       26.720061
+ 770.000008ps       25.851145
+ 780.000009ps        25.33016
+ 790.000010ps       25.440494
+ 800.000011ps       25.945854
+ 810.000012ps       25.968317
+ 820.000012ps         24.7339
+ 830.000013ps       22.883768
+ 840.000014ps       21.437325
+ 850.000015ps       20.151392
+ 860.000016ps       18.912033
+ 870.000016ps       17.798353
+ 880.000017ps       16.824385
+ 890.000018ps       15.876559
+ 900.000019ps        14.98966
+ 910.000020ps       14.115382
+ 920.000021ps       13.356169
+ 930.000021ps       12.694846
+ 939.999967ps       12.151692
+ 949.999968ps       11.733747
+ 959.999968ps       11.417518
+ 969.999969ps       11.175909
+ 979.999970ps       10.969773
+ 989.999971ps       10.795949
+ 999.999972ps       10.655546
+ 1009.999973ps        10.56769
+ 1019.999973ps       10.568224
+ 1029.999974ps        10.66485
+ 1039.999975ps        10.72415
+ 1049.999976ps       10.849652
+ 1059.999977ps       11.206381
+ 1069.999978ps       11.424321
+ 1079.999978ps       11.661652
+ 1089.999979ps       11.969968
+ 1099.999980ps       12.268492
+ 1109.999981ps       12.625036
+ 1119.999982ps        12.64268
+ 1129.999982ps       12.586067
+ 1139.999983ps       12.481214
+ 1149.999984ps       12.325268
+ 1159.999985ps       12.076636
+ 1169.999986ps       11.773792
+ 1179.999987ps       11.433903
+ 1189.999987ps       11.062808
+ 1199.999988ps       10.675288
+ 1209.999989ps       10.279452
+ 1219.999990ps       9.9035131
+ 1229.999991ps       9.5461564
+ 1239.999992ps       9.2671629
+ 1249.999992ps        9.045327
+ 1259.999993ps       8.8795941
+ 1269.999994ps       8.7517682
+ 1279.999995ps        8.639038
+ 1289.999996ps        8.587749
+ 1299.999997ps       8.5854822
+ 1309.999997ps       8.6277367
+ 1319.999998ps        8.780594
+ 1329.999999ps       9.1008154
+ 1340.000000ps       9.8794348
+ 1350.000001ps       11.632469
+ 1360.000002ps       13.840582
+ 1370.000002ps       15.020368
+ 1380.000003ps       15.236841
+ 1390.000004ps       16.284684
+ 1400.000005ps       18.641672
+ 1410.000006ps       21.905523
+ 1420.000006ps       24.674883
+ 1430.000007ps       25.061779
+ 1440.000008ps       23.969617
+ 1450.000009ps       23.705887
+ 1460.000010ps       23.882386
+ 1470.000011ps       24.397236
+ 1480.000011ps       23.942854
+ 1490.000012ps       22.349159
+ 1500.000013ps       20.588803
+ 1510.000014ps       19.357096
+ 1520.000015ps       18.130231
+ 1530.000016ps        16.95063
+ 1540.000016ps       15.914547
+ 1550.000017ps       14.975687
+ 1560.000018ps       14.102771
+ 1570.000019ps       13.277318
+ 1580.000020ps       12.445172
+ 1590.000021ps       11.703651
+ 1600.000021ps        11.11379
+ 1610.000022ps       10.690499
+ 1620.000023ps       10.346955
+ 1630.000024ps       10.025084
+ 1640.000025ps       9.7474503
+ 1650.000025ps        9.522586
+ 1660.000026ps         9.35644
+ 1670.000027ps       9.2434354
+ 1680.000028ps       9.2268386
+ 1690.000029ps        9.278708
+ 1700.000030ps        9.374135
+ 1710.000030ps       9.4846636
+ 1720.000031ps         9.74653
+ 1730.000032ps       10.134845
+ 1740.000033ps       10.415053
+ 1750.000034ps       10.721934
+ 1760.000035ps       11.068135
+ 1770.000035ps       11.455357
+ 1780.000036ps        11.73683
+ 1790.000037ps       11.801788
+ 1800.000038ps       11.786096
+ 1810.000039ps       11.714451
+ 1820.000040ps       11.541815
+ 1830.000040ps       11.277983
+ 1840.000041ps       10.957237
+ 1850.000042ps       10.606215
+ 1860.000043ps       10.239816
+ 1869.999933ps       9.8999874
+ 1879.999934ps       9.5648264
+ 1889.999934ps       9.2735638
+ 1899.999935ps       9.0145685
+ 1909.999936ps       8.7971682
+ 1919.999937ps       8.6257709
+ 1929.999938ps       8.5061278
+ 1939.999938ps       8.4251334
+ 1949.999939ps       8.3758997
+ 1959.999940ps       8.3556026
+ 1969.999941ps        8.357497
+ 1979.999942ps       8.4170459
+ 1989.999943ps       8.5736168
+ 1999.999943ps       8.9992536
+ 2009.999944ps       10.177228
+ 2019.999945ps       12.305403
+ 2029.999946ps       14.051795
+ 2039.999947ps       14.700194
+ 2049.999948ps       15.080781
+ 2059.999948ps       16.786829
+ 2069.999949ps       19.755462
+ 2079.999950ps       23.072916
+ 2089.999951ps       24.958926
+ 2099.999952ps       24.445489
+ 2109.999953ps       23.621176
+ 2119.999953ps       23.819713
+ 2129.999954ps       24.204897
+ 2139.999955ps        24.36043
+ 2149.999956ps       23.391856
+ 2159.999957ps       21.543141
+ 2169.999958ps       19.983868
+ 2179.999958ps       18.773206
+ 2189.999959ps       17.510621
+ 2199.999960ps       16.368687
+ 2209.999961ps       15.363516
+ 2219.999962ps       14.399114
+ 2229.999962ps       13.478968
+ 2239.999963ps       12.585547
+ 2249.999964ps       11.788608
+ 2259.999965ps       11.078443
+ 2269.999966ps       10.512162
+ 2279.999967ps       10.092532
+ 2289.999967ps       9.7686405
+ 2299.999968ps       9.5147654
+ 2309.999969ps       9.3142832
+ 2319.999970ps       9.1653515
+ 2329.999971ps       9.0592971
+ 2339.999972ps       9.0126162
+ 2349.999972ps       9.0624334
+ 2359.999973ps       9.1711264
+ 2369.999974ps       9.2841542
+ 2379.999975ps       9.4170106
+ 2389.999976ps       9.8223537
+ 2399.999977ps       10.139484
+ 2409.999977ps       10.425362
+ 2419.999978ps       10.788145
+ 2429.999979ps       11.117365
+ 2439.999980ps       11.561571
+ 2449.999981ps       11.668685
+ 2459.999982ps       11.693571
+ 2469.999982ps       11.653136
+ 2479.999983ps       11.558691
+ 2489.999984ps        11.38648
+ 2499.999985ps       11.152536
+ 2509.999986ps       10.863174
+ 2519.999986ps       10.527425
+ 2529.999987ps       10.170618
+ 2539.999988ps       9.8008109
+ 2549.999989ps       9.4531359
+ 2559.999990ps       9.1313866
+ 2569.999991ps       8.8572394
+ 2579.999991ps       8.6469249
+ 2589.999992ps       8.4950891
+ 2599.999993ps       8.3944552
+ 2609.999994ps       8.3100227
+ 2619.999995ps       8.2546669
+ 2629.999996ps       8.2416049
+ 2639.999996ps        8.277839
+ 2649.999997ps       8.3933398
+ 2659.999998ps       8.6196658
+ 2669.999999ps       9.1909352
+ 2680.000000ps       10.775764
+ 2690.000001ps       12.973729
+ 2700.000001ps       14.255606
+ 2710.000002ps       14.603559
+ 2720.000003ps       15.347005
+ 2730.000004ps       17.377465
+ 2740.000005ps       20.711889
+ 2750.000005ps       23.879415
+ 2760.000006ps       24.828842
+ 2770.000007ps       23.822199
+ 2780.000008ps       23.425339
+ 2790.000009ps        23.57278
+ 2800.000010ps       24.101568
+ 2810.000010ps       23.973851
+ 2820.000011ps       22.523164
+ 2830.000012ps       20.681441
+ 2840.000013ps       19.335899
+ 2850.000014ps       18.072103
+ 2860.000015ps       16.760453
+ 2870.000015ps       15.630474
+ 2880.000016ps       14.585676
+ 2890.000017ps       13.663898
+ 2900.000018ps       12.819329
+ 2910.000019ps       11.999065
+ 2920.000020ps       11.309593
+ 2930.000020ps       10.758931
+ 2940.000021ps       10.357013
+ 2950.000022ps       10.058761
+ 2960.000023ps       9.8329956
+ 2970.000024ps       9.6550171
+ 2980.000025ps       9.4865263
+ 2990.000025ps       9.3377571
+ 3000.000026ps       9.2118805
+ 3010.000027ps       9.1506848
+ 3020.000028ps       9.1506701
+ 3030.000029ps       9.2072333
+ 3040.000029ps       9.2852934
+ 3050.000030ps       9.4568447
+ 3060.000031ps       9.8589726
+ 3070.000032ps       10.139074
+ 3080.000033ps       10.462713
+ 3090.000034ps       10.864783
+ 3100.000034ps       11.268541
+ 3110.000035ps       11.688254
+ 3120.000036ps       11.782504
+ 3130.000037ps       11.802736
+ 3140.000038ps       11.753577
+ 3150.000039ps       11.636268
+ 3160.000039ps       11.407019
+ 3170.000040ps       11.109078
+ 3180.000041ps       10.739805
+ 3190.000042ps       10.331451
+ 3200.000043ps       9.9406271
+ 3210.000044ps       9.5767202
+ 3220.000044ps       9.2607742
+ 3230.000045ps       8.9876591
+ 3240.000046ps       8.7726161
+ 3250.000047ps       8.5909631
+ 3260.000048ps       8.4739913
+ 3270.000049ps       8.3863315
+ 3280.000049ps       8.3348737
+ 3290.000050ps       8.3029969
+ 3300.000051ps       8.2928134
+ 3310.000052ps       8.3325242
+ 3320.000053ps       8.4665654
+ 3330.000053ps       8.8130307
+ 3340.000054ps       9.7727568
+ 3350.000055ps       11.732685
+ 3360.000056ps       13.743651
+ 3370.000057ps       14.537103
+ 3380.000058ps       14.799179
+ 3390.000058ps       16.147406
+ 3400.000059ps       18.879207
+ 3410.000060ps       22.220496
+ 3420.000061ps       24.683127
+ 3430.000062ps       24.606767
+ 3440.000063ps       23.495543
+ 3450.000063ps        23.49299
+ 3460.000064ps       23.856662
+ 3470.000065ps       24.122873
+ 3480.000066ps       23.502753
+ 3490.000067ps       21.720035
+ 3500.000068ps       19.925865
+ 3510.000068ps       18.687874
+ 3520.000069ps       17.452822
+ 3530.000070ps       16.313828
+ 3540.000071ps        15.27084
+ 3550.000072ps       14.328114
+ 3560.000073ps       13.430565
+ 3570.000073ps       12.568001
+ 3580.000074ps        11.78233
+ 3590.000075ps        11.07525
+ 3600.000076ps       10.534803
+ 3610.000077ps       10.118788
+ 3620.000077ps       9.7975275
+ 3630.000078ps       9.5414502
+ 3640.000079ps       9.3265376
+ 3650.000080ps       9.1566176
+ 3660.000081ps       9.0347114
+ 3670.000082ps       8.9754293
+ 3680.000082ps       9.0113606
+ 3690.000083ps       9.0894137
+ 3700.000084ps       9.2677899
+ 3710.000085ps       9.3908566
+ 3720.000086ps        9.736918
+ 3729.999865ps       10.048111
+ 3739.999865ps       10.307092
+ 3749.999866ps       10.728213
+ 3759.999867ps       11.057407
+ 3769.999868ps       11.468204
+ 3779.999869ps       11.621768
+ 3789.999869ps       11.667464
+ 3799.999870ps       11.639573
+ 3809.999871ps       11.526552
+ 3819.999872ps       11.320191
+ 3829.999873ps       11.031374
+ 3839.999874ps       10.709239
+ 3849.999874ps       10.369151
+ 3859.999875ps       10.038345
+ 3869.999876ps       9.7017555
+ 3879.999877ps       9.3869034
+ 3889.999878ps       9.1183328
+ 3899.999879ps       8.9053709
+ 3909.999879ps       8.7205785
+ 3919.999880ps       8.5568276
+ 3929.999881ps       8.4204869
+ 3939.999882ps       8.3079996
+ 3949.999883ps       8.2278309
+ 3959.999884ps       8.1889166
+ 3969.999884ps       8.2069702
+ 3979.999885ps       8.2999265
+ 3989.999886ps       8.5228313
+ 3999.999887ps       9.1580027
+ 4009.999888ps       10.688622
+ 4019.999889ps       12.965942
+ 4029.999889ps       14.484746
+ 4039.999890ps       14.908967
+ 4049.999891ps       15.517516
+ 4059.999892ps       17.438961
+ 4069.999893ps       20.661498
+ 4079.999893ps       23.990078
+ 4089.999894ps       25.325797
+ 4099.999895ps       24.473051
+ 4109.999896ps       23.923707
+ 4119.999897ps       24.024303
+ 4129.999898ps       24.528151
+ 4139.999898ps       24.557245
+ 4149.999899ps       23.336836
+ 4159.999900ps       21.494458
+ 4169.999901ps        20.06881
+ 4179.999902ps       18.788377
+ 4189.999903ps       17.536688
+ 4199.999903ps       16.431487
+ 4209.999904ps       15.442749
+ 4219.999905ps       14.488331
+ 4229.999906ps       13.603826
+ 4239.999907ps       12.757091
+ 4249.999908ps       12.042866
+ 4259.999908ps       11.431615
+ 4269.999909ps       10.931232
+ 4279.999910ps       10.567312
+ 4289.999911ps       10.287578
+ 4299.999912ps       10.062424
+ 4309.999913ps        9.879387
+ 4319.999913ps       9.7304776
+ 4329.999914ps         9.62008
+ 4339.999915ps       9.5668765
+ 4349.999916ps       9.6154155
+ 4359.999917ps        9.741776
+ 4369.999917ps       9.8280653
+ 4379.999918ps       10.002446
+ 4389.999919ps       10.420068
+ 4399.999920ps       10.714161
+ 4409.999921ps       11.016904
+ 4419.999922ps       11.399569
+ 4429.999922ps       11.790816
+ 4439.999923ps       12.235965
+ 4449.999924ps        12.31767
+ 4459.999925ps       12.340437
+ 4469.999926ps       12.285794
+ 4479.999927ps       12.169357
+ 4489.999927ps       11.953515
+ 4499.999928ps       11.659773
+ 4509.999929ps       11.304053
+ 4519.999930ps       10.908763
+ 4529.999931ps       10.546211
+ 4539.999932ps       10.204886
+ 4549.999932ps       9.9050388
+ 4559.999933ps       9.6266648
+ 4569.999934ps       9.3876501
+ 4579.999935ps       9.1964728
+ 4589.999936ps       9.0553222
+ 4599.999937ps       8.9619173
+ 4609.999937ps        8.911829
+ 4619.999938ps       8.9007795
+ 4629.999939ps       8.9132664
+ 4639.999940ps       8.9543442
+ 4649.999941ps       9.1071931
+ 4659.999941ps       9.4210448
+ 4669.999942ps       10.187013
+ 4679.999943ps        11.88646
+ 4689.999944ps       14.041673
+ 4699.999945ps       15.150838
+ 4709.999946ps       15.332768
+ 4719.999946ps       16.391831
+ 4729.999947ps       18.797958
+ 4739.999948ps       22.094403
+ 4749.999949ps       24.873025
+ 4759.999950ps       25.256605
+ 4769.999951ps       24.174955
+ 4779.999951ps       23.967351
+ 4789.999952ps         24.1811
+ 4799.999953ps        24.72838
+ 4809.999954ps       24.287369
+ 4819.999955ps        22.67563
+ 4829.999956ps       20.897225
+ 4839.999956ps       19.633322
+ 4849.999957ps       18.387207
+ 4859.999958ps       17.171779
+ 4869.999959ps       16.079658
+ 4879.999960ps        15.10929
+ 4889.999961ps       14.216888
+ 4899.999961ps       13.374821
+ 4909.999962ps       12.555565
+ 4919.999963ps       11.809712
+ 4929.999964ps       11.199998
+ 4939.999965ps       10.715193
+ 4949.999965ps       10.339897
+ 4959.999966ps        10.05254
+ 4969.999967ps       9.8280517
+ 4979.999968ps       9.6577746
+ 4989.999969ps       9.5385777
+ 4999.999970ps        9.458824
+ 5009.999970ps       9.4583931
+ 5019.999971ps       9.5250561
+ 5029.999972ps       9.6414946
+ 5039.999973ps       9.7803778
+ 5049.999974ps       10.050199
+ 5059.999975ps       10.432819
+ 5069.999975ps       10.712257
+ 5079.999976ps       11.023305
+ 5089.999977ps       11.384355
+ 5099.999978ps       11.776878
+ 5109.999979ps       12.046554
+ 5119.999980ps       12.083115
+ 5129.999980ps       12.033802
+ 5139.999981ps       11.940939
+ 5149.999982ps       11.763793
+ 5159.999983ps       11.506172
+ 5169.999984ps       11.204832
+ 5179.999985ps       10.873882
+ 5189.999985ps       10.528329
+ 5199.999986ps       10.163626
+ 5209.999987ps       9.8005272
+ 5219.999988ps       9.4596123
+ 5229.999989ps       9.1480458
+ 5239.999989ps       8.8932551
+ 5249.999990ps       8.7010422
+ 5259.999991ps       8.5637944
+ 5269.999992ps       8.4561998
+ 5279.999993ps       8.3757006
+ 5289.999994ps       8.3518561
+ 5299.999994ps       8.3719262
+ 5309.999995ps       8.4716713
+ 5319.999996ps       8.6583983
+ 5329.999997ps       9.0963062
+ 5339.999998ps       10.282272
+ 5349.999999ps       12.437616
+ 5359.999999ps        14.22023
+ 5370.000000ps       14.913859
+ 5380.000001ps       15.310188
+ 5390.000002ps       16.985859
+ 5400.000003ps       19.903332
+ 5410.000004ps       23.167476
+ 5420.000004ps       25.011395
+ 5430.000005ps       24.464483
+ 5440.000006ps       23.603265
+ 5450.000007ps       23.737151
+ 5460.000008ps       24.096242
+ 5470.000009ps       24.257999
+ 5480.000009ps       23.298747
+ 5490.000010ps       21.479883
+ 5500.000011ps       19.955922
+ 5510.000012ps       18.768424
+ 5520.000013ps       17.542242
+ 5530.000013ps       16.437723
+ 5540.000014ps       15.460388
+ 5550.000015ps       14.538722
+ 5560.000016ps       13.682732
+ 5570.000017ps       12.838067
+ 5580.000018ps       12.085147
+ 5590.000018ps       11.403474
+ 5600.000019ps       10.867535
+ 5610.000020ps       10.493157
+ 5620.000021ps       10.188147
+ 5630.000022ps       9.9014481
+ 5640.000023ps       9.6360694
+ 5650.000023ps       9.4346592
+ 5660.000024ps       9.2995925
+ 5670.000025ps       9.2194673
+ 5680.000026ps       9.2578576
+ 5690.000027ps       9.3427847
+ 5700.000028ps       9.4292454
+ 5710.000028ps       9.5448891
+ 5720.000029ps        9.941605
+ 5730.000030ps       10.247477
+ 5740.000031ps       10.516769
+ 5750.000032ps       10.879645
+ 5760.000033ps       11.214645
+ 5770.000033ps       11.640548
+ 5780.000034ps       11.752956
+ 5790.000035ps       11.774444
+ 5800.000036ps       11.745586
+ 5810.000037ps       11.637539
+ 5820.000037ps       11.435905
+ 5830.000038ps       11.160232
+ 5840.000039ps       10.816143
+ 5850.000040ps       10.452155
+ 5860.000041ps       10.092604
+ 5870.000042ps       9.7486724
+ 5880.000042ps        9.427911
+ 5890.000043ps       9.1446061
+ 5900.000044ps       8.9024651
+ 5910.000045ps       8.7147378
+ 5920.000046ps       8.5674206
+ 5930.000047ps       8.4667202
+ 5940.000047ps       8.3980372
+ 5950.000048ps       8.3636965
+ 5960.000049ps        8.350134
+ 5970.000050ps        8.357557
+ 5980.000051ps       8.4491024
+ 5990.000052ps       8.6775909
+ 6000.000052ps       9.2853498
+ 6010.000053ps       10.917835
+ 6020.000054ps       13.151021
+ 6030.000055ps       14.446807
+ 6040.000056ps       14.806092
+ 6050.000056ps       15.568722
+ 6060.000057ps       17.635192
+ 6070.000058ps       20.984018
+ 6080.000059ps       24.160067
+ 6090.000060ps       25.111632
+ 6100.000061ps        24.07591
+ 6110.000061ps       23.680478
+ 6120.000062ps       23.819838
+ 6130.000063ps       24.321189
+ 6140.000064ps       24.136382
+ 6150.000065ps       22.662256
+ 6160.000066ps        20.81543
+ 6170.000066ps        19.49894
+ 6180.000067ps       18.244398
+ 6190.000068ps       16.989596
+ 6200.000069ps        15.89967
+ 6210.000070ps       14.933205
+ 6220.000071ps       14.013852
+ 6230.000071ps       13.137992
+ 6240.000072ps        12.25303
+ 6250.000073ps       11.475512
+ 6260.000074ps       10.832365
+ 6270.000075ps       10.311786
+ 6280.000076ps        9.951981
+ 6290.000076ps       9.6562566
+ 6300.000077ps       9.4199647
+ 6310.000078ps       9.2317796
+ 6320.000079ps        9.092835
+ 6330.000080ps       9.0131608
+ 6340.000080ps       9.0116732
+ 6350.000081ps       9.0698242
+ 6360.000082ps       9.1868836
+ 6370.000083ps        9.322059
+ 6380.000084ps       9.5363852
+ 6390.000085ps       9.9507932
+ 6400.000085ps       10.239177
+ 6410.000086ps       10.548687
+ 6420.000087ps       10.917954
+ 6430.000088ps       11.270592
+ 6440.000089ps       11.632607
+ 6450.000090ps       11.684186
+ 6460.000090ps       11.673094
+ 6470.000091ps       11.604464
+ 6480.000092ps       11.483323
+ 6490.000093ps       11.269431
+ 6500.000094ps       11.015271
+ 6510.000095ps       10.706819
+ 6520.000095ps       10.364224
+ 6530.000096ps       10.014587
+ 6540.000097ps       9.6520863
+ 6550.000098ps       9.3142531
+ 6560.000099ps       9.0141841
+ 6570.000100ps       8.7650579
+ 6580.000100ps       8.5726259
+ 6590.000101ps       8.4373311
+ 6600.000102ps       8.3500426
+ 6610.000103ps       8.2781639
+ 6620.000104ps       8.2387425
+ 6630.000104ps       8.2390477
+ 6640.000105ps        8.299133
+ 6650.000106ps       8.4457746
+ 6660.000107ps       8.7952219
+ 6670.000108ps       9.7170811
+ 6680.000109ps       11.630458
+ 6690.000109ps        13.60902
+ 6700.000110ps       14.406459
+ 6710.000111ps       14.681991
+ 6720.000112ps       16.026354
+ 6730.000113ps       18.737921
+ 6740.000114ps       22.082694
+ 6750.000114ps       24.564222
+ 6760.000115ps       24.486027
+ 6770.000116ps       23.399631
+ 6780.000117ps       23.405553
+ 6790.000118ps       23.800771
+ 6800.000119ps       24.131817
+ 6810.000119ps       23.579049
+ 6820.000120ps       21.837574
+ 6830.000121ps       20.032606
+ 6840.000122ps       18.764294
+ 6850.000123ps       17.488796
+ 6860.000124ps       16.274695
+ 6870.000124ps       15.204435
+ 6880.000125ps       14.194673
+ 6890.000126ps       13.305542
+ 6900.000127ps       12.471301
+ 6910.000128ps       11.711036
+ 6920.000128ps       11.051102
+ 6930.000129ps       10.554041
+ 6940.000130ps        10.20468
+ 6950.000131ps       9.9424549
+ 6960.000132ps       9.7490141
+ 6970.000133ps       9.5871747
+ 6980.000133ps       9.4367335
+ 6990.000134ps       9.2967321
+ 7000.000135ps       9.1945143
+ 7010.000136ps       9.1761573
+ 7020.000137ps       9.1925181
+ 7030.000138ps       9.2894877
+ 7040.000138ps       9.3501327
+ 7050.000139ps       9.6451687
+ 7060.000140ps       9.9500324
+ 7070.000141ps       10.206667
+ 7080.000142ps       10.642284
+ 7090.000143ps       10.993228
+ 7100.000143ps       11.452818
+ 7110.000144ps       11.651441
+ 7120.000145ps       11.726192
+ 7130.000146ps       11.748907
+ 7140.000147ps       11.681279
+ 7150.000147ps       11.523787
+ 7160.000148ps        11.28259
+ 7170.000149ps       10.964226
+ 7180.000150ps       10.583638
+ 7190.000151ps       10.177104
+ 7200.000152ps       9.7901466
+ 7210.000152ps       9.4410817
+ 7220.000153ps       9.1428344
+ 7230.000154ps       8.8910941
+ 7240.000155ps       8.6990439
+ 7250.000156ps       8.5391752
+ 7260.000157ps       8.4337604
+ 7270.000157ps       8.3595015
+ 7280.000158ps       8.3129728
+ 7290.000159ps       8.2966199
+ 7300.000160ps       8.3033258
+ 7310.000161ps        8.382695
+ 7320.000162ps       8.5769285
+ 7330.000162ps       9.0771878
+ 7340.000163ps       10.480706
+ 7350.000164ps       12.689915
+ 7360.000165ps       14.197684
+ 7370.000166ps        14.59868
+ 7380.000167ps       15.184373
+ 7390.000167ps       17.095782
+ 7400.000168ps       20.298417
+ 7410.000169ps       23.565177
+ 7420.000170ps       24.854876
+ 7430.000171ps       23.988171
+ 7440.000171ps       23.452218
+ 7450.000172ps       23.559909
+ 7459.999729ps       24.068469
+ 7469.999730ps       24.035514
+ 7479.999731ps       22.758063
+ 7489.999732ps       20.899438
+ 7499.999732ps       19.463993
+ 7509.999733ps       18.193519
+ 7519.999734ps       16.943255
+ 7529.999735ps       15.843665
+ 7539.999736ps       14.877726
+ 7549.999737ps       13.945336
+ 7559.999737ps        13.07256
+ 7569.999738ps       12.205032
+ 7579.999739ps       11.485533
+ 7589.999740ps       10.852617
+ 7599.999741ps       10.357275
+ 7609.999741ps       9.9809916
+ 7619.999742ps       9.6786532
+ 7629.999743ps       9.4442834
+ 7639.999744ps       9.2473476
+ 7649.999745ps       9.0880153
+ 7659.999746ps       8.9831139
+ 7669.999746ps        8.946932
+ 7679.999747ps        9.023411
+ 7689.999748ps       9.1699574
+ 7699.999749ps       9.2749087
+ 7709.999750ps       9.4484149
+ 7719.999751ps        9.866804
+ 7729.999751ps       10.156339
+ 7739.999752ps       10.463447
+ 7749.999753ps       10.829521
+ 7759.999754ps       11.190528
+ 7769.999755ps       11.586768
+ 7779.999756ps        11.64417
+ 7789.999756ps        11.65083
+ 7799.999757ps       11.578257
+ 7809.999758ps       11.451542
+ 7819.999759ps       11.210364
+ 7829.999760ps       10.912802
+ 7839.999761ps       10.578564
+ 7849.999761ps       10.234048
+ 7859.999762ps       9.9039824
+ 7869.999763ps       9.5692792
+ 7879.999764ps       9.2697058
+ 7889.999765ps       9.0113352
+ 7899.999765ps       8.8235349
+ 7909.999766ps       8.6615064
+ 7919.999767ps       8.5147827
+ 7929.999768ps        8.387561
+ 7939.999769ps       8.2793236
+ 7949.999770ps        8.210371
+ 7959.999770ps       8.1813195
+ 7969.999771ps       8.2139074
+ 7979.999772ps       8.3559747
+ 7989.999773ps       8.6690247
+)

Icursig14 PAR_1_2_VSS 0 pwl(
+ 0.000000ps      -4.7966443
+ 10.000000ps      -5.0480412
+ 20.000000ps      -5.5408726
+ 29.999999ps      -5.9975102
+ 40.000000ps      -6.4506305
+ 50.000001ps      -6.9330767
+ 59.999998ps      -7.4864989
+ 69.999999ps      -8.3674328
+ 80.000000ps      -10.278558
+ 90.000001ps      -12.900919
+ 100.000001ps      -14.885674
+ 110.000002ps      -15.834434
+ 119.999996ps      -16.619214
+ 129.999997ps      -17.068923
+ 139.999998ps      -18.069798
+ 149.999999ps      -19.832839
+ 159.999999ps       -20.26044
+ 170.000000ps       -20.01555
+ 180.000001ps      -19.159837
+ 190.000002ps      -17.472558
+ 200.000003ps      -15.843242
+ 210.000003ps      -14.580395
+ 220.000004ps      -13.544535
+ 230.000005ps      -12.656089
+ 239.999992ps      -11.928064
+ 249.999993ps      -11.306846
+ 259.999994ps      -10.843099
+ 269.999995ps      -10.412838
+ 279.999995ps      -9.9690026
+ 289.999996ps      -9.5981875
+ 299.999997ps      -9.2914752
+ 309.999998ps      -9.0750388
+ 319.999999ps      -8.9241501
+ 330.000000ps      -8.7950604
+ 340.000000ps      -8.7153933
+ 350.000001ps      -8.6498718
+ 360.000002ps      -8.6255955
+ 370.000003ps      -8.6309254
+ 380.000004ps      -8.6506735
+ 390.000005ps      -8.7415134
+ 400.000005ps      -8.8067191
+ 410.000006ps      -8.9062241
+ 420.000007ps      -9.1740665
+ 430.000008ps      -9.5971549
+ 440.000009ps      -10.260201
+ 450.000009ps      -10.993083
+ 460.000010ps      -11.824464
+ 469.999983ps      -12.689725
+ 479.999984ps      -13.390692
+ 489.999985ps      -13.803319
+ 499.999986ps      -13.877648
+ 509.999987ps      -13.645115
+ 519.999988ps      -13.147487
+ 529.999988ps      -12.523496
+ 539.999989ps      -11.843625
+ 549.999990ps       -11.18915
+ 559.999991ps       -10.58513
+ 569.999992ps      -10.023577
+ 579.999992ps      -9.5151094
+ 589.999993ps      -9.0705427
+ 599.999994ps      -8.7090496
+ 609.999995ps      -8.4202308
+ 619.999996ps      -8.2208622
+ 629.999997ps      -8.0841722
+ 639.999997ps      -7.9951629
+ 649.999998ps      -7.8896793
+ 659.999999ps      -7.7761224
+ 670.000000ps      -7.7120538
+ 680.000001ps      -7.6890702
+ 690.000002ps      -7.6683547
+ 700.000002ps      -7.7008413
+ 710.000003ps      -7.8968558
+ 720.000004ps      -8.2995431
+ 730.000005ps      -8.8610401
+ 740.000006ps      -10.008996
+ 750.000007ps      -11.987577
+ 760.000007ps      -14.364881
+ 770.000008ps      -15.948975
+ 780.000009ps      -17.013739
+ 790.000010ps      -17.679623
+ 800.000011ps      -18.115721
+ 810.000012ps      -19.268558
+ 820.000012ps      -20.716682
+ 830.000013ps      -20.815657
+ 840.000014ps        -20.3096
+ 850.000015ps      -19.144197
+ 860.000016ps      -17.267923
+ 870.000016ps      -15.678859
+ 880.000017ps      -14.411231
+ 890.000018ps      -13.399325
+ 900.000019ps      -12.573813
+ 910.000020ps      -11.890173
+ 920.000021ps      -11.299837
+ 930.000021ps      -10.826437
+ 939.999967ps      -10.349617
+ 949.999968ps      -9.9499728
+ 959.999968ps      -9.6043263
+ 969.999969ps      -9.3409727
+ 979.999970ps      -9.1404047
+ 989.999971ps      -8.9632657
+ 999.999972ps      -8.7974196
+ 1009.999973ps      -8.6435133
+ 1019.999973ps      -8.5420268
+ 1029.999974ps      -8.4603446
+ 1039.999975ps      -8.3830949
+ 1049.999976ps      -8.3495131
+ 1059.999977ps      -8.4002482
+ 1069.999978ps      -8.4617177
+ 1079.999978ps      -8.6152325
+ 1089.999979ps      -8.9130493
+ 1099.999980ps      -9.3868558
+ 1109.999981ps      -10.089897
+ 1119.999982ps      -10.854117
+ 1129.999982ps      -11.694839
+ 1139.999983ps      -12.528937
+ 1149.999984ps      -13.112889
+ 1159.999985ps      -13.399383
+ 1169.999986ps      -13.330581
+ 1179.999987ps      -12.941693
+ 1189.999987ps       -12.36917
+ 1199.999988ps      -11.739855
+ 1209.999989ps      -11.092606
+ 1219.999990ps      -10.435865
+ 1229.999991ps      -9.8446525
+ 1239.999992ps      -9.3291652
+ 1249.999992ps      -8.8740403
+ 1259.999993ps      -8.5119498
+ 1269.999994ps      -8.2247225
+ 1279.999995ps      -7.9831664
+ 1289.999996ps      -7.7849651
+ 1299.999997ps       -7.651142
+ 1309.999997ps      -7.5599745
+ 1319.999998ps      -7.4833956
+ 1329.999999ps      -7.4346469
+ 1340.000000ps      -7.3956012
+ 1350.000001ps      -7.4055174
+ 1360.000002ps      -7.4069117
+ 1370.000002ps      -7.4751454
+ 1380.000003ps      -7.7071971
+ 1390.000004ps      -8.1228859
+ 1400.000005ps       -8.844177
+ 1410.000006ps      -10.408044
+ 1420.000006ps      -12.653859
+ 1430.000007ps      -14.674459
+ 1440.000008ps      -15.885912
+ 1450.000009ps      -16.940515
+ 1460.000010ps      -17.399479
+ 1470.000011ps      -18.076568
+ 1480.000011ps      -19.519508
+ 1490.000012ps      -20.097489
+ 1500.000013ps      -20.186483
+ 1510.000014ps      -19.525372
+ 1520.000015ps      -17.901575
+ 1530.000016ps      -16.146508
+ 1540.000016ps      -14.751976
+ 1550.000017ps      -13.684412
+ 1560.000018ps      -12.754835
+ 1570.000019ps       -11.98913
+ 1580.000020ps      -11.335767
+ 1590.000021ps      -10.803907
+ 1600.000021ps      -10.373047
+ 1610.000022ps      -9.9102569
+ 1620.000023ps       -9.471039
+ 1630.000024ps       -9.127681
+ 1640.000025ps      -8.8587158
+ 1650.000025ps      -8.6412757
+ 1660.000026ps      -8.4549626
+ 1670.000027ps      -8.3108825
+ 1680.000028ps      -8.1906265
+ 1690.000029ps      -8.0982503
+ 1700.000030ps       -8.023761
+ 1710.000030ps       -8.004359
+ 1720.000031ps      -8.0649458
+ 1730.000032ps      -8.1401177
+ 1740.000033ps      -8.2865635
+ 1750.000034ps      -8.5677713
+ 1760.000035ps      -8.9839344
+ 1770.000035ps      -9.6294704
+ 1780.000036ps      -10.387823
+ 1790.000037ps      -11.213053
+ 1800.000038ps      -12.108778
+ 1810.000039ps      -12.882984
+ 1820.000040ps      -13.312587
+ 1830.000040ps      -13.468535
+ 1840.000041ps      -13.282839
+ 1850.000042ps      -12.811175
+ 1860.000043ps      -12.186028
+ 1869.999933ps      -11.504234
+ 1879.999934ps      -10.789005
+ 1889.999934ps      -10.110583
+ 1899.999935ps      -9.4805874
+ 1909.999936ps      -8.9471628
+ 1919.999937ps      -8.5025258
+ 1929.999938ps      -8.1465434
+ 1939.999938ps      -7.8787065
+ 1949.999939ps      -7.7106219
+ 1959.999940ps      -7.5791708
+ 1969.999941ps      -7.5028164
+ 1979.999942ps      -7.4318806
+ 1989.999943ps      -7.3642195
+ 1999.999943ps      -7.2877987
+ 2009.999944ps      -7.2319859
+ 2019.999945ps       -7.259062
+ 2029.999946ps       -7.302679
+ 2039.999947ps      -7.4796917
+ 2049.999948ps      -7.7862308
+ 2059.999948ps      -8.1812732
+ 2069.999949ps      -9.0470412
+ 2079.999950ps      -10.967637
+ 2089.999951ps      -13.430877
+ 2099.999952ps      -15.171802
+ 2109.999953ps      -16.073272
+ 2119.999953ps      -16.806826
+ 2129.999954ps      -17.256362
+ 2139.999955ps      -18.207505
+ 2149.999956ps      -19.914009
+ 2159.999957ps      -20.228142
+ 2169.999958ps      -19.783457
+ 2179.999958ps      -18.928734
+ 2189.999959ps      -17.185501
+ 2199.999960ps      -15.512998
+ 2209.999961ps      -14.242978
+ 2219.999962ps      -13.224271
+ 2229.999962ps      -12.346886
+ 2239.999963ps      -11.578516
+ 2249.999964ps      -10.941853
+ 2259.999965ps      -10.460839
+ 2269.999966ps      -9.9659957
+ 2279.999967ps      -9.5108579
+ 2289.999967ps      -9.0997944
+ 2299.999968ps      -8.8054453
+ 2309.999969ps      -8.6077552
+ 2319.999970ps      -8.4814678
+ 2329.999971ps      -8.3943066
+ 2339.999972ps      -8.3379577
+ 2349.999972ps      -8.3112553
+ 2359.999973ps      -8.2625222
+ 2369.999974ps      -8.2350029
+ 2379.999975ps      -8.2614849
+ 2389.999976ps      -8.3409458
+ 2399.999977ps      -8.4267666
+ 2409.999977ps      -8.5637003
+ 2419.999978ps      -8.8666339
+ 2429.999979ps      -9.3084237
+ 2439.999980ps      -9.9998394
+ 2449.999981ps      -10.742335
+ 2459.999982ps      -11.537428
+ 2469.999982ps      -12.351202
+ 2479.999983ps      -12.961717
+ 2489.999984ps       -13.27151
+ 2499.999985ps      -13.254321
+ 2509.999986ps      -12.959685
+ 2519.999986ps      -12.435862
+ 2529.999987ps      -11.842424
+ 2539.999988ps      -11.196382
+ 2549.999989ps      -10.562778
+ 2559.999990ps      -9.9583502
+ 2569.999991ps       -9.407831
+ 2579.999991ps      -8.9659271
+ 2589.999992ps      -8.5730115
+ 2599.999993ps      -8.2667252
+ 2609.999994ps      -8.0181925
+ 2619.999995ps       -7.820431
+ 2629.999996ps      -7.6532117
+ 2639.999996ps      -7.4994267
+ 2649.999997ps      -7.3762186
+ 2659.999998ps      -7.2649776
+ 2669.999999ps      -7.1904694
+ 2680.000000ps      -7.1635564
+ 2690.000001ps       -7.161259
+ 2700.000001ps      -7.2539309
+ 2710.000002ps      -7.4926071
+ 2720.000003ps      -7.8777989
+ 2730.000004ps      -8.4949756
+ 2740.000005ps      -9.8252803
+ 2750.000005ps      -12.024024
+ 2760.000006ps      -14.211256
+ 2770.000007ps      -15.492288
+ 2780.000008ps      -16.526642
+ 2790.000009ps       -17.04649
+ 2800.000010ps      -17.513539
+ 2810.000010ps      -19.011157
+ 2820.000011ps      -19.945266
+ 2830.000012ps      -20.056488
+ 2840.000013ps      -19.536083
+ 2850.000014ps      -18.167971
+ 2860.000015ps      -16.407613
+ 2870.000015ps      -14.989044
+ 2880.000016ps      -13.828016
+ 2890.000017ps      -12.884176
+ 2900.000018ps      -12.108444
+ 2910.000019ps      -11.409796
+ 2920.000020ps      -10.827717
+ 2930.000020ps      -10.326481
+ 2940.000021ps      -9.7875432
+ 2950.000022ps      -9.3668424
+ 2960.000023ps       -8.989196
+ 2970.000024ps      -8.6987002
+ 2980.000025ps      -8.5089322
+ 2990.000025ps      -8.3706266
+ 3000.000026ps      -8.2681553
+ 3010.000027ps      -8.1970886
+ 3020.000028ps      -8.1256112
+ 3030.000029ps      -8.0868224
+ 3040.000029ps      -8.0797941
+ 3050.000030ps      -8.1175915
+ 3060.000031ps      -8.2331708
+ 3070.000032ps      -8.3463859
+ 3080.000033ps      -8.5454603
+ 3090.000034ps      -8.9047856
+ 3100.000034ps      -9.4425541
+ 3110.000035ps      -10.175078
+ 3120.000036ps      -10.931032
+ 3130.000037ps      -11.768186
+ 3140.000038ps      -12.560877
+ 3150.000039ps      -13.051972
+ 3160.000039ps      -13.238925
+ 3170.000040ps      -13.128411
+ 3180.000041ps       -12.72306
+ 3190.000042ps       -12.16336
+ 3200.000043ps      -11.535857
+ 3210.000044ps      -10.900023
+ 3220.000044ps      -10.265425
+ 3230.000045ps        -9.67051
+ 3240.000046ps      -9.1346605
+ 3250.000047ps      -8.6906551
+ 3260.000048ps       -8.311064
+ 3270.000049ps      -8.0151163
+ 3280.000049ps      -7.7708324
+ 3290.000050ps      -7.5949219
+ 3300.000051ps      -7.4327247
+ 3310.000052ps      -7.3192474
+ 3320.000053ps      -7.2399173
+ 3330.000053ps      -7.1739891
+ 3340.000054ps      -7.1388051
+ 3350.000055ps      -7.1564689
+ 3360.000056ps      -7.1874223
+ 3370.000057ps      -7.3374901
+ 3380.000058ps      -7.6170013
+ 3390.000058ps       -8.008423
+ 3400.000059ps      -8.7742726
+ 3410.000060ps      -10.596385
+ 3420.000061ps       -13.15146
+ 3430.000062ps      -15.083235
+ 3440.000063ps      -15.956976
+ 3450.000063ps      -16.708886
+ 3460.000064ps      -17.156574
+ 3470.000065ps      -18.151896
+ 3480.000066ps      -19.914787
+ 3490.000067ps      -20.314388
+ 3500.000068ps      -20.049316
+ 3510.000068ps      -19.193668
+ 3520.000069ps      -17.478615
+ 3530.000070ps        -15.8269
+ 3540.000071ps      -14.524125
+ 3550.000072ps      -13.464259
+ 3560.000073ps      -12.565206
+ 3570.000073ps      -11.779538
+ 3580.000074ps      -11.079577
+ 3590.000075ps      -10.543756
+ 3600.000076ps      -10.069417
+ 3610.000077ps      -9.5598487
+ 3620.000077ps      -9.1717835
+ 3630.000078ps      -8.8880688
+ 3640.000079ps      -8.6566909
+ 3650.000080ps      -8.4914488
+ 3660.000081ps      -8.3493536
+ 3670.000082ps      -8.2399941
+ 3680.000082ps       -8.181893
+ 3690.000083ps      -8.1339273
+ 3700.000084ps      -8.0988889
+ 3710.000085ps      -8.0895267
+ 3720.000086ps      -8.1655787
+ 3729.999865ps      -8.2150937
+ 3739.999865ps      -8.3227862
+ 3749.999866ps      -8.5552069
+ 3759.999867ps      -8.9455965
+ 3769.999868ps      -9.5693404
+ 3779.999869ps      -10.268216
+ 3789.999869ps      -11.077624
+ 3799.999870ps      -11.933858
+ 3809.999871ps      -12.648328
+ 3819.999872ps      -13.074341
+ 3829.999873ps      -13.180444
+ 3839.999874ps      -13.004047
+ 3849.999874ps      -12.551706
+ 3859.999875ps      -11.986464
+ 3869.999876ps      -11.348147
+ 3879.999877ps      -10.690048
+ 3889.999878ps      -10.043112
+ 3899.999879ps      -9.4441676
+ 3909.999879ps      -8.9344713
+ 3919.999880ps      -8.5096407
+ 3929.999881ps      -8.1388237
+ 3939.999882ps      -7.8242691
+ 3949.999883ps      -7.5618845
+ 3959.999884ps      -7.3917037
+ 3969.999884ps      -7.2539575
+ 3979.999885ps       -7.167292
+ 3989.999886ps      -7.1426615
+ 3999.999887ps      -7.2320374
+ 4009.999888ps      -7.3979549
+ 4019.999889ps      -7.6043388
+ 4029.999889ps      -7.8303616
+ 4039.999890ps      -8.1573977
+ 4049.999891ps      -8.6241277
+ 4059.999892ps      -9.1978743
+ 4069.999893ps      -10.367194
+ 4079.999893ps      -12.355712
+ 4089.999894ps      -14.729882
+ 4099.999895ps      -16.295471
+ 4109.999896ps      -17.340717
+ 4119.999897ps      -17.997773
+ 4129.999898ps      -18.417419
+ 4139.999898ps      -19.538933
+ 4149.999899ps      -20.983401
+ 4159.999900ps      -21.110227
+ 4169.999901ps      -20.651193
+ 4179.999902ps      -19.575173
+ 4189.999903ps      -17.749271
+ 4199.999903ps      -16.204062
+ 4209.999904ps      -14.998771
+ 4219.999905ps      -14.002284
+ 4229.999906ps       -13.17895
+ 4239.999907ps       -12.47935
+ 4249.999908ps      -11.836661
+ 4259.999908ps      -11.312348
+ 4269.999909ps       -10.79191
+ 4279.999910ps      -10.392212
+ 4289.999911ps      -10.034562
+ 4299.999912ps      -9.7367058
+ 4309.999913ps      -9.5393686
+ 4319.999913ps      -9.3811122
+ 4329.999914ps      -9.2647147
+ 4339.999915ps      -9.1772111
+ 4349.999916ps      -9.1089726
+ 4359.999917ps      -9.0716336
+ 4369.999917ps      -9.0803551
+ 4379.999918ps       -9.097602
+ 4389.999919ps      -9.1953895
+ 4399.999920ps      -9.2763034
+ 4409.999921ps      -9.4081715
+ 4419.999922ps      -9.7158061
+ 4429.999922ps      -10.210441
+ 4439.999923ps      -10.967849
+ 4449.999924ps      -11.729734
+ 4459.999925ps      -12.578873
+ 4469.999926ps       -13.42646
+ 4479.999927ps      -13.985084
+ 4489.999927ps      -14.285033
+ 4499.999928ps      -14.216689
+ 4509.999929ps      -13.850201
+ 4519.999930ps      -13.290846
+ 4529.999931ps      -12.659664
+ 4539.999932ps      -11.979715
+ 4549.999932ps      -11.341324
+ 4559.999933ps      -10.731955
+ 4569.999934ps      -10.202662
+ 4579.999935ps      -9.7105056
+ 4589.999936ps      -9.3209756
+ 4599.999937ps      -8.9792065
+ 4609.999937ps      -8.7274711
+ 4619.999938ps      -8.5529033
+ 4629.999939ps      -8.4267555
+ 4639.999940ps      -8.3342238
+ 4649.999941ps      -8.2443461
+ 4659.999941ps      -8.1467436
+ 4669.999942ps       -8.078542
+ 4679.999943ps      -8.0575757
+ 4689.999944ps      -8.0549465
+ 4699.999945ps      -8.1259152
+ 4709.999946ps      -8.3546081
+ 4719.999946ps      -8.8011705
+ 4729.999947ps      -9.5605267
+ 4739.999948ps      -11.140061
+ 4749.999949ps      -13.382718
+ 4759.999950ps      -15.417832
+ 4769.999951ps      -16.660114
+ 4779.999951ps      -17.729745
+ 4789.999952ps      -18.213852
+ 4799.999953ps      -18.895117
+ 4809.999954ps      -20.353127
+ 4819.999955ps      -20.969591
+ 4829.999956ps      -21.092397
+ 4839.999956ps      -20.413382
+ 4849.999957ps        -18.7406
+ 4859.999958ps      -16.940995
+ 4869.999959ps       -15.52019
+ 4879.999960ps      -14.385758
+ 4889.999961ps      -13.409308
+ 4899.999961ps      -12.611191
+ 4909.999962ps      -11.962342
+ 4919.999963ps       -11.43171
+ 4929.999964ps      -10.963391
+ 4939.999965ps      -10.465736
+ 4949.999965ps      -10.083481
+ 4959.999966ps      -9.7622024
+ 4969.999967ps      -9.5109867
+ 4979.999968ps      -9.3070498
+ 4989.999969ps      -9.1154053
+ 4999.999970ps      -8.9212648
+ 5009.999970ps      -8.7386427
+ 5019.999971ps      -8.5828987
+ 5029.999972ps      -8.4545811
+ 5039.999973ps      -8.3520988
+ 5049.999974ps      -8.3004717
+ 5059.999975ps      -8.2946595
+ 5069.999975ps      -8.3352313
+ 5079.999976ps      -8.5274634
+ 5089.999977ps      -8.8575695
+ 5099.999978ps      -9.4072156
+ 5109.999979ps      -10.062325
+ 5119.999980ps      -10.811086
+ 5129.999980ps      -11.668797
+ 5139.999981ps      -12.444242
+ 5149.999982ps      -12.873813
+ 5159.999983ps      -13.011964
+ 5169.999984ps      -12.816436
+ 5179.999985ps       -12.33186
+ 5189.999985ps      -11.717796
+ 5199.999986ps      -11.039606
+ 5209.999987ps      -10.375521
+ 5219.999988ps      -9.7290507
+ 5229.999989ps      -9.1578431
+ 5239.999989ps      -8.6660367
+ 5249.999990ps      -8.2469767
+ 5259.999991ps      -7.9007131
+ 5269.999992ps      -7.6266434
+ 5279.999993ps      -7.4048761
+ 5289.999994ps      -7.2345806
+ 5299.999994ps      -7.1053038
+ 5309.999995ps      -7.0185555
+ 5319.999996ps      -6.9616964
+ 5329.999997ps      -6.9137935
+ 5339.999998ps      -6.8801904
+ 5349.999999ps      -6.8974638
+ 5359.999999ps      -6.9287305
+ 5370.000000ps      -7.0884484
+ 5380.000001ps      -7.4168787
+ 5390.000002ps      -7.8321422
+ 5400.000003ps      -8.7074914
+ 5410.000004ps      -10.656643
+ 5420.000004ps      -13.155203
+ 5430.000005ps      -14.912057
+ 5440.000006ps      -15.823463
+ 5450.000007ps      -16.551998
+ 5460.000008ps      -16.990461
+ 5470.000009ps      -17.920343
+ 5480.000009ps       -19.60027
+ 5490.000010ps      -19.872243
+ 5500.000011ps      -19.372914
+ 5510.000012ps      -18.465963
+ 5520.000013ps       -16.68705
+ 5530.000013ps      -14.994679
+ 5540.000014ps      -13.700391
+ 5550.000015ps      -12.710988
+ 5560.000016ps      -11.879188
+ 5570.000017ps      -11.147239
+ 5580.000018ps      -10.519626
+ 5590.000018ps      -10.065956
+ 5600.000019ps      -9.6226549
+ 5610.000020ps      -9.1851354
+ 5620.000021ps      -8.7665659
+ 5630.000022ps      -8.4460039
+ 5640.000023ps      -8.2156403
+ 5650.000023ps       -8.041064
+ 5660.000024ps      -7.8836183
+ 5670.000025ps      -7.7442256
+ 5680.000026ps       -7.628322
+ 5690.000027ps      -7.5339273
+ 5700.000028ps      -7.4647426
+ 5710.000028ps      -7.4734083
+ 5720.000029ps      -7.5523805
+ 5730.000030ps      -7.6279347
+ 5740.000031ps      -7.7968837
+ 5750.000032ps      -8.1414973
+ 5760.000033ps      -8.6314198
+ 5770.000033ps       -9.373948
+ 5780.000034ps      -10.187244
+ 5790.000035ps      -11.061803
+ 5800.000036ps      -11.910569
+ 5810.000037ps       -12.55235
+ 5820.000037ps      -12.890213
+ 5830.000038ps      -12.897917
+ 5840.000039ps       -12.60065
+ 5850.000040ps      -12.035963
+ 5860.000041ps      -11.403604
+ 5870.000042ps      -10.690191
+ 5880.000042ps      -9.9798204
+ 5890.000043ps       -9.292282
+ 5900.000044ps       -8.716814
+ 5910.000045ps      -8.2119434
+ 5920.000046ps        -7.79794
+ 5930.000047ps      -7.4805295
+ 5940.000047ps      -7.2513042
+ 5950.000048ps      -7.1033814
+ 5960.000049ps      -6.9934556
+ 5970.000050ps      -6.9234464
+ 5980.000051ps      -6.8653205
+ 5990.000052ps      -6.8009528
+ 6000.000052ps      -6.7297746
+ 6010.000053ps       -6.724633
+ 6020.000054ps      -6.7305058
+ 6030.000055ps      -6.8158277
+ 6040.000056ps      -7.0369845
+ 6050.000056ps        -7.41741
+ 6060.000057ps      -8.0047351
+ 6070.000058ps       -9.302917
+ 6080.000059ps      -11.488578
+ 6090.000060ps      -13.671687
+ 6100.000061ps       -14.95916
+ 6110.000061ps      -16.001193
+ 6120.000062ps      -16.514744
+ 6130.000063ps       -16.99383
+ 6140.000064ps       -18.48784
+ 6150.000065ps      -19.426294
+ 6160.000066ps      -19.532754
+ 6170.000066ps      -19.011821
+ 6180.000067ps      -17.622204
+ 6190.000068ps      -15.860493
+ 6200.000069ps      -14.435249
+ 6210.000070ps      -13.287916
+ 6220.000071ps      -12.316313
+ 6230.000071ps      -11.522715
+ 6240.000072ps      -10.826009
+ 6250.000073ps      -10.230433
+ 6260.000074ps      -9.7061945
+ 6270.000075ps      -9.1826203
+ 6280.000076ps      -8.7804103
+ 6290.000076ps      -8.4304791
+ 6300.000077ps      -8.1717407
+ 6310.000078ps      -8.0128677
+ 6320.000079ps      -7.8959626
+ 6330.000080ps      -7.8092705
+ 6340.000080ps      -7.7723306
+ 6350.000081ps      -7.7415996
+ 6360.000082ps      -7.7169156
+ 6370.000083ps      -7.6889169
+ 6380.000084ps      -7.7406761
+ 6390.000085ps      -7.8444781
+ 6400.000085ps      -7.9463204
+ 6410.000086ps      -8.1326278
+ 6420.000087ps      -8.4648062
+ 6430.000088ps      -9.0097952
+ 6440.000089ps      -9.7410111
+ 6450.000090ps      -10.509894
+ 6460.000090ps      -11.330078
+ 6470.000091ps      -12.125389
+ 6480.000092ps      -12.591754
+ 6490.000093ps      -12.762654
+ 6500.000094ps      -12.643644
+ 6510.000095ps      -12.238591
+ 6520.000095ps      -11.689028
+ 6530.000096ps      -11.040463
+ 6540.000097ps      -10.395602
+ 6550.000098ps       -9.766592
+ 6560.000099ps       -9.180701
+ 6570.000100ps      -8.6720747
+ 6580.000100ps      -8.2568668
+ 6590.000101ps      -7.9045228
+ 6600.000102ps      -7.6238954
+ 6610.000103ps      -7.3938307
+ 6620.000104ps      -7.2105011
+ 6630.000104ps       -7.048601
+ 6640.000105ps       -6.904497
+ 6650.000106ps      -6.8111025
+ 6660.000107ps      -6.7181524
+ 6670.000108ps      -6.6444105
+ 6680.000109ps      -6.6214568
+ 6690.000109ps      -6.6163186
+ 6700.000110ps      -6.7434256
+ 6710.000111ps      -7.0109037
+ 6720.000112ps      -7.4138012
+ 6730.000113ps      -8.1816341
+ 6740.000114ps      -10.002825
+ 6750.000114ps      -12.544015
+ 6760.000115ps      -14.469126
+ 6770.000116ps      -15.345154
+ 6780.000117ps      -16.076708
+ 6790.000118ps      -16.498137
+ 6800.000119ps      -17.470099
+ 6810.000119ps      -19.238748
+ 6820.000120ps      -19.679621
+ 6830.000121ps      -19.436721
+ 6840.000122ps      -18.596693
+ 6850.000123ps      -16.899724
+ 6860.000124ps      -15.269351
+ 6870.000124ps      -13.979419
+ 6880.000125ps      -12.925787
+ 6890.000126ps      -12.031384
+ 6900.000127ps      -11.261349
+ 6910.000128ps      -10.599739
+ 6920.000128ps      -10.076481
+ 6930.000129ps      -9.5949433
+ 6940.000130ps       -9.083194
+ 6950.000131ps      -8.6721621
+ 6960.000132ps      -8.3387588
+ 6970.000133ps      -8.0905785
+ 6980.000133ps      -7.9151335
+ 6990.000134ps      -7.7823196
+ 7000.000135ps      -7.6768625
+ 7010.000136ps      -7.6166795
+ 7020.000137ps      -7.5784931
+ 7030.000138ps      -7.5507806
+ 7040.000138ps      -7.5575666
+ 7050.000139ps      -7.6427193
+ 7060.000140ps      -7.7200606
+ 7070.000141ps      -7.8481727
+ 7080.000142ps      -8.1423301
+ 7090.000143ps      -8.5701176
+ 7100.000143ps      -9.2151216
+ 7110.000144ps      -9.9233698
+ 7120.000145ps      -10.707489
+ 7130.000146ps      -11.540082
+ 7140.000147ps      -12.228166
+ 7150.000147ps      -12.639922
+ 7160.000148ps      -12.703298
+ 7170.000149ps      -12.486222
+ 7180.000150ps      -11.980707
+ 7190.000151ps      -11.381344
+ 7200.000152ps      -10.740345
+ 7210.000152ps      -10.096619
+ 7220.000153ps      -9.4639763
+ 7230.000154ps      -8.8938792
+ 7240.000155ps      -8.4167124
+ 7250.000156ps      -8.0030689
+ 7260.000157ps      -7.6595474
+ 7270.000157ps      -7.3755419
+ 7280.000158ps      -7.1580695
+ 7290.000159ps      -6.9812606
+ 7300.000160ps      -6.8451394
+ 7310.000161ps      -6.7352254
+ 7320.000162ps       -6.662276
+ 7330.000162ps      -6.6217521
+ 7340.000163ps      -6.6148458
+ 7350.000164ps      -6.6155722
+ 7360.000165ps      -6.6676058
+ 7370.000166ps      -6.8882234
+ 7380.000167ps      -7.3006864
+ 7390.000167ps      -7.8541669
+ 7400.000168ps      -8.9977888
+ 7410.000169ps      -10.960089
+ 7420.000170ps      -13.333777
+ 7430.000171ps      -14.893505
+ 7440.000171ps      -15.923972
+ 7450.000172ps      -16.577273
+ 7459.999729ps      -16.990712
+ 7469.999730ps       -18.10633
+ 7479.999731ps      -19.543312
+ 7489.999732ps       -19.65374
+ 7499.999732ps      -19.186816
+ 7509.999733ps      -18.088796
+ 7519.999734ps        -16.2432
+ 7529.999735ps      -14.674423
+ 7539.999736ps       -13.44964
+ 7549.999737ps      -12.474064
+ 7559.999737ps      -11.672962
+ 7569.999738ps      -10.973488
+ 7579.999739ps      -10.347133
+ 7589.999740ps      -9.8046141
+ 7599.999741ps      -9.2939965
+ 7609.999741ps      -8.8537553
+ 7619.999742ps      -8.4874252
+ 7629.999743ps      -8.2021841
+ 7639.999744ps      -8.0204204
+ 7649.999745ps      -7.8755586
+ 7659.999746ps      -7.7478325
+ 7669.999746ps       -7.659353
+ 7679.999747ps      -7.6216309
+ 7689.999748ps      -7.5869574
+ 7699.999749ps      -7.5583631
+ 7709.999750ps      -7.5727797
+ 7719.999751ps      -7.6626495
+ 7729.999751ps      -7.7270318
+ 7739.999752ps      -7.8627013
+ 7749.999753ps       -8.137718
+ 7759.999754ps      -8.5937928
+ 7769.999755ps      -9.2899098
+ 7779.999756ps      -10.049238
+ 7789.999756ps      -10.887573
+ 7799.999757ps      -11.726707
+ 7809.999758ps      -12.302638
+ 7819.999759ps      -12.603598
+ 7829.999760ps      -12.578209
+ 7839.999761ps      -12.252537
+ 7849.999761ps       -11.73568
+ 7859.999762ps      -11.164533
+ 7869.999763ps      -10.525038
+ 7879.999764ps      -9.8688264
+ 7889.999765ps      -9.2461992
+ 7899.999765ps      -8.6867386
+ 7909.999766ps      -8.2129572
+ 7919.999767ps      -7.8240252
+ 7929.999768ps      -7.4874289
+ 7939.999769ps      -7.1989312
+ 7949.999770ps      -6.9707447
+ 7959.999770ps      -6.7997083
+ 7969.999771ps       -6.684428
+ 7979.999772ps      -6.6127069
+ 7989.999773ps       -6.649883
+)

Icursig15 PAR_1_2_VDD075CPU 0 pwl(
+ 0.000000ps       5.5820885
+ 10.000000ps       5.7275725
+ 20.000000ps       6.1204038
+ 29.999999ps       6.6150202
+ 40.000000ps       7.2252041
+ 50.000001ps       7.9498831
+ 59.999998ps       8.7927911
+ 69.999999ps       10.090283
+ 80.000000ps        12.58474
+ 90.000001ps       15.918919
+ 100.000001ps       18.490381
+ 110.000002ps       20.091539
+ 119.999996ps       21.708127
+ 129.999997ps       22.968605
+ 139.999998ps       24.658276
+ 149.999999ps       26.893734
+ 159.999999ps       27.473614
+ 170.000000ps       27.213841
+ 180.000001ps       26.267567
+ 190.000002ps       24.303753
+ 200.000003ps       22.511587
+ 210.000003ps       21.160819
+ 220.000004ps       20.079011
+ 230.000005ps       19.021366
+ 239.999992ps       18.008598
+ 249.999993ps       16.992693
+ 259.999994ps       16.058413
+ 269.999995ps       15.190724
+ 279.999995ps       14.343105
+ 289.999996ps       13.624565
+ 299.999997ps       13.031002
+ 309.999998ps       12.555763
+ 319.999999ps       12.200274
+ 330.000000ps       11.925983
+ 340.000000ps       11.705592
+ 350.000001ps       11.541712
+ 360.000002ps       11.412874
+ 370.000003ps       11.321863
+ 380.000004ps       11.311015
+ 390.000005ps       11.468088
+ 400.000005ps       11.382952
+ 410.000006ps       11.259242
+ 420.000007ps       11.347385
+ 430.000008ps       11.575257
+ 440.000009ps       11.948472
+ 450.000009ps       12.106104
+ 460.000010ps       12.341939
+ 469.999983ps       12.689491
+ 479.999984ps        13.04082
+ 489.999985ps       13.335491
+ 499.999986ps       13.560935
+ 509.999987ps       13.685065
+ 519.999988ps       13.710572
+ 529.999988ps       13.608624
+ 539.999989ps       13.389246
+ 549.999990ps       13.063435
+ 559.999991ps       12.676214
+ 569.999992ps       12.278628
+ 579.999992ps       11.876835
+ 589.999993ps        11.51636
+ 599.999994ps       11.216049
+ 609.999995ps       10.978446
+ 619.999996ps       10.813527
+ 629.999997ps       10.709693
+ 639.999997ps       10.625139
+ 649.999998ps       10.542723
+ 659.999999ps        10.45551
+ 670.000000ps       10.398337
+ 680.000001ps       10.397041
+ 690.000002ps       10.425229
+ 700.000002ps       10.507201
+ 710.000003ps       10.767073
+ 720.000004ps       11.267201
+ 730.000005ps       12.029223
+ 740.000006ps       13.504085
+ 750.000007ps       15.966536
+ 760.000007ps       18.875257
+ 770.000008ps       20.950894
+ 780.000009ps        22.61433
+ 790.000010ps       24.032187
+ 800.000011ps       25.095041
+ 810.000012ps       26.753003
+ 820.000012ps       28.481053
+ 830.000013ps       28.523625
+ 840.000014ps       27.909893
+ 850.000015ps       26.557503
+ 860.000016ps       24.367968
+ 870.000016ps        22.57296
+ 880.000017ps       21.265327
+ 890.000018ps       20.108787
+ 900.000019ps       19.054061
+ 910.000020ps       18.067263
+ 920.000021ps        17.05996
+ 930.000021ps       16.075583
+ 939.999967ps       15.149766
+ 949.999968ps       14.336145
+ 959.999968ps       13.616486
+ 969.999969ps       13.017479
+ 979.999970ps       12.536144
+ 989.999971ps       12.124125
+ 999.999972ps       11.746221
+ 1009.999973ps       11.417808
+ 1019.999973ps       11.131411
+ 1029.999974ps       10.911677
+ 1039.999975ps        10.71965
+ 1049.999976ps       10.625762
+ 1059.999977ps        10.68457
+ 1069.999978ps       10.510832
+ 1079.999978ps         10.3819
+ 1089.999979ps       10.450359
+ 1099.999980ps       10.644189
+ 1109.999981ps       10.944826
+ 1119.999982ps       11.032653
+ 1129.999982ps       11.223798
+ 1139.999983ps       11.548086
+ 1149.999984ps       11.853971
+ 1159.999985ps       12.087428
+ 1169.999986ps       12.209924
+ 1179.999987ps       12.243574
+ 1189.999987ps        12.17945
+ 1199.999988ps       12.005498
+ 1209.999989ps         11.7128
+ 1219.999990ps       11.346231
+ 1229.999991ps       10.950274
+ 1239.999992ps        10.56128
+ 1249.999992ps       10.197969
+ 1259.999993ps       9.8752946
+ 1269.999994ps       9.6153592
+ 1279.999995ps       9.3967532
+ 1289.999996ps       9.2396118
+ 1299.999997ps       9.1176208
+ 1309.999997ps       9.0267471
+ 1319.999998ps        8.964867
+ 1329.999999ps       8.9167999
+ 1340.000000ps       8.8802388
+ 1350.000001ps       8.8911753
+ 1360.000002ps       8.9219743
+ 1370.000002ps       9.0495381
+ 1380.000003ps       9.3480663
+ 1390.000004ps       9.8832151
+ 1400.000005ps       10.803831
+ 1410.000006ps       12.738215
+ 1420.000006ps        15.50896
+ 1430.000007ps       18.012117
+ 1440.000008ps       19.764555
+ 1450.000009ps       21.506174
+ 1460.000010ps       22.679103
+ 1470.000011ps       23.978205
+ 1480.000011ps       25.890061
+ 1490.000012ps       26.653079
+ 1500.000013ps       26.701047
+ 1510.000014ps       25.901417
+ 1520.000015ps       23.985097
+ 1530.000016ps       21.951258
+ 1540.000016ps       20.455485
+ 1550.000017ps       19.295819
+ 1560.000018ps         18.1579
+ 1570.000019ps       17.117407
+ 1580.000020ps       16.082196
+ 1590.000021ps       15.095309
+ 1600.000021ps       14.169519
+ 1610.000022ps       13.251891
+ 1620.000023ps       12.433344
+ 1630.000024ps       11.743181
+ 1640.000025ps       11.182122
+ 1650.000025ps       10.744604
+ 1660.000026ps       10.398313
+ 1670.000027ps       10.093304
+ 1680.000028ps       9.8434908
+ 1690.000029ps       9.6419838
+ 1700.000030ps       9.4858055
+ 1710.000030ps       9.4171839
+ 1720.000031ps       9.5227023
+ 1730.000032ps       9.4863835
+ 1740.000033ps       9.3925956
+ 1750.000034ps       9.4863506
+ 1760.000035ps       9.7358696
+ 1770.000035ps       10.140618
+ 1780.000036ps       10.389953
+ 1790.000037ps       10.616853
+ 1800.000038ps       10.921784
+ 1810.000039ps       11.252211
+ 1820.000040ps       11.540525
+ 1830.000040ps       11.774856
+ 1840.000041ps       11.887986
+ 1850.000042ps       11.908118
+ 1860.000043ps       11.810134
+ 1869.999933ps       11.569271
+ 1879.999934ps       11.187316
+ 1889.999934ps       10.736431
+ 1899.999935ps       10.285501
+ 1909.999936ps       9.8601008
+ 1919.999937ps       9.4981732
+ 1929.999938ps       9.2305185
+ 1939.999938ps       9.0320344
+ 1949.999939ps       8.8971739
+ 1959.999940ps       8.8041914
+ 1969.999941ps       8.7493783
+ 1979.999942ps       8.7000798
+ 1989.999943ps       8.6344671
+ 1999.999943ps       8.5744158
+ 2009.999944ps        8.568747
+ 2019.999945ps       8.6367274
+ 2029.999946ps       8.7267698
+ 2039.999947ps       8.9434404
+ 2049.999948ps       9.3331141
+ 2059.999948ps       9.8489853
+ 2069.999949ps        10.99088
+ 2079.999950ps       13.365364
+ 2089.999951ps        16.35428
+ 2099.999952ps       18.550282
+ 2109.999953ps       20.098496
+ 2119.999953ps       21.617938
+ 2129.999954ps       22.750054
+ 2139.999955ps        24.27459
+ 2149.999956ps       26.301449
+ 2159.999957ps       26.629491
+ 2169.999958ps        26.14672
+ 2179.999958ps       25.101795
+ 2189.999959ps       23.042242
+ 2199.999960ps       21.184419
+ 2209.999961ps       19.799849
+ 2219.999962ps       18.660683
+ 2229.999962ps       17.564373
+ 2239.999963ps       16.489487
+ 2249.999964ps        15.43375
+ 2259.999965ps       14.464231
+ 2269.999966ps       13.513859
+ 2279.999967ps       12.627758
+ 2289.999967ps       11.853546
+ 2299.999968ps       11.256032
+ 2309.999969ps       10.810192
+ 2319.999970ps       10.486128
+ 2329.999971ps       10.239689
+ 2339.999972ps       10.038011
+ 2349.999972ps       9.8712269
+ 2359.999973ps        9.726149
+ 2369.999974ps       9.6325398
+ 2379.999975ps       9.6392835
+ 2389.999976ps        9.767706
+ 2399.999977ps       9.6747518
+ 2409.999977ps       9.5779668
+ 2419.999978ps       9.6735796
+ 2429.999979ps       9.9129827
+ 2439.999980ps       10.239747
+ 2449.999981ps       10.375196
+ 2459.999982ps       10.563363
+ 2469.999982ps       10.873885
+ 2479.999983ps       11.175381
+ 2489.999984ps       11.430585
+ 2499.999985ps       11.615934
+ 2509.999986ps         11.7197
+ 2519.999986ps       11.750499
+ 2529.999987ps         11.6509
+ 2539.999988ps       11.426181
+ 2549.999989ps       11.085196
+ 2559.999990ps       10.700542
+ 2569.999991ps       10.326226
+ 2579.999991ps       9.9759824
+ 2589.999992ps       9.6738826
+ 2599.999993ps        9.424066
+ 2609.999994ps       9.2067094
+ 2619.999995ps       9.0121969
+ 2629.999996ps         8.84893
+ 2639.999996ps       8.7136161
+ 2649.999997ps       8.6085415
+ 2659.999998ps       8.5250833
+ 2669.999999ps       8.4521009
+ 2680.000000ps       8.4585129
+ 2690.000001ps       8.4907556
+ 2700.000001ps       8.6336608
+ 2710.000002ps       8.9444867
+ 2720.000003ps       9.4414258
+ 2730.000004ps        10.26054
+ 2740.000005ps       11.938251
+ 2750.000005ps       14.640195
+ 2760.000006ps       17.315592
+ 2770.000007ps       19.118405
+ 2780.000008ps       20.826425
+ 2790.000009ps       22.087563
+ 2800.000010ps       23.179985
+ 2810.000010ps       25.182518
+ 2820.000011ps         26.3173
+ 2830.000012ps       26.410389
+ 2840.000013ps       25.826706
+ 2850.000014ps         24.2297
+ 2860.000015ps       22.177728
+ 2870.000015ps       20.596808
+ 2880.000016ps       19.359744
+ 2890.000017ps       18.248636
+ 2900.000018ps       17.202441
+ 2910.000019ps       16.173594
+ 2920.000020ps       15.119457
+ 2930.000020ps       14.096442
+ 2940.000021ps       13.104551
+ 2950.000022ps       12.272872
+ 2960.000023ps       11.578548
+ 2970.000024ps       11.002208
+ 2980.000025ps       10.583334
+ 2990.000025ps       10.248955
+ 3000.000026ps       9.9864073
+ 3010.000027ps       9.7698292
+ 3020.000028ps       9.6083038
+ 3030.000029ps        9.469562
+ 3040.000029ps       9.3844949
+ 3050.000030ps       9.4382049
+ 3060.000031ps       9.5902414
+ 3070.000032ps       9.5118604
+ 3080.000033ps       9.4788995
+ 3090.000034ps       9.6381475
+ 3100.000034ps       9.9319045
+ 3110.000035ps       10.283368
+ 3120.000036ps       10.405109
+ 3130.000037ps       10.633888
+ 3140.000038ps       10.949348
+ 3150.000039ps       11.240964
+ 3160.000039ps       11.502451
+ 3170.000040ps       11.652823
+ 3180.000041ps       11.713336
+ 3190.000042ps       11.669463
+ 3200.000043ps       11.511277
+ 3210.000044ps       11.209189
+ 3220.000044ps       10.828514
+ 3230.000045ps       10.416427
+ 3240.000046ps         10.0261
+ 3250.000047ps       9.6769128
+ 3260.000048ps       9.3912767
+ 3270.000049ps       9.1576588
+ 3280.000049ps       8.9671694
+ 3290.000050ps       8.7895996
+ 3300.000051ps       8.6398792
+ 3310.000052ps       8.5326628
+ 3320.000053ps       8.4682054
+ 3330.000053ps       8.4383652
+ 3340.000054ps       8.4439619
+ 3350.000055ps       8.5031951
+ 3360.000056ps       8.5806585
+ 3370.000057ps       8.7809002
+ 3380.000058ps       9.1369133
+ 3390.000058ps       9.6612752
+ 3400.000059ps       10.659442
+ 3410.000060ps       12.881279
+ 3420.000061ps       15.983008
+ 3430.000062ps       18.384966
+ 3440.000063ps       19.854863
+ 3450.000063ps       21.341761
+ 3460.000064ps       22.491273
+ 3470.000065ps       24.082932
+ 3480.000066ps       26.214417
+ 3490.000067ps       26.709286
+ 3500.000068ps        26.34617
+ 3510.000068ps       25.314787
+ 3520.000069ps       23.297842
+ 3530.000070ps       21.435588
+ 3540.000071ps       20.021318
+ 3550.000072ps       18.896545
+ 3560.000073ps       17.797982
+ 3570.000073ps       16.718314
+ 3580.000074ps       15.613908
+ 3590.000075ps       14.570337
+ 3600.000076ps       13.617646
+ 3610.000077ps       12.696094
+ 3620.000077ps       11.928165
+ 3630.000078ps       11.318692
+ 3640.000079ps       10.840889
+ 3650.000080ps       10.466641
+ 3660.000081ps       10.153467
+ 3670.000082ps       9.9069554
+ 3680.000082ps       9.7209175
+ 3690.000083ps       9.5659342
+ 3700.000084ps       9.4360071
+ 3710.000085ps       9.3981648
+ 3720.000086ps       9.5257501
+ 3729.999865ps       9.4311673
+ 3739.999865ps       9.2919984
+ 3749.999866ps       9.3489704
+ 3759.999867ps       9.5229639
+ 3769.999868ps       9.8433655
+ 3779.999869ps       9.9455669
+ 3789.999869ps       10.140079
+ 3799.999870ps       10.477518
+ 3809.999871ps       10.840448
+ 3819.999872ps       11.166852
+ 3829.999873ps       11.430982
+ 3839.999874ps       11.595666
+ 3849.999874ps        11.66355
+ 3859.999875ps       11.590386
+ 3869.999876ps       11.379592
+ 3879.999877ps       11.033215
+ 3889.999878ps       10.630044
+ 3899.999879ps       10.214355
+ 3909.999879ps       9.8165784
+ 3919.999880ps       9.4697423
+ 3929.999881ps       9.1540359
+ 3939.999882ps        8.891856
+ 3949.999883ps       8.6610767
+ 3959.999884ps       8.5079644
+ 3969.999884ps       8.4080269
+ 3979.999885ps       8.3358382
+ 3989.999886ps       8.3395156
+ 3999.999887ps       8.4882185
+ 4009.999888ps       8.7259634
+ 4019.999889ps       8.8373615
+ 4029.999889ps       8.9575045
+ 4039.999890ps       9.2306977
+ 4049.999891ps       9.7034814
+ 4059.999892ps        10.41502
+ 4069.999893ps       11.849584
+ 4079.999893ps       14.284487
+ 4089.999894ps       17.176346
+ 4099.999895ps       19.248232
+ 4109.999896ps       20.912025
+ 4119.999897ps       22.336517
+ 4129.999898ps        23.40206
+ 4139.999898ps        25.05849
+ 4149.999899ps       26.816709
+ 4159.999900ps          26.902
+ 4169.999901ps       26.372031
+ 4179.999902ps       25.100304
+ 4189.999903ps       22.956911
+ 4199.999903ps       21.192771
+ 4209.999904ps       19.905798
+ 4219.999905ps       18.730747
+ 4229.999906ps        17.65826
+ 4239.999907ps       16.629172
+ 4249.999908ps       15.593871
+ 4259.999908ps       14.589001
+ 4269.999909ps       13.637492
+ 4279.999910ps       12.823475
+ 4289.999911ps       12.109122
+ 4299.999912ps       11.543613
+ 4309.999913ps       11.107235
+ 4319.999913ps       10.767849
+ 4329.999914ps       10.497064
+ 4339.999915ps       10.276904
+ 4349.999916ps       10.110178
+ 4359.999917ps       9.9722331
+ 4369.999917ps       9.8874378
+ 4379.999918ps       9.9022109
+ 4389.999919ps       10.040372
+ 4399.999920ps       9.9205974
+ 4409.999921ps       9.8270593
+ 4419.999922ps       9.9535288
+ 4429.999922ps       10.232271
+ 4439.999923ps       10.605123
+ 4449.999924ps       10.760435
+ 4459.999925ps       11.018543
+ 4469.999926ps       11.383086
+ 4479.999927ps       11.712008
+ 4489.999927ps       11.988869
+ 4499.999928ps       12.160275
+ 4509.999929ps       12.239559
+ 4519.999930ps       12.218141
+ 4529.999931ps       12.059939
+ 4539.999932ps       11.773601
+ 4549.999932ps       11.407052
+ 4559.999933ps       11.013309
+ 4569.999934ps       10.617417
+ 4579.999935ps       10.245678
+ 4589.999936ps       9.9115739
+ 4599.999937ps       9.6326271
+ 4609.999937ps       9.4074853
+ 4619.999938ps       9.2609649
+ 4629.999939ps       9.1624438
+ 4639.999940ps       9.0952132
+ 4649.999941ps       9.0235339
+ 4659.999941ps         8.93643
+ 4669.999942ps       8.8838562
+ 4679.999943ps       8.9014521
+ 4689.999944ps       8.9477736
+ 4699.999945ps       9.0836536
+ 4709.999946ps       9.3947808
+ 4719.999946ps       9.9604698
+ 4729.999947ps       10.919831
+ 4739.999948ps       12.878931
+ 4749.999949ps       15.672813
+ 4759.999950ps        18.20264
+ 4769.999951ps       19.999132
+ 4779.999951ps       21.773266
+ 4789.999952ps       22.964685
+ 4799.999953ps       24.274363
+ 4809.999954ps        26.19359
+ 4819.999955ps       26.951441
+ 4829.999956ps       26.981493
+ 4839.999956ps       26.173848
+ 4849.999957ps       24.230953
+ 4859.999958ps        22.16935
+ 4869.999959ps       20.643308
+ 4879.999960ps        19.45772
+ 4889.999961ps        18.30861
+ 4899.999961ps        17.26422
+ 4909.999962ps       16.251925
+ 4919.999963ps       15.277839
+ 4929.999964ps        14.34259
+ 4939.999965ps       13.441103
+ 4949.999965ps       12.659442
+ 4959.999966ps        12.03197
+ 4969.999967ps       11.498005
+ 4979.999968ps       11.080034
+ 4989.999969ps       10.721599
+ 4999.999970ps       10.400855
+ 5009.999970ps       10.127404
+ 5019.999971ps       9.9237133
+ 5029.999972ps       9.7697355
+ 5039.999973ps        9.683281
+ 5049.999974ps         9.74674
+ 5059.999975ps       9.6878934
+ 5069.999975ps        9.558143
+ 5079.999976ps       9.5908978
+ 5089.999977ps         9.77133
+ 5099.999978ps        10.08501
+ 5109.999979ps       10.277128
+ 5119.999980ps       10.464618
+ 5129.999980ps       10.769663
+ 5139.999981ps       11.124402
+ 5149.999982ps       11.439853
+ 5159.999983ps       11.684532
+ 5169.999984ps       11.802299
+ 5179.999985ps       11.827943
+ 5189.999985ps        11.72702
+ 5199.999986ps       11.515145
+ 5209.999987ps       11.197556
+ 5219.999988ps       10.823522
+ 5229.999989ps       10.453193
+ 5239.999989ps       10.090975
+ 5249.999990ps       9.7672841
+ 5259.999991ps       9.4918487
+ 5269.999992ps       9.2749965
+ 5279.999993ps       9.0976557
+ 5289.999994ps       8.9673962
+ 5299.999994ps       8.8747073
+ 5309.999995ps        8.800956
+ 5319.999996ps       8.7521614
+ 5329.999997ps       8.7211161
+ 5339.999998ps       8.6992835
+ 5349.999999ps       8.7358312
+ 5359.999999ps       8.8067925
+ 5370.000000ps       9.0264581
+ 5380.000001ps       9.4410677
+ 5390.000002ps       9.9793885
+ 5400.000003ps       11.157038
+ 5410.000004ps       13.561415
+ 5420.000004ps        16.57916
+ 5430.000005ps       18.797516
+ 5440.000006ps       20.339594
+ 5450.000007ps       21.848639
+ 5460.000008ps       22.957994
+ 5470.000009ps       24.470263
+ 5480.000009ps       26.475625
+ 5490.000010ps       26.783048
+ 5500.000011ps       26.250483
+ 5510.000012ps       25.177823
+ 5520.000013ps        23.09358
+ 5530.000013ps        21.20798
+ 5540.000014ps       19.821605
+ 5550.000015ps       18.699348
+ 5560.000016ps       17.639591
+ 5570.000017ps       16.600881
+ 5580.000018ps       15.566014
+ 5590.000018ps       14.627794
+ 5600.000019ps          13.716
+ 5610.000020ps       12.866379
+ 5620.000021ps        12.07506
+ 5630.000022ps       11.442758
+ 5640.000023ps       10.953513
+ 5650.000023ps       10.555896
+ 5660.000024ps       10.228279
+ 5670.000025ps       9.9523985
+ 5680.000026ps       9.7277726
+ 5690.000027ps       9.5432847
+ 5700.000028ps       9.4014198
+ 5710.000028ps       9.3762752
+ 5720.000029ps       9.4967333
+ 5730.000030ps       9.4165284
+ 5740.000031ps       9.3645908
+ 5750.000032ps       9.5085794
+ 5760.000033ps       9.8157804
+ 5770.000033ps       10.218217
+ 5780.000034ps       10.424924
+ 5790.000035ps       10.686437
+ 5800.000036ps       11.024058
+ 5810.000037ps       11.341964
+ 5820.000037ps       11.620953
+ 5830.000038ps       11.805624
+ 5840.000039ps       11.875572
+ 5850.000040ps       11.850692
+ 5860.000041ps       11.699031
+ 5870.000042ps       11.403445
+ 5880.000042ps       10.986481
+ 5890.000043ps       10.533414
+ 5900.000044ps       10.099542
+ 5910.000045ps       9.6967869
+ 5920.000046ps       9.3595578
+ 5930.000047ps       9.1069506
+ 5940.000047ps       8.9222677
+ 5950.000048ps       8.7994143
+ 5960.000049ps       8.7183855
+ 5970.000050ps       8.6773643
+ 5980.000051ps       8.6331654
+ 5990.000052ps       8.5799528
+ 6000.000052ps       8.5422027
+ 6010.000053ps       8.5723035
+ 6020.000054ps       8.6270063
+ 6030.000055ps       8.7576057
+ 6040.000056ps       9.0452091
+ 6050.000056ps       9.5004365
+ 6060.000057ps       10.269858
+ 6070.000058ps       11.906031
+ 6080.000059ps       14.582966
+ 6090.000060ps        17.26665
+ 6100.000061ps        19.07317
+ 6110.000061ps       20.791904
+ 6120.000062ps       22.049245
+ 6130.000063ps       23.158092
+ 6140.000064ps       25.172026
+ 6150.000065ps       26.323098
+ 6160.000066ps       26.409619
+ 6170.000066ps       25.796431
+ 6180.000067ps       24.158696
+ 6190.000068ps       22.085296
+ 6200.000069ps        20.49394
+ 6210.000070ps       19.297499
+ 6220.000071ps       18.164963
+ 6230.000071ps       17.103516
+ 6240.000072ps       16.064118
+ 6250.000073ps       15.040763
+ 6260.000074ps       14.062273
+ 6270.000075ps       13.090275
+ 6280.000076ps       12.272878
+ 6290.000076ps       11.586687
+ 6300.000077ps       11.038221
+ 6310.000078ps       10.632698
+ 6320.000079ps       10.326913
+ 6330.000080ps       10.099774
+ 6340.000080ps       9.9136874
+ 6350.000081ps       9.7663474
+ 6360.000082ps       9.6273576
+ 6370.000083ps       9.5550258
+ 6380.000084ps       9.5936298
+ 6390.000085ps       9.7153044
+ 6400.000085ps       9.6085196
+ 6410.000086ps       9.5454442
+ 6420.000087ps       9.6937726
+ 6430.000088ps       9.9769732
+ 6440.000089ps       10.317439
+ 6450.000090ps       10.460818
+ 6460.000090ps       10.685335
+ 6470.000091ps       11.005019
+ 6480.000092ps        11.26346
+ 6490.000093ps       11.488457
+ 6500.000094ps       11.630576
+ 6510.000095ps       11.709258
+ 6520.000095ps       11.687148
+ 6530.000096ps       11.535639
+ 6540.000097ps       11.256678
+ 6550.000098ps       10.890703
+ 6560.000099ps       10.504192
+ 6570.000100ps       10.130306
+ 6580.000100ps       9.7981686
+ 6590.000101ps       9.5154892
+ 6600.000102ps        9.289993
+ 6610.000103ps        9.090221
+ 6620.000104ps       8.9164765
+ 6630.000104ps       8.7722242
+ 6640.000105ps       8.6503908
+ 6650.000106ps       8.5542051
+ 6660.000107ps       8.4710988
+ 6670.000108ps       8.4112366
+ 6680.000109ps       8.4214176
+ 6690.000109ps       8.4688279
+ 6700.000110ps       8.6605425
+ 6710.000111ps       9.0140878
+ 6720.000112ps       9.5425852
+ 6730.000113ps       10.552795
+ 6740.000114ps       12.784953
+ 6750.000114ps       15.888912
+ 6760.000115ps       18.257726
+ 6770.000116ps       19.691097
+ 6780.000117ps       21.157691
+ 6790.000118ps        22.30923
+ 6800.000119ps       23.900419
+ 6810.000119ps       26.064583
+ 6820.000120ps        26.57803
+ 6830.000121ps       26.263133
+ 6840.000122ps       25.289046
+ 6850.000123ps       23.306905
+ 6860.000124ps       21.462673
+ 6870.000124ps       20.067375
+ 6880.000125ps       18.905816
+ 6890.000126ps       17.813866
+ 6900.000127ps       16.746295
+ 6910.000128ps       15.666143
+ 6920.000128ps        14.65146
+ 6930.000129ps       13.707126
+ 6940.000130ps       12.765473
+ 6950.000131ps       11.972014
+ 6960.000132ps       11.315756
+ 6970.000133ps       10.789214
+ 6980.000133ps       10.403198
+ 6990.000134ps        10.10139
+ 7000.000135ps        9.863124
+ 7010.000136ps       9.6810737
+ 7020.000137ps       9.5340668
+ 7030.000138ps       9.4063491
+ 7040.000138ps       9.3933243
+ 7050.000139ps       9.5647481
+ 7060.000140ps       9.5125357
+ 7070.000141ps       9.4218159
+ 7080.000142ps       9.5239786
+ 7090.000143ps       9.7469086
+ 7100.000143ps       10.105892
+ 7110.000144ps         10.2319
+ 7120.000145ps       10.409223
+ 7130.000146ps       10.722524
+ 7140.000147ps       11.034132
+ 7150.000147ps       11.323094
+ 7160.000148ps       11.549996
+ 7170.000149ps       11.666545
+ 7180.000150ps       11.687075
+ 7190.000151ps       11.581088
+ 7200.000152ps       11.359511
+ 7210.000152ps        11.01858
+ 7220.000153ps       10.627134
+ 7230.000154ps       10.233372
+ 7240.000155ps       9.8534746
+ 7250.000156ps       9.5282865
+ 7260.000157ps       9.2653041
+ 7270.000157ps        9.051308
+ 7280.000158ps       8.8775445
+ 7290.000159ps       8.7206805
+ 7300.000160ps       8.5847539
+ 7310.000161ps       8.4834266
+ 7320.000162ps       8.4278917
+ 7330.000162ps        8.415071
+ 7340.000163ps       8.4546098
+ 7350.000164ps       8.5095907
+ 7360.000165ps       8.6180311
+ 7370.000166ps       8.8934129
+ 7380.000167ps       9.3759338
+ 7390.000167ps       10.098952
+ 7400.000168ps       11.540481
+ 7410.000169ps       13.969566
+ 7420.000170ps       16.858501
+ 7430.000171ps       18.911414
+ 7440.000171ps       20.585795
+ 7450.000172ps       22.006348
+ 7459.999729ps       23.053205
+ 7469.999730ps       24.697828
+ 7479.999731ps       26.434467
+ 7489.999732ps       26.511813
+ 7499.999732ps       25.940395
+ 7509.999733ps       24.649307
+ 7519.999734ps       22.515845
+ 7529.999735ps       20.770532
+ 7539.999736ps       19.489386
+ 7549.999737ps       18.355309
+ 7559.999737ps       17.325337
+ 7569.999738ps       16.306784
+ 7579.999739ps       15.231567
+ 7589.999740ps       14.174063
+ 7599.999741ps        13.18869
+ 7609.999741ps       12.334649
+ 7619.999742ps       11.616717
+ 7629.999743ps       11.069714
+ 7639.999744ps       10.655077
+ 7649.999745ps        10.31272
+ 7659.999746ps       10.022604
+ 7669.999746ps       9.7922314
+ 7679.999747ps       9.6170002
+ 7689.999748ps       9.4797874
+ 7699.999749ps       9.3761158
+ 7709.999750ps       9.3721169
+ 7719.999751ps       9.4955394
+ 7729.999751ps       9.3855627
+ 7739.999752ps       9.2891009
+ 7749.999753ps       9.4024974
+ 7759.999754ps        9.614827
+ 7769.999755ps       9.9362891
+ 7779.999756ps       10.033132
+ 7789.999756ps       10.245518
+ 7799.999757ps       10.602399
+ 7809.999758ps       10.952801
+ 7819.999759ps       11.262125
+ 7829.999760ps       11.472889
+ 7839.999761ps        11.60465
+ 7849.999761ps       11.628826
+ 7859.999762ps       11.509541
+ 7869.999763ps        11.23329
+ 7879.999764ps       10.860084
+ 7889.999765ps       10.457022
+ 7899.999765ps       10.046645
+ 7909.999766ps       9.6664139
+ 7919.999767ps       9.3419451
+ 7929.999768ps       9.0456683
+ 7939.999769ps       8.7952618
+ 7949.999770ps       8.5754048
+ 7959.999770ps       8.4374955
+ 7969.999771ps       8.3469287
+ 7979.999772ps       8.2849042
+ 7989.999773ps       8.2902508
+)

Icursig16 PAR_2_2_VSS 0 pwl(
+ 0.000000ps      -1.0793835
+ 10.000000ps      -1.1552921
+ 20.000000ps      -1.3001478
+ 29.999999ps      -1.4226432
+ 40.000000ps      -1.5027962
+ 50.000001ps      -1.5639317
+ 59.999998ps       -1.610466
+ 69.999999ps      -1.6380752
+ 80.000000ps      -1.6632623
+ 90.000001ps      -1.6888762
+ 100.000001ps      -1.7114992
+ 110.000002ps      -1.7285284
+ 119.999996ps      -1.7469494
+ 129.999997ps      -1.7604608
+ 139.999998ps       -1.772384
+ 149.999999ps      -1.7764789
+ 159.999999ps      -1.7752867
+ 170.000000ps      -1.7773133
+ 180.000001ps      -1.7768288
+ 190.000002ps      -1.7849037
+ 200.000003ps      -1.7810725
+ 210.000003ps      -1.7858753
+ 220.000004ps      -1.7870241
+ 230.000005ps      -1.7823826
+ 239.999992ps      -1.7879055
+ 249.999993ps      -1.7953664
+ 259.999994ps      -1.8120629
+ 269.999995ps      -1.8295882
+ 279.999995ps      -1.8461518
+ 289.999996ps       -1.871155
+ 299.999997ps      -1.8901414
+ 309.999998ps      -1.9090688
+ 319.999999ps        -1.92531
+ 330.000000ps      -1.9213856
+ 340.000000ps      -1.9092945
+ 350.000001ps      -1.9078598
+ 360.000002ps      -1.9078005
+ 370.000003ps      -1.9065681
+ 380.000004ps      -1.8913538
+ 390.000005ps      -1.8808945
+ 400.000005ps      -1.8764649
+ 410.000006ps      -1.8824903
+ 420.000007ps      -1.8898015
+ 430.000008ps      -1.9063754
+ 440.000009ps      -1.9272241
+ 450.000009ps      -1.9409261
+ 460.000010ps       -1.953899
+ 469.999983ps      -1.9582019
+ 479.999984ps      -1.9607897
+ 489.999985ps      -1.9691033
+ 499.999986ps      -1.9729904
+ 509.999987ps      -1.9791518
+ 519.999988ps      -1.9847524
+ 529.999988ps      -1.9944738
+ 539.999989ps       -1.982711
+ 549.999990ps      -1.9778274
+ 559.999991ps      -1.9650188
+ 569.999992ps       -1.957415
+ 579.999992ps      -1.9647663
+ 589.999993ps      -1.9625841
+ 599.999994ps      -1.9630409
+ 609.999995ps      -1.9582718
+ 619.999996ps      -1.9417639
+ 629.999997ps       -1.924523
+ 639.999997ps      -1.9040534
+ 649.999998ps      -1.8912061
+ 659.999999ps      -1.8860071
+ 670.000000ps      -1.8823265
+ 680.000001ps      -1.8868414
+ 690.000002ps      -1.8762778
+ 700.000002ps      -1.8694927
+ 710.000003ps      -1.8647276
+ 720.000004ps      -1.8618502
+ 730.000005ps      -1.8601568
+ 740.000006ps      -1.8534951
+ 750.000007ps      -1.8598007
+ 760.000007ps      -1.8731254
+ 770.000008ps      -1.8844491
+ 780.000009ps      -1.8913792
+ 790.000010ps      -1.8851622
+ 800.000011ps      -1.8733212
+ 810.000012ps      -1.8625277
+ 820.000012ps      -1.8514932
+ 830.000013ps      -1.8436205
+ 840.000014ps      -1.8353544
+ 850.000015ps       -1.833294
+ 860.000016ps      -1.8438994
+ 870.000016ps      -1.8495981
+ 880.000017ps      -1.8565103
+ 890.000018ps      -1.8507763
+ 900.000019ps      -1.8463419
+ 910.000020ps      -1.8415599
+ 920.000021ps      -1.8345002
+ 930.000021ps      -1.8351334
+ 939.999967ps       -1.845731
+ 949.999968ps      -1.8502789
+ 959.999968ps      -1.8535065
+ 969.999969ps      -1.8472182
+ 979.999970ps      -1.8368049
+ 989.999971ps      -1.8273573
+ 999.999972ps      -1.8164847
+ 1009.999973ps      -1.7991711
+ 1019.999973ps       -1.789591
+ 1029.999974ps      -1.7892275
+ 1039.999975ps      -1.7870822
+ 1049.999976ps      -1.7905852
+ 1059.999977ps      -1.7905868
+ 1069.999978ps      -1.7879453
+ 1079.999978ps      -1.7886873
+ 1089.999979ps      -1.7916314
+ 1099.999980ps      -1.7952102
+ 1109.999981ps      -1.7874865
+ 1119.999982ps      -1.7849187
+ 1129.999982ps      -1.7830753
+ 1139.999983ps       -1.782062
+ 1149.999984ps      -1.7770297
+ 1159.999985ps      -1.7732872
+ 1169.999986ps      -1.7613626
+ 1179.999987ps      -1.7490479
+ 1189.999987ps       -1.732377
+ 1199.999988ps      -1.7279923
+ 1209.999989ps      -1.7439803
+ 1219.999990ps      -1.7533234
+ 1229.999991ps      -1.7737078
+ 1239.999992ps      -1.7906914
+ 1249.999992ps      -1.8078132
+ 1259.999993ps      -1.8252049
+ 1269.999994ps      -1.8325321
+ 1279.999995ps      -1.8204999
+ 1289.999996ps      -1.8001736
+ 1299.999997ps      -1.7851361
+ 1309.999997ps      -1.7697207
+ 1319.999998ps      -1.7640634
+ 1329.999999ps      -1.7638544
+ 1340.000000ps      -1.7571572
+ 1350.000001ps      -1.7476407
+ 1360.000002ps      -1.7382779
+ 1370.000002ps      -1.7303398
+ 1380.000003ps      -1.7269554
+ 1390.000004ps      -1.7256111
+ 1400.000005ps      -1.7306918
+ 1410.000006ps      -1.7406475
+ 1420.000006ps      -1.7598188
+ 1430.000007ps      -1.7784404
+ 1440.000008ps      -1.7902224
+ 1450.000009ps      -1.7901906
+ 1460.000010ps      -1.7884305
+ 1470.000011ps      -1.7791262
+ 1480.000011ps      -1.7667705
+ 1490.000012ps      -1.7575564
+ 1500.000013ps      -1.7390724
+ 1510.000014ps       -1.728879
+ 1520.000015ps      -1.7143779
+ 1530.000016ps      -1.7019002
+ 1540.000016ps      -1.6964753
+ 1550.000017ps      -1.6946381
+ 1560.000018ps       -1.695307
+ 1570.000019ps      -1.6970987
+ 1580.000020ps      -1.7043775
+ 1590.000021ps      -1.7103821
+ 1600.000021ps      -1.7208171
+ 1610.000022ps      -1.7316278
+ 1620.000023ps      -1.7194003
+ 1630.000024ps      -1.7061519
+ 1640.000025ps      -1.6921479
+ 1650.000025ps      -1.6855016
+ 1660.000026ps      -1.6795905
+ 1670.000027ps      -1.6797345
+ 1680.000028ps      -1.6873985
+ 1690.000029ps      -1.6985287
+ 1700.000030ps      -1.7052502
+ 1710.000030ps      -1.7006969
+ 1720.000031ps       -1.698685
+ 1730.000032ps      -1.6945989
+ 1740.000033ps      -1.6889507
+ 1750.000034ps      -1.6904266
+ 1760.000035ps      -1.6940442
+ 1770.000035ps      -1.7086551
+ 1780.000036ps      -1.7160557
+ 1790.000037ps      -1.7070054
+ 1800.000038ps      -1.6968564
+ 1810.000039ps      -1.6803299
+ 1820.000040ps      -1.6637963
+ 1830.000040ps      -1.6511091
+ 1840.000041ps      -1.6499572
+ 1850.000042ps      -1.6516938
+ 1860.000043ps      -1.6572443
+ 1869.999933ps      -1.6658363
+ 1879.999934ps      -1.6721242
+ 1889.999934ps        -1.67507
+ 1899.999935ps      -1.6724541
+ 1909.999936ps      -1.6713155
+ 1919.999937ps      -1.6645495
+ 1929.999938ps        -1.64066
+ 1939.999938ps      -1.6288973
+ 1949.999939ps       -1.614488
+ 1959.999940ps      -1.6070015
+ 1969.999941ps      -1.6039672
+ 1979.999942ps       -1.599608
+ 1989.999943ps      -1.6101758
+ 1999.999943ps       -1.618192
+ 2009.999944ps      -1.6298755
+ 2019.999945ps      -1.6409787
+ 2029.999946ps      -1.6552802
+ 2039.999947ps      -1.6618159
+ 2049.999948ps      -1.6663207
+ 2059.999948ps      -1.6654249
+ 2069.999949ps       -1.671069
+ 2079.999950ps      -1.6781919
+ 2089.999951ps      -1.6893377
+ 2099.999952ps      -1.6984913
+ 2109.999953ps      -1.6946703
+ 2119.999953ps      -1.6867444
+ 2129.999954ps       -1.675065
+ 2139.999955ps      -1.6737925
+ 2149.999956ps      -1.6696122
+ 2159.999957ps      -1.6680741
+ 2169.999958ps      -1.6595698
+ 2179.999958ps      -1.6482756
+ 2189.999959ps      -1.6343741
+ 2199.999960ps      -1.6276728
+ 2209.999961ps      -1.6259283
+ 2219.999962ps      -1.6225255
+ 2229.999962ps      -1.6308568
+ 2239.999963ps       -1.624739
+ 2249.999964ps       -1.625534
+ 2259.999965ps      -1.6286171
+ 2269.999966ps      -1.6310469
+ 2279.999967ps      -1.6371936
+ 2289.999967ps      -1.6511979
+ 2299.999968ps      -1.6650425
+ 2309.999969ps      -1.6679022
+ 2319.999970ps      -1.6687624
+ 2329.999971ps      -1.6787068
+ 2339.999972ps      -1.6792845
+ 2349.999972ps       -1.677874
+ 2359.999973ps      -1.6689931
+ 2369.999974ps      -1.6718264
+ 2379.999975ps       -1.678792
+ 2389.999976ps      -1.6898719
+ 2399.999977ps      -1.6937069
+ 2409.999977ps      -1.6938187
+ 2419.999978ps      -1.6895896
+ 2429.999979ps      -1.6900381
+ 2439.999980ps      -1.6798974
+ 2449.999981ps      -1.6815088
+ 2459.999982ps      -1.6836737
+ 2469.999982ps      -1.6881129
+ 2479.999983ps      -1.6889378
+ 2489.999984ps      -1.6883043
+ 2499.999985ps      -1.6897472
+ 2509.999986ps      -1.6867165
+ 2519.999986ps      -1.6919272
+ 2529.999987ps      -1.6921648
+ 2539.999988ps       -1.694715
+ 2549.999989ps      -1.7000299
+ 2559.999990ps      -1.7144098
+ 2569.999991ps      -1.7201962
+ 2579.999991ps      -1.7313044
+ 2589.999992ps      -1.7509409
+ 2599.999993ps      -1.7576688
+ 2609.999994ps      -1.7605288
+ 2619.999995ps      -1.7571936
+ 2629.999996ps      -1.7490476
+ 2639.999996ps      -1.7420578
+ 2649.999997ps      -1.7343635
+ 2659.999998ps      -1.7283131
+ 2669.999999ps      -1.7162893
+ 2680.000000ps      -1.7087689
+ 2690.000001ps      -1.7047133
+ 2700.000001ps      -1.6983148
+ 2710.000002ps       -1.702156
+ 2720.000003ps      -1.6987305
+ 2730.000004ps      -1.6940223
+ 2740.000005ps      -1.6837824
+ 2750.000005ps      -1.6789442
+ 2760.000006ps      -1.6752068
+ 2770.000007ps      -1.6657743
+ 2780.000008ps      -1.6615035
+ 2790.000009ps      -1.6653471
+ 2800.000010ps      -1.6745851
+ 2810.000010ps      -1.6816519
+ 2820.000011ps      -1.6738477
+ 2830.000012ps      -1.6616941
+ 2840.000013ps      -1.6627699
+ 2850.000014ps      -1.6658604
+ 2860.000015ps       -1.660456
+ 2870.000015ps      -1.6662156
+ 2880.000016ps      -1.6766833
+ 2890.000017ps       -1.671749
+ 2900.000018ps      -1.6715283
+ 2910.000019ps       -1.666844
+ 2920.000020ps      -1.6701851
+ 2930.000020ps      -1.6779699
+ 2940.000021ps       -1.689897
+ 2950.000022ps      -1.6966728
+ 2960.000023ps       -1.699096
+ 2970.000024ps       -1.702842
+ 2980.000025ps      -1.6989609
+ 2990.000025ps      -1.6870961
+ 3000.000026ps      -1.6746795
+ 3010.000027ps      -1.6591236
+ 3020.000028ps      -1.6535751
+ 3030.000029ps      -1.6510995
+ 3040.000029ps      -1.6525667
+ 3050.000030ps      -1.6637548
+ 3060.000031ps      -1.6776374
+ 3070.000032ps      -1.6861699
+ 3080.000033ps      -1.6886163
+ 3090.000034ps      -1.6965088
+ 3100.000034ps      -1.7077962
+ 3110.000035ps      -1.7082091
+ 3120.000036ps       -1.713211
+ 3130.000037ps      -1.7183534
+ 3140.000038ps      -1.7288316
+ 3150.000039ps      -1.7426173
+ 3160.000039ps      -1.7433113
+ 3170.000040ps      -1.7414282
+ 3180.000041ps      -1.7399568
+ 3190.000042ps      -1.7316384
+ 3200.000043ps      -1.7198025
+ 3210.000044ps      -1.7038598
+ 3220.000044ps      -1.6973406
+ 3230.000045ps      -1.6906482
+ 3240.000046ps      -1.6927216
+ 3250.000047ps      -1.7015049
+ 3260.000048ps      -1.7100688
+ 3270.000049ps      -1.7194473
+ 3280.000049ps      -1.7229841
+ 3290.000050ps      -1.7206281
+ 3300.000051ps       -1.709637
+ 3310.000052ps      -1.7021106
+ 3320.000053ps      -1.6970062
+ 3330.000053ps      -1.6900468
+ 3340.000054ps      -1.6829273
+ 3350.000055ps      -1.6791377
+ 3360.000056ps      -1.6803742
+ 3370.000057ps      -1.6827641
+ 3380.000058ps       -1.676007
+ 3390.000058ps       -1.660469
+ 3400.000059ps      -1.6480274
+ 3410.000060ps      -1.6381355
+ 3420.000061ps      -1.6266826
+ 3430.000062ps      -1.6229865
+ 3440.000063ps      -1.6141831
+ 3450.000063ps       -1.615402
+ 3460.000064ps      -1.6222073
+ 3470.000065ps      -1.6353818
+ 3480.000066ps      -1.6470953
+ 3490.000067ps      -1.6574891
+ 3500.000068ps      -1.6631461
+ 3510.000068ps      -1.6693888
+ 3520.000069ps       -1.668313
+ 3530.000070ps       -1.663288
+ 3540.000071ps      -1.6629622
+ 3550.000072ps      -1.6649515
+ 3560.000073ps      -1.6705879
+ 3570.000073ps      -1.6698618
+ 3580.000074ps      -1.6754776
+ 3590.000075ps      -1.6780365
+ 3600.000076ps      -1.6783395
+ 3610.000077ps      -1.6728909
+ 3620.000077ps      -1.6719791
+ 3630.000078ps      -1.6716782
+ 3640.000079ps      -1.6732153
+ 3650.000080ps      -1.6826247
+ 3660.000081ps      -1.6929873
+ 3670.000082ps      -1.7035841
+ 3680.000082ps      -1.7048886
+ 3690.000083ps      -1.7039972
+ 3700.000084ps       -1.707637
+ 3710.000085ps      -1.7061313
+ 3720.000086ps      -1.7098797
+ 3729.999865ps      -1.7067728
+ 3739.999865ps      -1.6916612
+ 3749.999866ps      -1.6757611
+ 3759.999867ps      -1.6619551
+ 3769.999868ps      -1.6545395
+ 3779.999869ps      -1.6432286
+ 3789.999869ps      -1.6351768
+ 3799.999870ps      -1.6297659
+ 3809.999871ps      -1.6259047
+ 3819.999872ps      -1.6274719
+ 3829.999873ps      -1.6314537
+ 3839.999874ps      -1.6404313
+ 3849.999874ps      -1.6380146
+ 3859.999875ps      -1.6360681
+ 3869.999876ps      -1.6367267
+ 3879.999877ps      -1.6297129
+ 3889.999878ps      -1.6277107
+ 3899.999879ps      -1.6285735
+ 3909.999879ps      -1.6282525
+ 3919.999880ps       -1.622761
+ 3929.999881ps      -1.6133495
+ 3939.999882ps      -1.6071063
+ 3949.999883ps      -1.6082085
+ 3959.999884ps      -1.6085461
+ 3969.999884ps      -1.6152305
+ 3979.999885ps      -1.6242858
+ 3989.999886ps      -1.6408486
+ 3999.999887ps      -1.6813671
+ 4009.999888ps      -1.7318913
+ 4019.999889ps      -1.7948843
+ 4029.999889ps      -1.8530156
+ 4039.999890ps      -1.9007813
+ 4049.999891ps       -1.936903
+ 4059.999892ps      -1.9705395
+ 4069.999893ps      -1.9948978
+ 4079.999893ps      -2.0229985
+ 4089.999894ps      -2.0393321
+ 4099.999895ps      -2.0527399
+ 4109.999896ps      -2.0782712
+ 4119.999897ps      -2.0940006
+ 4129.999898ps      -2.1160643
+ 4139.999898ps       -2.139684
+ 4149.999899ps      -2.1460604
+ 4159.999900ps      -2.1454018
+ 4169.999901ps      -2.1479686
+ 4179.999902ps      -2.1473729
+ 4189.999903ps      -2.1430354
+ 4199.999903ps      -2.1298353
+ 4209.999904ps      -2.1227389
+ 4219.999905ps      -2.1041537
+ 4229.999906ps      -2.0818544
+ 4239.999907ps      -2.0754454
+ 4249.999908ps      -2.0732034
+ 4259.999908ps      -2.0858554
+ 4269.999909ps      -2.0941329
+ 4279.999910ps      -2.1145289
+ 4289.999911ps      -2.1306892
+ 4299.999912ps      -2.1434466
+ 4309.999913ps      -2.1600996
+ 4319.999913ps      -2.1680239
+ 4329.999914ps      -2.1590485
+ 4339.999915ps      -2.1478911
+ 4349.999916ps      -2.1375523
+ 4359.999917ps      -2.1408822
+ 4369.999917ps      -2.1363668
+ 4379.999918ps       -2.123169
+ 4389.999919ps      -2.1130853
+ 4399.999920ps       -2.102704
+ 4409.999921ps      -2.0947204
+ 4419.999922ps      -2.1009433
+ 4429.999922ps      -2.1235104
+ 4439.999923ps      -2.1425015
+ 4449.999924ps      -2.1531904
+ 4459.999925ps      -2.1661568
+ 4469.999926ps      -2.1683362
+ 4479.999927ps      -2.1791233
+ 4489.999927ps      -2.1900549
+ 4499.999928ps      -2.2000327
+ 4509.999929ps      -2.2077063
+ 4519.999930ps      -2.2034931
+ 4529.999931ps      -2.2082757
+ 4539.999932ps      -2.2029801
+ 4549.999932ps      -2.1874958
+ 4559.999933ps      -2.1721067
+ 4569.999934ps      -2.1634976
+ 4579.999935ps      -2.1603045
+ 4589.999936ps      -2.1637776
+ 4599.999937ps      -2.1609682
+ 4609.999937ps      -2.1541839
+ 4619.999938ps       -2.140115
+ 4629.999939ps      -2.1226786
+ 4639.999940ps      -2.1042054
+ 4649.999941ps      -2.0960337
+ 4659.999941ps       -2.093848
+ 4669.999942ps      -2.0827624
+ 4679.999943ps      -2.0873363
+ 4689.999944ps      -2.0819713
+ 4699.999945ps      -2.0745764
+ 4709.999946ps      -2.0714035
+ 4719.999946ps      -2.0664037
+ 4729.999947ps      -2.0588873
+ 4739.999948ps      -2.0521002
+ 4749.999949ps      -2.0607159
+ 4759.999950ps      -2.0648094
+ 4769.999951ps      -2.0773463
+ 4779.999951ps      -2.0786362
+ 4789.999952ps      -2.0695875
+ 4799.999953ps      -2.0547536
+ 4809.999954ps      -2.0410906
+ 4819.999955ps      -2.0229031
+ 4829.999956ps      -2.0189546
+ 4839.999956ps      -2.0057854
+ 4849.999957ps      -2.0049326
+ 4859.999958ps      -2.0019128
+ 4869.999959ps      -1.9989727
+ 4879.999960ps      -2.0011329
+ 4889.999961ps      -2.0071706
+ 4899.999961ps      -1.9981759
+ 4909.999962ps      -1.9963537
+ 4919.999963ps      -1.9962867
+ 4929.999964ps      -1.9900598
+ 4939.999965ps      -2.0013431
+ 4949.999965ps      -2.0056041
+ 4959.999966ps       -1.996549
+ 4969.999967ps      -1.9855102
+ 4979.999968ps      -1.9661269
+ 4989.999969ps      -1.9502047
+ 4999.999970ps      -1.9245721
+ 5009.999970ps      -1.8896485
+ 5019.999971ps      -1.8625831
+ 5029.999972ps      -1.8443049
+ 5039.999973ps       -1.831126
+ 5049.999974ps      -1.8147131
+ 5059.999975ps      -1.8017428
+ 5069.999975ps      -1.7864638
+ 5079.999976ps      -1.7712196
+ 5089.999977ps      -1.7645692
+ 5099.999978ps      -1.7515864
+ 5109.999979ps       -1.733454
+ 5119.999980ps      -1.7193759
+ 5129.999980ps      -1.7038788
+ 5139.999981ps       -1.701385
+ 5149.999982ps      -1.6942983
+ 5159.999983ps      -1.6846186
+ 5169.999984ps      -1.6662559
+ 5179.999985ps       -1.645267
+ 5189.999985ps      -1.6303171
+ 5199.999986ps      -1.6262883
+ 5209.999987ps      -1.6329153
+ 5219.999988ps      -1.6469643
+ 5229.999989ps      -1.6576427
+ 5239.999989ps      -1.6765446
+ 5249.999990ps      -1.6975328
+ 5259.999991ps      -1.7116416
+ 5269.999992ps      -1.7131258
+ 5279.999993ps      -1.7005803
+ 5289.999994ps      -1.6860508
+ 5299.999994ps      -1.6651886
+ 5309.999995ps      -1.6524108
+ 5319.999996ps      -1.6400532
+ 5329.999997ps      -1.6376787
+ 5339.999998ps      -1.6269915
+ 5349.999999ps      -1.6105011
+ 5359.999999ps      -1.6026861
+ 5370.000000ps      -1.6001448
+ 5380.000001ps      -1.5960349
+ 5390.000002ps      -1.5954361
+ 5400.000003ps        -1.60065
+ 5410.000004ps      -1.6148201
+ 5420.000004ps      -1.6347381
+ 5430.000005ps      -1.6465891
+ 5440.000006ps      -1.6597392
+ 5450.000007ps      -1.6635637
+ 5460.000008ps      -1.6534081
+ 5470.000009ps      -1.6411649
+ 5480.000009ps      -1.6266293
+ 5490.000010ps      -1.6124451
+ 5500.000011ps      -1.6001947
+ 5510.000012ps      -1.5896732
+ 5520.000013ps      -1.5764064
+ 5530.000013ps      -1.5615188
+ 5540.000014ps      -1.5571533
+ 5550.000015ps       -1.551866
+ 5560.000016ps      -1.5548325
+ 5570.000017ps      -1.5546899
+ 5580.000018ps      -1.5663674
+ 5590.000018ps      -1.5745069
+ 5600.000019ps      -1.5847499
+ 5610.000020ps      -1.5897598
+ 5620.000021ps      -1.5804458
+ 5630.000022ps      -1.5710092
+ 5640.000023ps      -1.5540819
+ 5650.000023ps      -1.5422476
+ 5660.000024ps      -1.5384572
+ 5670.000025ps      -1.5385915
+ 5680.000026ps      -1.5453283
+ 5690.000027ps       -1.557806
+ 5700.000028ps      -1.5641489
+ 5710.000028ps      -1.5626625
+ 5720.000029ps      -1.5548683
+ 5730.000030ps      -1.5492643
+ 5740.000031ps       -1.546191
+ 5750.000032ps      -1.5483996
+ 5760.000033ps      -1.5524075
+ 5770.000033ps      -1.5622717
+ 5780.000034ps      -1.5636762
+ 5790.000035ps      -1.5565027
+ 5800.000036ps      -1.5512227
+ 5810.000037ps      -1.5345953
+ 5820.000037ps      -1.5178247
+ 5830.000038ps      -1.5042004
+ 5840.000039ps      -1.4973513
+ 5850.000040ps      -1.5022157
+ 5860.000041ps      -1.5099619
+ 5870.000042ps      -1.5197804
+ 5880.000042ps      -1.5255094
+ 5890.000043ps      -1.5279109
+ 5900.000044ps      -1.5248698
+ 5910.000045ps       -1.521815
+ 5920.000046ps      -1.5152448
+ 5930.000047ps      -1.4976813
+ 5940.000047ps      -1.4826748
+ 5950.000048ps      -1.4781809
+ 5960.000049ps      -1.4695976
+ 5970.000050ps      -1.4574788
+ 5980.000051ps      -1.4602191
+ 5990.000052ps      -1.4666702
+ 6000.000052ps      -1.4786112
+ 6010.000053ps      -1.4879682
+ 6020.000054ps      -1.4976548
+ 6030.000055ps      -1.5093924
+ 6040.000056ps      -1.5151594
+ 6050.000056ps       -1.523552
+ 6060.000057ps      -1.5293487
+ 6070.000058ps      -1.5312764
+ 6080.000059ps      -1.5373281
+ 6090.000060ps      -1.5529485
+ 6100.000061ps       -1.556518
+ 6110.000061ps       -1.552546
+ 6120.000062ps      -1.5461602
+ 6130.000063ps      -1.5352637
+ 6140.000064ps       -1.529803
+ 6150.000065ps      -1.5262176
+ 6160.000066ps      -1.5190393
+ 6170.000066ps      -1.5101171
+ 6180.000067ps      -1.4987494
+ 6190.000068ps      -1.4891311
+ 6200.000069ps      -1.4841579
+ 6210.000070ps      -1.4810159
+ 6220.000071ps      -1.4784727
+ 6230.000071ps      -1.4808026
+ 6240.000072ps      -1.4795112
+ 6250.000073ps      -1.4799428
+ 6260.000074ps      -1.4872304
+ 6270.000075ps      -1.4897551
+ 6280.000076ps      -1.5004744
+ 6290.000076ps      -1.5059933
+ 6300.000077ps       -1.515802
+ 6310.000078ps      -1.5210476
+ 6320.000079ps      -1.5256832
+ 6330.000080ps      -1.5240458
+ 6340.000080ps       -1.522509
+ 6350.000081ps      -1.5250463
+ 6360.000082ps      -1.5191695
+ 6370.000083ps       -1.520913
+ 6380.000084ps      -1.5228017
+ 6390.000085ps       -1.534113
+ 6400.000085ps      -1.5418066
+ 6410.000086ps      -1.5348556
+ 6420.000087ps      -1.5297591
+ 6430.000088ps      -1.5323756
+ 6440.000089ps      -1.5304894
+ 6450.000090ps      -1.5336403
+ 6460.000090ps      -1.5342297
+ 6470.000091ps      -1.5351003
+ 6480.000092ps      -1.5398009
+ 6490.000093ps      -1.5335073
+ 6500.000094ps      -1.5366372
+ 6510.000095ps      -1.5380903
+ 6520.000095ps      -1.5406915
+ 6530.000096ps      -1.5449655
+ 6540.000097ps      -1.5486821
+ 6550.000098ps      -1.5522874
+ 6560.000099ps      -1.5662449
+ 6570.000100ps      -1.5726706
+ 6580.000100ps         -1.5831
+ 6590.000101ps      -1.5884048
+ 6600.000102ps      -1.6018972
+ 6610.000103ps      -1.6022722
+ 6620.000104ps      -1.6018507
+ 6630.000104ps      -1.5949515
+ 6640.000105ps      -1.5913256
+ 6650.000106ps      -1.5856836
+ 6660.000107ps      -1.5788942
+ 6670.000108ps      -1.5712112
+ 6680.000109ps      -1.5655658
+ 6690.000109ps      -1.5618401
+ 6700.000110ps       -1.553101
+ 6710.000111ps       -1.555848
+ 6720.000112ps      -1.5499559
+ 6730.000113ps      -1.5393128
+ 6740.000114ps      -1.5241123
+ 6750.000114ps      -1.5227449
+ 6760.000115ps       -1.523794
+ 6770.000116ps      -1.5151295
+ 6780.000117ps       -1.512098
+ 6790.000118ps      -1.5228599
+ 6800.000119ps      -1.5277792
+ 6810.000119ps      -1.5339157
+ 6820.000120ps      -1.5328959
+ 6830.000121ps      -1.5247424
+ 6840.000122ps      -1.5247144
+ 6850.000123ps      -1.5267783
+ 6860.000124ps      -1.5229221
+ 6870.000124ps      -1.5221017
+ 6880.000125ps      -1.5279253
+ 6890.000126ps      -1.5263051
+ 6900.000127ps      -1.5274472
+ 6910.000128ps      -1.5330794
+ 6920.000128ps      -1.5303365
+ 6930.000129ps      -1.5340591
+ 6940.000130ps       -1.541075
+ 6950.000131ps       -1.553188
+ 6960.000132ps      -1.5586989
+ 6970.000133ps      -1.5574867
+ 6980.000133ps      -1.5596613
+ 6990.000134ps      -1.5525238
+ 7000.000135ps      -1.5388277
+ 7010.000136ps      -1.5232002
+ 7020.000137ps      -1.5119673
+ 7030.000138ps      -1.5117026
+ 7040.000138ps      -1.5122529
+ 7050.000139ps       -1.522562
+ 7060.000140ps      -1.5335927
+ 7070.000141ps      -1.5423533
+ 7080.000142ps      -1.5440494
+ 7090.000143ps      -1.5502668
+ 7100.000143ps      -1.5614299
+ 7110.000144ps      -1.5645006
+ 7120.000145ps      -1.5654558
+ 7130.000146ps      -1.5725487
+ 7140.000147ps      -1.5836215
+ 7150.000147ps      -1.5960787
+ 7160.000148ps      -1.5999591
+ 7170.000149ps      -1.6017353
+ 7180.000150ps      -1.5974822
+ 7190.000151ps      -1.5916513
+ 7200.000152ps      -1.5797964
+ 7210.000152ps      -1.5655933
+ 7220.000153ps      -1.5571635
+ 7230.000154ps      -1.5538349
+ 7240.000155ps      -1.5511466
+ 7250.000156ps       -1.555658
+ 7260.000157ps      -1.5693286
+ 7270.000157ps      -1.5781452
+ 7280.000158ps      -1.5828778
+ 7290.000159ps      -1.5813411
+ 7300.000160ps      -1.5699102
+ 7310.000161ps      -1.5624522
+ 7320.000162ps      -1.5521386
+ 7330.000162ps      -1.5456772
+ 7340.000163ps      -1.5415709
+ 7350.000164ps      -1.5326528
+ 7360.000165ps      -1.5212649
+ 7370.000166ps      -1.5270476
+ 7380.000167ps      -1.5234121
+ 7390.000167ps      -1.5064948
+ 7400.000168ps      -1.4979326
+ 7410.000169ps      -1.4831323
+ 7420.000170ps      -1.4750042
+ 7430.000171ps      -1.4692952
+ 7440.000171ps      -1.4651405
+ 7450.000172ps      -1.4692534
+ 7459.999729ps      -1.4753844
+ 7469.999730ps      -1.4877979
+ 7479.999731ps      -1.5062443
+ 7489.999732ps      -1.5151937
+ 7499.999732ps      -1.5157343
+ 7509.999733ps      -1.5185049
+ 7519.999734ps      -1.5220721
+ 7529.999735ps      -1.5209865
+ 7539.999736ps      -1.5173567
+ 7549.999737ps      -1.5179989
+ 7559.999737ps      -1.5206169
+ 7569.999738ps      -1.5235615
+ 7579.999739ps       -1.529707
+ 7589.999740ps      -1.5358542
+ 7599.999741ps      -1.5335315
+ 7609.999741ps      -1.5256702
+ 7619.999742ps      -1.5253572
+ 7629.999743ps      -1.5229028
+ 7639.999744ps      -1.5226045
+ 7649.999745ps      -1.5275334
+ 7659.999746ps      -1.5441989
+ 7669.999746ps      -1.5569512
+ 7679.999747ps      -1.5633683
+ 7689.999748ps      -1.5601298
+ 7699.999749ps      -1.5640581
+ 7709.999750ps      -1.5619369
+ 7719.999751ps      -1.5615546
+ 7729.999751ps      -1.5519964
+ 7739.999752ps      -1.5378513
+ 7749.999753ps      -1.5259121
+ 7759.999754ps      -1.5123585
+ 7769.999755ps       -1.502301
+ 7779.999756ps      -1.4962916
+ 7789.999756ps      -1.4898841
+ 7799.999757ps      -1.4854384
+ 7809.999758ps      -1.4814232
+ 7819.999759ps      -1.4809498
+ 7829.999760ps      -1.4778346
+ 7839.999761ps       -1.484074
+ 7849.999761ps      -1.4881493
+ 7859.999762ps      -1.4895786
+ 7869.999763ps      -1.4915461
+ 7879.999764ps      -1.4854123
+ 7889.999765ps      -1.4865987
+ 7899.999765ps       -1.487372
+ 7909.999766ps      -1.4827887
+ 7919.999767ps      -1.4800033
+ 7929.999768ps      -1.4754265
+ 7939.999769ps      -1.4732329
+ 7949.999770ps      -1.4716098
+ 7959.999770ps      -1.4696174
+ 7969.999771ps      -1.4757599
+ 7979.999772ps      -1.4896539
+ 7989.999773ps      -1.5182633
+)

Icursig17 PAR_2_2_VDD075CPU 0 pwl(
+ 0.000000ps       1.0742759
+ 10.000000ps       1.1096957
+ 20.000000ps       1.1956619
+ 29.999999ps       1.2988022
+ 40.000000ps       1.4028589
+ 50.000001ps       1.4956825
+ 59.999998ps       1.5781098
+ 69.999999ps       1.6528627
+ 80.000000ps       1.7191657
+ 90.000001ps       1.7764709
+ 100.000001ps       1.8241921
+ 110.000002ps       1.8723118
+ 119.999996ps        1.915433
+ 129.999997ps        1.951988
+ 139.999998ps       1.9718475
+ 149.999999ps       1.9867831
+ 159.999999ps       1.9907439
+ 170.000000ps       2.0008792
+ 180.000001ps       2.0077539
+ 190.000002ps       2.0200083
+ 200.000003ps       2.0318253
+ 210.000003ps       2.0426816
+ 220.000004ps       2.0546399
+ 230.000005ps       2.0618375
+ 239.999992ps       2.0782671
+ 249.999993ps       2.1010233
+ 259.999994ps       2.1307618
+ 269.999995ps       2.1594768
+ 279.999995ps       2.1910376
+ 289.999996ps       2.2151221
+ 299.999997ps       2.2394516
+ 309.999998ps       2.2543588
+ 319.999999ps       2.2590617
+ 330.000000ps        2.249548
+ 340.000000ps       2.2473999
+ 350.000001ps       2.2485642
+ 360.000002ps       2.2623415
+ 370.000003ps       2.2642329
+ 380.000004ps       2.2556205
+ 390.000005ps       2.2429828
+ 400.000005ps       2.2373778
+ 410.000006ps       2.2411442
+ 420.000007ps       2.2519339
+ 430.000008ps        2.271357
+ 440.000009ps       2.2851571
+ 450.000009ps       2.2988769
+ 460.000010ps       2.3094694
+ 469.999983ps        2.314006
+ 479.999984ps       2.3233435
+ 489.999985ps       2.3359815
+ 499.999986ps        2.348805
+ 509.999987ps       2.3645699
+ 519.999988ps       2.3687946
+ 529.999988ps       2.3732375
+ 539.999989ps       2.3677062
+ 549.999990ps       2.3480323
+ 559.999991ps       2.3276587
+ 569.999992ps       2.3110717
+ 579.999992ps       2.3022724
+ 589.999993ps       2.3027548
+ 599.999994ps       2.3029596
+ 609.999995ps        2.299174
+ 619.999996ps         2.28679
+ 629.999997ps       2.2703084
+ 639.999997ps       2.2477638
+ 649.999998ps       2.2399354
+ 659.999999ps       2.2446593
+ 670.000000ps        2.246538
+ 680.000001ps       2.2428882
+ 690.000002ps       2.2391971
+ 700.000002ps       2.2335085
+ 710.000003ps       2.2278042
+ 720.000004ps        2.221512
+ 730.000005ps       2.2139032
+ 740.000006ps       2.2118094
+ 750.000007ps       2.2136034
+ 760.000007ps       2.2222835
+ 770.000008ps       2.2282398
+ 780.000009ps       2.2275029
+ 790.000010ps       2.2235208
+ 800.000011ps       2.2138665
+ 810.000012ps       2.1974912
+ 820.000012ps       2.1819306
+ 830.000013ps       2.1701533
+ 840.000014ps       2.1616103
+ 850.000015ps       2.1646148
+ 860.000016ps       2.1649197
+ 870.000016ps       2.1675195
+ 880.000017ps         2.16359
+ 890.000018ps        2.165266
+ 900.000019ps       2.1614528
+ 910.000020ps       2.1637102
+ 920.000021ps       2.1678289
+ 930.000021ps       2.1725132
+ 939.999967ps       2.1799081
+ 949.999968ps        2.182637
+ 959.999968ps       2.1745057
+ 969.999969ps       2.1618369
+ 979.999970ps       2.1449298
+ 989.999971ps       2.1208134
+ 999.999972ps       2.0952463
+ 1009.999973ps       2.0748086
+ 1019.999973ps       2.0594557
+ 1029.999974ps       2.0536611
+ 1039.999975ps       2.0460801
+ 1049.999976ps       2.0428206
+ 1059.999977ps       2.0381369
+ 1069.999978ps       2.0287207
+ 1079.999978ps       2.0212942
+ 1089.999979ps       2.0133861
+ 1099.999980ps       1.9990025
+ 1109.999981ps       1.9786549
+ 1119.999982ps       1.9516246
+ 1129.999982ps        1.934123
+ 1139.999983ps       1.9243542
+ 1149.999984ps       1.9076319
+ 1159.999985ps       1.8907884
+ 1169.999986ps       1.8661698
+ 1179.999987ps        1.844772
+ 1189.999987ps       1.8252938
+ 1199.999988ps       1.8261812
+ 1209.999989ps       1.8358432
+ 1219.999990ps       1.8534002
+ 1229.999991ps       1.8689907
+ 1239.999992ps       1.8877136
+ 1249.999992ps       1.9038017
+ 1259.999993ps       1.9118967
+ 1269.999994ps       1.9012701
+ 1279.999995ps       1.8762096
+ 1289.999996ps       1.8485644
+ 1299.999997ps       1.8248892
+ 1309.999997ps       1.8130255
+ 1319.999998ps       1.8034381
+ 1329.999999ps        1.795123
+ 1340.000000ps       1.7817269
+ 1350.000001ps       1.7621081
+ 1360.000002ps       1.7427577
+ 1370.000002ps       1.7347503
+ 1380.000003ps       1.7356344
+ 1390.000004ps       1.7408537
+ 1400.000005ps       1.7512774
+ 1410.000006ps       1.7617691
+ 1420.000006ps       1.7776424
+ 1430.000007ps       1.7888588
+ 1440.000008ps       1.7903407
+ 1450.000009ps       1.7833624
+ 1460.000010ps       1.7650052
+ 1470.000011ps       1.7448008
+ 1480.000011ps       1.7272442
+ 1490.000012ps       1.7176325
+ 1500.000013ps       1.7131533
+ 1510.000014ps       1.7049789
+ 1520.000015ps       1.6839087
+ 1530.000016ps       1.6690149
+ 1540.000016ps        1.665171
+ 1550.000017ps       1.6618836
+ 1560.000018ps       1.6691763
+ 1570.000019ps       1.6787559
+ 1580.000020ps       1.6948781
+ 1590.000021ps          1.7113
+ 1600.000021ps       1.7274475
+ 1610.000022ps       1.7300793
+ 1620.000023ps       1.7198543
+ 1630.000024ps       1.7066065
+ 1640.000025ps        1.680251
+ 1650.000025ps       1.6598599
+ 1660.000026ps       1.6537197
+ 1670.000027ps       1.6596952
+ 1680.000028ps       1.6749796
+ 1690.000029ps       1.6839988
+ 1700.000030ps       1.6865985
+ 1710.000030ps       1.6745129
+ 1720.000031ps       1.6728289
+ 1730.000032ps       1.6726085
+ 1740.000033ps       1.6750065
+ 1750.000034ps       1.6789973
+ 1760.000035ps       1.6835039
+ 1770.000035ps       1.6960434
+ 1780.000036ps       1.7020013
+ 1790.000037ps       1.7052961
+ 1800.000038ps       1.6933764
+ 1810.000039ps       1.6699876
+ 1820.000040ps        1.648869
+ 1830.000040ps       1.6402131
+ 1840.000041ps       1.6420962
+ 1850.000042ps       1.6533083
+ 1860.000043ps        1.664952
+ 1869.999933ps       1.6710091
+ 1879.999934ps       1.6712653
+ 1889.999934ps       1.6671968
+ 1899.999935ps       1.6661484
+ 1909.999936ps       1.6591594
+ 1919.999937ps       1.6480333
+ 1929.999938ps       1.6287208
+ 1939.999938ps       1.6133296
+ 1949.999939ps       1.6001139
+ 1959.999940ps       1.5930429
+ 1969.999941ps       1.5924001
+ 1979.999942ps       1.6023311
+ 1989.999943ps       1.6173601
+ 1999.999943ps        1.635953
+ 2009.999944ps       1.6531149
+ 2019.999945ps       1.6690437
+ 2029.999946ps       1.6837992
+ 2039.999947ps       1.6911798
+ 2049.999948ps       1.6890389
+ 2059.999948ps       1.6857785
+ 2069.999949ps       1.6910034
+ 2079.999950ps       1.6939635
+ 2089.999951ps       1.7004261
+ 2099.999952ps       1.6921462
+ 2109.999953ps       1.6776379
+ 2119.999953ps       1.6539564
+ 2129.999954ps       1.6396929
+ 2139.999955ps       1.6331118
+ 2149.999956ps       1.6254027
+ 2159.999957ps       1.6170564
+ 2169.999958ps        1.606027
+ 2179.999958ps       1.5978086
+ 2189.999959ps        1.589628
+ 2199.999960ps       1.5874916
+ 2209.999961ps       1.5899211
+ 2219.999962ps       1.5928503
+ 2229.999962ps       1.5909857
+ 2239.999963ps       1.5937036
+ 2249.999964ps       1.5992864
+ 2259.999965ps       1.6070399
+ 2269.999966ps       1.6173366
+ 2279.999967ps       1.6318399
+ 2289.999967ps       1.6435158
+ 2299.999968ps       1.6538634
+ 2309.999969ps       1.6562092
+ 2319.999970ps       1.6575353
+ 2329.999971ps       1.6492913
+ 2339.999972ps       1.6411207
+ 2349.999972ps       1.6269899
+ 2359.999973ps       1.6230339
+ 2369.999974ps       1.6298752
+ 2379.999975ps       1.6410074
+ 2389.999976ps       1.6486426
+ 2399.999977ps       1.6557984
+ 2409.999977ps       1.6580312
+ 2419.999978ps        1.660539
+ 2429.999979ps       1.6631839
+ 2439.999980ps       1.6683259
+ 2449.999981ps       1.6763352
+ 2459.999982ps       1.6830909
+ 2469.999982ps       1.6886792
+ 2479.999983ps       1.6949866
+ 2489.999984ps       1.6884891
+ 2499.999985ps       1.6800121
+ 2509.999986ps       1.6638484
+ 2519.999986ps       1.6598501
+ 2529.999987ps       1.6565239
+ 2539.999988ps       1.6607465
+ 2549.999989ps       1.6716099
+ 2559.999990ps       1.6846544
+ 2569.999991ps       1.6993743
+ 2579.999991ps       1.7158497
+ 2589.999992ps       1.7285951
+ 2599.999993ps       1.7408516
+ 2609.999994ps       1.7464055
+ 2619.999995ps       1.7449768
+ 2629.999996ps       1.7319591
+ 2639.999996ps       1.7199117
+ 2649.999997ps       1.7103591
+ 2659.999998ps       1.6975589
+ 2669.999999ps       1.6851472
+ 2680.000000ps       1.6800573
+ 2690.000001ps       1.6705277
+ 2700.000001ps       1.6630292
+ 2710.000002ps       1.6541781
+ 2720.000003ps       1.6475116
+ 2730.000004ps       1.6317969
+ 2740.000005ps       1.6263446
+ 2750.000005ps       1.6298764
+ 2760.000006ps        1.631271
+ 2770.000007ps       1.6307975
+ 2780.000008ps       1.6326013
+ 2790.000009ps       1.6384715
+ 2800.000010ps       1.6433303
+ 2810.000010ps       1.6450732
+ 2820.000011ps       1.6412762
+ 2830.000012ps        1.636396
+ 2840.000013ps       1.6362791
+ 2850.000014ps       1.6428263
+ 2860.000015ps       1.6529367
+ 2870.000015ps       1.6564925
+ 2880.000016ps       1.6560023
+ 2890.000017ps       1.6488581
+ 2900.000018ps       1.6454689
+ 2910.000019ps       1.6423844
+ 2920.000020ps       1.6402766
+ 2930.000020ps       1.6423432
+ 2940.000021ps       1.6497683
+ 2950.000022ps       1.6563691
+ 2960.000023ps       1.6640146
+ 2970.000024ps       1.6652291
+ 2980.000025ps       1.6699174
+ 2990.000025ps       1.6649933
+ 3000.000026ps       1.6560768
+ 3010.000027ps       1.6429192
+ 3020.000028ps       1.6353195
+ 3030.000029ps       1.6365627
+ 3040.000029ps       1.6453082
+ 3050.000030ps       1.6616357
+ 3060.000031ps        1.675329
+ 3070.000032ps        1.686201
+ 3080.000033ps       1.6879555
+ 3090.000034ps       1.6960851
+ 3100.000034ps       1.7026142
+ 3110.000035ps       1.7061215
+ 3120.000036ps       1.7076039
+ 3130.000037ps       1.7145847
+ 3140.000038ps        1.724756
+ 3150.000039ps       1.7296277
+ 3160.000039ps       1.7348147
+ 3170.000040ps        1.729924
+ 3180.000041ps       1.7230645
+ 3190.000042ps       1.7119979
+ 3200.000043ps       1.7010237
+ 3210.000044ps       1.6888648
+ 3220.000044ps       1.6817755
+ 3230.000045ps       1.6805033
+ 3240.000046ps       1.6812544
+ 3250.000047ps       1.6923273
+ 3260.000048ps       1.7008726
+ 3270.000049ps       1.7137897
+ 3280.000049ps       1.7190124
+ 3290.000050ps       1.7178715
+ 3300.000051ps       1.7026641
+ 3310.000052ps       1.6852908
+ 3320.000053ps       1.6663308
+ 3330.000053ps       1.6516557
+ 3340.000054ps       1.6413595
+ 3350.000055ps       1.6366465
+ 3360.000056ps       1.6351732
+ 3370.000057ps         1.63331
+ 3380.000058ps       1.6261408
+ 3390.000058ps       1.6123774
+ 3400.000059ps       1.6066699
+ 3410.000060ps       1.5918481
+ 3420.000061ps       1.5846729
+ 3430.000062ps       1.5780647
+ 3440.000063ps       1.5740073
+ 3450.000063ps       1.5766995
+ 3460.000064ps       1.5840142
+ 3470.000065ps       1.5988529
+ 3480.000066ps        1.613625
+ 3490.000067ps       1.6193302
+ 3500.000068ps       1.6151875
+ 3510.000068ps       1.6145208
+ 3520.000069ps        1.614548
+ 3530.000070ps       1.6157014
+ 3540.000071ps       1.6169076
+ 3550.000072ps        1.619873
+ 3560.000073ps       1.6249218
+ 3570.000073ps       1.6317862
+ 3580.000074ps       1.6416908
+ 3590.000075ps       1.6438215
+ 3600.000076ps       1.6421194
+ 3610.000077ps       1.6314509
+ 3620.000077ps       1.6261607
+ 3630.000078ps       1.6272979
+ 3640.000079ps       1.6362417
+ 3650.000080ps       1.6503357
+ 3660.000081ps       1.6702436
+ 3670.000082ps       1.6773604
+ 3680.000082ps       1.6863198
+ 3690.000083ps       1.6897476
+ 3700.000084ps        1.691188
+ 3710.000085ps       1.6884691
+ 3720.000086ps       1.6794276
+ 3729.999865ps       1.6644422
+ 3739.999865ps       1.6472246
+ 3749.999866ps       1.6265888
+ 3759.999867ps       1.6067912
+ 3769.999868ps       1.5945835
+ 3779.999869ps       1.5911285
+ 3789.999869ps        1.589084
+ 3799.999870ps        1.590182
+ 3809.999871ps       1.5948362
+ 3819.999872ps       1.6021664
+ 3829.999873ps       1.6075049
+ 3839.999874ps       1.6137286
+ 3849.999874ps       1.6176045
+ 3859.999875ps        1.624778
+ 3869.999876ps       1.6332656
+ 3879.999877ps       1.6382728
+ 3889.999878ps       1.6445959
+ 3899.999879ps       1.6344224
+ 3909.999879ps       1.6211912
+ 3919.999880ps        1.597432
+ 3929.999881ps       1.5852415
+ 3939.999882ps       1.5742904
+ 3949.999883ps       1.5742947
+ 3959.999884ps       1.5810703
+ 3969.999884ps        1.591806
+ 3979.999885ps        1.597253
+ 3989.999886ps       1.6072937
+ 3999.999887ps       1.6461756
+ 4009.999888ps       1.6910227
+ 4019.999889ps       1.7113563
+ 4029.999889ps       1.7148032
+ 4039.999890ps       1.7089824
+ 4049.999891ps        1.707174
+ 4059.999892ps       1.7111523
+ 4069.999893ps       1.7193233
+ 4079.999893ps       1.7311536
+ 4089.999894ps        1.745296
+ 4099.999895ps        1.754382
+ 4109.999896ps       1.7655256
+ 4119.999897ps       1.7828549
+ 4129.999898ps       1.8005642
+ 4139.999898ps       1.8096545
+ 4149.999899ps       1.8182414
+ 4159.999900ps       1.8200119
+ 4169.999901ps       1.8168432
+ 4179.999902ps       1.8092562
+ 4189.999903ps       1.8008116
+ 4199.999903ps       1.7846532
+ 4209.999904ps       1.7708793
+ 4219.999905ps       1.7603575
+ 4229.999906ps        1.757822
+ 4239.999907ps       1.7651152
+ 4249.999908ps       1.7779918
+ 4259.999908ps       1.7905495
+ 4269.999909ps       1.8044224
+ 4279.999910ps       1.8180286
+ 4289.999911ps       1.8358097
+ 4299.999912ps       1.8548509
+ 4309.999913ps       1.8617663
+ 4319.999913ps       1.8649886
+ 4329.999914ps       1.8513896
+ 4339.999915ps       1.8407593
+ 4349.999916ps       1.8382167
+ 4359.999917ps       1.8449004
+ 4369.999917ps       1.8410197
+ 4379.999918ps       1.8291019
+ 4389.999919ps       1.8139022
+ 4399.999920ps       1.8123394
+ 4409.999921ps       1.8203209
+ 4419.999922ps       1.8326498
+ 4429.999922ps       1.8488043
+ 4439.999923ps       1.8606073
+ 4449.999924ps       1.8722692
+ 4459.999925ps       1.8791154
+ 4469.999926ps       1.8849361
+ 4479.999927ps       1.8903123
+ 4489.999927ps       1.8991987
+ 4499.999928ps       1.9101601
+ 4509.999929ps       1.9242219
+ 4519.999930ps       1.9293489
+ 4529.999931ps       1.9308711
+ 4539.999932ps       1.9232298
+ 4549.999932ps       1.9077067
+ 4559.999933ps       1.8920685
+ 4569.999934ps       1.8762988
+ 4579.999935ps       1.8739191
+ 4589.999936ps       1.8728796
+ 4599.999937ps       1.8715734
+ 4609.999937ps       1.8685918
+ 4619.999938ps       1.8553741
+ 4629.999939ps       1.8388334
+ 4639.999940ps       1.8163745
+ 4649.999941ps       1.8082044
+ 4659.999941ps       1.8111738
+ 4669.999942ps       1.8154779
+ 4679.999943ps       1.8110554
+ 4689.999944ps       1.8028965
+ 4699.999945ps       1.7975214
+ 4709.999946ps       1.7875715
+ 4719.999946ps        1.781865
+ 4729.999947ps       1.7745204
+ 4739.999948ps       1.7752447
+ 4749.999949ps       1.7814754
+ 4759.999950ps       1.7910241
+ 4769.999951ps        1.797833
+ 4779.999951ps       1.7995039
+ 4789.999952ps       1.7972356
+ 4799.999953ps       1.7918489
+ 4809.999954ps       1.7802006
+ 4819.999955ps       1.7670852
+ 4829.999956ps       1.7513828
+ 4839.999956ps       1.7494558
+ 4849.999957ps       1.7530719
+ 4859.999958ps       1.7624995
+ 4869.999959ps       1.7730371
+ 4879.999960ps       1.7749824
+ 4889.999961ps       1.7752349
+ 4899.999961ps       1.7735822
+ 4909.999962ps       1.7757756
+ 4919.999963ps       1.7759102
+ 4929.999964ps       1.7826887
+ 4939.999965ps       1.7954583
+ 4949.999965ps       1.7992808
+ 4959.999966ps       1.7994262
+ 4969.999967ps        1.790872
+ 4979.999968ps       1.7797541
+ 4989.999969ps       1.7657361
+ 4999.999970ps       1.7514245
+ 5009.999970ps       1.7430651
+ 5019.999971ps       1.7405302
+ 5029.999972ps       1.7483861
+ 5039.999973ps       1.7539284
+ 5049.999974ps       1.7671085
+ 5059.999975ps       1.7764979
+ 5069.999975ps       1.7821915
+ 5079.999976ps       1.7906026
+ 5089.999977ps       1.7979902
+ 5099.999978ps       1.7987033
+ 5109.999979ps       1.7913626
+ 5119.999980ps       1.7805901
+ 5129.999980ps       1.7779289
+ 5139.999981ps       1.7780222
+ 5149.999982ps       1.7686838
+ 5159.999983ps       1.7619847
+ 5169.999984ps       1.7455799
+ 5179.999985ps       1.7337801
+ 5189.999985ps       1.7192076
+ 5199.999986ps       1.7239964
+ 5209.999987ps       1.7400624
+ 5219.999988ps        1.761857
+ 5229.999989ps       1.7859662
+ 5239.999989ps       1.8117015
+ 5249.999990ps       1.8289695
+ 5259.999991ps       1.8385473
+ 5269.999992ps        1.833204
+ 5279.999993ps       1.8113969
+ 5289.999994ps       1.7844004
+ 5299.999994ps       1.7633174
+ 5309.999995ps       1.7517851
+ 5319.999996ps       1.7484427
+ 5329.999997ps       1.7427891
+ 5339.999998ps       1.7321414
+ 5349.999999ps        1.718106
+ 5359.999999ps       1.7012735
+ 5370.000000ps       1.6919155
+ 5380.000001ps       1.6946447
+ 5390.000002ps       1.7028539
+ 5400.000003ps       1.7151227
+ 5410.000004ps       1.7275368
+ 5420.000004ps       1.7449408
+ 5430.000005ps        1.759758
+ 5440.000006ps        1.760575
+ 5450.000007ps       1.7546794
+ 5460.000008ps       1.7362156
+ 5470.000009ps       1.7187661
+ 5480.000009ps       1.7044143
+ 5490.000010ps       1.7013905
+ 5500.000011ps       1.6972139
+ 5510.000012ps       1.6872349
+ 5520.000013ps       1.6692368
+ 5530.000013ps       1.6550277
+ 5540.000014ps       1.6504072
+ 5550.000015ps       1.6476705
+ 5560.000016ps       1.6546503
+ 5570.000017ps       1.6637917
+ 5580.000018ps       1.6777593
+ 5590.000018ps       1.6900373
+ 5600.000019ps       1.7034236
+ 5610.000020ps       1.7075941
+ 5620.000021ps       1.6967364
+ 5630.000022ps       1.6824759
+ 5640.000023ps       1.6578842
+ 5650.000023ps       1.6400389
+ 5660.000024ps       1.6322647
+ 5670.000025ps       1.6395959
+ 5680.000026ps       1.6565126
+ 5690.000027ps       1.6658938
+ 5700.000028ps        1.667963
+ 5710.000028ps       1.6581062
+ 5720.000029ps       1.6570849
+ 5730.000030ps       1.6574106
+ 5740.000031ps       1.6578526
+ 5750.000032ps       1.6622888
+ 5760.000033ps        1.668958
+ 5770.000033ps       1.6832973
+ 5780.000034ps       1.6926133
+ 5790.000035ps       1.6966649
+ 5800.000036ps       1.6837531
+ 5810.000037ps       1.6606196
+ 5820.000037ps       1.6396497
+ 5830.000038ps       1.6318328
+ 5840.000039ps       1.6386725
+ 5850.000040ps       1.6491477
+ 5860.000041ps       1.6604534
+ 5870.000042ps       1.6657671
+ 5880.000042ps       1.6682607
+ 5890.000043ps       1.6658041
+ 5900.000044ps       1.6643204
+ 5910.000045ps       1.6597487
+ 5920.000046ps       1.6497226
+ 5930.000047ps       1.6286318
+ 5940.000047ps        1.612696
+ 5950.000048ps       1.5955304
+ 5960.000049ps        1.587414
+ 5970.000050ps       1.5885687
+ 5980.000051ps       1.5969159
+ 5990.000052ps       1.6109641
+ 6000.000052ps       1.6267443
+ 6010.000053ps       1.6435275
+ 6020.000054ps       1.6613051
+ 6030.000055ps       1.6793495
+ 6040.000056ps        1.686371
+ 6050.000056ps       1.6840455
+ 6060.000057ps       1.6792757
+ 6070.000058ps       1.6828792
+ 6080.000059ps       1.6855481
+ 6090.000060ps       1.6905754
+ 6100.000061ps       1.6828318
+ 6110.000061ps       1.6707618
+ 6120.000062ps       1.6475145
+ 6130.000063ps       1.6308277
+ 6140.000064ps       1.6220685
+ 6150.000065ps       1.6135941
+ 6160.000066ps       1.6032913
+ 6170.000066ps        1.597258
+ 6180.000067ps       1.5887242
+ 6190.000068ps        1.582569
+ 6200.000069ps       1.5804758
+ 6210.000070ps       1.5826581
+ 6220.000071ps       1.5851612
+ 6230.000071ps       1.5891207
+ 6240.000072ps       1.5897437
+ 6250.000073ps       1.5951039
+ 6260.000074ps       1.6010779
+ 6270.000075ps       1.6118471
+ 6280.000076ps       1.6235729
+ 6290.000076ps       1.6356078
+ 6300.000077ps        1.648618
+ 6310.000078ps       1.6494998
+ 6320.000079ps       1.6495497
+ 6330.000080ps       1.6435994
+ 6340.000080ps       1.6373964
+ 6350.000081ps       1.6255154
+ 6360.000082ps       1.6235281
+ 6370.000083ps       1.6320936
+ 6380.000084ps       1.6449721
+ 6390.000085ps       1.6542325
+ 6400.000085ps        1.663798
+ 6410.000086ps       1.6687529
+ 6420.000087ps       1.6711332
+ 6430.000088ps       1.6738677
+ 6440.000089ps       1.6767998
+ 6450.000090ps       1.6799196
+ 6460.000090ps       1.6867691
+ 6470.000091ps       1.6941557
+ 6480.000092ps       1.7003275
+ 6490.000093ps       1.6942814
+ 6500.000094ps       1.6845456
+ 6510.000095ps       1.6672268
+ 6520.000095ps       1.6615342
+ 6530.000096ps       1.6567641
+ 6540.000097ps       1.6610266
+ 6550.000098ps       1.6734542
+ 6560.000099ps       1.6896376
+ 6570.000100ps       1.7058159
+ 6580.000100ps       1.7221788
+ 6590.000101ps       1.7386438
+ 6600.000102ps       1.7528335
+ 6610.000103ps       1.7578995
+ 6620.000104ps       1.7559218
+ 6630.000104ps       1.7421868
+ 6640.000105ps       1.7274237
+ 6650.000106ps       1.7180184
+ 6660.000107ps       1.7035791
+ 6670.000108ps       1.6886361
+ 6680.000109ps       1.6811133
+ 6690.000109ps       1.6706439
+ 6700.000110ps       1.6634128
+ 6710.000111ps       1.6550625
+ 6720.000112ps       1.6495052
+ 6730.000113ps       1.6356432
+ 6740.000114ps       1.6328942
+ 6750.000114ps       1.6353103
+ 6760.000115ps       1.6356748
+ 6770.000116ps       1.6357903
+ 6780.000117ps       1.6367488
+ 6790.000118ps         1.64211
+ 6800.000119ps       1.6472573
+ 6810.000119ps       1.6495413
+ 6820.000120ps       1.6433188
+ 6830.000121ps       1.6365944
+ 6840.000122ps       1.6359911
+ 6850.000123ps        1.640113
+ 6860.000124ps       1.6483543
+ 6870.000124ps       1.6536701
+ 6880.000125ps       1.6538736
+ 6890.000126ps        1.647164
+ 6900.000127ps       1.6428203
+ 6910.000128ps       1.6349525
+ 6920.000128ps        1.631288
+ 6930.000129ps       1.6377866
+ 6940.000130ps       1.6466699
+ 6950.000131ps       1.6539702
+ 6960.000132ps       1.6624341
+ 6970.000133ps       1.6651584
+ 6980.000133ps       1.6702687
+ 6990.000134ps       1.6609925
+ 7000.000135ps       1.6506574
+ 7010.000136ps       1.6361086
+ 7020.000137ps       1.6289704
+ 7030.000138ps       1.6311509
+ 7040.000138ps       1.6399442
+ 7050.000139ps       1.6587956
+ 7060.000140ps       1.6715978
+ 7070.000141ps       1.6830272
+ 7080.000142ps       1.6852732
+ 7090.000143ps       1.6940129
+ 7100.000143ps       1.6998402
+ 7110.000144ps       1.7049672
+ 7120.000145ps       1.7052618
+ 7130.000146ps       1.7109249
+ 7140.000147ps       1.7170611
+ 7150.000147ps       1.7226901
+ 7160.000148ps       1.7252929
+ 7170.000149ps       1.7208843
+ 7180.000150ps       1.7133973
+ 7190.000151ps        1.701782
+ 7200.000152ps       1.6946419
+ 7210.000152ps       1.6835349
+ 7220.000153ps       1.6767871
+ 7230.000154ps       1.6738518
+ 7240.000155ps       1.6741242
+ 7250.000156ps       1.6859124
+ 7260.000157ps       1.6899977
+ 7270.000157ps       1.7026816
+ 7280.000158ps       1.7063959
+ 7290.000159ps       1.7015525
+ 7300.000160ps       1.6861094
+ 7310.000161ps       1.6698634
+ 7320.000162ps       1.6528795
+ 7330.000162ps       1.6423619
+ 7340.000163ps       1.6340938
+ 7350.000164ps       1.6306252
+ 7360.000165ps       1.6322061
+ 7370.000166ps       1.6305818
+ 7380.000167ps       1.6260579
+ 7390.000167ps       1.6114397
+ 7400.000168ps       1.6075783
+ 7410.000169ps         1.59672
+ 7420.000170ps       1.5897976
+ 7430.000171ps       1.5827786
+ 7440.000171ps        1.576658
+ 7450.000172ps        1.580478
+ 7459.999729ps       1.5867933
+ 7469.999730ps       1.6011696
+ 7479.999731ps       1.6134333
+ 7489.999732ps       1.6185222
+ 7499.999732ps       1.6189884
+ 7509.999733ps       1.6195077
+ 7519.999734ps       1.6162966
+ 7529.999735ps       1.6150744
+ 7539.999736ps       1.6176544
+ 7549.999737ps        1.622937
+ 7559.999737ps       1.6301485
+ 7569.999738ps       1.6385232
+ 7579.999739ps       1.6469985
+ 7589.999740ps        1.648354
+ 7599.999741ps       1.6448261
+ 7609.999741ps       1.6365958
+ 7619.999742ps       1.6320861
+ 7629.999743ps       1.6347377
+ 7639.999744ps       1.6423546
+ 7649.999745ps       1.6571074
+ 7659.999746ps       1.6739789
+ 7669.999746ps       1.6755371
+ 7679.999747ps       1.6834458
+ 7689.999748ps       1.6871087
+ 7699.999749ps       1.6897919
+ 7709.999750ps       1.6881832
+ 7719.999751ps       1.6786553
+ 7729.999751ps       1.6658623
+ 7739.999752ps       1.6474426
+ 7749.999753ps       1.6272929
+ 7759.999754ps       1.6083224
+ 7769.999755ps       1.5954677
+ 7779.999756ps       1.5889941
+ 7789.999756ps       1.5859501
+ 7799.999757ps       1.5856793
+ 7809.999758ps        1.588695
+ 7819.999759ps       1.5930984
+ 7829.999760ps       1.6017062
+ 7839.999761ps       1.6106406
+ 7849.999761ps       1.6170652
+ 7859.999762ps       1.6231276
+ 7869.999763ps       1.6301529
+ 7879.999764ps       1.6350647
+ 7889.999765ps       1.6377193
+ 7899.999765ps         1.62837
+ 7909.999766ps       1.6164163
+ 7919.999767ps       1.5942062
+ 7929.999768ps       1.5795847
+ 7939.999769ps        1.567545
+ 7949.999770ps       1.5677179
+ 7959.999770ps       1.5731462
+ 7969.999771ps       1.5840891
+ 7979.999772ps       1.5909466
+ 7989.999773ps       1.6009444
+)

Icursig18 PAR_0_3_VSS 0 pwl(
+ 0.000000ps      -3.2102382
+ 10.000000ps      -3.6786244
+ 20.000000ps      -5.0712963
+ 29.999999ps       -7.063795
+ 40.000000ps      -8.1720024
+ 50.000001ps      -8.1137908
+ 59.999998ps      -8.0603113
+ 69.999999ps      -8.7508204
+ 80.000000ps      -10.071329
+ 90.000001ps      -11.585829
+ 100.000001ps      -12.320366
+ 110.000002ps      -11.802408
+ 119.999996ps       -11.23857
+ 129.999997ps      -11.309307
+ 139.999998ps      -11.942262
+ 149.999999ps      -13.062501
+ 159.999999ps      -14.352662
+ 170.000000ps      -15.008833
+ 180.000001ps      -14.809487
+ 190.000002ps       -14.48862
+ 200.000003ps      -14.935518
+ 210.000003ps      -15.413555
+ 220.000004ps      -16.285502
+ 230.000005ps      -16.139983
+ 239.999992ps      -14.821259
+ 249.999993ps      -13.365147
+ 259.999994ps      -12.373829
+ 269.999995ps      -11.692207
+ 279.999995ps      -10.920758
+ 289.999996ps      -10.180192
+ 299.999997ps      -9.4180947
+ 309.999998ps      -8.6296638
+ 319.999999ps      -7.8915466
+ 330.000000ps      -7.1850475
+ 340.000000ps      -6.6659595
+ 350.000001ps      -6.3993421
+ 360.000002ps      -6.3510029
+ 370.000003ps       -6.535816
+ 380.000004ps      -6.9475983
+ 390.000005ps      -7.9990985
+ 400.000005ps       -8.806018
+ 410.000006ps      -9.2884743
+ 420.000007ps      -10.344292
+ 430.000008ps      -11.334856
+ 440.000009ps      -11.508071
+ 450.000009ps       -10.74585
+ 460.000010ps      -9.9837856
+ 469.999983ps      -9.5350288
+ 479.999984ps      -9.3866238
+ 489.999985ps       -8.887215
+ 499.999986ps      -8.6247685
+ 509.999987ps       -8.798259
+ 519.999988ps      -9.2962942
+ 529.999988ps      -10.013457
+ 539.999989ps      -10.663645
+ 549.999990ps       -11.10606
+ 559.999991ps      -11.221473
+ 569.999992ps      -10.999685
+ 579.999992ps      -10.505799
+ 589.999993ps      -9.8388235
+ 599.999994ps      -9.1415943
+ 609.999995ps      -8.4416996
+ 619.999996ps       -7.795545
+ 629.999997ps      -7.1463119
+ 639.999997ps      -6.6700354
+ 649.999998ps      -6.4625319
+ 659.999999ps      -6.3714244
+ 670.000000ps      -6.2958842
+ 680.000001ps      -6.7090302
+ 690.000002ps      -8.0582356
+ 700.000002ps      -9.6658118
+ 710.000003ps      -10.204112
+ 720.000004ps      -9.6821753
+ 730.000005ps      -9.4913146
+ 740.000006ps      -10.266885
+ 750.000007ps      -11.615892
+ 760.000007ps       -12.92277
+ 770.000008ps      -13.021388
+ 780.000009ps      -12.303977
+ 790.000010ps      -11.932506
+ 800.000011ps      -11.996298
+ 810.000012ps      -12.756119
+ 820.000012ps      -14.086208
+ 830.000013ps      -15.016319
+ 840.000014ps      -15.347423
+ 850.000015ps      -14.727956
+ 860.000016ps      -14.570009
+ 870.000016ps      -15.301467
+ 880.000017ps      -16.016476
+ 890.000018ps      -16.484687
+ 900.000019ps      -15.868589
+ 910.000020ps      -14.322259
+ 920.000021ps      -12.920739
+ 930.000021ps      -12.101262
+ 939.999967ps      -11.436663
+ 949.999968ps      -10.675529
+ 959.999968ps      -9.9545193
+ 969.999969ps      -9.2087878
+ 979.999970ps      -8.3983967
+ 989.999971ps      -7.6231251
+ 999.999972ps       -6.989535
+ 1009.999973ps       -6.514282
+ 1019.999973ps      -6.3788071
+ 1029.999974ps      -6.4932515
+ 1039.999975ps      -6.6950632
+ 1049.999976ps      -7.2982924
+ 1059.999977ps      -8.4851346
+ 1069.999978ps      -9.0394655
+ 1079.999978ps      -9.6724546
+ 1089.999979ps      -10.748803
+ 1099.999980ps      -11.546846
+ 1109.999981ps       -11.44598
+ 1119.999982ps       -10.41196
+ 1129.999982ps      -9.7271484
+ 1139.999983ps      -9.3939997
+ 1149.999984ps      -9.2740059
+ 1159.999985ps      -8.8098814
+ 1169.999986ps      -8.6928943
+ 1179.999987ps      -9.0057661
+ 1189.999987ps      -9.5943347
+ 1199.999988ps      -10.317104
+ 1209.999989ps      -10.898253
+ 1219.999990ps      -11.237407
+ 1229.999991ps      -11.160027
+ 1239.999992ps      -10.832518
+ 1249.999992ps      -10.282634
+ 1259.999993ps      -9.6006943
+ 1269.999994ps      -8.8695264
+ 1279.999995ps      -8.1939049
+ 1289.999996ps      -7.5447918
+ 1299.999997ps      -6.9752487
+ 1309.999997ps      -6.5884321
+ 1319.999998ps      -6.4003613
+ 1329.999999ps      -6.3650797
+ 1340.000000ps      -6.3695425
+ 1350.000001ps      -7.2367466
+ 1360.000002ps      -8.9231884
+ 1370.000002ps      -10.023662
+ 1380.000003ps      -9.9519542
+ 1390.000004ps       -9.489829
+ 1400.000005ps      -9.7628408
+ 1410.000006ps      -10.833158
+ 1420.000006ps      -12.274602
+ 1430.000007ps      -13.115915
+ 1440.000008ps      -12.672642
+ 1450.000009ps      -12.020992
+ 1460.000010ps       -11.90731
+ 1470.000011ps      -12.261926
+ 1480.000011ps      -13.182606
+ 1490.000012ps       -14.45373
+ 1500.000013ps      -15.225874
+ 1510.000014ps      -15.220736
+ 1520.000015ps      -14.737973
+ 1530.000016ps      -14.968379
+ 1540.000016ps      -15.405901
+ 1550.000017ps      -16.212016
+ 1560.000018ps      -16.304586
+ 1570.000019ps      -15.252008
+ 1580.000020ps      -13.790457
+ 1590.000021ps      -12.615919
+ 1600.000021ps      -11.892816
+ 1610.000022ps      -11.151337
+ 1620.000023ps      -10.434187
+ 1630.000024ps      -9.6838843
+ 1640.000025ps      -8.8902218
+ 1650.000025ps      -8.1237476
+ 1660.000026ps      -7.3849466
+ 1670.000027ps      -6.8201141
+ 1680.000028ps      -6.4945904
+ 1690.000029ps       -6.436499
+ 1700.000030ps      -6.5340764
+ 1710.000030ps        -6.90625
+ 1720.000031ps      -7.7838355
+ 1730.000032ps      -8.7625218
+ 1740.000033ps      -9.3135483
+ 1750.000034ps       -10.09522
+ 1760.000035ps      -11.110287
+ 1770.000035ps      -11.603167
+ 1780.000036ps      -11.117853
+ 1790.000037ps      -10.182949
+ 1800.000038ps      -9.6036457
+ 1810.000039ps      -9.3640983
+ 1820.000040ps      -9.1150901
+ 1830.000040ps      -8.7830901
+ 1840.000041ps      -8.8061262
+ 1850.000042ps      -9.2281201
+ 1860.000043ps      -9.9062471
+ 1869.999933ps      -10.596183
+ 1879.999934ps      -11.058973
+ 1889.999934ps       -11.27204
+ 1899.999935ps      -11.088822
+ 1909.999936ps      -10.665066
+ 1919.999937ps      -10.028528
+ 1929.999938ps      -9.3293118
+ 1939.999938ps      -8.6121704
+ 1949.999939ps       -7.938148
+ 1959.999940ps       -7.295638
+ 1969.999941ps      -6.7894594
+ 1979.999942ps      -6.4971113
+ 1989.999943ps      -6.4025633
+ 1999.999943ps      -6.3651799
+ 2009.999944ps      -6.5576229
+ 2019.999945ps      -7.7304974
+ 2029.999946ps      -9.4608446
+ 2039.999947ps      -10.223146
+ 2049.999948ps      -9.8212966
+ 2059.999948ps      -9.5132262
+ 2069.999949ps      -10.097905
+ 2079.999950ps      -11.324838
+ 2089.999951ps      -12.777093
+ 2099.999952ps      -13.219311
+ 2109.999953ps      -12.437915
+ 2119.999953ps      -11.851605
+ 2129.999954ps      -11.930359
+ 2139.999955ps      -12.640375
+ 2149.999956ps       -13.77687
+ 2159.999957ps      -14.872511
+ 2169.999958ps      -15.323216
+ 2179.999958ps      -14.944597
+ 2189.999959ps       -14.68108
+ 2199.999960ps      -15.223761
+ 2209.999961ps      -15.832176
+ 2219.999962ps      -16.489614
+ 2229.999962ps      -16.116546
+ 2239.999963ps      -14.697258
+ 2249.999964ps      -13.208301
+ 2259.999965ps      -12.262467
+ 2269.999966ps      -11.598959
+ 2279.999967ps      -10.851428
+ 2289.999967ps      -10.126276
+ 2299.999968ps      -9.3680629
+ 2309.999969ps      -8.5924249
+ 2319.999970ps      -7.8513762
+ 2329.999971ps      -7.1610685
+ 2339.999972ps      -6.6351382
+ 2349.999972ps      -6.4377927
+ 2359.999973ps      -6.4855623
+ 2369.999974ps        -6.68533
+ 2379.999975ps      -7.1678996
+ 2389.999976ps      -8.2381805
+ 2399.999977ps      -8.9560803
+ 2409.999977ps      -9.5691824
+ 2419.999978ps      -10.596667
+ 2429.999979ps      -11.484147
+ 2439.999980ps      -11.473418
+ 2449.999981ps      -10.633452
+ 2459.999982ps      -9.8751729
+ 2469.999982ps      -9.4710869
+ 2479.999983ps      -9.3576245
+ 2489.999984ps      -8.8996669
+ 2499.999985ps      -8.7048383
+ 2509.999986ps      -8.9179877
+ 2519.999986ps       -9.475534
+ 2529.999987ps      -10.206539
+ 2539.999988ps      -10.835243
+ 2549.999989ps      -11.221389
+ 2559.999990ps      -11.228392
+ 2569.999991ps      -10.938434
+ 2579.999991ps      -10.429778
+ 2589.999992ps      -9.7484749
+ 2599.999993ps      -9.0304681
+ 2609.999994ps      -8.3349786
+ 2619.999995ps       -7.678788
+ 2629.999996ps       -7.073424
+ 2639.999996ps      -6.6459276
+ 2649.999997ps      -6.4712186
+ 2659.999998ps      -6.4163305
+ 2669.999999ps      -6.3478029
+ 2680.000000ps      -6.9500663
+ 2690.000001ps      -8.4951663
+ 2700.000001ps      -9.8266127
+ 2710.000002ps      -10.127829
+ 2720.000003ps       -9.639639
+ 2730.000004ps      -9.6327819
+ 2740.000005ps      -10.542704
+ 2750.000005ps       -11.90556
+ 2760.000006ps      -12.991756
+ 2770.000007ps      -12.988506
+ 2780.000008ps      -12.252212
+ 2790.000009ps      -11.899996
+ 2800.000010ps      -12.201395
+ 2810.000010ps      -13.053919
+ 2820.000011ps      -14.263012
+ 2830.000012ps      -15.107346
+ 2840.000013ps       -15.23986
+ 2850.000014ps      -14.737513
+ 2860.000015ps      -14.889144
+ 2870.000015ps      -15.379092
+ 2880.000016ps      -16.184664
+ 2890.000017ps      -16.421056
+ 2900.000018ps      -15.492636
+ 2910.000019ps      -14.031206
+ 2920.000020ps      -12.809369
+ 2930.000020ps      -11.997336
+ 2940.000021ps      -11.318334
+ 2950.000022ps      -10.573363
+ 2960.000023ps      -9.8351472
+ 2970.000024ps      -9.0585637
+ 2980.000025ps      -8.2762326
+ 2990.000025ps      -7.5255018
+ 3000.000026ps      -6.9379865
+ 3010.000027ps      -6.5515877
+ 3020.000028ps      -6.4239675
+ 3030.000029ps      -6.5167265
+ 3040.000029ps      -6.8365368
+ 3050.000030ps      -7.4967164
+ 3060.000031ps      -8.6717109
+ 3070.000032ps      -9.2292513
+ 3080.000033ps      -9.8689118
+ 3090.000034ps      -10.929145
+ 3100.000034ps      -11.552502
+ 3110.000035ps      -11.364846
+ 3120.000036ps      -10.363777
+ 3130.000037ps      -9.6927852
+ 3140.000038ps      -9.3935774
+ 3150.000039ps      -9.2083433
+ 3160.000039ps      -8.8010257
+ 3170.000040ps      -8.7785742
+ 3180.000041ps      -9.1432822
+ 3190.000042ps      -9.7934598
+ 3200.000043ps      -10.488886
+ 3210.000044ps      -10.995279
+ 3220.000044ps      -11.262383
+ 3230.000045ps      -11.144682
+ 3240.000046ps       -10.77533
+ 3250.000047ps      -10.166576
+ 3260.000048ps      -9.4806248
+ 3270.000049ps      -8.7639313
+ 3280.000049ps      -8.0895046
+ 3290.000050ps      -7.4243467
+ 3300.000051ps      -6.8857508
+ 3310.000052ps      -6.5543449
+ 3320.000053ps      -6.4303329
+ 3330.000053ps      -6.3763863
+ 3340.000054ps      -6.4494919
+ 3350.000055ps      -7.4940332
+ 3360.000056ps      -9.2253811
+ 3370.000057ps      -10.142803
+ 3380.000058ps      -9.9450114
+ 3390.000058ps      -9.5085884
+ 3400.000059ps      -9.8848523
+ 3410.000060ps      -11.095499
+ 3420.000061ps      -12.521982
+ 3430.000062ps      -13.190278
+ 3440.000063ps      -12.606874
+ 3450.000063ps      -11.972054
+ 3460.000064ps      -11.945327
+ 3470.000065ps      -12.490929
+ 3480.000066ps      -13.529356
+ 3490.000067ps      -14.720646
+ 3500.000068ps      -15.297845
+ 3510.000068ps      -15.042104
+ 3520.000069ps      -14.681883
+ 3530.000070ps      -15.106856
+ 3540.000071ps      -15.568108
+ 3550.000072ps      -16.419155
+ 3560.000073ps      -16.259416
+ 3570.000073ps      -14.932762
+ 3580.000074ps      -13.462728
+ 3590.000075ps      -12.470844
+ 3600.000076ps      -11.792865
+ 3610.000077ps      -11.031797
+ 3620.000077ps      -10.290591
+ 3630.000078ps      -9.5173916
+ 3640.000079ps      -8.7219986
+ 3650.000080ps      -7.9865735
+ 3660.000081ps      -7.2719763
+ 3670.000082ps      -6.7362387
+ 3680.000082ps      -6.4772533
+ 3690.000083ps      -6.4289317
+ 3700.000084ps      -6.6022932
+ 3710.000085ps      -7.0128001
+ 3720.000086ps       -8.062895
+ 3729.999865ps      -8.8709025
+ 3739.999865ps      -9.3516399
+ 3749.999866ps      -10.398601
+ 3759.999867ps      -11.384426
+ 3769.999868ps      -11.564557
+ 3779.999869ps      -10.804793
+ 3789.999869ps      -10.043965
+ 3799.999870ps       -9.592097
+ 3809.999871ps      -9.4413969
+ 3819.999872ps      -8.9365529
+ 3829.999873ps      -8.6732336
+ 3839.999874ps      -8.8442029
+ 3849.999874ps      -9.3443053
+ 3859.999875ps      -10.060244
+ 3869.999876ps      -10.712154
+ 3879.999877ps      -11.154189
+ 3889.999878ps      -11.268867
+ 3899.999879ps      -11.034825
+ 3909.999879ps      -10.545913
+ 3919.999880ps      -9.8780767
+ 3929.999881ps      -9.1797536
+ 3939.999882ps       -8.478873
+ 3949.999883ps      -7.8194688
+ 3959.999884ps      -7.1640978
+ 3969.999884ps      -6.6979674
+ 3979.999885ps      -6.4921958
+ 3989.999886ps      -6.4038781
+ 3999.999887ps      -6.3291915
+ 4009.999888ps      -6.7432324
+ 4019.999889ps       -8.092621
+ 4029.999889ps      -9.7011079
+ 4039.999890ps      -10.240297
+ 4049.999891ps      -9.7183905
+ 4059.999892ps      -9.5241268
+ 4069.999893ps      -10.299827
+ 4079.999893ps       -11.64861
+ 4089.999894ps      -12.957084
+ 4099.999895ps      -13.053316
+ 4109.999896ps      -12.335149
+ 4119.999897ps      -11.959393
+ 4129.999898ps      -12.022693
+ 4139.999898ps      -12.785732
+ 4149.999899ps      -14.119027
+ 4159.999900ps      -15.050082
+ 4169.999901ps      -15.381178
+ 4179.999902ps      -14.762786
+ 4189.999903ps      -14.603075
+ 4199.999903ps      -15.329645
+ 4209.999904ps      -16.037226
+ 4219.999905ps      -16.504825
+ 4229.999906ps      -15.897862
+ 4239.999907ps      -14.355373
+ 4249.999908ps      -12.952781
+ 4259.999908ps       -12.13008
+ 4269.999909ps      -11.460754
+ 4279.999910ps      -10.700871
+ 4289.999911ps      -9.9835567
+ 4299.999912ps      -9.2444048
+ 4309.999913ps         -8.4309
+ 4319.999913ps      -7.6629929
+ 4329.999914ps      -7.0297492
+ 4339.999915ps       -6.564003
+ 4349.999916ps      -6.4178202
+ 4359.999917ps      -6.5361094
+ 4369.999917ps      -6.7398565
+ 4379.999918ps      -7.3425055
+ 4389.999919ps      -8.5249791
+ 4399.999920ps       -9.089787
+ 4409.999921ps      -9.7122299
+ 4419.999922ps      -10.796856
+ 4429.999922ps      -11.587774
+ 4439.999923ps      -11.477225
+ 4449.999924ps      -10.441431
+ 4459.999925ps      -9.7562104
+ 4469.999926ps       -9.425427
+ 4479.999927ps      -9.3052824
+ 4489.999927ps      -8.8416259
+ 4499.999928ps      -8.7272524
+ 4509.999929ps      -9.0346244
+ 4519.999930ps      -9.6219581
+ 4529.999931ps      -10.350583
+ 4539.999932ps      -10.928806
+ 4549.999932ps      -11.262975
+ 4559.999933ps      -11.189928
+ 4569.999934ps      -10.869191
+ 4579.999935ps      -10.314572
+ 4589.999936ps      -9.6325177
+ 4599.999937ps      -8.8986562
+ 4609.999937ps      -8.2223708
+ 4619.999938ps      -7.5873654
+ 4629.999939ps      -7.0231183
+ 4639.999940ps      -6.6281676
+ 4649.999941ps      -6.4373741
+ 4659.999941ps      -6.3987933
+ 4669.999942ps      -6.4005346
+ 4679.999943ps        -7.26471
+ 4689.999944ps      -8.9500663
+ 4699.999945ps      -10.049181
+ 4709.999946ps       -9.976628
+ 4719.999946ps      -9.5188472
+ 4729.999947ps      -9.7874482
+ 4739.999948ps        -10.8547
+ 4749.999949ps      -12.297575
+ 4759.999950ps      -13.140602
+ 4769.999951ps       -12.69771
+ 4779.999951ps      -12.049399
+ 4789.999952ps      -11.939889
+ 4799.999953ps      -12.290399
+ 4809.999954ps      -13.210923
+ 4819.999955ps      -14.485451
+ 4829.999956ps      -15.255216
+ 4839.999956ps      -15.245797
+ 4849.999957ps      -14.756985
+ 4859.999958ps      -14.985064
+ 4869.999959ps       -15.42024
+ 4879.999960ps      -16.225068
+ 4889.999961ps      -16.316216
+ 4899.999961ps      -15.258986
+ 4909.999962ps      -13.803474
+ 4919.999963ps       -12.64044
+ 4929.999964ps      -11.923104
+ 4939.999965ps      -11.175674
+ 4949.999965ps      -10.458326
+ 4959.999966ps      -9.7026612
+ 4969.999967ps      -8.8978882
+ 4979.999968ps      -8.1371372
+ 4989.999969ps      -7.3948905
+ 4999.999970ps      -6.8319078
+ 5009.999970ps      -6.4932092
+ 5019.999971ps      -6.4358983
+ 5029.999972ps      -6.5362536
+ 5039.999973ps      -6.9024287
+ 5049.999974ps      -7.7697296
+ 5059.999975ps      -8.7566337
+ 5069.999975ps      -9.2932425
+ 5079.999976ps      -10.065825
+ 5089.999977ps      -11.101901
+ 5099.999978ps      -11.599301
+ 5109.999979ps      -11.121974
+ 5119.999980ps      -10.188887
+ 5129.999980ps      -9.6114966
+ 5139.999981ps      -9.3734081
+ 5149.999982ps       -9.118158
+ 5159.999983ps      -8.7823734
+ 5169.999984ps      -8.8079093
+ 5179.999985ps       -9.230719
+ 5189.999985ps      -9.9120364
+ 5199.999986ps      -10.599087
+ 5209.999987ps      -11.059822
+ 5219.999988ps      -11.275608
+ 5229.999989ps      -11.095824
+ 5239.999989ps      -10.670137
+ 5249.999990ps      -10.033045
+ 5259.999991ps      -9.3371127
+ 5269.999992ps      -8.6210004
+ 5279.999993ps      -7.9474477
+ 5289.999994ps      -7.3041867
+ 5299.999994ps      -6.7857815
+ 5309.999995ps      -6.4983019
+ 5319.999996ps      -6.4013718
+ 5329.999997ps      -6.3615298
+ 5339.999998ps      -6.5528511
+ 5349.999999ps      -7.7401196
+ 5359.999999ps      -9.4775219
+ 5370.000000ps      -10.228668
+ 5380.000001ps      -9.8230519
+ 5390.000002ps      -9.5141175
+ 5400.000003ps       -10.09425
+ 5410.000004ps      -11.334474
+ 5420.000004ps      -12.793592
+ 5430.000005ps       -13.22691
+ 5440.000006ps      -12.444501
+ 5450.000007ps      -11.854987
+ 5460.000008ps       -11.93355
+ 5470.000009ps       -12.64502
+ 5480.000009ps      -13.783147
+ 5490.000010ps      -14.871516
+ 5500.000011ps       -15.31839
+ 5510.000012ps      -14.937973
+ 5520.000013ps      -14.676902
+ 5530.000013ps      -15.219304
+ 5540.000014ps      -15.834485
+ 5550.000015ps      -16.502029
+ 5560.000016ps      -16.130588
+ 5570.000017ps      -14.713403
+ 5580.000018ps       -13.22251
+ 5590.000018ps      -12.274011
+ 5600.000019ps      -11.604984
+ 5610.000020ps      -10.854469
+ 5620.000021ps      -10.127089
+ 5630.000022ps      -9.3784698
+ 5640.000023ps      -8.6047121
+ 5650.000023ps      -7.8618513
+ 5660.000024ps      -7.1725002
+ 5670.000025ps      -6.6491641
+ 5680.000026ps      -6.4577072
+ 5690.000027ps      -6.5100576
+ 5700.000028ps      -6.7084908
+ 5710.000028ps      -7.1924044
+ 5720.000029ps      -8.2622933
+ 5730.000030ps      -8.9829186
+ 5740.000031ps      -9.5832422
+ 5750.000032ps      -10.614492
+ 5760.000033ps      -11.513188
+ 5770.000033ps       -11.50473
+ 5780.000034ps      -10.660318
+ 5790.000035ps      -9.9004896
+ 5800.000036ps      -9.4951493
+ 5810.000037ps      -9.3844897
+ 5820.000037ps      -8.9227498
+ 5830.000038ps      -8.7232571
+ 5840.000039ps      -8.9352955
+ 5850.000040ps      -9.4913532
+ 5860.000041ps       -10.22373
+ 5870.000042ps      -10.851762
+ 5880.000042ps      -11.236675
+ 5890.000043ps      -11.241038
+ 5900.000044ps      -10.960934
+ 5910.000045ps      -10.445436
+ 5920.000046ps      -9.7645087
+ 5930.000047ps      -9.0461968
+ 5940.000047ps      -8.3507696
+ 5950.000048ps      -7.6930339
+ 5960.000049ps      -7.0879308
+ 5970.000050ps      -6.6632912
+ 5980.000051ps      -6.4894284
+ 5990.000052ps      -6.4339011
+ 6000.000052ps      -6.3617967
+ 6010.000053ps      -6.9619769
+ 6020.000054ps      -8.5067486
+ 6030.000055ps        -9.83873
+ 6040.000056ps      -10.146236
+ 6050.000056ps      -9.6515458
+ 6060.000057ps      -9.6448308
+ 6070.000058ps      -10.554171
+ 6080.000059ps      -11.918466
+ 6090.000060ps      -13.005868
+ 6100.000061ps      -13.006371
+ 6110.000061ps      -12.271812
+ 6120.000062ps      -11.922609
+ 6130.000063ps        -12.2252
+ 6140.000064ps      -13.076607
+ 6150.000065ps      -14.283128
+ 6160.000066ps      -15.123889
+ 6170.000066ps      -15.257578
+ 6180.000067ps      -14.748846
+ 6190.000068ps      -14.891633
+ 6200.000069ps       -15.38187
+ 6210.000070ps      -16.189753
+ 6220.000071ps      -16.423005
+ 6230.000071ps      -15.492984
+ 6240.000072ps      -14.042553
+ 6250.000073ps      -12.832965
+ 6260.000074ps      -12.038632
+ 6270.000075ps      -11.353927
+ 6280.000076ps      -10.609751
+ 6290.000076ps        -9.86619
+ 6300.000077ps      -9.0822793
+ 6310.000078ps      -8.2921094
+ 6320.000079ps      -7.5357796
+ 6330.000080ps      -6.9374705
+ 6340.000080ps      -6.5468866
+ 6350.000081ps      -6.4156455
+ 6360.000082ps      -6.5133065
+ 6370.000083ps       -6.831121
+ 6380.000084ps      -7.4899911
+ 6390.000085ps      -8.6624678
+ 6400.000085ps      -9.2261134
+ 6410.000086ps       -9.864425
+ 6420.000087ps      -10.926237
+ 6430.000088ps      -11.549466
+ 6440.000089ps      -11.354783
+ 6450.000090ps      -10.355035
+ 6460.000090ps      -9.6856061
+ 6470.000091ps      -9.3927235
+ 6480.000092ps       -9.206495
+ 6490.000093ps      -8.8013196
+ 6500.000094ps      -8.7795808
+ 6510.000095ps      -9.1453428
+ 6520.000095ps      -9.7923098
+ 6530.000096ps      -10.485124
+ 6540.000097ps      -10.991611
+ 6550.000098ps      -11.265773
+ 6560.000099ps      -11.145069
+ 6570.000100ps      -10.776104
+ 6580.000100ps      -10.168369
+ 6590.000101ps      -9.4794375
+ 6600.000102ps      -8.7639086
+ 6610.000103ps      -8.0914101
+ 6620.000104ps      -7.4278764
+ 6630.000104ps      -6.8748633
+ 6640.000105ps      -6.5491944
+ 6650.000106ps      -6.4252555
+ 6660.000107ps      -6.3763413
+ 6670.000108ps      -6.4509365
+ 6680.000109ps      -7.4983959
+ 6690.000109ps       -9.229893
+ 6700.000110ps      -10.147687
+ 6710.000111ps      -9.9491722
+ 6720.000112ps      -9.5107109
+ 6730.000113ps      -9.8862231
+ 6740.000114ps      -11.095403
+ 6750.000114ps      -12.522003
+ 6760.000115ps       -13.18996
+ 6770.000116ps       -12.60575
+ 6780.000117ps      -11.971929
+ 6790.000118ps      -11.941281
+ 6800.000119ps      -12.491508
+ 6810.000119ps       -13.52823
+ 6820.000120ps      -14.721443
+ 6830.000121ps       -15.29564
+ 6840.000122ps      -15.041278
+ 6850.000123ps      -14.681546
+ 6860.000124ps      -15.108988
+ 6870.000124ps      -15.573438
+ 6880.000125ps      -16.426232
+ 6890.000126ps      -16.265934
+ 6900.000127ps      -14.931589
+ 6910.000128ps      -13.471925
+ 6920.000128ps      -12.478276
+ 6930.000129ps      -11.799115
+ 6940.000130ps      -11.030201
+ 6950.000131ps      -10.286303
+ 6960.000132ps      -9.5179842
+ 6970.000133ps      -8.7325955
+ 6980.000133ps      -7.9990407
+ 6990.000134ps      -7.2866696
+ 7000.000135ps        -6.75439
+ 7010.000136ps      -6.4893179
+ 7020.000137ps       -6.437847
+ 7030.000138ps      -6.6175176
+ 7040.000138ps       -7.030736
+ 7050.000139ps      -8.0793835
+ 7060.000140ps      -8.8875903
+ 7070.000141ps      -9.3683431
+ 7080.000142ps      -10.422178
+ 7090.000143ps      -11.414157
+ 7100.000143ps      -11.589488
+ 7110.000144ps      -10.822956
+ 7120.000145ps      -10.057497
+ 7130.000146ps      -9.6022074
+ 7140.000147ps      -9.4525274
+ 7150.000147ps      -8.9552139
+ 7160.000148ps      -8.6926459
+ 7170.000149ps      -8.8629314
+ 7180.000150ps      -9.3627566
+ 7190.000151ps      -10.074482
+ 7200.000152ps      -10.726163
+ 7210.000152ps      -11.168601
+ 7220.000153ps      -11.282116
+ 7230.000154ps      -11.052991
+ 7240.000155ps      -10.559038
+ 7250.000156ps      -9.8925614
+ 7260.000157ps      -9.1957345
+ 7270.000157ps      -8.4944452
+ 7280.000158ps      -7.8349868
+ 7290.000159ps      -7.1791811
+ 7300.000160ps       -6.713973
+ 7310.000161ps      -6.5088872
+ 7320.000162ps      -6.4188271
+ 7330.000162ps      -6.3415308
+ 7340.000163ps      -6.7521384
+ 7350.000164ps      -8.1008191
+ 7360.000165ps      -9.7079888
+ 7370.000166ps      -10.246052
+ 7380.000167ps      -9.7246569
+ 7390.000167ps      -9.5320934
+ 7400.000168ps      -10.308309
+ 7410.000169ps      -11.658351
+ 7420.000170ps      -12.965098
+ 7430.000171ps      -13.063677
+ 7440.000171ps      -12.345502
+ 7450.000172ps      -11.975324
+ 7459.999729ps      -12.038125
+ 7469.999730ps      -12.797696
+ 7479.999731ps       -14.12498
+ 7489.999732ps      -15.053454
+ 7499.999732ps      -15.386212
+ 7509.999733ps      -14.769673
+ 7519.999734ps      -14.607796
+ 7529.999735ps      -15.336517
+ 7539.999736ps      -16.047238
+ 7549.999737ps      -16.510637
+ 7559.999737ps      -15.891453
+ 7569.999738ps      -14.351142
+ 7579.999739ps       -12.95219
+ 7589.999740ps      -12.128525
+ 7599.999741ps      -11.467739
+ 7609.999741ps      -10.710867
+ 7619.999742ps      -9.9952184
+ 7629.999743ps      -9.2502828
+ 7639.999744ps      -8.4398828
+ 7649.999745ps      -7.6683041
+ 7659.999746ps      -7.0326119
+ 7669.999746ps      -6.5485314
+ 7679.999747ps      -6.4148741
+ 7689.999748ps      -6.5278848
+ 7699.999749ps      -6.7271205
+ 7709.999750ps      -7.3245551
+ 7719.999751ps      -8.5130516
+ 7729.999751ps      -9.0722987
+ 7739.999752ps      -9.6986681
+ 7749.999753ps       -10.79061
+ 7759.999754ps      -11.585132
+ 7769.999755ps      -11.471361
+ 7779.999756ps      -10.434468
+ 7789.999756ps      -9.7479626
+ 7799.999757ps      -9.4165879
+ 7809.999758ps      -9.2964502
+ 7819.999759ps      -8.8346378
+ 7829.999760ps      -8.7226477
+ 7839.999761ps      -9.0323467
+ 7849.999761ps      -9.6240832
+ 7859.999762ps      -10.347981
+ 7869.999763ps      -10.930228
+ 7879.999764ps      -11.262642
+ 7889.999765ps      -11.186541
+ 7899.999765ps        -10.8573
+ 7909.999766ps      -10.305941
+ 7919.999767ps      -9.6245872
+ 7929.999768ps      -8.8950328
+ 7939.999769ps      -8.2227457
+ 7949.999770ps      -7.5727507
+ 7959.999770ps      -7.0023681
+ 7969.999771ps      -6.6150924
+ 7979.999772ps      -6.4231377
+ 7989.999773ps      -6.3824646
+)

Icursig19 PAR_0_3_VDD075CPU 0 pwl(
+ 0.000000ps       3.0142969
+ 10.000000ps       3.4371562
+ 20.000000ps       4.8477422
+ 29.999999ps       6.9994257
+ 40.000000ps       8.4290315
+ 50.000001ps       8.8083628
+ 59.999998ps         9.30276
+ 69.999999ps        10.50147
+ 80.000000ps       12.258836
+ 90.000001ps        14.17778
+ 100.000001ps       15.110721
+ 110.000002ps       14.469515
+ 119.999996ps       13.667295
+ 129.999997ps       13.394445
+ 139.999998ps       13.675666
+ 149.999999ps       14.404809
+ 159.999999ps       15.474328
+ 170.000000ps       16.153771
+ 180.000001ps       16.156871
+ 190.000002ps       16.068795
+ 200.000003ps       16.553169
+ 210.000003ps        17.01389
+ 220.000004ps       17.853553
+ 230.000005ps       17.760008
+ 239.999992ps       16.627255
+ 249.999993ps       15.369192
+ 259.999994ps       14.431207
+ 269.999995ps       13.597351
+ 279.999995ps       12.771299
+ 289.999996ps       11.923944
+ 299.999997ps       10.973213
+ 309.999998ps       9.9645399
+ 319.999999ps       8.9516739
+ 330.000000ps       7.9621004
+ 340.000000ps       7.1211919
+ 350.000001ps       6.4984219
+ 360.000002ps       6.0460623
+ 370.000003ps       5.8103053
+ 380.000004ps        5.820273
+ 390.000005ps       6.1301216
+ 400.000005ps       6.2308407
+ 410.000006ps       6.2140762
+ 420.000007ps       6.6354901
+ 430.000008ps       7.3845663
+ 440.000009ps       7.6588206
+ 450.000009ps       7.3621351
+ 460.000010ps       7.1996398
+ 469.999983ps       7.2251314
+ 479.999984ps       7.4229285
+ 489.999985ps       7.0971003
+ 499.999986ps       6.8591399
+ 509.999987ps       6.9090001
+ 519.999988ps       7.1539906
+ 529.999988ps       7.5007653
+ 539.999989ps       7.7914369
+ 549.999990ps       7.9798638
+ 559.999991ps       8.1228692
+ 569.999992ps       8.2122377
+ 579.999992ps       8.1904696
+ 589.999993ps       8.0973106
+ 599.999994ps       8.0102386
+ 609.999995ps       7.7972117
+ 619.999996ps       7.3920146
+ 629.999997ps        6.900289
+ 639.999997ps       6.4999471
+ 649.999998ps       6.2880659
+ 659.999999ps       6.1841306
+ 670.000000ps       6.1308226
+ 680.000001ps       6.5989403
+ 690.000002ps       8.0480321
+ 700.000002ps       9.8125633
+ 710.000003ps       10.661926
+ 720.000004ps       10.663757
+ 730.000005ps       11.001968
+ 740.000006ps       12.235469
+ 750.000007ps       14.000193
+ 760.000007ps       15.580504
+ 770.000008ps       15.772229
+ 780.000009ps       14.884535
+ 790.000010ps       14.174218
+ 800.000011ps       13.885036
+ 810.000012ps       14.283951
+ 820.000012ps       15.256303
+ 830.000013ps       16.095306
+ 840.000014ps       16.520231
+ 850.000015ps       16.193026
+ 860.000016ps        16.20917
+ 870.000016ps       16.867184
+ 880.000017ps        17.48378
+ 890.000018ps       18.009628
+ 900.000019ps        17.51609
+ 910.000020ps       16.229066
+ 920.000021ps       14.983811
+ 930.000021ps       14.095274
+ 939.999967ps       13.291941
+ 949.999968ps       12.482337
+ 959.999968ps       11.634615
+ 969.999969ps       10.683254
+ 979.999970ps        9.614889
+ 989.999971ps        8.563687
+ 999.999972ps       7.6447239
+ 1009.999973ps       6.8557716
+ 1019.999973ps       6.2915811
+ 1029.999974ps       5.9683347
+ 1039.999975ps       5.8159041
+ 1049.999976ps       5.9367332
+ 1059.999977ps       6.2715521
+ 1069.999978ps       6.2013393
+ 1079.999978ps       6.3173979
+ 1089.999979ps       6.9003707
+ 1099.999980ps       7.5815582
+ 1109.999981ps       7.6847733
+ 1119.999982ps       7.2194224
+ 1129.999982ps       7.1197484
+ 1139.999983ps       7.2255463
+ 1149.999984ps       7.3916219
+ 1159.999985ps       7.0480255
+ 1169.999986ps       6.8841798
+ 1179.999987ps       7.0074602
+ 1189.999987ps       7.3091847
+ 1199.999988ps       7.6477479
+ 1209.999989ps       7.9030192
+ 1219.999990ps       8.0691598
+ 1229.999991ps       8.1821186
+ 1239.999992ps       8.2181077
+ 1249.999992ps       8.1789307
+ 1259.999993ps       8.0659112
+ 1269.999994ps       7.9549323
+ 1279.999995ps       7.6290859
+ 1289.999996ps       7.1992467
+ 1299.999997ps       6.7552797
+ 1309.999997ps        6.406892
+ 1319.999998ps       6.2100207
+ 1329.999999ps        6.139681
+ 1340.000000ps       6.2110029
+ 1350.000001ps       7.1622646
+ 1360.000002ps       8.9643737
+ 1370.000002ps       10.289898
+ 1380.000003ps       10.578653
+ 1390.000004ps       10.669131
+ 1400.000005ps       11.451474
+ 1410.000006ps       12.944604
+ 1420.000006ps       14.789723
+ 1430.000007ps       15.826102
+ 1440.000008ps       15.340757
+ 1450.000009ps       14.474666
+ 1460.000010ps       14.024417
+ 1470.000011ps       14.039218
+ 1480.000011ps       14.565633
+ 1490.000012ps       15.555592
+ 1500.000013ps        16.29269
+ 1510.000014ps       16.490903
+ 1520.000015ps       16.271852
+ 1530.000016ps       16.555132
+ 1540.000016ps       16.951213
+ 1550.000017ps       17.737456
+ 1560.000018ps       17.865565
+ 1570.000019ps       16.978446
+ 1580.000020ps       15.711359
+ 1590.000021ps       14.626801
+ 1600.000021ps       13.788222
+ 1610.000022ps       12.969011
+ 1620.000023ps       12.161447
+ 1630.000024ps       11.250424
+ 1640.000025ps       10.234534
+ 1650.000025ps       9.2050131
+ 1660.000026ps       8.1757914
+ 1670.000027ps       7.3071839
+ 1680.000028ps       6.6328537
+ 1690.000029ps       6.1505345
+ 1700.000030ps       5.8579183
+ 1710.000030ps       5.8354759
+ 1720.000031ps         6.05528
+ 1730.000032ps       6.2629845
+ 1740.000033ps       6.2522379
+ 1750.000034ps       6.5021899
+ 1760.000035ps       7.1466331
+ 1770.000035ps       7.6741069
+ 1780.000036ps         7.54788
+ 1790.000037ps       7.2218424
+ 1800.000038ps        7.178827
+ 1810.000039ps        7.313866
+ 1820.000040ps       7.2540193
+ 1830.000040ps       6.9901291
+ 1840.000041ps       6.9254509
+ 1850.000042ps       7.1358601
+ 1860.000043ps       7.4552345
+ 1869.999933ps       7.7608854
+ 1879.999934ps        7.966542
+ 1889.999934ps       8.1242098
+ 1899.999935ps       8.2253969
+ 1909.999936ps       8.2214042
+ 1919.999937ps       8.1440909
+ 1929.999938ps        8.039413
+ 1939.999938ps       7.8761467
+ 1949.999939ps       7.4767878
+ 1959.999940ps       7.0048537
+ 1969.999941ps       6.5895296
+ 1979.999942ps        6.304693
+ 1989.999943ps       6.1978253
+ 1999.999943ps       6.1559192
+ 2009.999944ps        6.403702
+ 2019.999945ps       7.6786598
+ 2029.999946ps       9.5667949
+ 2039.999947ps       10.616702
+ 2049.999948ps       10.665167
+ 2059.999948ps       10.893309
+ 2069.999949ps       11.945734
+ 2079.999950ps        13.59301
+ 2089.999951ps       15.395671
+ 2099.999952ps       15.964339
+ 2109.999953ps       15.054126
+ 2119.999953ps        14.16999
+ 2129.999954ps       13.877476
+ 2139.999955ps        14.21639
+ 2149.999956ps       14.988734
+ 2159.999957ps       15.917553
+ 2169.999958ps       16.417495
+ 2179.999958ps       16.289751
+ 2189.999959ps       16.245836
+ 2199.999960ps       16.791514
+ 2209.999961ps       17.342116
+ 2219.999962ps       17.990124
+ 2229.999962ps       17.699653
+ 2239.999963ps       16.495617
+ 2249.999964ps       15.221819
+ 2259.999965ps       14.282765
+ 2269.999966ps       13.460474
+ 2279.999967ps       12.658659
+ 2289.999967ps       11.812547
+ 2299.999968ps       10.855622
+ 2309.999969ps       9.8445985
+ 2319.999970ps        8.822426
+ 2329.999971ps       7.8546789
+ 2339.999972ps       7.0195627
+ 2349.999972ps       6.4334309
+ 2359.999973ps       6.0535865
+ 2369.999974ps       5.8698899
+ 2379.999975ps       5.9136151
+ 2389.999976ps       6.1697695
+ 2399.999977ps       6.2254934
+ 2409.999977ps       6.3118372
+ 2419.999978ps       6.7753156
+ 2429.999979ps       7.4837853
+ 2439.999980ps       7.6371915
+ 2449.999981ps       7.2979465
+ 2459.999982ps       7.1518901
+ 2469.999982ps       7.1940979
+ 2479.999983ps       7.4134178
+ 2489.999984ps       7.0956031
+ 2499.999985ps       6.8887657
+ 2509.999986ps       6.9576685
+ 2519.999986ps       7.2388831
+ 2529.999987ps       7.5900234
+ 2539.999988ps       7.8531641
+ 2549.999989ps       8.0353641
+ 2559.999990ps       8.1552972
+ 2569.999991ps       8.2163076
+ 2579.999991ps       8.1845222
+ 2589.999992ps       8.0827028
+ 2599.999993ps       7.9876933
+ 2609.999994ps       7.7189444
+ 2619.999995ps       7.2905044
+ 2629.999996ps       6.8298413
+ 2639.999996ps       6.4528792
+ 2649.999997ps       6.2631084
+ 2659.999998ps       6.1822574
+ 2669.999999ps       6.1649733
+ 2680.000000ps       6.8388201
+ 2690.000001ps       8.4854078
+ 2700.000001ps       10.000559
+ 2710.000002ps       10.640157
+ 2720.000003ps       10.710035
+ 2730.000004ps       11.217734
+ 2740.000005ps       12.564595
+ 2750.000005ps       14.329487
+ 2760.000006ps       15.655902
+ 2770.000007ps       15.671123
+ 2780.000008ps       14.754702
+ 2790.000009ps       14.069483
+ 2800.000010ps       14.009167
+ 2810.000010ps        14.50001
+ 2820.000011ps       15.388373
+ 2830.000012ps       16.176844
+ 2840.000013ps       16.471109
+ 2850.000014ps       16.213106
+ 2860.000015ps       16.429772
+ 2870.000015ps       16.911815
+ 2880.000016ps       17.635379
+ 2890.000017ps       17.956595
+ 2900.000018ps       17.213759
+ 2910.000019ps       15.936744
+ 2920.000020ps       14.811494
+ 2930.000020ps       13.937157
+ 2940.000021ps       13.137157
+ 2950.000022ps       12.334898
+ 2960.000023ps       11.447466
+ 2970.000024ps       10.452679
+ 2980.000025ps       9.4108364
+ 2990.000025ps       8.3757286
+ 3000.000026ps       7.4837669
+ 3010.000027ps       6.7460184
+ 3020.000028ps       6.2313531
+ 3030.000029ps       5.9074605
+ 3040.000029ps        5.827674
+ 3050.000030ps        5.936399
+ 3060.000031ps       6.2824453
+ 3070.000032ps       6.2579308
+ 3080.000033ps       6.3987822
+ 3090.000034ps       6.9904942
+ 3100.000034ps        7.587636
+ 3110.000035ps       7.6739695
+ 3120.000036ps       7.2656797
+ 3130.000037ps       7.1640059
+ 3140.000038ps        7.278251
+ 3150.000039ps       7.3229144
+ 3160.000039ps       7.0263446
+ 3170.000040ps        6.915558
+ 3180.000041ps        7.094517
+ 3190.000042ps       7.4020999
+ 3200.000043ps       7.7121819
+ 3210.000044ps       7.9375198
+ 3220.000044ps       8.1010477
+ 3230.000045ps       8.2058802
+ 3240.000046ps       8.2248641
+ 3250.000047ps       8.1631576
+ 3260.000048ps        8.064451
+ 3270.000049ps       7.9386196
+ 3280.000049ps       7.5727957
+ 3290.000050ps       7.1018305
+ 3300.000051ps       6.6715294
+ 3310.000052ps       6.3578815
+ 3320.000053ps       6.2284832
+ 3330.000053ps       6.1553466
+ 3340.000054ps       6.2823082
+ 3350.000055ps       7.4177698
+ 3360.000056ps       9.3042492
+ 3370.000057ps       10.480732
+ 3380.000058ps       10.644145
+ 3390.000058ps       10.749619
+ 3400.000059ps       11.637115
+ 3410.000060ps       13.272471
+ 3420.000061ps       15.086793
+ 3430.000062ps       15.951309
+ 3440.000063ps       15.225002
+ 3450.000063ps       14.341536
+ 3460.000064ps       13.966671
+ 3470.000065ps       14.151177
+ 3480.000066ps       14.788846
+ 3490.000067ps       15.774011
+ 3500.000068ps       16.372441
+ 3510.000068ps       16.324731
+ 3520.000069ps       16.206511
+ 3530.000070ps       16.670442
+ 3540.000071ps       17.116304
+ 3550.000072ps       17.937571
+ 3560.000073ps       17.833076
+ 3570.000073ps       16.688877
+ 3580.000074ps       15.426931
+ 3590.000075ps        14.48687
+ 3600.000076ps       13.650371
+ 3610.000077ps       12.825192
+ 3620.000077ps       11.983508
+ 3630.000078ps       11.020638
+ 3640.000079ps        10.01234
+ 3650.000080ps       8.9966287
+ 3660.000081ps       8.0085137
+ 3670.000082ps       7.1664776
+ 3680.000082ps       6.5415959
+ 3690.000083ps       6.0832684
+ 3700.000084ps       5.8398524
+ 3710.000085ps        5.844771
+ 3720.000086ps       6.1526701
+ 3729.999865ps       6.2504302
+ 3739.999865ps       6.2285475
+ 3749.999866ps       6.6472275
+ 3759.999867ps       7.3999927
+ 3769.999868ps       7.6745595
+ 3779.999869ps       7.3772365
+ 3789.999869ps       7.2141869
+ 3799.999870ps         7.23823
+ 3809.999871ps       7.4348315
+ 3819.999872ps       7.1094637
+ 3829.999873ps       6.8664641
+ 3839.999874ps       6.9151417
+ 3849.999874ps       7.1586321
+ 3859.999875ps       7.5129937
+ 3869.999876ps       7.8067224
+ 3879.999877ps       7.9923122
+ 3889.999878ps       8.1310918
+ 3899.999879ps       8.2182724
+ 3909.999879ps       8.1946182
+ 3919.999880ps         8.10192
+ 3929.999881ps       8.0098794
+ 3939.999882ps       7.8004175
+ 3949.999883ps       7.3880321
+ 3959.999884ps       6.8825898
+ 3969.999884ps       6.4927462
+ 3979.999885ps       6.2800964
+ 3989.999886ps       6.1759049
+ 3999.999887ps       6.1239485
+ 4009.999888ps        6.597156
+ 4019.999889ps       8.0455221
+ 4029.999889ps       9.8118264
+ 4039.999890ps       10.662039
+ 4049.999891ps       10.665075
+ 4059.999892ps       11.005431
+ 4069.999893ps       12.237065
+ 4079.999893ps       14.001099
+ 4089.999894ps       15.581838
+ 4099.999895ps       15.780562
+ 4109.999896ps       14.898492
+ 4119.999897ps       14.188363
+ 4129.999898ps        13.89871
+ 4139.999898ps        14.29865
+ 4149.999899ps       15.274312
+ 4159.999900ps       16.110768
+ 4169.999901ps       16.536038
+ 4179.999902ps       16.203684
+ 4189.999903ps        16.21023
+ 4199.999903ps       16.866918
+ 4209.999904ps       17.490897
+ 4219.999905ps       18.009643
+ 4229.999906ps       17.505641
+ 4239.999907ps       16.224785
+ 4249.999908ps       14.981607
+ 4259.999908ps       14.086953
+ 4269.999909ps       13.275657
+ 4279.999910ps       12.465461
+ 4289.999911ps       11.619026
+ 4299.999912ps       10.671506
+ 4309.999913ps       9.6060385
+ 4319.999913ps       8.5530925
+ 4329.999914ps       7.6411132
+ 4339.999915ps       6.8524848
+ 4349.999916ps       6.3088977
+ 4359.999917ps       5.9710054
+ 4369.999917ps       5.8153887
+ 4379.999918ps        5.929549
+ 4389.999919ps       6.2691718
+ 4399.999920ps       6.1997609
+ 4409.999921ps       6.3214206
+ 4419.999922ps       6.9049997
+ 4429.999922ps       7.5949256
+ 4439.999923ps       7.6892484
+ 4449.999924ps       7.2279513
+ 4459.999925ps       7.1283068
+ 4469.999926ps       7.2290182
+ 4479.999927ps       7.3949454
+ 4489.999927ps       7.0534566
+ 4499.999928ps       6.8859049
+ 4509.999929ps       7.0107238
+ 4519.999930ps       7.3113727
+ 4529.999931ps       7.6536227
+ 4539.999932ps       7.9107649
+ 4549.999932ps        8.078155
+ 4559.999933ps       8.1840927
+ 4569.999934ps       8.2237987
+ 4579.999935ps       8.1807211
+ 4589.999936ps       8.0758562
+ 4599.999937ps          7.9686
+ 4609.999937ps       7.6446622
+ 4619.999938ps       7.2211116
+ 4629.999939ps       6.7867913
+ 4639.999940ps        6.429193
+ 4649.999941ps       6.2344913
+ 4659.999941ps       6.1599283
+ 4669.999942ps        6.226778
+ 4679.999943ps       7.1761135
+ 4689.999944ps       8.9750555
+ 4699.999945ps       10.298403
+ 4709.999946ps       10.586034
+ 4719.999946ps       10.676947
+ 4729.999947ps       11.454756
+ 4739.999948ps       12.949346
+ 4749.999949ps       14.791417
+ 4759.999950ps       15.830801
+ 4769.999951ps       15.342841
+ 4779.999951ps       14.473008
+ 4789.999952ps       14.024215
+ 4799.999953ps       14.045911
+ 4809.999954ps       14.563126
+ 4819.999955ps       15.552129
+ 4829.999956ps       16.287967
+ 4839.999956ps       16.488043
+ 4849.999957ps       16.267317
+ 4859.999958ps       16.551031
+ 4869.999959ps       16.947692
+ 4879.999960ps       17.735606
+ 4889.999961ps       17.871731
+ 4899.999961ps       16.993536
+ 4909.999962ps       15.725304
+ 4919.999963ps        14.64684
+ 4929.999964ps       13.808705
+ 4939.999965ps        12.98319
+ 4949.999965ps       12.182709
+ 4959.999966ps       11.262964
+ 4969.999967ps        10.24634
+ 4979.999968ps       9.2177986
+ 4989.999969ps       8.1915343
+ 4999.999970ps       7.3164577
+ 5009.999970ps       6.6230062
+ 5019.999971ps        6.152433
+ 5029.999972ps       5.8695092
+ 5039.999973ps       5.8457985
+ 5049.999974ps       6.0625275
+ 5059.999975ps       6.2631395
+ 5069.999975ps        6.246956
+ 5079.999976ps       6.4973622
+ 5089.999977ps        7.141394
+ 5099.999978ps       7.6670256
+ 5109.999979ps       7.5390276
+ 5119.999980ps       7.2157088
+ 5129.999980ps          7.1685
+ 5139.999981ps       7.3089846
+ 5149.999982ps       7.2479494
+ 5159.999983ps       6.9832911
+ 5169.999984ps       6.9139459
+ 5179.999985ps       7.1285802
+ 5189.999985ps       7.4432618
+ 5199.999986ps       7.7479173
+ 5209.999987ps       7.9512237
+ 5219.999988ps       8.1097538
+ 5229.999989ps       8.2100203
+ 5239.999989ps       8.2072781
+ 5249.999990ps       8.1326509
+ 5259.999991ps       8.0268834
+ 5269.999992ps       7.8631275
+ 5279.999993ps       7.4611055
+ 5289.999994ps       6.9905405
+ 5299.999994ps       6.5756903
+ 5309.999995ps       6.2914839
+ 5319.999996ps        6.180408
+ 5329.999997ps       6.1369543
+ 5339.999998ps       6.3836973
+ 5349.999999ps       7.6676694
+ 5359.999999ps        9.565069
+ 5370.000000ps       10.610647
+ 5380.000001ps       10.656473
+ 5390.000002ps       10.881207
+ 5400.000003ps        11.92894
+ 5410.000004ps        13.58475
+ 5420.000004ps       15.398374
+ 5430.000005ps       15.962725
+ 5440.000006ps       15.050242
+ 5450.000007ps       14.171815
+ 5460.000008ps       13.877902
+ 5470.000009ps       14.214437
+ 5480.000009ps       14.996912
+ 5490.000010ps       15.923589
+ 5500.000011ps       16.421666
+ 5510.000012ps       16.291107
+ 5520.000013ps        16.24913
+ 5530.000013ps       16.792402
+ 5540.000014ps       17.343284
+ 5550.000015ps       17.982588
+ 5560.000016ps       17.683567
+ 5570.000017ps       16.480287
+ 5580.000018ps        15.20465
+ 5590.000018ps       14.273498
+ 5600.000019ps        13.46257
+ 5610.000020ps       12.655009
+ 5620.000021ps       11.815389
+ 5630.000022ps       10.853729
+ 5640.000023ps       9.8310734
+ 5650.000023ps       8.8036964
+ 5660.000024ps       7.8384948
+ 5670.000025ps       7.0061648
+ 5680.000026ps       6.4180845
+ 5690.000027ps       6.0374688
+ 5700.000028ps       5.8553492
+ 5710.000028ps       5.9058982
+ 5720.000029ps       6.1689181
+ 5730.000030ps       6.2288577
+ 5740.000031ps       6.3149683
+ 5750.000032ps       6.7834056
+ 5760.000033ps       7.4929689
+ 5770.000033ps       7.6488904
+ 5780.000034ps       7.3121783
+ 5790.000035ps        7.166609
+ 5800.000036ps       7.2165563
+ 5810.000037ps       7.4283613
+ 5820.000037ps       7.1052581
+ 5830.000038ps       6.9009432
+ 5840.000039ps       6.9699566
+ 5850.000040ps       7.2553743
+ 5860.000041ps       7.6106866
+ 5870.000042ps       7.8724854
+ 5880.000042ps       8.0508486
+ 5890.000043ps       8.1710183
+ 5900.000044ps       8.2315331
+ 5910.000045ps       8.1980087
+ 5920.000046ps        8.097309
+ 5930.000047ps       8.0067197
+ 5940.000047ps       7.7328345
+ 5950.000048ps       7.3174389
+ 5960.000049ps        6.852226
+ 5970.000050ps       6.4743462
+ 5980.000051ps       6.2864703
+ 5990.000052ps       6.2051679
+ 6000.000052ps       6.1867094
+ 6010.000053ps       6.8561874
+ 6020.000054ps       8.5027518
+ 6030.000055ps        10.01617
+ 6040.000056ps       10.654159
+ 6050.000056ps        10.72284
+ 6060.000057ps        11.22719
+ 6070.000058ps       12.575123
+ 6080.000059ps       14.343542
+ 6090.000060ps       15.668741
+ 6100.000061ps       15.682541
+ 6110.000061ps       14.758266
+ 6120.000062ps       14.078617
+ 6130.000063ps       14.021909
+ 6140.000064ps       14.507761
+ 6150.000065ps       15.391055
+ 6160.000066ps        16.17623
+ 6170.000066ps       16.459354
+ 6180.000067ps       16.201437
+ 6190.000068ps       16.420624
+ 6200.000069ps       16.907867
+ 6210.000070ps       17.639849
+ 6220.000071ps       17.963094
+ 6230.000071ps       17.218895
+ 6240.000072ps        15.94617
+ 6250.000073ps       14.827972
+ 6260.000074ps       13.954927
+ 6270.000075ps       13.149737
+ 6280.000076ps       12.345991
+ 6290.000076ps       11.455806
+ 6300.000077ps       10.463006
+ 6310.000078ps       9.4201247
+ 6320.000079ps       8.3828779
+ 6330.000080ps       7.4938373
+ 6340.000080ps       6.7559814
+ 6350.000081ps       6.2434432
+ 6360.000082ps       5.9178344
+ 6370.000083ps       5.8403577
+ 6380.000084ps       5.9459762
+ 6390.000085ps       6.2897028
+ 6400.000085ps       6.2659531
+ 6410.000086ps       6.4041285
+ 6420.000087ps       6.9956705
+ 6430.000088ps       7.5889832
+ 6440.000089ps       7.6683287
+ 6450.000090ps       7.2598224
+ 6460.000090ps        7.150351
+ 6470.000091ps       7.2673154
+ 6480.000092ps       7.3175327
+ 6490.000093ps       7.0184053
+ 6500.000094ps       6.9016963
+ 6510.000095ps       7.0783263
+ 6520.000095ps       7.3875294
+ 6530.000096ps        7.697083
+ 6540.000097ps       7.9226805
+ 6550.000098ps       8.0862986
+ 6560.000099ps        8.190459
+ 6570.000100ps       8.2117407
+ 6580.000100ps       8.1508563
+ 6590.000101ps       8.0487917
+ 6600.000102ps       7.9239848
+ 6610.000103ps       7.5557515
+ 6620.000104ps       7.0760298
+ 6630.000104ps       6.6515419
+ 6640.000105ps       6.3413635
+ 6650.000106ps       6.2076535
+ 6660.000107ps       6.1376238
+ 6670.000108ps       6.2673928
+ 6680.000109ps       7.4049807
+ 6690.000109ps       9.2921661
+ 6700.000110ps        10.46896
+ 6710.000111ps       10.634358
+ 6720.000112ps       10.740422
+ 6730.000113ps       11.627485
+ 6740.000114ps       13.262388
+ 6750.000114ps        15.07842
+ 6760.000115ps       15.944043
+ 6770.000116ps       15.221104
+ 6780.000117ps       14.343709
+ 6790.000118ps       13.968253
+ 6800.000119ps       14.148934
+ 6810.000119ps       14.794409
+ 6820.000120ps        15.77742
+ 6830.000121ps       16.377804
+ 6840.000122ps       16.329369
+ 6850.000123ps       16.207054
+ 6860.000124ps       16.660391
+ 6870.000124ps       17.103243
+ 6880.000125ps       17.920779
+ 6890.000126ps       17.816279
+ 6900.000127ps       16.683696
+ 6910.000128ps       15.424172
+ 6920.000128ps       14.483144
+ 6930.000129ps       13.641895
+ 6940.000130ps       12.816235
+ 6950.000131ps       11.974519
+ 6960.000132ps       11.020437
+ 6970.000133ps       10.009249
+ 6980.000133ps       8.9996006
+ 6990.000134ps       8.0082051
+ 7000.000135ps       7.1576891
+ 7010.000136ps       6.5307147
+ 7020.000137ps       6.0746343
+ 7030.000138ps       5.8408631
+ 7040.000138ps       5.8460791
+ 7050.000139ps       6.1527961
+ 7060.000140ps        6.250792
+ 7070.000141ps       6.2321572
+ 7080.000142ps       6.6553758
+ 7090.000143ps       7.4101947
+ 7100.000143ps       7.6837133
+ 7110.000144ps       7.3824458
+ 7120.000145ps       7.2132258
+ 7130.000146ps       7.2409077
+ 7140.000147ps       7.4376004
+ 7150.000147ps        7.112433
+ 7160.000148ps       6.8777944
+ 7170.000149ps       6.9283521
+ 7180.000150ps       7.1726567
+ 7190.000151ps        7.523871
+ 7200.000152ps       7.8143057
+ 7210.000152ps       8.0013828
+ 7220.000153ps       8.1421544
+ 7230.000154ps       8.2266923
+ 7240.000155ps       8.2035984
+ 7250.000156ps       8.1091974
+ 7260.000157ps       8.0220122
+ 7270.000157ps       7.8115715
+ 7280.000158ps       7.4068212
+ 7290.000159ps       6.9135394
+ 7300.000160ps       6.5111656
+ 7310.000161ps       6.2967049
+ 7320.000162ps       6.1929337
+ 7330.000162ps       6.1384479
+ 7340.000163ps       6.6070944
+ 7350.000164ps       8.0565651
+ 7360.000165ps       9.8223119
+ 7370.000166ps       10.670873
+ 7380.000167ps       10.672263
+ 7390.000167ps       11.008824
+ 7400.000168ps       12.241592
+ 7410.000169ps       14.005655
+ 7420.000170ps       15.584702
+ 7430.000171ps       15.778519
+ 7440.000171ps       14.891892
+ 7450.000172ps        14.18182
+ 7459.999729ps       13.895426
+ 7469.999730ps       14.295669
+ 7479.999731ps       15.262324
+ 7489.999732ps       16.100205
+ 7499.999732ps       16.523135
+ 7509.999733ps       16.196073
+ 7519.999734ps       16.205516
+ 7529.999735ps       16.866933
+ 7539.999736ps       17.486199
+ 7549.999737ps       18.008074
+ 7559.999737ps       17.503134
+ 7569.999738ps       16.214175
+ 7579.999739ps       14.974079
+ 7589.999740ps       14.088229
+ 7599.999741ps       13.293189
+ 7609.999741ps       12.488482
+ 7619.999742ps       11.637326
+ 7629.999743ps       10.685855
+ 7639.999744ps       9.6273149
+ 7649.999745ps       8.5717612
+ 7659.999746ps       7.6514978
+ 7669.999746ps       6.8599974
+ 7679.999747ps       6.3075777
+ 7689.999748ps        5.967812
+ 7699.999749ps       5.8139072
+ 7709.999750ps       5.9308234
+ 7719.999751ps        6.263983
+ 7729.999751ps       6.1911109
+ 7739.999752ps       6.3071904
+ 7749.999753ps       6.8953487
+ 7759.999754ps       7.5842167
+ 7769.999755ps       7.6845037
+ 7779.999756ps       7.2201376
+ 7789.999756ps       7.1195077
+ 7799.999757ps        7.220109
+ 7809.999758ps       7.3876818
+ 7819.999759ps       7.0434399
+ 7829.999760ps       6.8813521
+ 7839.999761ps       7.0052066
+ 7849.999761ps        7.304161
+ 7859.999762ps       7.6432441
+ 7869.999763ps       7.9014147
+ 7879.999764ps       8.0690602
+ 7889.999765ps       8.1758843
+ 7899.999765ps       8.2141986
+ 7909.999766ps        8.172548
+ 7919.999767ps       8.0604094
+ 7929.999768ps       7.9501557
+ 7939.999769ps       7.6343795
+ 7949.999770ps       7.1980636
+ 7959.999770ps       6.7682323
+ 7969.999771ps       6.4128172
+ 7979.999772ps       6.2109834
+ 7989.999773ps       6.1344122
+)

Icursig20 PAR_1_3_VSS 0 pwl(
+ 0.000000ps      -2.8900913
+ 10.000000ps      -2.9538189
+ 20.000000ps      -3.0304507
+ 29.999999ps      -3.2135248
+ 40.000000ps      -3.6064734
+ 50.000001ps      -4.2587559
+ 59.999998ps      -5.1374714
+ 69.999999ps      -6.6102774
+ 80.000000ps        -8.38486
+ 90.000001ps      -9.5620322
+ 100.000001ps      -9.6107526
+ 110.000002ps      -10.136892
+ 119.999996ps      -11.494338
+ 129.999997ps      -13.668274
+ 139.999998ps      -16.371815
+ 149.999999ps      -17.762961
+ 159.999999ps      -17.451726
+ 170.000000ps      -17.145159
+ 180.000001ps      -17.556214
+ 190.000002ps      -17.537464
+ 200.000003ps      -17.941441
+ 210.000003ps      -18.358196
+ 220.000004ps       -17.96724
+ 230.000005ps      -17.114202
+ 239.999992ps      -15.763693
+ 249.999993ps      -14.196579
+ 259.999994ps      -12.827609
+ 269.999995ps       -11.51437
+ 279.999995ps      -10.476266
+ 289.999996ps      -9.6845313
+ 299.999997ps      -8.8755055
+ 309.999998ps      -8.0709655
+ 319.999999ps      -7.1809456
+ 330.000000ps      -6.4000388
+ 340.000000ps        -5.87285
+ 350.000001ps      -5.6115924
+ 360.000002ps      -5.6823241
+ 370.000003ps      -5.3349383
+ 380.000004ps      -5.1380579
+ 390.000005ps      -5.5766757
+ 400.000005ps      -5.9522385
+ 410.000006ps      -6.6041063
+ 420.000007ps      -6.7589845
+ 430.000008ps      -7.2832607
+ 440.000009ps      -8.4799153
+ 450.000009ps      -9.3144621
+ 460.000010ps      -10.066745
+ 469.999983ps      -10.303625
+ 479.999984ps      -10.450908
+ 489.999985ps      -10.781749
+ 499.999986ps      -11.136323
+ 509.999987ps      -11.170807
+ 519.999988ps      -11.261744
+ 529.999988ps      -11.488189
+ 539.999989ps      -11.729596
+ 549.999990ps       -11.52495
+ 559.999991ps      -10.876281
+ 569.999992ps      -10.170076
+ 579.999992ps      -9.4074965
+ 589.999993ps      -8.6022439
+ 599.999994ps      -7.8130644
+ 609.999995ps      -7.0275203
+ 619.999996ps      -6.3383231
+ 629.999997ps      -5.7223832
+ 639.999997ps      -5.1881944
+ 649.999998ps      -4.7345705
+ 659.999999ps      -4.3820538
+ 670.000000ps      -4.1322194
+ 680.000001ps      -3.9338695
+ 690.000002ps      -3.8410461
+ 700.000002ps      -3.9593046
+ 710.000003ps      -4.4260561
+ 720.000004ps       -5.127396
+ 730.000005ps      -6.1915241
+ 740.000006ps      -7.6335812
+ 750.000007ps      -9.0167927
+ 760.000007ps      -9.6622457
+ 770.000008ps      -9.9647445
+ 780.000009ps      -10.716229
+ 790.000010ps      -12.545747
+ 800.000011ps      -14.945304
+ 810.000012ps      -17.182872
+ 820.000012ps       -17.89223
+ 830.000013ps      -17.281099
+ 840.000014ps       -17.23576
+ 850.000015ps      -17.647053
+ 860.000016ps      -17.785032
+ 870.000016ps        -18.3157
+ 880.000017ps       -18.31799
+ 890.000018ps       -17.63801
+ 900.000019ps      -16.559088
+ 910.000020ps      -15.139197
+ 920.000021ps      -13.650233
+ 930.000021ps        -12.2817
+ 939.999967ps       -11.06112
+ 949.999968ps      -10.136528
+ 959.999968ps      -9.4603463
+ 969.999969ps       -8.585054
+ 979.999970ps       -7.721066
+ 989.999971ps      -6.8662637
+ 999.999972ps       -6.188937
+ 1009.999973ps       -5.720796
+ 1019.999973ps      -5.4896411
+ 1029.999974ps      -5.5962135
+ 1039.999975ps       -5.312163
+ 1049.999976ps      -5.1986444
+ 1059.999977ps      -5.7626592
+ 1069.999978ps      -6.3358046
+ 1079.999978ps      -6.6767715
+ 1089.999979ps      -6.8930779
+ 1099.999980ps      -7.7936496
+ 1109.999981ps      -9.0082641
+ 1119.999982ps      -9.8950709
+ 1129.999982ps      -10.110312
+ 1139.999983ps      -10.267176
+ 1149.999984ps      -10.547968
+ 1159.999985ps      -11.040368
+ 1169.999986ps      -11.116988
+ 1179.999987ps      -11.163423
+ 1189.999987ps      -11.384525
+ 1199.999988ps      -11.636192
+ 1209.999989ps      -11.801793
+ 1219.999990ps       -11.24227
+ 1229.999991ps      -10.587432
+ 1239.999992ps      -9.8670502
+ 1249.999992ps      -9.0903411
+ 1259.999993ps      -8.2871655
+ 1269.999994ps      -7.5112292
+ 1279.999995ps      -6.7496332
+ 1289.999996ps      -6.0818815
+ 1299.999997ps      -5.4985685
+ 1309.999997ps      -5.0103717
+ 1319.999998ps      -4.5945148
+ 1329.999999ps      -4.2734158
+ 1340.000000ps      -4.0502693
+ 1350.000001ps      -3.8892899
+ 1360.000002ps       -3.855003
+ 1370.000002ps      -4.0769378
+ 1380.000003ps      -4.6382119
+ 1390.000004ps      -5.4344775
+ 1400.000005ps      -6.6736842
+ 1410.000006ps      -8.2391358
+ 1420.000006ps      -9.4641874
+ 1430.000007ps      -9.7708641
+ 1440.000008ps      -10.286457
+ 1450.000009ps      -11.337305
+ 1460.000010ps      -13.386842
+ 1470.000011ps      -15.941753
+ 1480.000011ps      -17.575517
+ 1490.000012ps      -17.709012
+ 1500.000013ps      -17.126382
+ 1510.000014ps      -17.480499
+ 1520.000015ps      -17.687617
+ 1530.000016ps      -17.943573
+ 1540.000016ps       -18.36603
+ 1550.000017ps      -18.023309
+ 1560.000018ps       -17.29332
+ 1570.000019ps      -16.250178
+ 1580.000020ps      -14.629701
+ 1590.000021ps      -13.188448
+ 1600.000021ps      -11.811732
+ 1610.000022ps      -10.730065
+ 1620.000023ps      -9.9236614
+ 1630.000024ps      -9.1058648
+ 1640.000025ps      -8.2770935
+ 1650.000025ps      -7.3714805
+ 1660.000026ps      -6.5556917
+ 1670.000027ps      -6.0050888
+ 1680.000028ps      -5.7206296
+ 1690.000029ps      -5.7464997
+ 1700.000030ps      -5.4206745
+ 1710.000030ps      -5.1777851
+ 1720.000031ps      -5.4930978
+ 1730.000032ps      -5.8858502
+ 1740.000033ps      -6.6129358
+ 1750.000034ps      -6.7231891
+ 1760.000035ps      -7.1317537
+ 1770.000035ps      -8.2516813
+ 1780.000036ps      -9.1584385
+ 1790.000037ps      -10.044708
+ 1800.000038ps      -10.297224
+ 1810.000039ps      -10.405315
+ 1820.000040ps      -10.724504
+ 1830.000040ps      -11.182436
+ 1840.000041ps      -11.207712
+ 1850.000042ps      -11.235605
+ 1860.000043ps         -11.467
+ 1869.999933ps      -11.703097
+ 1879.999934ps      -11.680661
+ 1889.999934ps      -11.039076
+ 1899.999935ps      -10.317917
+ 1909.999936ps      -9.5809637
+ 1919.999937ps      -8.7771871
+ 1929.999938ps      -7.9976397
+ 1939.999938ps      -7.2321997
+ 1949.999939ps      -6.5045391
+ 1959.999940ps      -5.8582764
+ 1969.999941ps      -5.3120178
+ 1979.999942ps      -4.8453685
+ 1989.999943ps      -4.4680412
+ 1999.999943ps       -4.176544
+ 2009.999944ps      -3.9901083
+ 2019.999945ps      -3.8834169
+ 2029.999946ps      -3.9626359
+ 2039.999947ps       -4.306263
+ 2049.999948ps       -4.858953
+ 2059.999948ps      -5.7902688
+ 2069.999949ps      -7.2977757
+ 2079.999950ps      -8.8879795
+ 2089.999951ps      -9.7717519
+ 2099.999952ps      -9.9128042
+ 2109.999953ps      -10.499132
+ 2119.999953ps      -12.091252
+ 2129.999954ps      -14.353463
+ 2139.999955ps        -16.8943
+ 2149.999956ps      -17.992264
+ 2159.999957ps      -17.487536
+ 2169.999958ps       -17.26165
+ 2179.999958ps      -17.618195
+ 2189.999959ps      -17.638605
+ 2199.999960ps      -18.268132
+ 2209.999961ps      -18.501879
+ 2219.999962ps      -17.856157
+ 2229.999962ps      -16.857438
+ 2239.999963ps      -15.536414
+ 2249.999964ps      -14.028991
+ 2259.999965ps      -12.585868
+ 2269.999966ps      -11.286752
+ 2279.999967ps       -10.33503
+ 2289.999967ps      -9.6292463
+ 2299.999968ps      -8.8130575
+ 2309.999969ps      -7.9341006
+ 2319.999970ps       -7.045302
+ 2329.999971ps       -6.324725
+ 2339.999972ps      -5.8178902
+ 2349.999972ps       -5.583495
+ 2359.999973ps      -5.6674494
+ 2369.999974ps       -5.346135
+ 2379.999975ps      -5.1895849
+ 2389.999976ps      -5.6918318
+ 2399.999977ps      -6.2751441
+ 2409.999977ps      -6.6362334
+ 2419.999978ps      -6.7902216
+ 2429.999979ps      -7.5940304
+ 2439.999980ps      -8.7879949
+ 2449.999981ps      -9.7361357
+ 2459.999982ps      -10.055638
+ 2469.999982ps      -10.260685
+ 2479.999983ps      -10.505435
+ 2489.999984ps      -10.910683
+ 2499.999985ps      -11.147116
+ 2509.999986ps      -11.187777
+ 2519.999986ps      -11.343522
+ 2529.999987ps      -11.586233
+ 2539.999988ps       -11.78158
+ 2549.999989ps      -11.440828
+ 2559.999990ps        -10.7803
+ 2569.999991ps      -10.051431
+ 2579.999991ps      -9.2804138
+ 2589.999992ps      -8.4747625
+ 2599.999993ps      -7.6898629
+ 2609.999994ps      -6.9142487
+ 2619.999995ps      -6.2284244
+ 2629.999996ps      -5.6299653
+ 2639.999996ps      -5.1212445
+ 2649.999997ps      -4.6879091
+ 2659.999998ps      -4.3501725
+ 2669.999999ps      -4.1153692
+ 2680.000000ps      -3.9387926
+ 2690.000001ps      -3.8848528
+ 2700.000001ps      -4.0440827
+ 2710.000002ps      -4.5139172
+ 2720.000003ps      -5.2911729
+ 2730.000004ps      -6.4819245
+ 2740.000005ps      -8.0073926
+ 2750.000005ps      -9.3051353
+ 2760.000006ps      -9.7091303
+ 2770.000007ps      -10.130418
+ 2780.000008ps      -11.005231
+ 2790.000009ps      -12.964714
+ 2800.000010ps      -15.563913
+ 2810.000010ps      -17.503316
+ 2820.000011ps      -17.842422
+ 2830.000012ps      -17.090544
+ 2840.000013ps      -17.195576
+ 2850.000014ps      -17.795562
+ 2860.000015ps      -17.939831
+ 2870.000015ps      -18.375141
+ 2880.000016ps      -18.236016
+ 2890.000017ps      -17.421928
+ 2900.000018ps      -16.372138
+ 2910.000019ps      -14.943072
+ 2920.000020ps      -13.427127
+ 2930.000020ps      -12.032013
+ 2940.000021ps      -10.902009
+ 2950.000022ps      -10.031762
+ 2960.000023ps       -9.306383
+ 2970.000024ps      -8.4557964
+ 2980.000025ps      -7.5643332
+ 2990.000025ps       -6.733331
+ 3000.000026ps      -6.1160195
+ 3010.000027ps      -5.7483585
+ 3020.000028ps      -5.6529265
+ 3030.000029ps       -5.511445
+ 3040.000029ps       -5.232366
+ 3050.000030ps       -5.305775
+ 3060.000031ps      -5.8786546
+ 3070.000032ps      -6.5393808
+ 3080.000033ps      -6.6632217
+ 3090.000034ps      -6.9879747
+ 3100.000034ps       -7.983408
+ 3110.000035ps      -9.1722996
+ 3120.000036ps      -10.023919
+ 3130.000037ps      -10.229421
+ 3140.000038ps      -10.354375
+ 3150.000039ps      -10.656407
+ 3160.000039ps      -11.165479
+ 3170.000040ps      -11.175133
+ 3180.000041ps      -11.205656
+ 3190.000042ps       -11.46028
+ 3200.000043ps      -11.699261
+ 3210.000044ps      -11.774346
+ 3220.000044ps      -11.139309
+ 3230.000045ps      -10.469548
+ 3240.000046ps      -9.7380746
+ 3250.000047ps      -8.9475775
+ 3260.000048ps      -8.1589173
+ 3270.000049ps      -7.3873024
+ 3280.000049ps      -6.6440373
+ 3290.000050ps      -5.9847586
+ 3300.000051ps      -5.4259769
+ 3310.000052ps      -4.9435295
+ 3320.000053ps      -4.5453666
+ 3330.000053ps      -4.2376963
+ 3340.000054ps      -4.0269128
+ 3350.000055ps      -3.8878687
+ 3360.000056ps      -3.8988604
+ 3370.000057ps       -4.156992
+ 3380.000058ps      -4.6979381
+ 3390.000058ps       -5.505009
+ 3400.000059ps      -6.9186281
+ 3410.000060ps      -8.6441437
+ 3420.000061ps      -9.7903056
+ 3430.000062ps      -9.8103936
+ 3440.000063ps       -10.31563
+ 3450.000063ps      -11.641748
+ 3460.000064ps      -13.813261
+ 3470.000065ps      -16.506453
+ 3480.000066ps        -17.8901
+ 3490.000067ps      -17.572386
+ 3500.000068ps      -17.256169
+ 3510.000068ps      -17.652688
+ 3520.000069ps      -17.629816
+ 3530.000070ps      -18.035893
+ 3540.000071ps      -18.456942
+ 3550.000072ps      -18.066298
+ 3560.000073ps      -17.215146
+ 3570.000073ps      -15.864222
+ 3580.000074ps       -14.29481
+ 3590.000075ps      -12.922249
+ 3600.000076ps      -11.601184
+ 3610.000077ps      -10.557985
+ 3620.000077ps      -9.7627113
+ 3630.000078ps      -8.9490346
+ 3640.000079ps      -8.1308076
+ 3650.000080ps      -7.2423539
+ 3660.000081ps        -6.46154
+ 3670.000082ps      -5.9236583
+ 3680.000082ps      -5.6571336
+ 3690.000083ps      -5.7271957
+ 3700.000084ps      -5.3738768
+ 3710.000085ps      -5.1759601
+ 3720.000086ps      -5.6145394
+ 3729.999865ps      -5.9904982
+ 3739.999865ps      -6.6454399
+ 3749.999866ps      -6.7959706
+ 3759.999867ps      -7.3216193
+ 3769.999868ps      -8.5156215
+ 3779.999869ps      -9.3492141
+ 3789.999869ps      -10.097086
+ 3799.999870ps      -10.336646
+ 3809.999871ps      -10.488768
+ 3819.999872ps      -10.820125
+ 3829.999873ps      -11.174432
+ 3839.999874ps      -11.210803
+ 3849.999874ps      -11.305504
+ 3859.999875ps      -11.533893
+ 3869.999876ps      -11.776186
+ 3879.999877ps      -11.569953
+ 3889.999878ps      -10.912459
+ 3899.999879ps      -10.199655
+ 3909.999879ps      -9.4462672
+ 3919.999880ps      -8.6409902
+ 3929.999881ps      -7.8529848
+ 3939.999882ps      -7.0680001
+ 3949.999883ps      -6.3667222
+ 3959.999884ps      -5.7465713
+ 3969.999884ps      -5.2215018
+ 3979.999885ps      -4.7699014
+ 3989.999886ps      -4.4182738
+ 3999.999887ps      -4.1680097
+ 4009.999888ps      -3.9694179
+ 4019.999889ps      -3.8767219
+ 4029.999889ps      -3.9934209
+ 4039.999890ps      -4.4592081
+ 4049.999891ps      -5.1676871
+ 4059.999892ps      -6.2280048
+ 4069.999893ps      -7.6709472
+ 4079.999893ps       -9.052739
+ 4089.999894ps      -9.6972624
+ 4099.999895ps          -9.998
+ 4109.999896ps      -10.749281
+ 4119.999897ps      -12.578667
+ 4129.999898ps      -14.976782
+ 4139.999898ps      -17.217593
+ 4149.999899ps      -17.924285
+ 4159.999900ps      -17.308984
+ 4169.999901ps      -17.261787
+ 4179.999902ps      -17.669428
+ 4189.999903ps      -17.804687
+ 4199.999903ps      -18.332807
+ 4209.999904ps       -18.34248
+ 4219.999905ps      -17.666049
+ 4229.999906ps      -16.588146
+ 4239.999907ps      -15.163321
+ 4249.999908ps      -13.668072
+ 4259.999908ps      -12.300958
+ 4269.999909ps      -11.078746
+ 4279.999910ps      -10.159947
+ 4289.999911ps      -9.4877279
+ 4299.999912ps      -8.6135558
+ 4309.999913ps      -7.7522797
+ 4319.999913ps      -6.8979474
+ 4329.999914ps       -6.219535
+ 4339.999915ps       -5.766735
+ 4349.999916ps      -5.5386779
+ 4359.999917ps      -5.6473608
+ 4369.999917ps      -5.3549187
+ 4379.999918ps      -5.2361062
+ 4389.999919ps      -5.7930605
+ 4399.999920ps      -6.3594841
+ 4409.999921ps      -6.6970599
+ 4419.999922ps      -6.9187696
+ 4429.999922ps      -7.8201113
+ 4439.999923ps      -9.0528647
+ 4449.999924ps      -9.9347006
+ 4459.999925ps      -10.149973
+ 4469.999926ps      -10.307491
+ 4479.999927ps      -10.590708
+ 4489.999927ps      -11.076827
+ 4499.999928ps      -11.153582
+ 4509.999929ps      -11.194816
+ 4519.999930ps      -11.419591
+ 4529.999931ps      -11.673341
+ 4539.999932ps       -11.83629
+ 4549.999932ps      -11.281145
+ 4559.999933ps      -10.626773
+ 4569.999934ps      -9.9113067
+ 4579.999935ps      -9.1250026
+ 4589.999936ps      -8.3204566
+ 4599.999937ps      -7.5427226
+ 4609.999937ps      -6.7778429
+ 4619.999938ps      -6.1206493
+ 4629.999939ps      -5.5403087
+ 4639.999940ps      -5.0423406
+ 4649.999941ps      -4.6225608
+ 4659.999941ps       -4.299238
+ 4669.999942ps      -4.0744322
+ 4679.999943ps       -3.912718
+ 4689.999944ps       -3.878163
+ 4699.999945ps      -4.1007406
+ 4709.999946ps      -4.6619232
+ 4719.999946ps       -5.449855
+ 4729.999947ps      -6.6943151
+ 4739.999948ps      -8.2599674
+ 4749.999949ps      -9.4857798
+ 4759.999950ps       -9.793826
+ 4769.999951ps      -10.307921
+ 4779.999951ps      -11.359102
+ 4789.999952ps      -13.409208
+ 4799.999953ps      -15.963662
+ 4809.999954ps      -17.595484
+ 4819.999955ps      -17.737418
+ 4829.999956ps      -17.159518
+ 4839.999956ps      -17.516592
+ 4849.999957ps      -17.723051
+ 4859.999958ps      -17.973928
+ 4869.999959ps      -18.395074
+ 4879.999960ps      -18.047715
+ 4889.999961ps      -17.322297
+ 4899.999961ps       -16.28156
+ 4909.999962ps      -14.666015
+ 4919.999963ps      -13.218465
+ 4929.999964ps      -11.842558
+ 4939.999965ps       -10.75576
+ 4949.999965ps       -9.944492
+ 4959.999966ps       -9.124363
+ 4969.999967ps      -8.2910468
+ 4979.999968ps      -7.3850372
+ 4989.999969ps      -6.5637635
+ 4999.999970ps      -6.0056676
+ 5009.999970ps      -5.7144322
+ 5019.999971ps      -5.7450917
+ 5029.999972ps      -5.4257357
+ 5039.999973ps      -5.1876688
+ 5049.999974ps      -5.5062068
+ 5059.999975ps      -5.8916189
+ 5069.999975ps      -6.6132201
+ 5079.999976ps      -6.7204553
+ 5089.999977ps      -7.1298176
+ 5099.999978ps      -8.2524347
+ 5109.999979ps      -9.1633289
+ 5119.999980ps      -10.054332
+ 5129.999980ps      -10.310663
+ 5139.999981ps       -10.42443
+ 5149.999982ps      -10.742887
+ 5159.999983ps      -11.200421
+ 5169.999984ps      -11.220775
+ 5179.999985ps      -11.248643
+ 5189.999985ps      -11.481184
+ 5199.999986ps      -11.717018
+ 5209.999987ps      -11.696082
+ 5219.999988ps      -11.046165
+ 5229.999989ps      -10.331436
+ 5239.999989ps      -9.5961459
+ 5249.999990ps      -8.7963487
+ 5259.999991ps      -8.0157608
+ 5269.999992ps      -7.2491816
+ 5279.999993ps      -6.5213327
+ 5289.999994ps      -5.8734708
+ 5299.999994ps      -5.3157368
+ 5309.999995ps      -4.8527921
+ 5319.999996ps      -4.4758258
+ 5329.999997ps      -4.1851338
+ 5339.999998ps      -3.9998222
+ 5349.999999ps      -3.8927487
+ 5359.999999ps      -3.9724073
+ 5370.000000ps      -4.3174537
+ 5380.000001ps      -4.8710726
+ 5390.000002ps      -5.8001522
+ 5400.000003ps      -7.3080155
+ 5410.000004ps      -8.8987302
+ 5420.000004ps      -9.7803792
+ 5430.000005ps      -9.9197938
+ 5440.000006ps      -10.505695
+ 5450.000007ps      -12.097797
+ 5460.000008ps      -14.360721
+ 5470.000009ps      -16.903924
+ 5480.000009ps      -17.995745
+ 5490.000010ps      -17.489918
+ 5500.000011ps      -17.267396
+ 5510.000012ps      -17.627774
+ 5520.000013ps      -17.645942
+ 5530.000013ps      -18.273509
+ 5540.000014ps      -18.502611
+ 5550.000015ps      -17.854178
+ 5560.000016ps      -16.849387
+ 5570.000017ps      -15.524275
+ 5580.000018ps      -14.013299
+ 5590.000018ps      -12.572294
+ 5600.000019ps       -11.27798
+ 5610.000020ps      -10.329131
+ 5620.000021ps      -9.6196933
+ 5630.000022ps      -8.8123596
+ 5640.000023ps      -7.9357579
+ 5650.000023ps      -7.0561037
+ 5660.000024ps      -6.3422842
+ 5670.000025ps      -5.8437226
+ 5680.000026ps      -5.6109517
+ 5690.000027ps      -5.6980733
+ 5700.000028ps      -5.3826067
+ 5710.000028ps      -5.2225848
+ 5720.000029ps      -5.7185423
+ 5730.000030ps      -6.2951908
+ 5740.000031ps      -6.6507838
+ 5750.000032ps      -6.8094744
+ 5760.000033ps      -7.6128927
+ 5770.000033ps      -8.8067404
+ 5780.000034ps      -9.7521967
+ 5790.000035ps      -10.074032
+ 5800.000036ps      -10.281007
+ 5810.000037ps      -10.526519
+ 5820.000037ps      -10.930764
+ 5830.000038ps      -11.165221
+ 5840.000039ps      -11.208761
+ 5850.000040ps      -11.368674
+ 5860.000041ps       -11.60872
+ 5870.000042ps      -11.801626
+ 5880.000042ps      -11.459894
+ 5890.000043ps      -10.787838
+ 5900.000044ps      -10.077783
+ 5910.000045ps      -9.3010371
+ 5920.000046ps      -8.4909826
+ 5930.000047ps       -7.704162
+ 5940.000047ps      -6.9275037
+ 5950.000048ps      -6.2389205
+ 5960.000049ps      -5.6384643
+ 5970.000050ps      -5.1281343
+ 5980.000051ps      -4.6966899
+ 5990.000052ps      -4.3596191
+ 6000.000052ps      -4.1254723
+ 6010.000053ps      -3.9504255
+ 6020.000054ps       -3.896881
+ 6030.000055ps      -4.0566526
+ 6040.000056ps      -4.5325546
+ 6050.000056ps      -5.3124394
+ 6060.000057ps      -6.4968243
+ 6070.000058ps      -8.0215891
+ 6080.000059ps      -9.3206537
+ 6090.000060ps      -9.7253034
+ 6100.000061ps      -10.146972
+ 6110.000061ps      -11.024216
+ 6120.000062ps      -12.982245
+ 6130.000063ps      -15.580349
+ 6140.000064ps      -17.517061
+ 6150.000065ps      -17.854997
+ 6160.000066ps      -17.109732
+ 6170.000066ps      -17.221879
+ 6180.000067ps      -17.822872
+ 6190.000068ps      -17.964849
+ 6200.000069ps      -18.404521
+ 6210.000070ps      -18.264541
+ 6220.000071ps      -17.449785
+ 6230.000071ps      -16.391471
+ 6240.000072ps      -14.965646
+ 6250.000073ps      -13.449781
+ 6260.000074ps      -12.054332
+ 6270.000075ps      -10.921516
+ 6280.000076ps      -10.050382
+ 6290.000076ps      -9.3292681
+ 6300.000077ps      -8.4740531
+ 6310.000078ps      -7.5751881
+ 6320.000079ps      -6.7441494
+ 6330.000080ps       -6.128912
+ 6340.000080ps      -5.7601175
+ 6350.000081ps      -5.6597553
+ 6360.000082ps      -5.5192957
+ 6370.000083ps       -5.232371
+ 6380.000084ps      -5.3115999
+ 6390.000085ps      -5.8871697
+ 6400.000085ps      -6.5466998
+ 6410.000086ps      -6.6746346
+ 6420.000087ps      -6.9953698
+ 6430.000088ps      -7.9904988
+ 6440.000089ps      -9.1778118
+ 6450.000090ps        -10.0289
+ 6460.000090ps      -10.236334
+ 6470.000091ps      -10.363719
+ 6480.000092ps      -10.663118
+ 6490.000093ps      -11.170426
+ 6500.000094ps      -11.176486
+ 6510.000095ps      -11.206302
+ 6520.000095ps       -11.46004
+ 6530.000096ps      -11.702694
+ 6540.000097ps      -11.779915
+ 6550.000098ps      -11.144077
+ 6560.000099ps      -10.474652
+ 6570.000100ps      -9.7452797
+ 6580.000100ps      -8.9547448
+ 6590.000101ps      -8.1665983
+ 6600.000102ps      -7.3930308
+ 6610.000103ps      -6.6501773
+ 6620.000104ps       -5.992087
+ 6630.000104ps      -5.4227212
+ 6640.000105ps       -4.946878
+ 6650.000106ps      -4.5498252
+ 6660.000107ps      -4.2436266
+ 6670.000108ps      -4.0336459
+ 6680.000109ps      -3.8953653
+ 6690.000109ps      -3.9069196
+ 6700.000110ps      -4.1643144
+ 6710.000111ps      -4.7039442
+ 6720.000112ps      -5.5091614
+ 6730.000113ps      -6.9231534
+ 6740.000114ps      -8.6474823
+ 6750.000114ps      -9.7935362
+ 6760.000115ps      -9.8134379
+ 6770.000116ps      -10.321036
+ 6780.000117ps      -11.662669
+ 6790.000118ps      -13.825584
+ 6800.000119ps      -16.518316
+ 6810.000119ps      -17.896693
+ 6820.000120ps      -17.575733
+ 6830.000121ps      -17.259735
+ 6840.000122ps      -17.661912
+ 6850.000123ps      -17.638126
+ 6860.000124ps      -18.039855
+ 6870.000124ps       -18.45124
+ 6880.000125ps       -18.06103
+ 6890.000126ps      -17.207528
+ 6900.000127ps      -15.856612
+ 6910.000128ps      -14.283684
+ 6920.000128ps      -12.907671
+ 6930.000129ps      -11.590449
+ 6940.000130ps      -10.557097
+ 6950.000131ps      -9.7608262
+ 6960.000132ps      -8.9498187
+ 6970.000133ps      -8.1348155
+ 6980.000133ps      -7.2429935
+ 6990.000134ps      -6.4629611
+ 7000.000135ps       -5.931182
+ 7010.000136ps      -5.6721222
+ 7020.000137ps      -5.7480696
+ 7030.000138ps      -5.3972486
+ 7040.000138ps      -5.1983924
+ 7050.000139ps       -5.637071
+ 7060.000140ps      -6.0123918
+ 7070.000141ps      -6.6598768
+ 7080.000142ps      -6.8090289
+ 7090.000143ps      -7.3380972
+ 7100.000143ps       -8.528736
+ 7110.000144ps      -9.3662965
+ 7120.000145ps      -10.115768
+ 7130.000146ps       -10.34983
+ 7140.000147ps      -10.500744
+ 7150.000147ps      -10.832105
+ 7160.000148ps      -11.191358
+ 7170.000149ps      -11.225577
+ 7180.000150ps       -11.31786
+ 7190.000151ps      -11.547322
+ 7200.000152ps      -11.786631
+ 7210.000152ps      -11.578927
+ 7220.000153ps      -10.921001
+ 7230.000154ps       -10.20915
+ 7240.000155ps      -9.4530708
+ 7250.000156ps      -8.6482399
+ 7260.000157ps      -7.8626678
+ 7270.000157ps        -7.07826
+ 7280.000158ps      -6.3752136
+ 7290.000159ps      -5.7544105
+ 7300.000160ps       -5.229073
+ 7310.000161ps      -4.7764688
+ 7320.000162ps      -4.4233792
+ 7330.000162ps      -4.1736978
+ 7340.000163ps      -3.9753609
+ 7350.000164ps      -3.8828428
+ 7360.000165ps      -4.0010218
+ 7370.000166ps        -4.46777
+ 7380.000167ps      -5.1685746
+ 7390.000167ps      -6.2326999
+ 7400.000168ps      -7.6750366
+ 7410.000169ps      -9.0576255
+ 7420.000170ps      -9.7011423
+ 7430.000171ps      -10.003072
+ 7440.000171ps      -10.755447
+ 7450.000172ps      -12.584907
+ 7459.999729ps      -14.982338
+ 7469.999730ps       -17.22238
+ 7479.999731ps      -17.932557
+ 7489.999732ps      -17.318308
+ 7499.999732ps       -17.27081
+ 7509.999733ps      -17.681878
+ 7519.999734ps      -17.822236
+ 7529.999735ps      -18.354855
+ 7539.999736ps      -18.362321
+ 7549.999737ps      -17.679736
+ 7559.999737ps      -16.600737
+ 7569.999738ps      -15.180404
+ 7579.999739ps      -13.688193
+ 7589.999740ps      -12.319648
+ 7599.999741ps       -11.09676
+ 7609.999741ps      -10.175272
+ 7619.999742ps      -9.4968062
+ 7629.999743ps      -8.6208547
+ 7639.999744ps      -7.7569341
+ 7649.999745ps      -6.8978119
+ 7659.999746ps      -6.2191782
+ 7669.999746ps      -5.7538597
+ 7679.999747ps      -5.5243716
+ 7689.999748ps      -5.6314973
+ 7699.999749ps      -5.3421086
+ 7709.999750ps       -5.225976
+ 7719.999751ps       -5.790204
+ 7729.999751ps      -6.3625197
+ 7739.999752ps      -6.6960049
+ 7749.999753ps      -6.9133418
+ 7759.999754ps      -7.8112257
+ 7769.999755ps      -9.0423689
+ 7779.999756ps      -9.9227442
+ 7789.999756ps      -10.136188
+ 7799.999757ps      -10.290217
+ 7809.999758ps      -10.576785
+ 7819.999759ps      -11.069999
+ 7829.999760ps      -11.148547
+ 7839.999761ps      -11.194894
+ 7849.999761ps      -11.421574
+ 7859.999762ps      -11.671746
+ 7869.999763ps      -11.834942
+ 7879.999764ps      -11.277921
+ 7889.999765ps      -10.616628
+ 7899.999765ps      -9.8954746
+ 7909.999766ps      -9.1182764
+ 7919.999767ps      -8.3158461
+ 7929.999768ps       -7.541228
+ 7939.999769ps      -6.7792344
+ 7949.999770ps       -6.112085
+ 7959.999770ps      -5.5287503
+ 7969.999771ps      -5.0399332
+ 7979.999772ps      -4.6244663
+ 7989.999773ps      -4.3044006
+)

Icursig21 PAR_1_3_VDD075CPU 0 pwl(
+ 0.000000ps       2.9376998
+ 10.000000ps       2.9832454
+ 20.000000ps       3.0679902
+ 29.999999ps       3.2876202
+ 40.000000ps       3.7401055
+ 50.000001ps       4.4620451
+ 59.999998ps        5.448129
+ 69.999999ps       7.0715894
+ 80.000000ps       9.1273055
+ 90.000001ps       10.743323
+ 100.000001ps       11.347029
+ 110.000002ps       12.361034
+ 119.999996ps       14.117327
+ 129.999997ps       16.549852
+ 139.999998ps       19.503883
+ 149.999999ps       21.236953
+ 159.999999ps       21.397889
+ 170.000000ps         21.5521
+ 180.000001ps       22.326592
+ 190.000002ps       22.650447
+ 200.000003ps        23.47087
+ 210.000003ps       24.228027
+ 220.000004ps       23.976503
+ 230.000005ps       22.935871
+ 239.999992ps       21.119681
+ 249.999993ps       19.010988
+ 259.999994ps       17.137622
+ 269.999995ps       15.425275
+ 279.999995ps       13.906576
+ 289.999996ps       12.621075
+ 299.999997ps        11.31576
+ 309.999998ps       10.013789
+ 319.999999ps       8.6926214
+ 330.000000ps       7.5438379
+ 340.000000ps        6.701401
+ 350.000001ps       6.1969837
+ 360.000002ps       6.0855756
+ 370.000003ps       5.5342391
+ 380.000004ps       5.0996582
+ 390.000005ps       5.2128213
+ 400.000005ps       5.4506767
+ 410.000006ps       5.8974446
+ 420.000007ps       5.5862412
+ 430.000008ps       5.4885728
+ 440.000009ps       5.9261312
+ 450.000009ps       6.3066436
+ 460.000010ps       6.7180713
+ 469.999983ps       6.7083145
+ 479.999984ps       6.8386341
+ 489.999985ps       7.2707401
+ 499.999986ps        7.656233
+ 509.999987ps       7.6194643
+ 519.999988ps       7.6001911
+ 529.999988ps       7.7614972
+ 539.999989ps       7.9536504
+ 549.999990ps       7.9701589
+ 559.999991ps       7.6928645
+ 569.999992ps       7.4522211
+ 579.999992ps       7.2479492
+ 589.999993ps       6.9841433
+ 599.999994ps       6.5969231
+ 609.999995ps       6.1434065
+ 619.999996ps       5.6641142
+ 629.999997ps       5.2183228
+ 639.999997ps       4.8219776
+ 649.999998ps        4.499215
+ 659.999999ps       4.2587854
+ 670.000000ps       4.0905599
+ 680.000001ps       3.9594431
+ 690.000002ps       3.9164621
+ 700.000002ps       4.0793844
+ 710.000003ps       4.5863061
+ 720.000004ps       5.3608971
+ 730.000005ps       6.5500439
+ 740.000006ps       8.1695075
+ 750.000007ps       9.8592047
+ 760.000007ps       11.014351
+ 770.000008ps       11.865714
+ 780.000009ps       13.043855
+ 790.000010ps       15.190611
+ 800.000011ps       17.858907
+ 810.000012ps       20.363474
+ 820.000012ps        21.52969
+ 830.000013ps       21.380927
+ 840.000014ps       21.759552
+ 850.000015ps       22.482164
+ 860.000016ps        22.95524
+ 870.000016ps       23.986993
+ 880.000017ps       24.238086
+ 890.000018ps       23.527242
+ 900.000019ps       22.208165
+ 910.000020ps       20.186962
+ 920.000021ps        18.12948
+ 930.000021ps       16.366489
+ 939.999967ps       14.702591
+ 949.999968ps       13.330368
+ 959.999968ps       12.162133
+ 969.999969ps       10.799258
+ 979.999970ps       9.4640239
+ 989.999971ps       8.1930492
+ 999.999972ps       7.1665897
+ 1009.999973ps       6.4162845
+ 1019.999973ps       5.9613724
+ 1029.999974ps       5.9147791
+ 1039.999975ps       5.4381995
+ 1049.999976ps       5.0611281
+ 1059.999977ps       5.2930945
+ 1069.999978ps        5.714793
+ 1079.999978ps       5.8157398
+ 1089.999979ps       5.5188709
+ 1099.999980ps       5.7054834
+ 1109.999981ps       6.2103649
+ 1119.999982ps       6.6665836
+ 1129.999982ps       6.6243641
+ 1139.999983ps       6.6431632
+ 1149.999984ps       6.9609621
+ 1159.999985ps       7.5426894
+ 1169.999986ps       7.6410862
+ 1179.999987ps       7.5434293
+ 1189.999987ps       7.6773644
+ 1199.999988ps       7.8508877
+ 1209.999989ps       8.0958202
+ 1219.999990ps       7.8287334
+ 1229.999991ps       7.5704574
+ 1239.999992ps       7.3774689
+ 1249.999992ps        7.157148
+ 1259.999993ps       6.8378482
+ 1269.999994ps       6.4234142
+ 1279.999995ps       5.9435604
+ 1289.999996ps       5.4684196
+ 1299.999997ps       5.0348419
+ 1309.999997ps       4.6777388
+ 1319.999998ps       4.3852544
+ 1329.999999ps       4.1655341
+ 1340.000000ps       4.0181855
+ 1350.000001ps        3.917281
+ 1360.000002ps       3.9312215
+ 1370.000002ps        4.199573
+ 1380.000003ps       4.8071687
+ 1390.000004ps       5.6897905
+ 1400.000005ps        7.065864
+ 1410.000006ps       8.8739982
+ 1420.000006ps       10.486932
+ 1430.000007ps       11.318365
+ 1440.000008ps       12.357726
+ 1450.000009ps        13.84967
+ 1460.000010ps       16.139967
+ 1470.000011ps       18.950587
+ 1480.000011ps       20.888511
+ 1490.000012ps       21.496448
+ 1500.000013ps        21.39766
+ 1510.000014ps       22.120735
+ 1520.000015ps       22.662342
+ 1530.000016ps       23.313878
+ 1540.000016ps       24.163235
+ 1550.000017ps       23.982157
+ 1560.000018ps       23.136184
+ 1570.000019ps       21.674697
+ 1580.000020ps       19.492809
+ 1590.000021ps        17.52383
+ 1600.000021ps       15.760627
+ 1610.000022ps       14.219462
+ 1620.000023ps       12.923698
+ 1630.000024ps       11.606357
+ 1640.000025ps       10.280859
+ 1650.000025ps       8.9223483
+ 1660.000026ps       7.7151007
+ 1670.000027ps        6.834508
+ 1680.000028ps       6.2980872
+ 1690.000029ps       6.1277924
+ 1700.000030ps        5.605975
+ 1710.000030ps       5.1414943
+ 1720.000031ps       5.1558045
+ 1730.000032ps       5.3618235
+ 1740.000033ps       5.8971319
+ 1750.000034ps       5.6104945
+ 1760.000035ps       5.4250159
+ 1770.000035ps       5.8128565
+ 1780.000036ps       6.2102504
+ 1790.000037ps       6.7251879
+ 1800.000038ps       6.7026379
+ 1810.000039ps       6.7665905
+ 1820.000040ps       7.1543079
+ 1830.000040ps       7.6494284
+ 1840.000041ps       7.6360181
+ 1850.000042ps        7.552061
+ 1860.000043ps       7.7144749
+ 1869.999933ps       7.8856852
+ 1879.999934ps       8.0450542
+ 1889.999934ps        7.750264
+ 1899.999935ps       7.4865172
+ 1909.999936ps       7.2870392
+ 1919.999937ps        7.042976
+ 1929.999938ps       6.6747856
+ 1939.999938ps       6.2548312
+ 1949.999939ps       5.7736953
+ 1959.999940ps       5.3125947
+ 1969.999941ps       4.9039352
+ 1979.999942ps       4.5652522
+ 1989.999943ps       4.3009272
+ 1999.999943ps       4.0987755
+ 2009.999944ps       3.9790302
+ 2019.999945ps        3.925869
+ 2029.999946ps       4.0528344
+ 2039.999947ps       4.4387067
+ 2049.999948ps       5.0558426
+ 2059.999948ps       6.0962167
+ 2069.999949ps       7.7583934
+ 2079.999950ps       9.6468475
+ 2089.999951ps       10.990487
+ 2099.999952ps       11.705384
+ 2109.999953ps       12.744594
+ 2119.999953ps       14.691749
+ 2129.999954ps       17.201128
+ 2139.999955ps       19.972644
+ 2149.999956ps       21.463481
+ 2159.999957ps       21.472075
+ 2169.999958ps       21.697804
+ 2179.999958ps       22.358965
+ 2189.999959ps       22.729888
+ 2199.999960ps       23.799911
+ 2209.999961ps       24.328337
+ 2219.999962ps       23.765469
+ 2229.999962ps       22.576562
+ 2239.999963ps       20.682556
+ 2249.999964ps       18.605216
+ 2259.999965ps       16.719148
+ 2269.999966ps       14.994205
+ 2279.999967ps       13.581171
+ 2289.999967ps       12.398415
+ 2299.999968ps       11.095252
+ 2309.999969ps       9.7382974
+ 2319.999970ps       8.4384982
+ 2329.999971ps       7.3600003
+ 2339.999972ps       6.5655922
+ 2349.999972ps       6.1032079
+ 2359.999973ps       6.0167647
+ 2369.999974ps        5.495657
+ 2379.999975ps       5.0819914
+ 2389.999976ps       5.2718528
+ 2399.999977ps         5.70366
+ 2409.999977ps       5.8312834
+ 2419.999978ps       5.4933977
+ 2429.999979ps       5.6332587
+ 2439.999980ps       6.1054599
+ 2449.999981ps        6.574729
+ 2459.999982ps       6.6100626
+ 2469.999982ps       6.6283977
+ 2479.999983ps       6.8784317
+ 2489.999984ps       7.3805279
+ 2499.999985ps       7.6450693
+ 2509.999986ps       7.5897621
+ 2519.999986ps       7.6290435
+ 2529.999987ps       7.7993891
+ 2539.999988ps       8.0185495
+ 2549.999989ps       7.9275575
+ 2559.999990ps        7.650418
+ 2569.999991ps       7.4301118
+ 2579.999991ps       7.2124433
+ 2589.999992ps       6.9153385
+ 2599.999993ps       6.5154591
+ 2609.999994ps       6.0530722
+ 2619.999995ps       5.5664201
+ 2629.999996ps       5.1306413
+ 2639.999996ps       4.7519165
+ 2649.999997ps       4.4472732
+ 2659.999998ps       4.2133865
+ 2669.999999ps       4.0556686
+ 2680.000000ps       3.9433391
+ 2690.000001ps       3.9414225
+ 2700.000001ps       4.1475557
+ 2710.000002ps       4.6591198
+ 2720.000003ps       5.5167368
+ 2730.000004ps       6.8445588
+ 2740.000005ps       8.5819501
+ 2750.000005ps       10.221544
+ 2760.000006ps       11.146769
+ 2770.000007ps       12.088305
+ 2780.000008ps       13.401922
+ 2790.000009ps       15.646537
+ 2800.000010ps       18.526248
+ 2810.000010ps        20.76269
+ 2820.000011ps       21.531739
+ 2830.000012ps       21.231709
+ 2840.000013ps       21.732972
+ 2850.000014ps       22.681208
+ 2860.000015ps        23.19356
+ 2870.000015ps        24.11228
+ 2880.000016ps       24.186778
+ 2890.000017ps       23.291111
+ 2900.000018ps       21.891116
+ 2910.000019ps       19.880173
+ 2920.000020ps        17.83448
+ 2930.000020ps        16.04182
+ 2940.000021ps       14.452103
+ 2950.000022ps       13.114646
+ 2960.000023ps       11.889642
+ 2970.000024ps       10.535211
+ 2980.000025ps         9.18955
+ 2990.000025ps       7.9644695
+ 3000.000026ps       7.0075009
+ 3010.000027ps       6.3636044
+ 3020.000028ps       6.0651601
+ 3030.000029ps       5.7417652
+ 3040.000029ps       5.2577332
+ 3050.000030ps       5.0719442
+ 3060.000031ps       5.3390142
+ 3070.000032ps       5.8318858
+ 3080.000033ps       5.6642235
+ 3090.000034ps       5.4297455
+ 3100.000034ps       5.7234598
+ 3110.000035ps       6.2358506
+ 3120.000036ps       6.7044036
+ 3130.000037ps       6.6556919
+ 3140.000038ps       6.7024177
+ 3150.000039ps       7.0545645
+ 3160.000039ps       7.6069552
+ 3170.000040ps       7.6355619
+ 3180.000041ps       7.5458266
+ 3190.000042ps       7.7083803
+ 3200.000043ps         7.88124
+ 3210.000044ps       8.0833243
+ 3220.000044ps        7.773902
+ 3230.000045ps       7.5167584
+ 3240.000046ps       7.3305276
+ 3250.000047ps       7.0926444
+ 3260.000048ps       6.7514391
+ 3270.000049ps       6.3377398
+ 3280.000049ps       5.8582104
+ 3290.000050ps       5.3947317
+ 3300.000051ps       4.9703901
+ 3310.000052ps       4.6239076
+ 3320.000053ps       4.3457469
+ 3330.000053ps       4.1328626
+ 3340.000054ps       3.9967352
+ 3350.000055ps       3.9123199
+ 3360.000056ps       3.9697066
+ 3370.000057ps       4.2782497
+ 3380.000058ps       4.8711216
+ 3390.000058ps       5.7673886
+ 3400.000059ps       7.3171953
+ 3410.000060ps       9.3177771
+ 3420.000061ps       10.891871
+ 3430.000062ps       11.468798
+ 3440.000063ps       12.457464
+ 3450.000063ps       14.187174
+ 3460.000064ps       16.611977
+ 3470.000065ps       19.550081
+ 3480.000066ps       21.283138
+ 3490.000067ps         21.4384
+ 3500.000068ps       21.580192
+ 3510.000068ps       22.336131
+ 3520.000069ps        22.64857
+ 3530.000070ps       23.474985
+ 3540.000071ps       24.240435
+ 3550.000072ps       23.973459
+ 3560.000073ps       22.933702
+ 3570.000073ps       21.116832
+ 3580.000074ps       19.006748
+ 3590.000075ps       17.128942
+ 3600.000076ps       15.419515
+ 3610.000077ps       13.911686
+ 3620.000077ps       12.632898
+ 3630.000078ps       11.325823
+ 3640.000079ps       10.030154
+ 3650.000080ps       8.6980943
+ 3660.000081ps       7.5446775
+ 3670.000082ps       6.7034298
+ 3680.000082ps       6.2039601
+ 3690.000083ps       6.0961773
+ 3700.000084ps       5.5458704
+ 3710.000085ps       5.1043341
+ 3720.000086ps       5.2134216
+ 3729.999865ps        5.449465
+ 3739.999865ps       5.8916513
+ 3749.999866ps       5.5779755
+ 3759.999867ps       5.4835691
+ 3769.999868ps       5.9253266
+ 3779.999869ps       6.3138849
+ 3789.999869ps       6.7236586
+ 3799.999870ps       6.7156308
+ 3809.999871ps       6.8443979
+ 3819.999872ps       7.2808673
+ 3829.999873ps       7.6645312
+ 3839.999874ps       7.6284607
+ 3849.999874ps       7.6111511
+ 3859.999875ps       7.7745369
+ 3869.999876ps       7.9661215
+ 3879.999877ps        7.979931
+ 3889.999878ps       7.7031194
+ 3899.999879ps       7.4658505
+ 3909.999879ps       7.2592276
+ 3919.999880ps       6.9914429
+ 3929.999881ps       6.6029555
+ 3939.999882ps       6.1457957
+ 3949.999883ps       5.6582298
+ 3959.999884ps       5.2084059
+ 3969.999884ps       4.8175767
+ 3979.999885ps        4.495778
+ 3989.999886ps       4.2539872
+ 3999.999887ps       4.0821266
+ 4009.999888ps       3.9526998
+ 4019.999889ps       3.9105686
+ 4029.999889ps       4.0752287
+ 4039.999890ps       4.5836271
+ 4049.999891ps       5.3686451
+ 4059.999892ps       6.5553576
+ 4069.999893ps       8.1744455
+ 4079.999893ps       9.8635032
+ 4089.999894ps       11.019306
+ 4099.999895ps       11.873523
+ 4109.999896ps       13.049511
+ 4119.999897ps       15.197164
+ 4129.999898ps       17.871597
+ 4139.999898ps       20.377828
+ 4149.999899ps       21.535041
+ 4159.999900ps       21.385432
+ 4169.999901ps       21.769158
+ 4179.999902ps       22.502951
+ 4189.999903ps       22.967527
+ 4199.999903ps       23.996061
+ 4209.999904ps       24.245738
+ 4219.999905ps       23.551554
+ 4229.999906ps         22.2374
+ 4239.999907ps       20.215546
+ 4249.999908ps       18.160145
+ 4259.999908ps       16.385396
+ 4269.999909ps       14.715238
+ 4279.999910ps       13.337886
+ 4289.999911ps       12.166573
+ 4299.999912ps       10.796595
+ 4309.999913ps       9.4598219
+ 4319.999913ps       8.1960838
+ 4329.999914ps       7.1667443
+ 4339.999915ps       6.4132211
+ 4349.999916ps       5.9648895
+ 4359.999917ps       5.9092519
+ 4369.999917ps       5.4244209
+ 4379.999918ps       5.0484877
+ 4389.999919ps       5.2761514
+ 4399.999920ps        5.697891
+ 4409.999921ps       5.7926259
+ 4419.999922ps       5.4962979
+ 4429.999922ps       5.6873884
+ 4439.999923ps        6.201017
+ 4449.999924ps         6.65529
+ 4459.999925ps       6.6161474
+ 4469.999926ps       6.6377464
+ 4479.999927ps        6.955601
+ 4489.999927ps       7.5354362
+ 4499.999928ps       7.6316034
+ 4509.999929ps       7.5355071
+ 4519.999930ps       7.6702942
+ 4529.999931ps       7.8424127
+ 4539.999932ps       8.0873195
+ 4549.999932ps       7.8242191
+ 4559.999933ps       7.5659081
+ 4569.999934ps       7.3719902
+ 4579.999935ps       7.1558247
+ 4589.999936ps         6.84045
+ 4599.999937ps       6.4248461
+ 4609.999937ps       5.9556829
+ 4619.999938ps       5.4832832
+ 4629.999939ps       5.0496325
+ 4639.999940ps       4.6860764
+ 4649.999941ps       4.3930267
+ 4659.999941ps       4.1718133
+ 4669.999942ps       4.0240529
+ 4679.999943ps       3.9220359
+ 4689.999944ps       3.9356094
+ 4699.999945ps       4.2028191
+ 4709.999946ps       4.8102887
+ 4719.999946ps       5.6903358
+ 4729.999947ps       7.0666054
+ 4739.999948ps       8.8751537
+ 4749.999949ps       10.487454
+ 4759.999950ps       11.317929
+ 4769.999951ps       12.359017
+ 4779.999951ps       13.848694
+ 4789.999952ps        16.13863
+ 4799.999953ps       18.941697
+ 4809.999954ps       20.886129
+ 4819.999955ps       21.493745
+ 4829.999956ps        21.39622
+ 4839.999956ps       22.111361
+ 4849.999957ps       22.647393
+ 4859.999958ps       23.299564
+ 4869.999959ps        24.15643
+ 4879.999960ps       23.962184
+ 4889.999961ps       23.116258
+ 4899.999961ps       21.650277
+ 4909.999962ps       19.463067
+ 4919.999963ps        17.48979
+ 4929.999964ps        15.73422
+ 4939.999965ps       14.197406
+ 4949.999965ps       12.908219
+ 4959.999966ps       11.594535
+ 4969.999967ps       10.271099
+ 4979.999968ps       8.9165184
+ 4989.999969ps       7.7156353
+ 4999.999970ps         6.84154
+ 5009.999970ps       6.3021533
+ 5019.999971ps       6.1485755
+ 5029.999972ps        5.628826
+ 5039.999973ps       5.1693965
+ 5049.999974ps       5.1799238
+ 5059.999975ps        5.371123
+ 5069.999975ps       5.9040435
+ 5079.999976ps        5.614579
+ 5089.999977ps       5.4284948
+ 5099.999978ps       5.8205572
+ 5109.999979ps       6.2206977
+ 5119.999980ps       6.7316009
+ 5129.999980ps       6.7146658
+ 5139.999981ps       6.7877292
+ 5149.999982ps       7.1727181
+ 5159.999983ps       7.6682727
+ 5169.999984ps       7.6509242
+ 5179.999985ps       7.5676114
+ 5189.999985ps       7.7303893
+ 5199.999986ps       7.9007839
+ 5209.999987ps       8.0576446
+ 5219.999988ps       7.7601627
+ 5229.999989ps       7.4949511
+ 5239.999989ps       7.2931462
+ 5249.999990ps       7.0457866
+ 5259.999991ps       6.6783335
+ 5269.999992ps       6.2557343
+ 5279.999993ps       5.7634328
+ 5289.999994ps       5.3059335
+ 5299.999994ps       4.8967406
+ 5309.999995ps       4.5567564
+ 5319.999996ps       4.2905872
+ 5329.999997ps       4.0870796
+ 5339.999998ps       3.9672199
+ 5349.999999ps       3.9130699
+ 5359.999999ps       4.0397944
+ 5370.000000ps       4.4271134
+ 5380.000001ps       5.0454135
+ 5390.000002ps       6.0867848
+ 5400.000003ps       7.7502676
+ 5410.000004ps       9.6388341
+ 5420.000004ps       10.984276
+ 5430.000005ps       11.698822
+ 5440.000006ps        12.74237
+ 5450.000007ps       14.689264
+ 5460.000008ps        17.20197
+ 5470.000009ps       19.973796
+ 5480.000009ps       21.456853
+ 5490.000010ps       21.469657
+ 5500.000011ps       21.708123
+ 5510.000012ps       22.379271
+ 5520.000013ps       22.747413
+ 5530.000013ps       23.812211
+ 5540.000014ps       24.332115
+ 5550.000015ps       23.779511
+ 5560.000016ps       22.590027
+ 5570.000017ps       20.691557
+ 5580.000018ps       18.608632
+ 5590.000018ps       16.727554
+ 5600.000019ps       15.012104
+ 5610.000020ps       13.592056
+ 5620.000021ps       12.406192
+ 5630.000022ps       11.101528
+ 5640.000023ps       9.7422417
+ 5650.000023ps        8.435921
+ 5660.000024ps       7.3524687
+ 5670.000025ps       6.5482096
+ 5680.000026ps       6.0843955
+ 5690.000027ps       6.0019605
+ 5700.000028ps        5.478524
+ 5710.000028ps       5.0704964
+ 5720.000029ps       5.2608778
+ 5730.000030ps       5.6964936
+ 5740.000031ps       5.8168512
+ 5750.000032ps       5.4767231
+ 5760.000033ps       5.6170019
+ 5770.000033ps       6.0882173
+ 5780.000034ps       6.5552047
+ 5790.000035ps       6.5947741
+ 5800.000036ps       6.6201123
+ 5810.000037ps       6.8721868
+ 5820.000037ps       7.3717543
+ 5830.000038ps       7.6323785
+ 5840.000039ps       7.5779554
+ 5850.000040ps       7.6156963
+ 5860.000041ps       7.7890686
+ 5870.000042ps       8.0125195
+ 5880.000042ps       7.9234877
+ 5890.000043ps       7.6487657
+ 5900.000044ps       7.4299217
+ 5910.000045ps       7.2147641
+ 5920.000046ps       6.9167017
+ 5930.000047ps       6.5142862
+ 5940.000047ps       6.0516781
+ 5950.000048ps       5.5752548
+ 5960.000049ps        5.134576
+ 5970.000050ps       4.7549516
+ 5980.000051ps       4.4497704
+ 5990.000052ps       4.2173505
+ 6000.000052ps       4.0619285
+ 6010.000053ps       3.9518602
+ 6020.000054ps       3.9499188
+ 6030.000055ps       4.1562686
+ 6040.000056ps       4.6679576
+ 6050.000056ps       5.5249109
+ 6060.000057ps        6.849628
+ 6070.000058ps       8.5864373
+ 6080.000059ps       10.224774
+ 6090.000060ps       11.150393
+ 6100.000061ps       12.093408
+ 6110.000061ps       13.403477
+ 6120.000062ps       15.645067
+ 6130.000063ps       18.518453
+ 6140.000064ps         20.7557
+ 6150.000065ps       21.530449
+ 6160.000066ps       21.234901
+ 6170.000066ps       21.733069
+ 6180.000067ps       22.674933
+ 6190.000068ps        23.18399
+ 6200.000069ps       24.109439
+ 6210.000070ps       24.183835
+ 6220.000071ps       23.272757
+ 6230.000071ps        21.87239
+ 6240.000072ps       19.877642
+ 6250.000073ps       17.823342
+ 6260.000074ps       16.034401
+ 6270.000075ps       14.448484
+ 6280.000076ps       13.116026
+ 6290.000076ps       11.888641
+ 6300.000077ps       10.536534
+ 6310.000078ps       9.1905948
+ 6320.000079ps        7.963765
+ 6330.000080ps       7.0154959
+ 6340.000080ps       6.3794294
+ 6350.000081ps       6.0896178
+ 6360.000082ps       5.7665236
+ 6370.000083ps       5.2813201
+ 6380.000084ps       5.0894864
+ 6390.000085ps       5.3516359
+ 6400.000085ps       5.8443239
+ 6410.000086ps       5.6805431
+ 6420.000087ps        5.451025
+ 6430.000088ps       5.7443441
+ 6440.000089ps       6.2537676
+ 6450.000090ps       6.7272889
+ 6460.000090ps       6.6819312
+ 6470.000091ps       6.7209884
+ 6480.000092ps       7.0657512
+ 6490.000093ps       7.6184151
+ 6500.000094ps       7.6470169
+ 6510.000095ps       7.5568408
+ 6520.000095ps       7.7170898
+ 6530.000096ps       7.8910258
+ 6540.000097ps       8.0914564
+ 6550.000098ps       7.7818362
+ 6560.000099ps       7.5236231
+ 6570.000100ps       7.3356831
+ 6580.000100ps       7.0997232
+ 6590.000101ps       6.7582496
+ 6600.000102ps        6.340501
+ 6610.000103ps       5.8521833
+ 6620.000104ps       5.3839681
+ 6630.000104ps       4.9646916
+ 6640.000105ps       4.6181333
+ 6650.000106ps       4.3388075
+ 6660.000107ps       4.1265927
+ 6670.000108ps       3.9895016
+ 6680.000109ps       3.9055296
+ 6690.000109ps       3.9637859
+ 6700.000110ps       4.2717514
+ 6710.000111ps       4.8662935
+ 6720.000112ps       5.7638794
+ 6730.000113ps       7.3137951
+ 6740.000114ps       9.3139817
+ 6750.000114ps       10.888818
+ 6760.000115ps       11.464353
+ 6770.000116ps       12.457758
+ 6780.000117ps       14.198423
+ 6790.000118ps       16.616566
+ 6800.000119ps       19.558687
+ 6810.000119ps        21.28516
+ 6820.000120ps       21.438655
+ 6830.000121ps       21.587141
+ 6840.000122ps       22.354206
+ 6850.000123ps       22.673903
+ 6860.000124ps       23.493528
+ 6870.000124ps       24.252042
+ 6880.000125ps       23.991115
+ 6890.000126ps       22.953454
+ 6900.000127ps       21.133277
+ 6910.000128ps       19.022727
+ 6920.000128ps        17.14869
+ 6930.000129ps       15.429884
+ 6940.000130ps       13.921857
+ 6950.000131ps        12.63192
+ 6960.000132ps       11.322062
+ 6970.000133ps       10.026486
+ 6980.000133ps       8.6990552
+ 6990.000134ps        7.541011
+ 7000.000135ps       6.6961112
+ 7010.000136ps       6.1988482
+ 7020.000137ps       6.0887862
+ 7030.000138ps       5.5365003
+ 7040.000138ps       5.0949791
+ 7050.000139ps       5.2076005
+ 7060.000140ps       5.4453165
+ 7070.000141ps        5.884698
+ 7080.000142ps        5.569756
+ 7090.000143ps       5.4745771
+ 7100.000143ps       5.9169451
+ 7110.000144ps       6.2993835
+ 7120.000145ps       6.7099671
+ 7130.000146ps       6.7041251
+ 7140.000147ps       6.8350214
+ 7150.000147ps       7.2712978
+ 7160.000148ps       7.6569477
+ 7170.000149ps       7.6224447
+ 7180.000150ps        7.606098
+ 7190.000151ps       7.7692477
+ 7200.000152ps       7.9622732
+ 7210.000152ps       7.9734765
+ 7220.000153ps       7.6939239
+ 7230.000154ps       7.4532578
+ 7240.000155ps       7.2486477
+ 7250.000156ps       6.9846703
+ 7260.000157ps       6.5993641
+ 7270.000157ps       6.1456321
+ 7280.000158ps       5.6675602
+ 7290.000159ps       5.2208516
+ 7300.000160ps       4.8249448
+ 7310.000161ps       4.5012599
+ 7320.000162ps       4.2610865
+ 7330.000162ps       4.0937949
+ 7340.000163ps        3.962826
+ 7350.000164ps       3.9199663
+ 7360.000165ps       4.0832295
+ 7370.000166ps       4.5909692
+ 7380.000167ps       5.3643303
+ 7390.000167ps       6.5530491
+ 7400.000168ps       8.1724095
+ 7410.000169ps       9.8616897
+ 7420.000170ps       11.016954
+ 7430.000171ps       11.866301
+ 7440.000171ps       13.044309
+ 7450.000172ps       15.193592
+ 7459.999729ps        17.86622
+ 7469.999730ps       20.368052
+ 7479.999731ps       21.533877
+ 7489.999732ps       21.379739
+ 7499.999732ps        21.75406
+ 7509.999733ps        22.47789
+ 7519.999734ps       22.949784
+ 7529.999735ps       23.986183
+ 7539.999736ps       24.239781
+ 7549.999737ps       23.528317
+ 7559.999737ps        22.20938
+ 7569.999738ps       20.194752
+ 7579.999739ps       18.135468
+ 7589.999740ps       16.369573
+ 7599.999741ps       14.708794
+ 7609.999741ps       13.332586
+ 7619.999742ps       12.166247
+ 7629.999743ps       10.795293
+ 7639.999744ps       9.4515433
+ 7649.999745ps       8.1868228
+ 7659.999746ps       7.1607013
+ 7669.999746ps       6.4184318
+ 7679.999747ps       5.9749227
+ 7689.999748ps       5.9214786
+ 7699.999749ps        5.438927
+ 7709.999750ps       5.0603775
+ 7719.999751ps       5.2936621
+ 7729.999751ps       5.7161139
+ 7739.999752ps       5.8109343
+ 7749.999753ps       5.5142988
+ 7759.999754ps       5.6991158
+ 7769.999755ps       6.2028056
+ 7779.999756ps       6.6598875
+ 7789.999756ps       6.6182502
+ 7799.999757ps       6.6346503
+ 7809.999758ps       6.9533343
+ 7819.999759ps       7.5392234
+ 7829.999760ps       7.6417985
+ 7839.999761ps       7.5452337
+ 7849.999761ps       7.6832746
+ 7859.999762ps       7.8559615
+ 7869.999763ps       8.0977575
+ 7879.999764ps       7.8336203
+ 7889.999765ps       7.5745309
+ 7899.999765ps       7.3791608
+ 7909.999766ps       7.1584117
+ 7919.999767ps       6.8400301
+ 7929.999768ps       6.4268751
+ 7939.999769ps       5.9553875
+ 7949.999770ps         5.47316
+ 7959.999770ps       5.0471091
+ 7969.999771ps       4.6837207
+ 7979.999772ps       4.3882201
+ 7989.999773ps       4.1669396
+)

Icursig22 PAR_0_0_VSS 0 pwl(
+ 0.000000ps      -6.3207711
+ 10.000000ps      -6.7717078
+ 20.000000ps      -7.6190265
+ 29.999999ps      -8.3780959
+ 40.000000ps      -8.9208023
+ 50.000001ps      -9.3358674
+ 59.999998ps      -9.6203757
+ 69.999999ps      -9.8468219
+ 80.000000ps       -10.07927
+ 90.000001ps      -10.269121
+ 100.000001ps      -10.473788
+ 110.000002ps      -10.673588
+ 119.999996ps      -10.855933
+ 129.999997ps      -11.057561
+ 139.999998ps      -11.188159
+ 149.999999ps      -11.247485
+ 159.999999ps       -11.34444
+ 170.000000ps      -11.432882
+ 180.000001ps      -11.466424
+ 190.000002ps      -11.459817
+ 200.000003ps      -11.350099
+ 210.000003ps      -11.211802
+ 220.000004ps       -11.09829
+ 230.000005ps      -11.032426
+ 239.999992ps      -11.001398
+ 249.999993ps       -11.02561
+ 259.999994ps      -11.056979
+ 269.999995ps      -11.100061
+ 279.999995ps      -11.186548
+ 289.999996ps       -11.24365
+ 299.999997ps      -11.241194
+ 309.999998ps      -11.232451
+ 319.999999ps      -11.213544
+ 330.000000ps      -11.224382
+ 340.000000ps      -11.235482
+ 350.000001ps      -11.284856
+ 360.000002ps      -11.368491
+ 370.000003ps      -11.471781
+ 380.000004ps       -11.63252
+ 390.000005ps      -11.846755
+ 400.000005ps      -12.056104
+ 410.000006ps      -12.258008
+ 420.000007ps      -12.237666
+ 430.000008ps      -12.195528
+ 440.000009ps      -12.161887
+ 450.000009ps       -12.09003
+ 460.000010ps      -12.000987
+ 469.999983ps      -11.874568
+ 479.999984ps      -11.748877
+ 489.999985ps      -11.638666
+ 499.999986ps      -11.534561
+ 509.999987ps      -11.475189
+ 519.999988ps      -11.422243
+ 529.999988ps      -11.344928
+ 539.999989ps      -11.282867
+ 549.999990ps      -11.248346
+ 559.999991ps      -11.231323
+ 569.999992ps      -11.222544
+ 579.999992ps      -11.227175
+ 589.999993ps      -11.245921
+ 599.999994ps      -11.248591
+ 609.999995ps      -11.279459
+ 619.999996ps      -11.324487
+ 629.999997ps      -11.411919
+ 639.999997ps      -11.529041
+ 649.999998ps      -11.676474
+ 659.999999ps      -11.812052
+ 670.000000ps      -11.915836
+ 680.000001ps      -11.937274
+ 690.000002ps      -11.951093
+ 700.000002ps      -11.940937
+ 710.000003ps      -11.898729
+ 720.000004ps       -11.84698
+ 730.000005ps      -11.712009
+ 740.000006ps        -11.5543
+ 750.000007ps      -11.432836
+ 760.000007ps      -11.354888
+ 770.000008ps      -11.312384
+ 780.000009ps      -11.333443
+ 790.000010ps      -11.332367
+ 800.000011ps      -11.351673
+ 810.000012ps      -11.352453
+ 820.000012ps      -11.351364
+ 830.000013ps      -11.363847
+ 840.000014ps      -11.322422
+ 850.000015ps      -11.261712
+ 860.000016ps      -11.212932
+ 870.000016ps      -11.216997
+ 880.000017ps       -11.22552
+ 890.000018ps      -11.291894
+ 900.000019ps      -11.403386
+ 910.000020ps      -11.568779
+ 920.000021ps      -11.793867
+ 930.000021ps      -12.050052
+ 939.999967ps      -12.310163
+ 949.999968ps      -12.311021
+ 959.999968ps      -12.257784
+ 969.999969ps      -12.137275
+ 979.999970ps      -12.016121
+ 989.999971ps      -11.827416
+ 999.999972ps      -11.607022
+ 1009.999973ps      -11.417243
+ 1019.999973ps      -11.234269
+ 1029.999974ps      -11.100491
+ 1039.999975ps      -10.959717
+ 1049.999976ps      -10.871145
+ 1059.999977ps      -10.837419
+ 1069.999978ps      -10.810431
+ 1079.999978ps      -10.786772
+ 1089.999979ps      -10.738001
+ 1099.999980ps      -10.716519
+ 1109.999981ps       -10.69627
+ 1119.999982ps      -10.691425
+ 1129.999982ps      -10.674734
+ 1139.999983ps      -10.695156
+ 1149.999984ps       -10.72933
+ 1159.999985ps      -10.792612
+ 1169.999986ps      -10.904921
+ 1179.999987ps      -11.044266
+ 1189.999987ps      -11.203426
+ 1199.999988ps      -11.317983
+ 1209.999989ps      -11.375859
+ 1219.999990ps      -11.360528
+ 1229.999991ps      -11.369166
+ 1239.999992ps      -11.374434
+ 1249.999992ps      -11.338442
+ 1259.999993ps      -11.208026
+ 1269.999994ps      -11.079264
+ 1279.999995ps      -10.955347
+ 1289.999996ps      -10.834369
+ 1299.999997ps      -10.766684
+ 1309.999997ps      -10.742595
+ 1319.999998ps       -10.72719
+ 1329.999999ps      -10.729277
+ 1340.000000ps      -10.757126
+ 1350.000001ps      -10.816509
+ 1360.000002ps      -10.857444
+ 1370.000002ps      -10.857621
+ 1380.000003ps      -10.844242
+ 1390.000004ps      -10.833489
+ 1400.000005ps      -10.816054
+ 1410.000006ps       -10.81593
+ 1420.000006ps      -10.831691
+ 1430.000007ps      -10.899246
+ 1440.000008ps      -10.993657
+ 1450.000009ps      -11.160541
+ 1460.000010ps      -11.341834
+ 1470.000011ps      -11.557908
+ 1480.000011ps      -11.602131
+ 1490.000012ps      -11.527101
+ 1500.000013ps      -11.416092
+ 1510.000014ps      -11.311899
+ 1520.000015ps      -11.185518
+ 1530.000016ps      -11.068204
+ 1540.000016ps      -10.923146
+ 1550.000017ps       -10.79904
+ 1560.000018ps      -10.688732
+ 1570.000019ps      -10.626871
+ 1580.000020ps       -10.59947
+ 1590.000021ps      -10.582471
+ 1600.000021ps      -10.590872
+ 1610.000022ps      -10.609754
+ 1620.000023ps      -10.626274
+ 1630.000024ps      -10.657896
+ 1640.000025ps      -10.679842
+ 1650.000025ps      -10.672911
+ 1660.000026ps      -10.674692
+ 1670.000027ps      -10.704896
+ 1680.000028ps      -10.746071
+ 1690.000029ps      -10.813871
+ 1700.000030ps      -10.928817
+ 1710.000030ps      -11.049577
+ 1720.000031ps       -11.19334
+ 1730.000032ps      -11.324324
+ 1740.000033ps      -11.410167
+ 1750.000034ps      -11.446416
+ 1760.000035ps      -11.497925
+ 1770.000035ps      -11.542213
+ 1780.000036ps      -11.504453
+ 1790.000037ps      -11.348659
+ 1800.000038ps      -11.190735
+ 1810.000039ps      -11.013389
+ 1820.000040ps      -10.868344
+ 1830.000040ps      -10.778606
+ 1840.000041ps      -10.740156
+ 1850.000042ps      -10.714151
+ 1860.000043ps      -10.696128
+ 1869.999933ps      -10.718021
+ 1879.999934ps      -10.754495
+ 1889.999934ps      -10.751718
+ 1899.999935ps      -10.722775
+ 1909.999936ps      -10.712085
+ 1919.999937ps      -10.637829
+ 1929.999938ps       -10.58195
+ 1939.999938ps      -10.568545
+ 1949.999939ps       -10.61034
+ 1959.999940ps      -10.698461
+ 1969.999941ps      -10.779255
+ 1979.999942ps      -10.937661
+ 1989.999943ps      -11.119841
+ 1999.999943ps      -11.311424
+ 2009.999944ps       -11.40096
+ 2019.999945ps      -11.358159
+ 2029.999946ps      -11.271836
+ 2039.999947ps      -11.204433
+ 2049.999948ps      -11.150585
+ 2059.999948ps      -11.076099
+ 2069.999949ps      -10.984308
+ 2079.999950ps      -10.885975
+ 2089.999951ps      -10.777828
+ 2099.999952ps      -10.683427
+ 2109.999953ps      -10.606502
+ 2119.999953ps      -10.559862
+ 2129.999954ps      -10.493216
+ 2139.999955ps      -10.447802
+ 2149.999956ps      -10.423042
+ 2159.999957ps      -10.416568
+ 2169.999958ps      -10.437258
+ 2179.999958ps       -10.46821
+ 2189.999959ps      -10.504723
+ 2199.999960ps      -10.501596
+ 2209.999961ps      -10.503256
+ 2219.999962ps      -10.547111
+ 2229.999962ps      -10.653889
+ 2239.999963ps       -10.77001
+ 2249.999964ps      -10.904265
+ 2259.999965ps       -11.06673
+ 2269.999966ps       -11.15386
+ 2279.999967ps      -11.176385
+ 2289.999967ps      -11.168054
+ 2299.999968ps      -11.138262
+ 2309.999969ps      -11.107269
+ 2319.999970ps       -11.01507
+ 2329.999971ps      -10.897626
+ 2339.999972ps      -10.767041
+ 2349.999972ps      -10.655602
+ 2359.999973ps      -10.562263
+ 2369.999974ps      -10.512502
+ 2379.999975ps       -10.51256
+ 2389.999976ps      -10.496965
+ 2399.999977ps      -10.455144
+ 2409.999977ps      -10.448071
+ 2419.999978ps      -10.456066
+ 2429.999979ps      -10.486882
+ 2439.999980ps      -10.484868
+ 2449.999981ps      -10.493508
+ 2459.999982ps      -10.472536
+ 2469.999982ps      -10.453726
+ 2479.999983ps      -10.455699
+ 2489.999984ps      -10.481776
+ 2499.999985ps      -10.568559
+ 2509.999986ps      -10.714923
+ 2519.999986ps      -10.883147
+ 2529.999987ps      -11.079784
+ 2539.999988ps      -11.274437
+ 2549.999989ps      -11.275121
+ 2559.999990ps      -11.201563
+ 2569.999991ps      -11.151225
+ 2579.999991ps       -11.12138
+ 2589.999992ps       -11.06666
+ 2599.999993ps       -11.00887
+ 2609.999994ps      -10.945628
+ 2619.999995ps      -10.833468
+ 2629.999996ps      -10.735132
+ 2639.999996ps      -10.647686
+ 2649.999997ps      -10.543184
+ 2659.999998ps      -10.466813
+ 2669.999999ps      -10.431479
+ 2680.000000ps      -10.389048
+ 2690.000001ps      -10.338874
+ 2700.000001ps      -10.280695
+ 2710.000002ps      -10.262841
+ 2720.000003ps      -10.264895
+ 2730.000004ps      -10.292074
+ 2740.000005ps       -10.33622
+ 2750.000005ps      -10.397214
+ 2760.000006ps      -10.497505
+ 2770.000007ps      -10.634392
+ 2780.000008ps      -10.818021
+ 2790.000009ps      -11.016516
+ 2800.000010ps       -11.16539
+ 2810.000010ps      -11.221881
+ 2820.000011ps      -11.254652
+ 2830.000012ps       -11.28643
+ 2840.000013ps      -11.279442
+ 2850.000014ps      -11.231128
+ 2860.000015ps      -11.085371
+ 2870.000015ps      -10.925848
+ 2880.000016ps      -10.794728
+ 2890.000017ps       -10.68115
+ 2900.000018ps      -10.591484
+ 2910.000019ps      -10.528337
+ 2920.000020ps      -10.510873
+ 2930.000020ps      -10.531745
+ 2940.000021ps      -10.524731
+ 2950.000022ps      -10.500348
+ 2960.000023ps      -10.459608
+ 2970.000024ps      -10.417555
+ 2980.000025ps      -10.404655
+ 2990.000025ps      -10.403318
+ 3000.000026ps      -10.435663
+ 3010.000027ps      -10.488756
+ 3020.000028ps      -10.568497
+ 3030.000029ps      -10.659195
+ 3040.000029ps      -10.793276
+ 3050.000030ps      -10.970245
+ 3060.000031ps      -11.223109
+ 3070.000032ps      -11.422341
+ 3080.000033ps      -11.395349
+ 3090.000034ps      -11.319799
+ 3100.000034ps      -11.253904
+ 3110.000035ps      -11.167003
+ 3120.000036ps       -11.04651
+ 3130.000037ps      -10.935727
+ 3140.000038ps      -10.788403
+ 3150.000039ps      -10.649282
+ 3160.000039ps      -10.577384
+ 3170.000040ps      -10.495863
+ 3180.000041ps      -10.440013
+ 3190.000042ps      -10.412401
+ 3200.000043ps      -10.388204
+ 3210.000044ps      -10.375962
+ 3220.000044ps      -10.355068
+ 3230.000045ps      -10.391941
+ 3240.000046ps      -10.412933
+ 3250.000047ps      -10.452104
+ 3260.000048ps      -10.468948
+ 3270.000049ps      -10.483825
+ 3280.000049ps      -10.506028
+ 3290.000050ps      -10.556463
+ 3300.000051ps      -10.637997
+ 3310.000052ps      -10.742951
+ 3320.000053ps      -10.854205
+ 3330.000053ps       -10.93986
+ 3340.000054ps      -10.969636
+ 3350.000055ps      -10.979033
+ 3360.000056ps      -10.992823
+ 3370.000057ps      -11.006931
+ 3380.000058ps      -10.952599
+ 3390.000058ps      -10.846607
+ 3400.000059ps      -10.761827
+ 3410.000060ps      -10.699914
+ 3420.000061ps       -10.61837
+ 3430.000062ps      -10.540672
+ 3440.000063ps      -10.518022
+ 3450.000063ps      -10.443192
+ 3460.000064ps       -10.39167
+ 3470.000065ps      -10.335391
+ 3480.000066ps      -10.322814
+ 3490.000067ps      -10.293967
+ 3500.000068ps      -10.254603
+ 3510.000068ps      -10.258824
+ 3520.000069ps      -10.267276
+ 3530.000070ps      -10.280846
+ 3540.000071ps      -10.295285
+ 3550.000072ps      -10.388021
+ 3560.000073ps       -10.47277
+ 3570.000073ps      -10.607003
+ 3580.000074ps      -10.790582
+ 3590.000075ps      -11.015721
+ 3600.000076ps      -11.237278
+ 3610.000077ps      -11.196118
+ 3620.000077ps       -11.09115
+ 3630.000078ps      -10.983538
+ 3640.000079ps      -10.903143
+ 3650.000080ps      -10.816461
+ 3660.000081ps      -10.725388
+ 3670.000082ps      -10.634141
+ 3680.000082ps      -10.562744
+ 3690.000083ps      -10.499579
+ 3700.000084ps      -10.456357
+ 3710.000085ps      -10.420633
+ 3720.000086ps      -10.372707
+ 3729.999865ps      -10.305087
+ 3739.999865ps      -10.260094
+ 3749.999866ps      -10.237715
+ 3759.999867ps      -10.235225
+ 3769.999868ps      -10.214214
+ 3779.999869ps      -10.202348
+ 3789.999869ps      -10.203072
+ 3799.999870ps      -10.198713
+ 3809.999871ps      -10.201586
+ 3819.999872ps      -10.251669
+ 3829.999873ps      -10.349428
+ 3839.999874ps      -10.482263
+ 3849.999874ps       -10.66454
+ 3859.999875ps      -10.832211
+ 3869.999876ps      -10.897677
+ 3879.999877ps      -10.919907
+ 3889.999878ps      -10.951803
+ 3899.999879ps      -10.968426
+ 3909.999879ps      -10.893095
+ 3919.999880ps      -10.776476
+ 3929.999881ps      -10.628695
+ 3939.999882ps      -10.481497
+ 3949.999883ps      -10.360338
+ 3959.999884ps       -10.29979
+ 3969.999884ps      -10.280065
+ 3979.999885ps      -10.262746
+ 3989.999886ps      -10.309337
+ 3999.999887ps      -10.443623
+ 4009.999888ps      -10.685651
+ 4019.999889ps      -11.037076
+ 4029.999889ps      -11.361245
+ 4039.999890ps      -11.638093
+ 4049.999891ps      -11.816305
+ 4059.999892ps      -11.960368
+ 4069.999893ps      -12.067133
+ 4079.999893ps      -12.167439
+ 4089.999894ps        -12.2692
+ 4099.999895ps      -12.415596
+ 4109.999896ps      -12.613578
+ 4119.999897ps      -12.825413
+ 4129.999898ps       -13.06924
+ 4139.999898ps      -13.136465
+ 4149.999899ps       -13.08357
+ 4159.999900ps      -13.028693
+ 4169.999901ps      -12.972765
+ 4179.999902ps      -12.916161
+ 4189.999903ps      -12.829314
+ 4199.999903ps      -12.683419
+ 4209.999904ps      -12.547431
+ 4219.999905ps      -12.443047
+ 4229.999906ps      -12.403515
+ 4239.999907ps       -12.39636
+ 4249.999908ps      -12.466254
+ 4259.999908ps      -12.498107
+ 4269.999909ps       -12.52581
+ 4279.999910ps      -12.521427
+ 4289.999911ps      -12.494752
+ 4299.999912ps      -12.446438
+ 4309.999913ps      -12.403767
+ 4319.999913ps      -12.369588
+ 4329.999914ps      -12.346678
+ 4339.999915ps      -12.360669
+ 4349.999916ps      -12.401805
+ 4359.999917ps      -12.481214
+ 4369.999917ps      -12.589076
+ 4379.999918ps      -12.731727
+ 4389.999919ps      -12.881917
+ 4399.999920ps      -12.967794
+ 4409.999921ps      -12.979801
+ 4419.999922ps      -13.006564
+ 4429.999922ps      -13.105665
+ 4439.999923ps      -13.145803
+ 4449.999924ps      -13.063328
+ 4459.999925ps      -12.969404
+ 4469.999926ps      -12.836003
+ 4479.999927ps      -12.693066
+ 4489.999927ps      -12.542911
+ 4499.999928ps      -12.405115
+ 4509.999929ps      -12.317302
+ 4519.999930ps      -12.249922
+ 4529.999931ps      -12.185622
+ 4539.999932ps        -12.1474
+ 4549.999932ps      -12.129546
+ 4559.999933ps      -12.116403
+ 4569.999934ps      -12.086388
+ 4579.999935ps      -12.079574
+ 4589.999936ps      -12.097416
+ 4599.999937ps      -12.130856
+ 4609.999937ps      -12.214568
+ 4619.999938ps      -12.357994
+ 4629.999939ps      -12.500442
+ 4639.999940ps       -12.70966
+ 4649.999941ps      -12.910197
+ 4659.999941ps      -13.112433
+ 4669.999942ps      -13.234482
+ 4679.999943ps      -13.154572
+ 4689.999944ps      -13.035609
+ 4699.999945ps      -12.856485
+ 4709.999946ps      -12.680306
+ 4719.999946ps      -12.496838
+ 4729.999947ps      -12.332698
+ 4739.999948ps      -12.219373
+ 4749.999949ps      -12.144547
+ 4759.999950ps      -12.111881
+ 4769.999951ps      -12.094162
+ 4779.999951ps      -12.113081
+ 4789.999952ps      -12.105281
+ 4799.999953ps      -12.097548
+ 4809.999954ps      -12.080343
+ 4819.999955ps      -12.083859
+ 4829.999956ps      -12.117717
+ 4839.999956ps        -12.0938
+ 4849.999957ps      -12.024344
+ 4859.999958ps      -11.970983
+ 4869.999959ps      -11.961385
+ 4879.999960ps      -11.966304
+ 4889.999961ps      -12.011834
+ 4899.999961ps      -12.098068
+ 4909.999962ps      -12.244489
+ 4919.999963ps      -12.363582
+ 4929.999964ps      -12.442984
+ 4939.999965ps      -12.508414
+ 4949.999965ps      -12.572153
+ 4959.999966ps      -12.621908
+ 4969.999967ps      -12.638803
+ 4979.999968ps      -12.538443
+ 4989.999969ps      -12.306418
+ 4999.999970ps      -12.012311
+ 5009.999970ps      -11.724777
+ 5019.999971ps      -11.454056
+ 5029.999972ps      -11.207423
+ 5039.999973ps      -10.985581
+ 5049.999974ps      -10.833216
+ 5059.999975ps      -10.747435
+ 5069.999975ps      -10.683762
+ 5079.999976ps      -10.637705
+ 5089.999977ps      -10.588018
+ 5099.999978ps      -10.531011
+ 5109.999979ps      -10.459744
+ 5119.999980ps      -10.388859
+ 5129.999980ps      -10.318664
+ 5139.999981ps      -10.308018
+ 5149.999982ps       -10.33843
+ 5159.999983ps      -10.430373
+ 5169.999984ps       -10.59596
+ 5179.999985ps      -10.760335
+ 5189.999985ps      -10.961603
+ 5199.999986ps      -11.076061
+ 5209.999987ps      -10.964577
+ 5219.999988ps      -10.790167
+ 5229.999989ps      -10.629631
+ 5239.999989ps       -10.49453
+ 5249.999990ps      -10.330586
+ 5259.999991ps      -10.178336
+ 5269.999992ps      -10.052903
+ 5279.999993ps      -9.9579842
+ 5289.999994ps      -9.8838631
+ 5299.999994ps      -9.8456445
+ 5309.999995ps      -9.8294309
+ 5319.999996ps      -9.8259527
+ 5329.999997ps       -9.819953
+ 5339.999998ps      -9.8400278
+ 5349.999999ps      -9.8694817
+ 5359.999999ps      -9.9124656
+ 5370.000000ps      -9.9438387
+ 5380.000001ps      -9.9479726
+ 5390.000002ps      -9.9198383
+ 5400.000003ps      -9.9115139
+ 5410.000004ps       -9.907543
+ 5420.000004ps      -9.9422163
+ 5430.000005ps       -10.03073
+ 5440.000006ps      -10.142329
+ 5450.000007ps      -10.284007
+ 5460.000008ps      -10.410784
+ 5470.000009ps      -10.483734
+ 5480.000009ps      -10.554891
+ 5490.000010ps      -10.613044
+ 5500.000011ps      -10.622782
+ 5510.000012ps      -10.574676
+ 5520.000013ps      -10.487482
+ 5530.000013ps      -10.336683
+ 5540.000014ps      -10.164182
+ 5550.000015ps       -9.987362
+ 5560.000016ps      -9.8809017
+ 5570.000017ps      -9.8004069
+ 5580.000018ps       -9.753521
+ 5590.000018ps      -9.7364916
+ 5600.000019ps      -9.7355769
+ 5610.000020ps      -9.7462434
+ 5620.000021ps      -9.7616105
+ 5630.000022ps      -9.7654158
+ 5640.000023ps      -9.7813986
+ 5650.000023ps      -9.7996372
+ 5660.000024ps      -9.8229372
+ 5670.000025ps      -9.8906901
+ 5680.000026ps      -9.9828073
+ 5690.000027ps       -10.09365
+ 5700.000028ps      -10.273733
+ 5710.000028ps      -10.459367
+ 5720.000029ps      -10.659134
+ 5730.000030ps      -10.793655
+ 5740.000031ps      -10.710591
+ 5750.000032ps      -10.563903
+ 5760.000033ps      -10.460206
+ 5770.000033ps      -10.340874
+ 5780.000034ps      -10.217647
+ 5790.000035ps      -10.094389
+ 5800.000036ps      -9.9847978
+ 5810.000037ps        -9.88387
+ 5820.000037ps       -9.794595
+ 5830.000038ps      -9.7616895
+ 5840.000039ps      -9.7421066
+ 5850.000040ps      -9.7638436
+ 5860.000041ps      -9.7777418
+ 5870.000042ps      -9.8115227
+ 5880.000042ps      -9.8637303
+ 5890.000043ps      -9.8857277
+ 5900.000044ps      -9.9034576
+ 5910.000045ps      -9.9185687
+ 5920.000046ps      -9.9183136
+ 5930.000047ps      -9.8911725
+ 5940.000047ps      -9.8753724
+ 5950.000048ps      -9.8952598
+ 5960.000049ps      -9.9369712
+ 5970.000050ps      -10.017038
+ 5980.000051ps      -10.126048
+ 5990.000052ps      -10.211102
+ 6000.000052ps      -10.251788
+ 6010.000053ps      -10.270713
+ 6020.000054ps      -10.303342
+ 6030.000055ps      -10.339753
+ 6040.000056ps      -10.315105
+ 6050.000056ps      -10.245039
+ 6060.000057ps      -10.168829
+ 6070.000058ps      -10.082482
+ 6080.000059ps      -9.9701355
+ 6090.000060ps      -9.8646088
+ 6100.000061ps      -9.7895082
+ 6110.000061ps      -9.6999474
+ 6120.000062ps       -9.638647
+ 6130.000063ps      -9.5857519
+ 6140.000064ps      -9.5543546
+ 6150.000065ps      -9.5140655
+ 6160.000066ps      -9.4910713
+ 6170.000066ps      -9.4896805
+ 6180.000067ps      -9.5137929
+ 6190.000068ps      -9.5404041
+ 6200.000069ps      -9.5807063
+ 6210.000070ps      -9.6696692
+ 6220.000071ps      -9.7731288
+ 6230.000071ps       -9.931666
+ 6240.000072ps      -10.153018
+ 6250.000073ps       -10.35667
+ 6260.000074ps      -10.571913
+ 6270.000075ps      -10.543412
+ 6280.000076ps      -10.430684
+ 6290.000076ps      -10.285182
+ 6300.000077ps       -10.14595
+ 6310.000078ps      -10.015921
+ 6320.000079ps      -9.8691416
+ 6330.000080ps      -9.7618271
+ 6340.000080ps      -9.6987518
+ 6350.000081ps      -9.6535801
+ 6360.000082ps      -9.6204384
+ 6370.000083ps      -9.5991852
+ 6380.000084ps      -9.5898607
+ 6390.000085ps      -9.5619439
+ 6400.000085ps      -9.5505157
+ 6410.000086ps      -9.5560621
+ 6420.000087ps      -9.5761299
+ 6430.000088ps      -9.6108965
+ 6440.000089ps      -9.5998813
+ 6450.000090ps       -9.591645
+ 6460.000090ps       -9.554423
+ 6470.000091ps      -9.5163811
+ 6480.000092ps      -9.5292077
+ 6490.000093ps       -9.594194
+ 6500.000094ps      -9.7132374
+ 6510.000095ps      -9.8518942
+ 6520.000095ps       -9.992725
+ 6530.000096ps      -10.078119
+ 6540.000097ps      -10.126243
+ 6550.000098ps      -10.209518
+ 6560.000099ps      -10.254691
+ 6570.000100ps      -10.253936
+ 6580.000100ps       -10.18405
+ 6590.000101ps       -10.09661
+ 6600.000102ps      -10.019874
+ 6610.000103ps      -9.9332156
+ 6620.000104ps      -9.8675918
+ 6630.000104ps      -9.7801862
+ 6640.000105ps       -9.702165
+ 6650.000106ps      -9.6218544
+ 6660.000107ps      -9.5364827
+ 6670.000108ps      -9.4809981
+ 6680.000109ps      -9.4484652
+ 6690.000109ps      -9.3920489
+ 6700.000110ps      -9.3595927
+ 6710.000111ps      -9.3921182
+ 6720.000112ps      -9.4217512
+ 6730.000113ps      -9.4884209
+ 6740.000114ps      -9.6113374
+ 6750.000114ps      -9.7549861
+ 6760.000115ps      -9.9713819
+ 6770.000116ps      -10.221592
+ 6780.000117ps      -10.432459
+ 6790.000118ps      -10.606103
+ 6800.000119ps       -10.63583
+ 6810.000119ps      -10.549545
+ 6820.000120ps      -10.433444
+ 6830.000121ps      -10.318394
+ 6840.000122ps      -10.188414
+ 6850.000123ps      -10.064972
+ 6860.000124ps      -9.9072626
+ 6870.000124ps      -9.7921477
+ 6880.000125ps      -9.7127558
+ 6890.000126ps      -9.6584334
+ 6900.000127ps      -9.6257097
+ 6910.000128ps      -9.5912073
+ 6920.000128ps      -9.5968663
+ 6930.000129ps      -9.6000921
+ 6940.000130ps      -9.5983848
+ 6950.000131ps      -9.5697834
+ 6960.000132ps      -9.5493451
+ 6970.000133ps      -9.5191946
+ 6980.000133ps      -9.4819251
+ 6990.000134ps      -9.4770469
+ 7000.000135ps       -9.503386
+ 7010.000136ps      -9.5405619
+ 7020.000137ps      -9.6258064
+ 7030.000138ps      -9.7500222
+ 7040.000138ps      -9.9070695
+ 7050.000139ps      -10.075874
+ 7060.000140ps      -10.203472
+ 7070.000141ps      -10.237984
+ 7080.000142ps      -10.291227
+ 7090.000143ps      -10.324541
+ 7100.000143ps      -10.309832
+ 7110.000144ps      -10.264036
+ 7120.000145ps      -10.176602
+ 7130.000146ps      -10.056895
+ 7140.000147ps      -9.9201019
+ 7150.000147ps      -9.7981769
+ 7160.000148ps      -9.7333785
+ 7170.000149ps      -9.6925137
+ 7180.000150ps      -9.6486133
+ 7190.000151ps      -9.6021218
+ 7200.000152ps      -9.5431842
+ 7210.000152ps      -9.5209123
+ 7220.000153ps      -9.5013697
+ 7230.000154ps      -9.5162754
+ 7240.000155ps      -9.5245287
+ 7250.000156ps      -9.5604973
+ 7260.000157ps      -9.6065594
+ 7270.000157ps      -9.6652363
+ 7280.000158ps      -9.7288802
+ 7290.000159ps      -9.8260964
+ 7300.000160ps      -9.9838901
+ 7310.000161ps       -10.14865
+ 7320.000162ps      -10.325623
+ 7330.000162ps      -10.413571
+ 7340.000163ps      -10.302606
+ 7350.000164ps      -10.190618
+ 7360.000165ps      -10.076631
+ 7370.000166ps      -9.9561571
+ 7380.000167ps      -9.8220879
+ 7390.000167ps      -9.6970794
+ 7400.000168ps      -9.6194468
+ 7410.000169ps      -9.5564648
+ 7420.000170ps      -9.4797206
+ 7430.000171ps      -9.4250134
+ 7440.000171ps      -9.3948653
+ 7450.000172ps      -9.3697765
+ 7459.999729ps      -9.3639571
+ 7469.999730ps      -9.3485855
+ 7479.999731ps      -9.3366513
+ 7489.999732ps      -9.3107888
+ 7499.999732ps      -9.2961011
+ 7509.999733ps       -9.288881
+ 7519.999734ps      -9.2975305
+ 7529.999735ps      -9.3139539
+ 7539.999736ps      -9.3300493
+ 7549.999737ps      -9.4143109
+ 7559.999737ps      -9.5496714
+ 7569.999738ps      -9.7132805
+ 7579.999739ps      -9.9144268
+ 7589.999740ps      -10.064906
+ 7599.999741ps      -10.151246
+ 7609.999741ps      -10.195768
+ 7619.999742ps      -10.188704
+ 7629.999743ps      -10.159668
+ 7639.999744ps      -10.085467
+ 7649.999745ps      -9.9808433
+ 7659.999746ps      -9.8925905
+ 7669.999746ps      -9.8203977
+ 7679.999747ps       -9.728884
+ 7689.999748ps       -9.664207
+ 7699.999749ps      -9.6213794
+ 7709.999750ps      -9.6020802
+ 7719.999751ps       -9.574664
+ 7729.999751ps      -9.5365129
+ 7739.999752ps      -9.5105726
+ 7749.999753ps       -9.490863
+ 7759.999754ps      -9.4769595
+ 7769.999755ps      -9.4533295
+ 7779.999756ps      -9.4308837
+ 7789.999756ps      -9.4410679
+ 7799.999757ps      -9.4450022
+ 7809.999758ps      -9.4634251
+ 7819.999759ps      -9.5237456
+ 7829.999760ps      -9.6708037
+ 7839.999761ps      -9.8308741
+ 7849.999761ps      -10.053012
+ 7859.999762ps      -10.244579
+ 7869.999763ps      -10.178851
+ 7879.999764ps      -10.065965
+ 7889.999765ps       -9.953618
+ 7899.999765ps      -9.8426211
+ 7909.999766ps      -9.6988406
+ 7919.999767ps      -9.5663319
+ 7929.999768ps      -9.4364378
+ 7939.999769ps      -9.3349641
+ 7949.999770ps      -9.2752118
+ 7959.999770ps      -9.2524881
+ 7969.999771ps      -9.2654939
+ 7979.999772ps        -9.31147
+ 7989.999773ps      -9.5287344
+)

.ends
.SUBCKT PowerModel PAR_0_0_VDD075CPU PAR_1_0_VSS PAR_1_0_VDD075CPU PAR_2_0_VSS PAR_2_0_VDD075CPU
+ PAR_0_1_VSS PAR_0_1_VDD075CPU PAR_1_1_VSS PAR_1_1_VDD075CPU PAR_2_1_VSS
+ PAR_2_1_VDD075CPU PAR_0_2_VSS PAR_0_2_VDD075CPU PAR_1_2_VSS PAR_1_2_VDD075CPU
+ PAR_2_2_VSS PAR_2_2_VDD075CPU PAR_0_3_VSS PAR_0_3_VDD075CPU PAR_1_3_VSS
+ PAR_1_3_VDD075CPU PAR_0_0_VSS
**********************************************************
* Ansys RedHawk-SC Chip Power Model [Accurate RC reduction]
* Model Subcircuit of Die PDN
* Copyright (c) 2002-2020 ANSYS, Inc.
**********************************************************

* Pad name : Subckt terminal : net
* VDD075CPU_01118   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01356   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01357   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01358   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01359   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01122   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01121   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01120   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01119   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01355   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01403   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01402   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01401   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01400   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01399   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01398   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01397   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01396   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01154   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01430   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01429   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01291   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01292   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01074   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01113   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01114   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01155   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01395   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01153   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01152   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01151   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01150   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01149   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01148   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01115   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01329   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01327   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01043   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01044   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01045   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01046   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01047   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01048   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01325   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01326   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01042   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01328   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01366   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01365   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01364   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01363   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01362   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01361   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01360   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01321   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01394   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01393   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01392   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01117   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01116   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01318   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01319   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01320   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01431   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01322   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01323   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01324   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01037   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01038   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01039   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01040   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01041   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01475   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01218   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01217   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01216   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01215   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01214   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01082   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01477   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01476   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01083   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01474   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01473   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01472   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01471   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01470   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01469   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01468   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01467   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01251   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01111   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01244   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01245   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01246   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01247   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01248   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01249   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01250   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01432   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01252   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01253   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01254   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01255   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01112   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01085   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01084   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01440   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01283   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01284   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01285   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01286   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01287   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01288   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01289   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01290   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01081   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01439   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01438   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01437   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01436   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01435   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01434   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01433   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01281   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01466   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01080   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01079   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01078   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01077   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01188   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01187   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01186   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01185   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01184   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01183   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01182   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01181   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01076   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01075   PAR_0_0_VDD075CPU   VDD075CPU
* VDD075CPU_01282   PAR_0_0_VDD075CPU   VDD075CPU
* VSS_04706   PAR_1_0_VSS   VSS
* VSS_04896   PAR_1_0_VSS   VSS
* VSS_04885   PAR_1_0_VSS   VSS
* VSS_04224   PAR_1_0_VSS   VSS
* VSS_04895   PAR_1_0_VSS   VSS
* VSS_04894   PAR_1_0_VSS   VSS
* VSS_04893   PAR_1_0_VSS   VSS
* VSS_04892   PAR_1_0_VSS   VSS
* VSS_04891   PAR_1_0_VSS   VSS
* VSS_04890   PAR_1_0_VSS   VSS
* VSS_04889   PAR_1_0_VSS   VSS
* VSS_04888   PAR_1_0_VSS   VSS
* VSS_04887   PAR_1_0_VSS   VSS
* VSS_04886   PAR_1_0_VSS   VSS
* VSS_04790   PAR_1_0_VSS   VSS
* VSS_04801   PAR_1_0_VSS   VSS
* VSS_04800   PAR_1_0_VSS   VSS
* VSS_04799   PAR_1_0_VSS   VSS
* VSS_04798   PAR_1_0_VSS   VSS
* VSS_04797   PAR_1_0_VSS   VSS
* VSS_04796   PAR_1_0_VSS   VSS
* VSS_04795   PAR_1_0_VSS   VSS
* VSS_04794   PAR_1_0_VSS   VSS
* VSS_04793   PAR_1_0_VSS   VSS
* VSS_04792   PAR_1_0_VSS   VSS
* VSS_04791   PAR_1_0_VSS   VSS
* VSS_04231   PAR_1_0_VSS   VSS
* VSS_04038   PAR_1_0_VSS   VSS
* VSS_04037   PAR_1_0_VSS   VSS
* VSS_04036   PAR_1_0_VSS   VSS
* VSS_04035   PAR_1_0_VSS   VSS
* VSS_04034   PAR_1_0_VSS   VSS
* VSS_04033   PAR_1_0_VSS   VSS
* VSS_04032   PAR_1_0_VSS   VSS
* VSS_04031   PAR_1_0_VSS   VSS
* VSS_04030   PAR_1_0_VSS   VSS
* VSS_04229   PAR_1_0_VSS   VSS
* VSS_04230   PAR_1_0_VSS   VSS
* VSS_04039   PAR_1_0_VSS   VSS
* VSS_04315   PAR_1_0_VSS   VSS
* VSS_04316   PAR_1_0_VSS   VSS
* VSS_04317   PAR_1_0_VSS   VSS
* VSS_04318   PAR_1_0_VSS   VSS
* VSS_04319   PAR_1_0_VSS   VSS
* VSS_04320   PAR_1_0_VSS   VSS
* VSS_04321   PAR_1_0_VSS   VSS
* VSS_04322   PAR_1_0_VSS   VSS
* VSS_04323   PAR_1_0_VSS   VSS
* VSS_04324   PAR_1_0_VSS   VSS
* VSS_04325   PAR_1_0_VSS   VSS
* VSS_04132   PAR_1_0_VSS   VSS
* VSS_04223   PAR_1_0_VSS   VSS
* VSS_04222   PAR_1_0_VSS   VSS
* VSS_04221   PAR_1_0_VSS   VSS
* VSS_04220   PAR_1_0_VSS   VSS
* VSS_04225   PAR_1_0_VSS   VSS
* VSS_04226   PAR_1_0_VSS   VSS
* VSS_04227   PAR_1_0_VSS   VSS
* VSS_04136   PAR_1_0_VSS   VSS
* VSS_04135   PAR_1_0_VSS   VSS
* VSS_04134   PAR_1_0_VSS   VSS
* VSS_04133   PAR_1_0_VSS   VSS
* VSS_04326   PAR_1_0_VSS   VSS
* VSS_04131   PAR_1_0_VSS   VSS
* VSS_04130   PAR_1_0_VSS   VSS
* VSS_04129   PAR_1_0_VSS   VSS
* VSS_04128   PAR_1_0_VSS   VSS
* VSS_04127   PAR_1_0_VSS   VSS
* VSS_04126   PAR_1_0_VSS   VSS
* VSS_04125   PAR_1_0_VSS   VSS
* VSS_04228   PAR_1_0_VSS   VSS
* VSS_04041   PAR_1_0_VSS   VSS
* VSS_04040   PAR_1_0_VSS   VSS
* VSS_04609   PAR_1_0_VSS   VSS
* VSS_04516   PAR_1_0_VSS   VSS
* VSS_04599   PAR_1_0_VSS   VSS
* VSS_04600   PAR_1_0_VSS   VSS
* VSS_04601   PAR_1_0_VSS   VSS
* VSS_04602   PAR_1_0_VSS   VSS
* VSS_04603   PAR_1_0_VSS   VSS
* VSS_04604   PAR_1_0_VSS   VSS
* VSS_04605   PAR_1_0_VSS   VSS
* VSS_04606   PAR_1_0_VSS   VSS
* VSS_04607   PAR_1_0_VSS   VSS
* VSS_04608   PAR_1_0_VSS   VSS
* VSS_04515   PAR_1_0_VSS   VSS
* VSS_04610   PAR_1_0_VSS   VSS
* VSS_04695   PAR_1_0_VSS   VSS
* VSS_04696   PAR_1_0_VSS   VSS
* VSS_04697   PAR_1_0_VSS   VSS
* VSS_04698   PAR_1_0_VSS   VSS
* VSS_04699   PAR_1_0_VSS   VSS
* VSS_04700   PAR_1_0_VSS   VSS
* VSS_04701   PAR_1_0_VSS   VSS
* VSS_04702   PAR_1_0_VSS   VSS
* VSS_04703   PAR_1_0_VSS   VSS
* VSS_04704   PAR_1_0_VSS   VSS
* VSS_04424   PAR_1_0_VSS   VSS
* VSS_04413   PAR_1_0_VSS   VSS
* VSS_04414   PAR_1_0_VSS   VSS
* VSS_04415   PAR_1_0_VSS   VSS
* VSS_04416   PAR_1_0_VSS   VSS
* VSS_04417   PAR_1_0_VSS   VSS
* VSS_04418   PAR_1_0_VSS   VSS
* VSS_04419   PAR_1_0_VSS   VSS
* VSS_04420   PAR_1_0_VSS   VSS
* VSS_04421   PAR_1_0_VSS   VSS
* VSS_04422   PAR_1_0_VSS   VSS
* VSS_04423   PAR_1_0_VSS   VSS
* VSS_04705   PAR_1_0_VSS   VSS
* VSS_04505   PAR_1_0_VSS   VSS
* VSS_04506   PAR_1_0_VSS   VSS
* VSS_04507   PAR_1_0_VSS   VSS
* VSS_04508   PAR_1_0_VSS   VSS
* VSS_04509   PAR_1_0_VSS   VSS
* VSS_04510   PAR_1_0_VSS   VSS
* VSS_04511   PAR_1_0_VSS   VSS
* VSS_04512   PAR_1_0_VSS   VSS
* VSS_04513   PAR_1_0_VSS   VSS
* VSS_04514   PAR_1_0_VSS   VSS
* VSS_04983   PAR_1_0_VSS   VSS
* VSS_05180   PAR_1_0_VSS   VSS
* VSS_05181   PAR_1_0_VSS   VSS
* VSS_05182   PAR_1_0_VSS   VSS
* VSS_05079   PAR_1_0_VSS   VSS
* VSS_05078   PAR_1_0_VSS   VSS
* VSS_05077   PAR_1_0_VSS   VSS
* VSS_05076   PAR_1_0_VSS   VSS
* VSS_04981   PAR_1_0_VSS   VSS
* VSS_04982   PAR_1_0_VSS   VSS
* VSS_05171   PAR_1_0_VSS   VSS
* VSS_04984   PAR_1_0_VSS   VSS
* VSS_04985   PAR_1_0_VSS   VSS
* VSS_04986   PAR_1_0_VSS   VSS
* VSS_04987   PAR_1_0_VSS   VSS
* VSS_04988   PAR_1_0_VSS   VSS
* VSS_04989   PAR_1_0_VSS   VSS
* VSS_04990   PAR_1_0_VSS   VSS
* VSS_04992   PAR_1_0_VSS   VSS
* VSS_04991   PAR_1_0_VSS   VSS
* VSS_05173   PAR_1_0_VSS   VSS
* VSS_05178   PAR_1_0_VSS   VSS
* VSS_05179   PAR_1_0_VSS   VSS
* VSS_05177   PAR_1_0_VSS   VSS
* VSS_05176   PAR_1_0_VSS   VSS
* VSS_05082   PAR_1_0_VSS   VSS
* VSS_05081   PAR_1_0_VSS   VSS
* VSS_05080   PAR_1_0_VSS   VSS
* VSS_05086   PAR_1_0_VSS   VSS
* VSS_05087   PAR_1_0_VSS   VSS
* VSS_05175   PAR_1_0_VSS   VSS
* VSS_05174   PAR_1_0_VSS   VSS
* VSS_05083   PAR_1_0_VSS   VSS
* VSS_05172   PAR_1_0_VSS   VSS
* VSS_05084   PAR_1_0_VSS   VSS
* VSS_05085   PAR_1_0_VSS   VSS
* VDD075CPU_01090   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01338   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01091   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01092   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01093   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01407   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01448   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01335   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01336   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01094   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01095   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01096   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01097   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01410   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01098   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01337   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01331   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01379   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01124   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01123   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01404   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01483   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01482   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01416   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01415   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01414   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01330   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01408   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01332   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01333   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01334   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01405   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01406   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01413   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01412   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01411   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01125   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01409   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01050   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01060   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01059   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01058   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01057   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01056   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01055   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01054   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01053   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01052   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01051   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01061   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01049   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01371   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01372   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01373   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01374   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01375   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01376   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01377   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01378   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01480   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01088   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01087   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01086   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01339   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01340   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01341   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01342   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01449   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01450   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01481   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01089   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01479   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01478   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01451   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01452   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01367   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01368   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01369   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01370   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01453   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01196   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01263   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01264   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01265   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01266   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01267   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01268   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01201   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01200   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01199   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01198   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01197   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01262   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01195   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01194   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01193   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01192   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01191   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01190   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01189   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01443   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01444   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01445   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01227   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01441   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01442   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01256   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01257   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01258   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01259   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01231   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01230   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01229   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01228   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01127   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01226   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01225   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01224   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01223   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01222   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01221   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01220   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01219   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01260   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01261   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01488   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01159   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01158   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01157   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01156   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01296   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01297   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01298   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01299   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01300   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01301   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01302   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01303   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01304   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01305   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01447   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01487   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01486   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01485   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01484   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01135   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01134   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01133   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01132   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01131   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01130   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01129   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01128   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01126   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01161   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01294   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01295   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01168   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01167   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01166   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01165   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01164   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01163   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01162   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01160   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01293   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01489   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01490   PAR_1_0_VDD075CPU   VDD075CPU
* VDD075CPU_01446   PAR_1_0_VDD075CPU   VDD075CPU
* VSS_04331   PAR_2_0_VSS   VSS
* VSS_04329   PAR_2_0_VSS   VSS
* VSS_04330   PAR_2_0_VSS   VSS
* VSS_04047   PAR_2_0_VSS   VSS
* VSS_04328   PAR_2_0_VSS   VSS
* VSS_04327   PAR_2_0_VSS   VSS
* VSS_04241   PAR_2_0_VSS   VSS
* VSS_04240   PAR_2_0_VSS   VSS
* VSS_04339   PAR_2_0_VSS   VSS
* VSS_04242   PAR_2_0_VSS   VSS
* VSS_04243   PAR_2_0_VSS   VSS
* VSS_04244   PAR_2_0_VSS   VSS
* VSS_04332   PAR_2_0_VSS   VSS
* VSS_04333   PAR_2_0_VSS   VSS
* VSS_04334   PAR_2_0_VSS   VSS
* VSS_04335   PAR_2_0_VSS   VSS
* VSS_04336   PAR_2_0_VSS   VSS
* VSS_04337   PAR_2_0_VSS   VSS
* VSS_04338   PAR_2_0_VSS   VSS
* VSS_04144   PAR_2_0_VSS   VSS
* VSS_05186   PAR_2_0_VSS   VSS
* VSS_05187   PAR_2_0_VSS   VSS
* VSS_05188   PAR_2_0_VSS   VSS
* VSS_05189   PAR_2_0_VSS   VSS
* VSS_04137   PAR_2_0_VSS   VSS
* VSS_04138   PAR_2_0_VSS   VSS
* VSS_04139   PAR_2_0_VSS   VSS
* VSS_04140   PAR_2_0_VSS   VSS
* VSS_04141   PAR_2_0_VSS   VSS
* VSS_04142   PAR_2_0_VSS   VSS
* VSS_04143   PAR_2_0_VSS   VSS
* VSS_04054   PAR_2_0_VSS   VSS
* VSS_04145   PAR_2_0_VSS   VSS
* VSS_04146   PAR_2_0_VSS   VSS
* VSS_04147   PAR_2_0_VSS   VSS
* VSS_04148   PAR_2_0_VSS   VSS
* VSS_04149   PAR_2_0_VSS   VSS
* VSS_05190   PAR_2_0_VSS   VSS
* VSS_05191   PAR_2_0_VSS   VSS
* VSS_05192   PAR_2_0_VSS   VSS
* VSS_05193   PAR_2_0_VSS   VSS
* VSS_05194   PAR_2_0_VSS   VSS
* VSS_05195   PAR_2_0_VSS   VSS
* VSS_04043   PAR_2_0_VSS   VSS
* VSS_04238   PAR_2_0_VSS   VSS
* VSS_04237   PAR_2_0_VSS   VSS
* VSS_04236   PAR_2_0_VSS   VSS
* VSS_04235   PAR_2_0_VSS   VSS
* VSS_04234   PAR_2_0_VSS   VSS
* VSS_04233   PAR_2_0_VSS   VSS
* VSS_04232   PAR_2_0_VSS   VSS
* VSS_05183   PAR_2_0_VSS   VSS
* VSS_05184   PAR_2_0_VSS   VSS
* VSS_05185   PAR_2_0_VSS   VSS
* VSS_04042   PAR_2_0_VSS   VSS
* VSS_04239   PAR_2_0_VSS   VSS
* VSS_04044   PAR_2_0_VSS   VSS
* VSS_04045   PAR_2_0_VSS   VSS
* VSS_04046   PAR_2_0_VSS   VSS
* VSS_04899   PAR_2_0_VSS   VSS
* VSS_04048   PAR_2_0_VSS   VSS
* VSS_04049   PAR_2_0_VSS   VSS
* VSS_04050   PAR_2_0_VSS   VSS
* VSS_04051   PAR_2_0_VSS   VSS
* VSS_04052   PAR_2_0_VSS   VSS
* VSS_04053   PAR_2_0_VSS   VSS
* VSS_04712   PAR_2_0_VSS   VSS
* VSS_04719   PAR_2_0_VSS   VSS
* VSS_04718   PAR_2_0_VSS   VSS
* VSS_04717   PAR_2_0_VSS   VSS
* VSS_04716   PAR_2_0_VSS   VSS
* VSS_04715   PAR_2_0_VSS   VSS
* VSS_04993   PAR_2_0_VSS   VSS
* VSS_04994   PAR_2_0_VSS   VSS
* VSS_04995   PAR_2_0_VSS   VSS
* VSS_04996   PAR_2_0_VSS   VSS
* VSS_04997   PAR_2_0_VSS   VSS
* VSS_04714   PAR_2_0_VSS   VSS
* VSS_04713   PAR_2_0_VSS   VSS
* VSS_04802   PAR_2_0_VSS   VSS
* VSS_04711   PAR_2_0_VSS   VSS
* VSS_04710   PAR_2_0_VSS   VSS
* VSS_04709   PAR_2_0_VSS   VSS
* VSS_04708   PAR_2_0_VSS   VSS
* VSS_04707   PAR_2_0_VSS   VSS
* VSS_04998   PAR_2_0_VSS   VSS
* VSS_04999   PAR_2_0_VSS   VSS
* VSS_05000   PAR_2_0_VSS   VSS
* VSS_05001   PAR_2_0_VSS   VSS
* VSS_05002   PAR_2_0_VSS   VSS
* VSS_05003   PAR_2_0_VSS   VSS
* VSS_05004   PAR_2_0_VSS   VSS
* VSS_04809   PAR_2_0_VSS   VSS
* VSS_04900   PAR_2_0_VSS   VSS
* VSS_04898   PAR_2_0_VSS   VSS
* VSS_04897   PAR_2_0_VSS   VSS
* VSS_04901   PAR_2_0_VSS   VSS
* VSS_04902   PAR_2_0_VSS   VSS
* VSS_04903   PAR_2_0_VSS   VSS
* VSS_04904   PAR_2_0_VSS   VSS
* VSS_04814   PAR_2_0_VSS   VSS
* VSS_04813   PAR_2_0_VSS   VSS
* VSS_04812   PAR_2_0_VSS   VSS
* VSS_04811   PAR_2_0_VSS   VSS
* VSS_04810   PAR_2_0_VSS   VSS
* VSS_05099   PAR_2_0_VSS   VSS
* VSS_04905   PAR_2_0_VSS   VSS
* VSS_04906   PAR_2_0_VSS   VSS
* VSS_04907   PAR_2_0_VSS   VSS
* VSS_04908   PAR_2_0_VSS   VSS
* VSS_04909   PAR_2_0_VSS   VSS
* VSS_04808   PAR_2_0_VSS   VSS
* VSS_04807   PAR_2_0_VSS   VSS
* VSS_04806   PAR_2_0_VSS   VSS
* VSS_04805   PAR_2_0_VSS   VSS
* VSS_04804   PAR_2_0_VSS   VSS
* VSS_04803   PAR_2_0_VSS   VSS
* VSS_04431   PAR_2_0_VSS   VSS
* VSS_04520   PAR_2_0_VSS   VSS
* VSS_04519   PAR_2_0_VSS   VSS
* VSS_04518   PAR_2_0_VSS   VSS
* VSS_04517   PAR_2_0_VSS   VSS
* VSS_05092   PAR_2_0_VSS   VSS
* VSS_05093   PAR_2_0_VSS   VSS
* VSS_04437   PAR_2_0_VSS   VSS
* VSS_04436   PAR_2_0_VSS   VSS
* VSS_04435   PAR_2_0_VSS   VSS
* VSS_04434   PAR_2_0_VSS   VSS
* VSS_04433   PAR_2_0_VSS   VSS
* VSS_04432   PAR_2_0_VSS   VSS
* VSS_04623   PAR_2_0_VSS   VSS
* VSS_04430   PAR_2_0_VSS   VSS
* VSS_04429   PAR_2_0_VSS   VSS
* VSS_04428   PAR_2_0_VSS   VSS
* VSS_04427   PAR_2_0_VSS   VSS
* VSS_04426   PAR_2_0_VSS   VSS
* VSS_04425   PAR_2_0_VSS   VSS
* VSS_05094   PAR_2_0_VSS   VSS
* VSS_05095   PAR_2_0_VSS   VSS
* VSS_05096   PAR_2_0_VSS   VSS
* VSS_05097   PAR_2_0_VSS   VSS
* VSS_05098   PAR_2_0_VSS   VSS
* VSS_05100   PAR_2_0_VSS   VSS
* VSS_04522   PAR_2_0_VSS   VSS
* VSS_05005   PAR_2_0_VSS   VSS
* VSS_04622   PAR_2_0_VSS   VSS
* VSS_04621   PAR_2_0_VSS   VSS
* VSS_04620   PAR_2_0_VSS   VSS
* VSS_04619   PAR_2_0_VSS   VSS
* VSS_04618   PAR_2_0_VSS   VSS
* VSS_04617   PAR_2_0_VSS   VSS
* VSS_04616   PAR_2_0_VSS   VSS
* VSS_04615   PAR_2_0_VSS   VSS
* VSS_04614   PAR_2_0_VSS   VSS
* VSS_04613   PAR_2_0_VSS   VSS
* VSS_04612   PAR_2_0_VSS   VSS
* VSS_04611   PAR_2_0_VSS   VSS
* VSS_05088   PAR_2_0_VSS   VSS
* VSS_05089   PAR_2_0_VSS   VSS
* VSS_05090   PAR_2_0_VSS   VSS
* VSS_05091   PAR_2_0_VSS   VSS
* VSS_04528   PAR_2_0_VSS   VSS
* VSS_04527   PAR_2_0_VSS   VSS
* VSS_04526   PAR_2_0_VSS   VSS
* VSS_04525   PAR_2_0_VSS   VSS
* VSS_04524   PAR_2_0_VSS   VSS
* VSS_04523   PAR_2_0_VSS   VSS
* VSS_04521   PAR_2_0_VSS   VSS
* VDD075CPU_01502   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01501   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01169   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01110   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01136   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01137   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01138   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01139   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01140   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01141   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01142   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01143   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01144   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01145   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01146   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01147   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01109   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01170   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01171   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01172   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01173   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01174   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01175   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01176   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01177   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01178   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01179   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01180   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01202   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01203   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01070   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01381   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01380   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01354   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01353   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01352   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01062   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01063   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01064   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01065   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01066   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01067   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01068   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01069   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01204   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01071   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01072   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01073   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01099   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01100   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01101   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01102   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01103   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01104   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01105   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01106   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01107   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01108   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01313   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01275   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01276   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01277   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01278   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01279   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01280   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01306   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01307   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01308   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01309   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01310   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01311   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01312   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01274   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01314   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01315   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01316   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01317   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01343   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01344   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01345   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01346   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01347   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01348   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01349   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01350   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01351   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01236   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01205   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01206   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01207   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01208   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01209   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01210   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01211   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01212   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01213   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01232   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01233   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01234   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01235   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01382   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01237   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01238   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01239   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01240   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01241   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01242   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01243   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01269   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01270   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01271   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01272   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01273   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01465   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01455   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01456   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01457   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01458   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01459   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01460   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01461   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01462   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01463   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01464   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01383   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01491   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01492   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01493   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01494   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01495   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01496   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01497   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01498   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01499   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01500   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01428   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01454   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01384   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01385   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01386   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01387   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01388   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01389   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01390   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01391   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01417   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01419   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01418   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01427   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01426   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01425   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01424   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01423   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01422   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01421   PAR_2_0_VDD075CPU   VDD075CPU
* VDD075CPU_01420   PAR_2_0_VDD075CPU   VDD075CPU
* VSS_02887   PAR_0_1_VSS   VSS
* VSS_02888   PAR_0_1_VSS   VSS
* VSS_02889   PAR_0_1_VSS   VSS
* VSS_02890   PAR_0_1_VSS   VSS
* VSS_02891   PAR_0_1_VSS   VSS
* VSS_02892   PAR_0_1_VSS   VSS
* VSS_02893   PAR_0_1_VSS   VSS
* VSS_02894   PAR_0_1_VSS   VSS
* VSS_02895   PAR_0_1_VSS   VSS
* VSS_02896   PAR_0_1_VSS   VSS
* VSS_02897   PAR_0_1_VSS   VSS
* VSS_02974   PAR_0_1_VSS   VSS
* VSS_02975   PAR_0_1_VSS   VSS
* VSS_02976   PAR_0_1_VSS   VSS
* VSS_02977   PAR_0_1_VSS   VSS
* VSS_02978   PAR_0_1_VSS   VSS
* VSS_02979   PAR_0_1_VSS   VSS
* VSS_02800   PAR_0_1_VSS   VSS
* VSS_03162   PAR_0_1_VSS   VSS
* VSS_03166   PAR_0_1_VSS   VSS
* VSS_02794   PAR_0_1_VSS   VSS
* VSS_02795   PAR_0_1_VSS   VSS
* VSS_02796   PAR_0_1_VSS   VSS
* VSS_02797   PAR_0_1_VSS   VSS
* VSS_02798   PAR_0_1_VSS   VSS
* VSS_02799   PAR_0_1_VSS   VSS
* VSS_02886   PAR_0_1_VSS   VSS
* VSS_02801   PAR_0_1_VSS   VSS
* VSS_02802   PAR_0_1_VSS   VSS
* VSS_02803   PAR_0_1_VSS   VSS
* VSS_02804   PAR_0_1_VSS   VSS
* VSS_02805   PAR_0_1_VSS   VSS
* VSS_02806   PAR_0_1_VSS   VSS
* VSS_02885   PAR_0_1_VSS   VSS
* VSS_03075   PAR_0_1_VSS   VSS
* VSS_03071   PAR_0_1_VSS   VSS
* VSS_03071_2584   PAR_0_1_VSS   VSS
* VSS_03072   PAR_0_1_VSS   VSS
* VSS_03072_2585   PAR_0_1_VSS   VSS
* VSS_03073   PAR_0_1_VSS   VSS
* VSS_03073_2586   PAR_0_1_VSS   VSS
* VSS_03074   PAR_0_1_VSS   VSS
* VSS_03074_2587   PAR_0_1_VSS   VSS
* VSS_03070_2583   PAR_0_1_VSS   VSS
* VSS_03075_2588   PAR_0_1_VSS   VSS
* VSS_03076   PAR_0_1_VSS   VSS
* VSS_03076_2589   PAR_0_1_VSS   VSS
* VSS_03077   PAR_0_1_VSS   VSS
* VSS_03077_2590   PAR_0_1_VSS   VSS
* VSS_03078   PAR_0_1_VSS   VSS
* VSS_03078_2591   PAR_0_1_VSS   VSS
* VSS_02980   PAR_0_1_VSS   VSS
* VSS_03070   PAR_0_1_VSS   VSS
* VSS_03069_2582   PAR_0_1_VSS   VSS
* VSS_03069   PAR_0_1_VSS   VSS
* VSS_03068_2581   PAR_0_1_VSS   VSS
* VSS_03068   PAR_0_1_VSS   VSS
* VSS_03067_2580   PAR_0_1_VSS   VSS
* VSS_03067   PAR_0_1_VSS   VSS
* VSS_03066_2579   PAR_0_1_VSS   VSS
* VSS_03066   PAR_0_1_VSS   VSS
* VSS_02986   PAR_0_1_VSS   VSS
* VSS_02985   PAR_0_1_VSS   VSS
* VSS_02984   PAR_0_1_VSS   VSS
* VSS_02983   PAR_0_1_VSS   VSS
* VSS_02982   PAR_0_1_VSS   VSS
* VSS_02981   PAR_0_1_VSS   VSS
* VSS_03648   PAR_0_1_VSS   VSS
* VSS_03744   PAR_0_1_VSS   VSS
* VSS_03743   PAR_0_1_VSS   VSS
* VSS_03742   PAR_0_1_VSS   VSS
* VSS_03741   PAR_0_1_VSS   VSS
* VSS_03740   PAR_0_1_VSS   VSS
* VSS_03739   PAR_0_1_VSS   VSS
* VSS_03738   PAR_0_1_VSS   VSS
* VSS_03737   PAR_0_1_VSS   VSS
* VSS_03736   PAR_0_1_VSS   VSS
* VSS_03735   PAR_0_1_VSS   VSS
* VSS_03734   PAR_0_1_VSS   VSS
* VSS_03733   PAR_0_1_VSS   VSS
* VSS_03732   PAR_0_1_VSS   VSS
* VSS_03649   PAR_0_1_VSS   VSS
* VSS_03827   PAR_0_1_VSS   VSS
* VSS_03161   PAR_0_1_VSS   VSS
* VSS_03647   PAR_0_1_VSS   VSS
* VSS_03646   PAR_0_1_VSS   VSS
* VSS_03645   PAR_0_1_VSS   VSS
* VSS_03644   PAR_0_1_VSS   VSS
* VSS_03643   PAR_0_1_VSS   VSS
* VSS_03642   PAR_0_1_VSS   VSS
* VSS_03641   PAR_0_1_VSS   VSS
* VSS_03640   PAR_0_1_VSS   VSS
* VSS_03639   PAR_0_1_VSS   VSS
* VSS_03638   PAR_0_1_VSS   VSS
* VSS_03637   PAR_0_1_VSS   VSS
* VSS_03554   PAR_0_1_VSS   VSS
* VSS_03923   PAR_0_1_VSS   VSS
* VSS_03163   PAR_0_1_VSS   VSS
* VSS_03164   PAR_0_1_VSS   VSS
* VSS_03165   PAR_0_1_VSS   VSS
* VSS_03934   PAR_0_1_VSS   VSS
* VSS_03933   PAR_0_1_VSS   VSS
* VSS_03932   PAR_0_1_VSS   VSS
* VSS_03931   PAR_0_1_VSS   VSS
* VSS_03930   PAR_0_1_VSS   VSS
* VSS_03929   PAR_0_1_VSS   VSS
* VSS_03928   PAR_0_1_VSS   VSS
* VSS_03927   PAR_0_1_VSS   VSS
* VSS_03926   PAR_0_1_VSS   VSS
* VSS_03925   PAR_0_1_VSS   VSS
* VSS_03924   PAR_0_1_VSS   VSS
* VSS_03553   PAR_0_1_VSS   VSS
* VSS_03922   PAR_0_1_VSS   VSS
* VSS_03839   PAR_0_1_VSS   VSS
* VSS_03838   PAR_0_1_VSS   VSS
* VSS_03837   PAR_0_1_VSS   VSS
* VSS_03836   PAR_0_1_VSS   VSS
* VSS_03835   PAR_0_1_VSS   VSS
* VSS_03834   PAR_0_1_VSS   VSS
* VSS_03833   PAR_0_1_VSS   VSS
* VSS_03832   PAR_0_1_VSS   VSS
* VSS_03831   PAR_0_1_VSS   VSS
* VSS_03830   PAR_0_1_VSS   VSS
* VSS_03829   PAR_0_1_VSS   VSS
* VSS_03828   PAR_0_1_VSS   VSS
* VSS_03265   PAR_0_1_VSS   VSS
* VSS_03360   PAR_0_1_VSS   VSS
* VSS_03359   PAR_0_1_VSS   VSS
* VSS_03358   PAR_0_1_VSS   VSS
* VSS_03357   PAR_0_1_VSS   VSS
* VSS_03356   PAR_0_1_VSS   VSS
* VSS_03355   PAR_0_1_VSS   VSS
* VSS_03354   PAR_0_1_VSS   VSS
* VSS_03353   PAR_0_1_VSS   VSS
* VSS_03352   PAR_0_1_VSS   VSS
* VSS_03270   PAR_0_1_VSS   VSS
* VSS_03269   PAR_0_1_VSS   VSS
* VSS_03268   PAR_0_1_VSS   VSS
* VSS_03267   PAR_0_1_VSS   VSS
* VSS_03266   PAR_0_1_VSS   VSS
* VSS_03361   PAR_0_1_VSS   VSS
* VSS_03264   PAR_0_1_VSS   VSS
* VSS_03263   PAR_0_1_VSS   VSS
* VSS_03262   PAR_0_1_VSS   VSS
* VSS_03261   PAR_0_1_VSS   VSS
* VSS_03260   PAR_0_1_VSS   VSS
* VSS_03259   PAR_0_1_VSS   VSS
* VSS_03258   PAR_0_1_VSS   VSS
* VSS_03173   PAR_0_1_VSS   VSS
* VSS_03172   PAR_0_1_VSS   VSS
* VSS_03171   PAR_0_1_VSS   VSS
* VSS_03170   PAR_0_1_VSS   VSS
* VSS_03169   PAR_0_1_VSS   VSS
* VSS_03168   PAR_0_1_VSS   VSS
* VSS_03457   PAR_0_1_VSS   VSS
* VSS_03552   PAR_0_1_VSS   VSS
* VSS_03551   PAR_0_1_VSS   VSS
* VSS_03550   PAR_0_1_VSS   VSS
* VSS_03549   PAR_0_1_VSS   VSS
* VSS_03548   PAR_0_1_VSS   VSS
* VSS_03547   PAR_0_1_VSS   VSS
* VSS_03546   PAR_0_1_VSS   VSS
* VSS_03545   PAR_0_1_VSS   VSS
* VSS_03544   PAR_0_1_VSS   VSS
* VSS_03543   PAR_0_1_VSS   VSS
* VSS_03542   PAR_0_1_VSS   VSS
* VSS_03459   PAR_0_1_VSS   VSS
* VSS_03458   PAR_0_1_VSS   VSS
* VSS_03167   PAR_0_1_VSS   VSS
* VSS_03456   PAR_0_1_VSS   VSS
* VSS_03455   PAR_0_1_VSS   VSS
* VSS_03454   PAR_0_1_VSS   VSS
* VSS_03453   PAR_0_1_VSS   VSS
* VSS_03452   PAR_0_1_VSS   VSS
* VSS_03451   PAR_0_1_VSS   VSS
* VSS_03450   PAR_0_1_VSS   VSS
* VSS_03449   PAR_0_1_VSS   VSS
* VSS_03448   PAR_0_1_VSS   VSS
* VSS_03447   PAR_0_1_VSS   VSS
* VSS_03364   PAR_0_1_VSS   VSS
* VSS_03363   PAR_0_1_VSS   VSS
* VSS_03362   PAR_0_1_VSS   VSS
* VDD075CPU_00854   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00964   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00963   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00822   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00823   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00824   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00825   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00826   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00852   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00853   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00821   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00855   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00856   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00857   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00858   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00859   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00860   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00861   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00862   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00787   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00779   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00780   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00781   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00782   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00783   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00784   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00785   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00786   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00863   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00788   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00789   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00815   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00816   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00817   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00818   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00819   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00820   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01000   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01004   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00926   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00927   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00928   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00929   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01003   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01002   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01001   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01005   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00930   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00931   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00932   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00933   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00934   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00935   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00936   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00937   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00898   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00889   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00890   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00891   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00893   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00894   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00895   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00896   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00897   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00892   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00899   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00900   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01011   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01010   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01009   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01008   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01007   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_01006   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00654   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00678   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00677   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00676   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00675   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00747   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00748   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00657   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00656   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00655   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00679   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00653   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00652   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00651   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00650   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00649   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00648   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00647   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00749   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00719   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00710   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00711   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00712   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00713   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00714   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00715   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00716   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00717   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00718   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00674   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00720   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00721   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00685   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00684   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00683   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00682   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00681   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00680   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00752   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00622   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00623   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00624   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00625   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00626   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00627   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00628   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00966   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00965   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00751   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00753   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00754   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00755   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00756   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00757   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00758   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00646   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00629   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00620   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00974   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00973   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00972   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00971   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00750   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00970   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00969   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00968   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00967   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00621   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00619   PAR_0_1_VDD075CPU   VDD075CPU
* VDD075CPU_00618   PAR_0_1_VDD075CPU   VDD075CPU
* VSS_02817   PAR_1_1_VSS   VSS
* VSS_02809   PAR_1_1_VSS   VSS
* VSS_02810   PAR_1_1_VSS   VSS
* VSS_02811   PAR_1_1_VSS   VSS
* VSS_02812   PAR_1_1_VSS   VSS
* VSS_02813   PAR_1_1_VSS   VSS
* VSS_02814   PAR_1_1_VSS   VSS
* VSS_02815   PAR_1_1_VSS   VSS
* VSS_02816   PAR_1_1_VSS   VSS
* VSS_03461   PAR_1_1_VSS   VSS
* VSS_02818   PAR_1_1_VSS   VSS
* VSS_03462   PAR_1_1_VSS   VSS
* VSS_03463   PAR_1_1_VSS   VSS
* VSS_03464   PAR_1_1_VSS   VSS
* VSS_03465   PAR_1_1_VSS   VSS
* VSS_03466   PAR_1_1_VSS   VSS
* VSS_03467   PAR_1_1_VSS   VSS
* VSS_03468   PAR_1_1_VSS   VSS
* VSS_03469   PAR_1_1_VSS   VSS
* VSS_03470   PAR_1_1_VSS   VSS
* VSS_03944   PAR_1_1_VSS   VSS
* VSS_03939   PAR_1_1_VSS   VSS
* VSS_03940   PAR_1_1_VSS   VSS
* VSS_03941   PAR_1_1_VSS   VSS
* VSS_03942   PAR_1_1_VSS   VSS
* VSS_03943   PAR_1_1_VSS   VSS
* VSS_03556   PAR_1_1_VSS   VSS
* VSS_03937   PAR_1_1_VSS   VSS
* VSS_03936   PAR_1_1_VSS   VSS
* VSS_03935   PAR_1_1_VSS   VSS
* VSS_02808   PAR_1_1_VSS   VSS
* VSS_03945   PAR_1_1_VSS   VSS
* VSS_03946   PAR_1_1_VSS   VSS
* VSS_03460   PAR_1_1_VSS   VSS
* VSS_03555   PAR_1_1_VSS   VSS
* VSS_03559   PAR_1_1_VSS   VSS
* VSS_03560   PAR_1_1_VSS   VSS
* VSS_03557   PAR_1_1_VSS   VSS
* VSS_03938   PAR_1_1_VSS   VSS
* VSS_02807   PAR_1_1_VSS   VSS
* VSS_03085   PAR_1_1_VSS   VSS
* VSS_03079   PAR_1_1_VSS   VSS
* VSS_03079_2592   PAR_1_1_VSS   VSS
* VSS_03080   PAR_1_1_VSS   VSS
* VSS_03080_2593   PAR_1_1_VSS   VSS
* VSS_03081   PAR_1_1_VSS   VSS
* VSS_03081_2594   PAR_1_1_VSS   VSS
* VSS_03082   PAR_1_1_VSS   VSS
* VSS_03082_2595   PAR_1_1_VSS   VSS
* VSS_03083   PAR_1_1_VSS   VSS
* VSS_03083_2596   PAR_1_1_VSS   VSS
* VSS_03084   PAR_1_1_VSS   VSS
* VSS_03084_2597   PAR_1_1_VSS   VSS
* VSS_02998   PAR_1_1_VSS   VSS
* VSS_03085_2598   PAR_1_1_VSS   VSS
* VSS_03086   PAR_1_1_VSS   VSS
* VSS_03086_2599   PAR_1_1_VSS   VSS
* VSS_03087   PAR_1_1_VSS   VSS
* VSS_03087_2600   PAR_1_1_VSS   VSS
* VSS_03088   PAR_1_1_VSS   VSS
* VSS_03088_2601   PAR_1_1_VSS   VSS
* VSS_03089   PAR_1_1_VSS   VSS
* VSS_03089_2602   PAR_1_1_VSS   VSS
* VSS_03090   PAR_1_1_VSS   VSS
* VSS_03090_2603   PAR_1_1_VSS   VSS
* VSS_03561   PAR_1_1_VSS   VSS
* VSS_02987   PAR_1_1_VSS   VSS
* VSS_02898   PAR_1_1_VSS   VSS
* VSS_02899   PAR_1_1_VSS   VSS
* VSS_02900   PAR_1_1_VSS   VSS
* VSS_02901   PAR_1_1_VSS   VSS
* VSS_02902   PAR_1_1_VSS   VSS
* VSS_02903   PAR_1_1_VSS   VSS
* VSS_02904   PAR_1_1_VSS   VSS
* VSS_02905   PAR_1_1_VSS   VSS
* VSS_02906   PAR_1_1_VSS   VSS
* VSS_02907   PAR_1_1_VSS   VSS
* VSS_02908   PAR_1_1_VSS   VSS
* VSS_02909   PAR_1_1_VSS   VSS
* VSS_03471   PAR_1_1_VSS   VSS
* VSS_02988   PAR_1_1_VSS   VSS
* VSS_02989   PAR_1_1_VSS   VSS
* VSS_02990   PAR_1_1_VSS   VSS
* VSS_02991   PAR_1_1_VSS   VSS
* VSS_02992   PAR_1_1_VSS   VSS
* VSS_02993   PAR_1_1_VSS   VSS
* VSS_02994   PAR_1_1_VSS   VSS
* VSS_02995   PAR_1_1_VSS   VSS
* VSS_03558   PAR_1_1_VSS   VSS
* VSS_02996   PAR_1_1_VSS   VSS
* VSS_02997   PAR_1_1_VSS   VSS
* VSS_03278   PAR_1_1_VSS   VSS
* VSS_03370   PAR_1_1_VSS   VSS
* VSS_03371   PAR_1_1_VSS   VSS
* VSS_03372   PAR_1_1_VSS   VSS
* VSS_03373   PAR_1_1_VSS   VSS
* VSS_03658   PAR_1_1_VSS   VSS
* VSS_03657   PAR_1_1_VSS   VSS
* VSS_03374   PAR_1_1_VSS   VSS
* VSS_03375   PAR_1_1_VSS   VSS
* VSS_03376   PAR_1_1_VSS   VSS
* VSS_03275   PAR_1_1_VSS   VSS
* VSS_03276   PAR_1_1_VSS   VSS
* VSS_03277   PAR_1_1_VSS   VSS
* VSS_03369   PAR_1_1_VSS   VSS
* VSS_03279   PAR_1_1_VSS   VSS
* VSS_03280   PAR_1_1_VSS   VSS
* VSS_03281   PAR_1_1_VSS   VSS
* VSS_03282   PAR_1_1_VSS   VSS
* VSS_03177   PAR_1_1_VSS   VSS
* VSS_03749   PAR_1_1_VSS   VSS
* VSS_03748   PAR_1_1_VSS   VSS
* VSS_03656   PAR_1_1_VSS   VSS
* VSS_03655   PAR_1_1_VSS   VSS
* VSS_03840   PAR_1_1_VSS   VSS
* VSS_03841   PAR_1_1_VSS   VSS
* VSS_03752   PAR_1_1_VSS   VSS
* VSS_03755   PAR_1_1_VSS   VSS
* VSS_03754   PAR_1_1_VSS   VSS
* VSS_03176   PAR_1_1_VSS   VSS
* VSS_03175   PAR_1_1_VSS   VSS
* VSS_03174   PAR_1_1_VSS   VSS
* VSS_03753   PAR_1_1_VSS   VSS
* VSS_03566   PAR_1_1_VSS   VSS
* VSS_03565   PAR_1_1_VSS   VSS
* VSS_03564   PAR_1_1_VSS   VSS
* VSS_03563   PAR_1_1_VSS   VSS
* VSS_03562   PAR_1_1_VSS   VSS
* VSS_03842   PAR_1_1_VSS   VSS
* VSS_03751   PAR_1_1_VSS   VSS
* VSS_03750   PAR_1_1_VSS   VSS
* VSS_03756   PAR_1_1_VSS   VSS
* VSS_03274   PAR_1_1_VSS   VSS
* VSS_03661   PAR_1_1_VSS   VSS
* VSS_03660   PAR_1_1_VSS   VSS
* VSS_03659   PAR_1_1_VSS   VSS
* VSS_03365   PAR_1_1_VSS   VSS
* VSS_03366   PAR_1_1_VSS   VSS
* VSS_03367   PAR_1_1_VSS   VSS
* VSS_03368   PAR_1_1_VSS   VSS
* VSS_03651   PAR_1_1_VSS   VSS
* VSS_03183   PAR_1_1_VSS   VSS
* VSS_03184   PAR_1_1_VSS   VSS
* VSS_03185   PAR_1_1_VSS   VSS
* VSS_03650   PAR_1_1_VSS   VSS
* VSS_03746   PAR_1_1_VSS   VSS
* VSS_03745   PAR_1_1_VSS   VSS
* VSS_03178   PAR_1_1_VSS   VSS
* VSS_03851   PAR_1_1_VSS   VSS
* VSS_03182   PAR_1_1_VSS   VSS
* VSS_03843   PAR_1_1_VSS   VSS
* VSS_03844   PAR_1_1_VSS   VSS
* VSS_03845   PAR_1_1_VSS   VSS
* VSS_03846   PAR_1_1_VSS   VSS
* VSS_03847   PAR_1_1_VSS   VSS
* VSS_03848   PAR_1_1_VSS   VSS
* VSS_03849   PAR_1_1_VSS   VSS
* VSS_03850   PAR_1_1_VSS   VSS
* VSS_03271   PAR_1_1_VSS   VSS
* VSS_03654   PAR_1_1_VSS   VSS
* VSS_03653   PAR_1_1_VSS   VSS
* VSS_03652   PAR_1_1_VSS   VSS
* VSS_03200   PAR_1_1_VSS   VSS
* VSS_03199   PAR_1_1_VSS   VSS
* VSS_03747   PAR_1_1_VSS   VSS
* VSS_03272   PAR_1_1_VSS   VSS
* VSS_03273   PAR_1_1_VSS   VSS
* VSS_03179   PAR_1_1_VSS   VSS
* VSS_03180   PAR_1_1_VSS   VSS
* VSS_03181   PAR_1_1_VSS   VSS
* VDD075CPU_00733   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00734   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00802   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00827   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00729   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00828   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00829   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00830   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00831   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00832   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00833   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00834   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00835   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00836   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00837   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00838   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00839   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00686   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00687   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00688   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00874   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00696   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00730   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00731   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00732   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00695   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00694   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00693   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00692   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00691   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00876   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00875   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00689   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00873   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00872   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00871   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00870   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00869   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00868   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00867   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00866   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00865   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00864   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00690   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00765   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00637   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00636   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00635   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00634   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00633   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00632   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00631   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00630   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00638   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00766   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00663   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00664   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00665   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00666   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00667   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00668   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00761   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00662   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00661   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00660   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00659   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00658   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00975   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00759   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00760   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00669   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00762   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00763   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00764   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00642   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00641   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00640   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00639   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00793   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01021   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01020   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01019   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01018   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01017   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00790   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00791   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00792   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01022   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00794   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00795   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00796   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00797   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00798   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00799   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00800   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00801   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01023   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01024   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00987   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00986   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00985   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00984   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00983   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00982   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00981   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00980   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00979   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00978   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00977   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00976   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00670   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00906   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01013   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01014   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00912   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00911   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00910   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00909   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00908   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00907   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01012   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00905   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00904   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00903   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00902   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00901   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01015   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_01016   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00946   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00938   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00939   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00940   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00941   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00942   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00943   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00944   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00945   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00727   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00947   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00948   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00949   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00950   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00698   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00697   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00913   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00723   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00728   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00722   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00724   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00725   PAR_1_1_VDD075CPU   VDD075CPU
* VDD075CPU_00726   PAR_1_1_VDD075CPU   VDD075CPU
* VSS_03378   PAR_2_1_VSS   VSS
* VSS_03863   PAR_2_1_VSS   VSS
* VSS_02822   PAR_2_1_VSS   VSS
* VSS_02821   PAR_2_1_VSS   VSS
* VSS_02820   PAR_2_1_VSS   VSS
* VSS_02819   PAR_2_1_VSS   VSS
* VSS_03377   PAR_2_1_VSS   VSS
* VSS_03957   PAR_2_1_VSS   VSS
* VSS_03379   PAR_2_1_VSS   VSS
* VSS_03380   PAR_2_1_VSS   VSS
* VSS_03381   PAR_2_1_VSS   VSS
* VSS_03198   PAR_2_1_VSS   VSS
* VSS_03382   PAR_2_1_VSS   VSS
* VSS_03383   PAR_2_1_VSS   VSS
* VSS_03959   PAR_2_1_VSS   VSS
* VSS_03958   PAR_2_1_VSS   VSS
* VSS_03956   PAR_2_1_VSS   VSS
* VSS_03663   PAR_2_1_VSS   VSS
* VSS_03295   PAR_2_1_VSS   VSS
* VSS_03474   PAR_2_1_VSS   VSS
* VSS_02913   PAR_2_1_VSS   VSS
* VSS_02912   PAR_2_1_VSS   VSS
* VSS_02911   PAR_2_1_VSS   VSS
* VSS_02910   PAR_2_1_VSS   VSS
* VSS_03666   PAR_2_1_VSS   VSS
* VSS_03665   PAR_2_1_VSS   VSS
* VSS_03664   PAR_2_1_VSS   VSS
* VSS_03100   PAR_2_1_VSS   VSS
* VSS_03662   PAR_2_1_VSS   VSS
* VSS_03095   PAR_2_1_VSS   VSS
* VSS_03096   PAR_2_1_VSS   VSS
* VSS_03097   PAR_2_1_VSS   VSS
* VSS_03473   PAR_2_1_VSS   VSS
* VSS_03472   PAR_2_1_VSS   VSS
* VSS_03098   PAR_2_1_VSS   VSS
* VSS_03099   PAR_2_1_VSS   VSS
* VSS_03389   PAR_2_1_VSS   VSS
* VSS_03852   PAR_2_1_VSS   VSS
* VSS_03191   PAR_2_1_VSS   VSS
* VSS_03190   PAR_2_1_VSS   VSS
* VSS_03189   PAR_2_1_VSS   VSS
* VSS_03188   PAR_2_1_VSS   VSS
* VSS_03187   PAR_2_1_VSS   VSS
* VSS_03186   PAR_2_1_VSS   VSS
* VSS_03853   PAR_2_1_VSS   VSS
* VSS_03854   PAR_2_1_VSS   VSS
* VSS_03388   PAR_2_1_VSS   VSS
* VSS_03855   PAR_2_1_VSS   VSS
* VSS_03856   PAR_2_1_VSS   VSS
* VSS_03857   PAR_2_1_VSS   VSS
* VSS_03858   PAR_2_1_VSS   VSS
* VSS_03859   PAR_2_1_VSS   VSS
* VSS_03860   PAR_2_1_VSS   VSS
* VSS_03861   PAR_2_1_VSS   VSS
* VSS_03862   PAR_2_1_VSS   VSS
* VSS_03864   PAR_2_1_VSS   VSS
* VSS_03384   PAR_2_1_VSS   VSS
* VSS_03955   PAR_2_1_VSS   VSS
* VSS_03954   PAR_2_1_VSS   VSS
* VSS_03953   PAR_2_1_VSS   VSS
* VSS_03952   PAR_2_1_VSS   VSS
* VSS_03951   PAR_2_1_VSS   VSS
* VSS_03950   PAR_2_1_VSS   VSS
* VSS_03949   PAR_2_1_VSS   VSS
* VSS_03948   PAR_2_1_VSS   VSS
* VSS_03947   PAR_2_1_VSS   VSS
* VSS_03567   PAR_2_1_VSS   VSS
* VSS_03197   PAR_2_1_VSS   VSS
* VSS_03385   PAR_2_1_VSS   VSS
* VSS_03386   PAR_2_1_VSS   VSS
* VSS_03387   PAR_2_1_VSS   VSS
* VSS_03196   PAR_2_1_VSS   VSS
* VSS_03195   PAR_2_1_VSS   VSS
* VSS_03194   PAR_2_1_VSS   VSS
* VSS_03193   PAR_2_1_VSS   VSS
* VSS_03192   PAR_2_1_VSS   VSS
* VSS_03103   PAR_2_1_VSS   VSS
* VSS_03283   PAR_2_1_VSS   VSS
* VSS_03284   PAR_2_1_VSS   VSS
* VSS_03286   PAR_2_1_VSS   VSS
* VSS_03484   PAR_2_1_VSS   VSS
* VSS_03483   PAR_2_1_VSS   VSS
* VSS_03576   PAR_2_1_VSS   VSS
* VSS_03577   PAR_2_1_VSS   VSS
* VSS_03578   PAR_2_1_VSS   VSS
* VSS_03579   PAR_2_1_VSS   VSS
* VSS_03674   PAR_2_1_VSS   VSS
* VSS_03287   PAR_2_1_VSS   VSS
* VSS_03102   PAR_2_1_VSS   VSS
* VSS_03101   PAR_2_1_VSS   VSS
* VSS_03673   PAR_2_1_VSS   VSS
* VSS_03672   PAR_2_1_VSS   VSS
* VSS_03671   PAR_2_1_VSS   VSS
* VSS_03670   PAR_2_1_VSS   VSS
* VSS_03669   PAR_2_1_VSS   VSS
* VSS_03482   PAR_2_1_VSS   VSS
* VSS_03481   PAR_2_1_VSS   VSS
* VSS_03574   PAR_2_1_VSS   VSS
* VSS_03294   PAR_2_1_VSS   VSS
* VSS_03757   PAR_2_1_VSS   VSS
* VSS_03758   PAR_2_1_VSS   VSS
* VSS_03759   PAR_2_1_VSS   VSS
* VSS_03568   PAR_2_1_VSS   VSS
* VSS_03569   PAR_2_1_VSS   VSS
* VSS_03570   PAR_2_1_VSS   VSS
* VSS_03571   PAR_2_1_VSS   VSS
* VSS_03572   PAR_2_1_VSS   VSS
* VSS_03573   PAR_2_1_VSS   VSS
* VSS_03480   PAR_2_1_VSS   VSS
* VSS_03575   PAR_2_1_VSS   VSS
* VSS_03760   PAR_2_1_VSS   VSS
* VSS_03761   PAR_2_1_VSS   VSS
* VSS_03293   PAR_2_1_VSS   VSS
* VSS_03292   PAR_2_1_VSS   VSS
* VSS_03291   PAR_2_1_VSS   VSS
* VSS_03290   PAR_2_1_VSS   VSS
* VSS_03289   PAR_2_1_VSS   VSS
* VSS_03288   PAR_2_1_VSS   VSS
* VSS_03764   PAR_2_1_VSS   VSS
* VSS_03094_2607   PAR_2_1_VSS   VSS
* VSS_03001   PAR_2_1_VSS   VSS
* VSS_03000   PAR_2_1_VSS   VSS
* VSS_02999   PAR_2_1_VSS   VSS
* VSS_03092   PAR_2_1_VSS   VSS
* VSS_03092_2605   PAR_2_1_VSS   VSS
* VSS_03093   PAR_2_1_VSS   VSS
* VSS_03762   PAR_2_1_VSS   VSS
* VSS_03763   PAR_2_1_VSS   VSS
* VSS_03002   PAR_2_1_VSS   VSS
* VSS_03765   PAR_2_1_VSS   VSS
* VSS_03766   PAR_2_1_VSS   VSS
* VSS_03767   PAR_2_1_VSS   VSS
* VSS_03768   PAR_2_1_VSS   VSS
* VSS_03668   PAR_2_1_VSS   VSS
* VSS_03667   PAR_2_1_VSS   VSS
* VSS_03769   PAR_2_1_VSS   VSS
* VSS_03093_2606   PAR_2_1_VSS   VSS
* VSS_03094   PAR_2_1_VSS   VSS
* VSS_03091   PAR_2_1_VSS   VSS
* VSS_03285   PAR_2_1_VSS   VSS
* VSS_03475   PAR_2_1_VSS   VSS
* VSS_03476   PAR_2_1_VSS   VSS
* VSS_03477   PAR_2_1_VSS   VSS
* VSS_03478   PAR_2_1_VSS   VSS
* VSS_03479   PAR_2_1_VSS   VSS
* VSS_03091_2604   PAR_2_1_VSS   VSS
* VDD075CPU_00744   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00735   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00736   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00737   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00745   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00738   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00739   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00740   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00741   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00742   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00743   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00746   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01036   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00881   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00957   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00888   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00887   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00886   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00885   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00884   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00883   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00882   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00956   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00880   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00879   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00878   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00877   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00958   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00851   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00850   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00849   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00917   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00925   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00924   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00923   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00922   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00921   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00920   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00919   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00918   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00848   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00916   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00915   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00914   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00951   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00952   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00953   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00954   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00955   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00776   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00808   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00807   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00806   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00805   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00804   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00803   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00778   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00777   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00809   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00775   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00774   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00773   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00772   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00771   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00770   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00769   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00768   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00959   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00847   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00846   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00845   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00844   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00843   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00842   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00841   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00840   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00767   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00960   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00961   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00962   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00814   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00813   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00812   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00811   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00810   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00672   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00994   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00995   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00996   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00997   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00998   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00999   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00990   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00989   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00988   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00673   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00708   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00671   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00709   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00645   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00644   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00643   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01029   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01028   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01027   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01025   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01026   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01033   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00700   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00699   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00706   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00705   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00704   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01035   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01034   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00993   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01032   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01031   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00701   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00702   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00703   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_01030   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00992   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00991   PAR_2_1_VDD075CPU   VDD075CPU
* VDD075CPU_00707   PAR_2_1_VDD075CPU   VDD075CPU
* VSS_01894   PAR_0_2_VSS   VSS
* VSS_01896   PAR_0_2_VSS   VSS
* VSS_01893   PAR_0_2_VSS   VSS
* VSS_01895   PAR_0_2_VSS   VSS
* VSS_01892   PAR_0_2_VSS   VSS
* VSS_01891   PAR_0_2_VSS   VSS
* VSS_01890   PAR_0_2_VSS   VSS
* VSS_02526   PAR_0_2_VSS   VSS
* VSS_01901   PAR_0_2_VSS   VSS
* VSS_02527   PAR_0_2_VSS   VSS
* VSS_02528   PAR_0_2_VSS   VSS
* VSS_02529   PAR_0_2_VSS   VSS
* VSS_02530   PAR_0_2_VSS   VSS
* VSS_02531   PAR_0_2_VSS   VSS
* VSS_02532   PAR_0_2_VSS   VSS
* VSS_02533   PAR_0_2_VSS   VSS
* VSS_02534   PAR_0_2_VSS   VSS
* VSS_02535   PAR_0_2_VSS   VSS
* VSS_01984   PAR_0_2_VSS   VSS
* VSS_02715   PAR_0_2_VSS   VSS
* VSS_02073   PAR_0_2_VSS   VSS
* VSS_02072   PAR_0_2_VSS   VSS
* VSS_02071   PAR_0_2_VSS   VSS
* VSS_02070   PAR_0_2_VSS   VSS
* VSS_01991   PAR_0_2_VSS   VSS
* VSS_01990   PAR_0_2_VSS   VSS
* VSS_01989   PAR_0_2_VSS   VSS
* VSS_01988   PAR_0_2_VSS   VSS
* VSS_01987   PAR_0_2_VSS   VSS
* VSS_01986   PAR_0_2_VSS   VSS
* VSS_01985   PAR_0_2_VSS   VSS
* VSS_01897   PAR_0_2_VSS   VSS
* VSS_01983   PAR_0_2_VSS   VSS
* VSS_01982   PAR_0_2_VSS   VSS
* VSS_01981   PAR_0_2_VSS   VSS
* VSS_01980   PAR_0_2_VSS   VSS
* VSS_01979   PAR_0_2_VSS   VSS
* VSS_02524   PAR_0_2_VSS   VSS
* VSS_02525   PAR_0_2_VSS   VSS
* VSS_01902   PAR_0_2_VSS   VSS
* VSS_01808   PAR_0_2_VSS   VSS
* VSS_01900   PAR_0_2_VSS   VSS
* VSS_01899   PAR_0_2_VSS   VSS
* VSS_01898   PAR_0_2_VSS   VSS
* VSS_02624   PAR_0_2_VSS   VSS
* VSS_01707   PAR_0_2_VSS   VSS
* VSS_02614   PAR_0_2_VSS   VSS
* VSS_02615   PAR_0_2_VSS   VSS
* VSS_02616   PAR_0_2_VSS   VSS
* VSS_02617   PAR_0_2_VSS   VSS
* VSS_02618   PAR_0_2_VSS   VSS
* VSS_02619   PAR_0_2_VSS   VSS
* VSS_02620   PAR_0_2_VSS   VSS
* VSS_02621   PAR_0_2_VSS   VSS
* VSS_02622   PAR_0_2_VSS   VSS
* VSS_02623   PAR_0_2_VSS   VSS
* VSS_01708   PAR_0_2_VSS   VSS
* VSS_02625   PAR_0_2_VSS   VSS
* VSS_02703   PAR_0_2_VSS   VSS
* VSS_02704   PAR_0_2_VSS   VSS
* VSS_02705   PAR_0_2_VSS   VSS
* VSS_02706   PAR_0_2_VSS   VSS
* VSS_02707   PAR_0_2_VSS   VSS
* VSS_02708   PAR_0_2_VSS   VSS
* VSS_02626   PAR_0_2_VSS   VSS
* VSS_02711   PAR_0_2_VSS   VSS
* VSS_02710   PAR_0_2_VSS   VSS
* VSS_02709   PAR_0_2_VSS   VSS
* VSS_01799   PAR_0_2_VSS   VSS
* VSS_01811   PAR_0_2_VSS   VSS
* VSS_01810   PAR_0_2_VSS   VSS
* VSS_01809   PAR_0_2_VSS   VSS
* VSS_01807   PAR_0_2_VSS   VSS
* VSS_01806   PAR_0_2_VSS   VSS
* VSS_01805   PAR_0_2_VSS   VSS
* VSS_01804   PAR_0_2_VSS   VSS
* VSS_01803   PAR_0_2_VSS   VSS
* VSS_01802   PAR_0_2_VSS   VSS
* VSS_01801   PAR_0_2_VSS   VSS
* VSS_01800   PAR_0_2_VSS   VSS
* VSS_02536   PAR_0_2_VSS   VSS
* VSS_01719   PAR_0_2_VSS   VSS
* VSS_01718   PAR_0_2_VSS   VSS
* VSS_01717   PAR_0_2_VSS   VSS
* VSS_01716   PAR_0_2_VSS   VSS
* VSS_01715   PAR_0_2_VSS   VSS
* VSS_01714   PAR_0_2_VSS   VSS
* VSS_01713   PAR_0_2_VSS   VSS
* VSS_01712   PAR_0_2_VSS   VSS
* VSS_01711   PAR_0_2_VSS   VSS
* VSS_01710   PAR_0_2_VSS   VSS
* VSS_01709   PAR_0_2_VSS   VSS
* VSS_02434   PAR_0_2_VSS   VSS
* VSS_02256   PAR_0_2_VSS   VSS
* VSS_02257   PAR_0_2_VSS   VSS
* VSS_02258   PAR_0_2_VSS   VSS
* VSS_02259   PAR_0_2_VSS   VSS
* VSS_02260   PAR_0_2_VSS   VSS
* VSS_02261   PAR_0_2_VSS   VSS
* VSS_02262   PAR_0_2_VSS   VSS
* VSS_02164   PAR_0_2_VSS   VSS
* VSS_02163   PAR_0_2_VSS   VSS
* VSS_02162   PAR_0_2_VSS   VSS
* VSS_02433   PAR_0_2_VSS   VSS
* VSS_02255   PAR_0_2_VSS   VSS
* VSS_02435   PAR_0_2_VSS   VSS
* VSS_02436   PAR_0_2_VSS   VSS
* VSS_02437   PAR_0_2_VSS   VSS
* VSS_02438   PAR_0_2_VSS   VSS
* VSS_02439   PAR_0_2_VSS   VSS
* VSS_02440   PAR_0_2_VSS   VSS
* VSS_02263   PAR_0_2_VSS   VSS
* VSS_02264   PAR_0_2_VSS   VSS
* VSS_02265   PAR_0_2_VSS   VSS
* VSS_02349   PAR_0_2_VSS   VSS
* VSS_02254   PAR_0_2_VSS   VSS
* VSS_02714   PAR_0_2_VSS   VSS
* VSS_02713   PAR_0_2_VSS   VSS
* VSS_02712   PAR_0_2_VSS   VSS
* VSS_02355   PAR_0_2_VSS   VSS
* VSS_02354   PAR_0_2_VSS   VSS
* VSS_02353   PAR_0_2_VSS   VSS
* VSS_02352   PAR_0_2_VSS   VSS
* VSS_02351   PAR_0_2_VSS   VSS
* VSS_02350   PAR_0_2_VSS   VSS
* VSS_02253   PAR_0_2_VSS   VSS
* VSS_02445   PAR_0_2_VSS   VSS
* VSS_02174   PAR_0_2_VSS   VSS
* VSS_02173   PAR_0_2_VSS   VSS
* VSS_02172   PAR_0_2_VSS   VSS
* VSS_02171   PAR_0_2_VSS   VSS
* VSS_02170   PAR_0_2_VSS   VSS
* VSS_02169   PAR_0_2_VSS   VSS
* VSS_02168   PAR_0_2_VSS   VSS
* VSS_02167   PAR_0_2_VSS   VSS
* VSS_02166   PAR_0_2_VSS   VSS
* VSS_02165   PAR_0_2_VSS   VSS
* VSS_02075   PAR_0_2_VSS   VSS
* VSS_02345   PAR_0_2_VSS   VSS
* VSS_02082   PAR_0_2_VSS   VSS
* VSS_02081   PAR_0_2_VSS   VSS
* VSS_02080   PAR_0_2_VSS   VSS
* VSS_02079   PAR_0_2_VSS   VSS
* VSS_02078   PAR_0_2_VSS   VSS
* VSS_02077   PAR_0_2_VSS   VSS
* VSS_02076   PAR_0_2_VSS   VSS
* VSS_02347   PAR_0_2_VSS   VSS
* VSS_02074   PAR_0_2_VSS   VSS
* VSS_02344   PAR_0_2_VSS   VSS
* VSS_02343   PAR_0_2_VSS   VSS
* VSS_02441   PAR_0_2_VSS   VSS
* VSS_02442   PAR_0_2_VSS   VSS
* VSS_02443   PAR_0_2_VSS   VSS
* VSS_02444   PAR_0_2_VSS   VSS
* VSS_02346   PAR_0_2_VSS   VSS
* VSS_02348   PAR_0_2_VSS   VSS
* VDD075CPU_00288   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00287   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00506   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00507   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00508   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00509   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00510   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00511   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00289   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00290   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00291   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00292   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00293   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00294   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00295   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00516   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00310   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00593   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00594   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00595   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00596   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00513   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00514   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00515   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00286   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00517   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00441   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00489   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00488   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00487   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00486   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00485   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00571   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00544   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00543   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00542   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00541   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00540   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00539   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00538   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00537   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00567   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00568   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00569   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00570   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00536   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00535   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00534   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00566   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00572   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00573   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00565   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00564   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00563   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00562   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00296   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00297   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00590   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00591   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00592   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00545   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00512   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00312   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00311   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00388   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00456   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00457   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00597   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00598   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00407   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00406   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00393   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00392   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00391   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00390   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00389   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00455   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00387   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00386   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00385   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00384   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00599   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00600   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00601   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00458   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00459   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00460   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00417   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00440   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00439   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00438   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00437   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00436   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00435   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00434   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00433   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00432   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00431   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00430   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00313   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00416   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00415   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00414   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00413   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00412   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00411   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00410   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00409   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00408   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00454   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00483   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00345   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00344   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00343   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00342   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00341   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00340   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00339   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00338   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00337   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00336   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00335   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00462   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00334   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00321   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00320   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00319   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00318   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00317   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00316   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00315   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00314   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00484   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00481   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00461   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00463   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00464   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00465   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00478   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00479   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00383   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00382   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00369   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00368   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00367   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00366   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00365   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00364   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00363   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00362   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00361   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00360   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00359   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00358   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00480   PAR_0_2_VDD075CPU   VDD075CPU
* VDD075CPU_00482   PAR_0_2_VDD075CPU   VDD075CPU
* VSS_01730   PAR_1_2_VSS   VSS
* VSS_02086   PAR_1_2_VSS   VSS
* VSS_02450   PAR_1_2_VSS   VSS
* VSS_02449   PAR_1_2_VSS   VSS
* VSS_02448   PAR_1_2_VSS   VSS
* VSS_02447   PAR_1_2_VSS   VSS
* VSS_02446   PAR_1_2_VSS   VSS
* VSS_02083   PAR_1_2_VSS   VSS
* VSS_02084   PAR_1_2_VSS   VSS
* VSS_02085   PAR_1_2_VSS   VSS
* VSS_02003   PAR_1_2_VSS   VSS
* VSS_02087   PAR_1_2_VSS   VSS
* VSS_02088   PAR_1_2_VSS   VSS
* VSS_02089   PAR_1_2_VSS   VSS
* VSS_02090   PAR_1_2_VSS   VSS
* VSS_02091   PAR_1_2_VSS   VSS
* VSS_02092   PAR_1_2_VSS   VSS
* VSS_02367   PAR_1_2_VSS   VSS
* VSS_02366   PAR_1_2_VSS   VSS
* VSS_01994   PAR_1_2_VSS   VSS
* VSS_02456   PAR_1_2_VSS   VSS
* VSS_02455   PAR_1_2_VSS   VSS
* VSS_02454   PAR_1_2_VSS   VSS
* VSS_02453   PAR_1_2_VSS   VSS
* VSS_02452   PAR_1_2_VSS   VSS
* VSS_02451   PAR_1_2_VSS   VSS
* VSS_01992   PAR_1_2_VSS   VSS
* VSS_01993   PAR_1_2_VSS   VSS
* VSS_02365   PAR_1_2_VSS   VSS
* VSS_01995   PAR_1_2_VSS   VSS
* VSS_01996   PAR_1_2_VSS   VSS
* VSS_01997   PAR_1_2_VSS   VSS
* VSS_01998   PAR_1_2_VSS   VSS
* VSS_01999   PAR_1_2_VSS   VSS
* VSS_02000   PAR_1_2_VSS   VSS
* VSS_02001   PAR_1_2_VSS   VSS
* VSS_02002   PAR_1_2_VSS   VSS
* VSS_02269   PAR_1_2_VSS   VSS
* VSS_02182   PAR_1_2_VSS   VSS
* VSS_02183   PAR_1_2_VSS   VSS
* VSS_02184   PAR_1_2_VSS   VSS
* VSS_02185   PAR_1_2_VSS   VSS
* VSS_02186   PAR_1_2_VSS   VSS
* VSS_02266   PAR_1_2_VSS   VSS
* VSS_02267   PAR_1_2_VSS   VSS
* VSS_02268   PAR_1_2_VSS   VSS
* VSS_02181   PAR_1_2_VSS   VSS
* VSS_02277   PAR_1_2_VSS   VSS
* VSS_02276   PAR_1_2_VSS   VSS
* VSS_02275   PAR_1_2_VSS   VSS
* VSS_02274   PAR_1_2_VSS   VSS
* VSS_02273   PAR_1_2_VSS   VSS
* VSS_02272   PAR_1_2_VSS   VSS
* VSS_02270   PAR_1_2_VSS   VSS
* VSS_02271   PAR_1_2_VSS   VSS
* VSS_02179   PAR_1_2_VSS   VSS
* VSS_02364   PAR_1_2_VSS   VSS
* VSS_02363   PAR_1_2_VSS   VSS
* VSS_02093   PAR_1_2_VSS   VSS
* VSS_02094   PAR_1_2_VSS   VSS
* VSS_02175   PAR_1_2_VSS   VSS
* VSS_02176   PAR_1_2_VSS   VSS
* VSS_02177   PAR_1_2_VSS   VSS
* VSS_02178   PAR_1_2_VSS   VSS
* VSS_02717   PAR_1_2_VSS   VSS
* VSS_02180   PAR_1_2_VSS   VSS
* VSS_02362   PAR_1_2_VSS   VSS
* VSS_02361   PAR_1_2_VSS   VSS
* VSS_02360   PAR_1_2_VSS   VSS
* VSS_02359   PAR_1_2_VSS   VSS
* VSS_02358   PAR_1_2_VSS   VSS
* VSS_02357   PAR_1_2_VSS   VSS
* VSS_02356   PAR_1_2_VSS   VSS
* VSS_01723   PAR_1_2_VSS   VSS
* VSS_02631   PAR_1_2_VSS   VSS
* VSS_02630   PAR_1_2_VSS   VSS
* VSS_02629   PAR_1_2_VSS   VSS
* VSS_02628   PAR_1_2_VSS   VSS
* VSS_02627   PAR_1_2_VSS   VSS
* VSS_01720   PAR_1_2_VSS   VSS
* VSS_01721   PAR_1_2_VSS   VSS
* VSS_01722   PAR_1_2_VSS   VSS
* VSS_02632   PAR_1_2_VSS   VSS
* VSS_01724   PAR_1_2_VSS   VSS
* VSS_01725   PAR_1_2_VSS   VSS
* VSS_01726   PAR_1_2_VSS   VSS
* VSS_01727   PAR_1_2_VSS   VSS
* VSS_01728   PAR_1_2_VSS   VSS
* VSS_01729   PAR_1_2_VSS   VSS
* VSS_01731   PAR_1_2_VSS   VSS
* VSS_02548   PAR_1_2_VSS   VSS
* VSS_02725   PAR_1_2_VSS   VSS
* VSS_02716   PAR_1_2_VSS   VSS
* VSS_02718   PAR_1_2_VSS   VSS
* VSS_02719   PAR_1_2_VSS   VSS
* VSS_02720   PAR_1_2_VSS   VSS
* VSS_02721   PAR_1_2_VSS   VSS
* VSS_02722   PAR_1_2_VSS   VSS
* VSS_02723   PAR_1_2_VSS   VSS
* VSS_02724   PAR_1_2_VSS   VSS
* VSS_01914   PAR_1_2_VSS   VSS
* VSS_02726   PAR_1_2_VSS   VSS
* VSS_02727   PAR_1_2_VSS   VSS
* VSS_02638   PAR_1_2_VSS   VSS
* VSS_02637   PAR_1_2_VSS   VSS
* VSS_02636   PAR_1_2_VSS   VSS
* VSS_02635   PAR_1_2_VSS   VSS
* VSS_02634   PAR_1_2_VSS   VSS
* VSS_02633   PAR_1_2_VSS   VSS
* VSS_01906   PAR_1_2_VSS   VSS
* VSS_01821   PAR_1_2_VSS   VSS
* VSS_01822   PAR_1_2_VSS   VSS
* VSS_01823   PAR_1_2_VSS   VSS
* VSS_02538   PAR_1_2_VSS   VSS
* VSS_02537   PAR_1_2_VSS   VSS
* VSS_01903   PAR_1_2_VSS   VSS
* VSS_01904   PAR_1_2_VSS   VSS
* VSS_01905   PAR_1_2_VSS   VSS
* VSS_02546   PAR_1_2_VSS   VSS
* VSS_01907   PAR_1_2_VSS   VSS
* VSS_01908   PAR_1_2_VSS   VSS
* VSS_01909   PAR_1_2_VSS   VSS
* VSS_01910   PAR_1_2_VSS   VSS
* VSS_01911   PAR_1_2_VSS   VSS
* VSS_01912   PAR_1_2_VSS   VSS
* VSS_01913   PAR_1_2_VSS   VSS
* VSS_02457   PAR_1_2_VSS   VSS
* VSS_01819   PAR_1_2_VSS   VSS
* VSS_02547   PAR_1_2_VSS   VSS
* VSS_02545   PAR_1_2_VSS   VSS
* VSS_02544   PAR_1_2_VSS   VSS
* VSS_02543   PAR_1_2_VSS   VSS
* VSS_02542   PAR_1_2_VSS   VSS
* VSS_02541   PAR_1_2_VSS   VSS
* VSS_02540   PAR_1_2_VSS   VSS
* VSS_02539   PAR_1_2_VSS   VSS
* VSS_01812   PAR_1_2_VSS   VSS
* VSS_01813   PAR_1_2_VSS   VSS
* VSS_01814   PAR_1_2_VSS   VSS
* VSS_01815   PAR_1_2_VSS   VSS
* VSS_01816   PAR_1_2_VSS   VSS
* VSS_01817   PAR_1_2_VSS   VSS
* VSS_01818   PAR_1_2_VSS   VSS
* VSS_01820   PAR_1_2_VSS   VSS
* VDD075CPU_00529   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00424   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00402   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00403   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00404   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00405   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00418   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00419   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00420   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00421   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00422   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00423   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00401   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00425   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00426   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00427   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00428   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00429   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00442   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00443   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00444   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00445   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00379   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00370   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00371   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00372   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00373   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00374   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00375   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00376   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00377   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00378   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00446   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00380   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00381   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00394   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00395   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00396   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00397   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00398   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00399   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00400   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00500   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00491   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00492   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00493   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00494   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00495   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00496   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00497   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00498   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00499   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00490   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00501   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00502   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00518   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00519   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00520   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00521   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00522   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00523   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00524   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00468   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00447   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00448   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00449   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00450   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00451   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00452   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00453   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00466   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00467   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00357   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00469   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00470   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00471   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00472   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00473   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00474   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00475   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00476   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00477   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00556   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00580   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00579   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00578   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00577   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00576   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00575   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00574   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00558   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00557   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00581   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00555   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00554   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00553   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00552   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00551   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00550   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00549   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00548   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00547   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00606   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00530   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00614   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00613   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00612   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00611   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00610   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00609   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00608   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00607   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00356   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00605   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00604   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00603   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00602   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00586   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00585   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00584   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00583   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00582   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00346   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00325   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00326   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00327   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00328   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00329   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00330   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00331   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00332   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00333   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00528   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00347   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00348   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00349   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00350   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00351   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00352   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00353   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00354   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00355   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00323   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00546   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00527   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00526   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00525   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00298   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00299   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00300   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00301   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00302   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00303   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00304   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00305   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00306   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00307   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00308   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00309   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00322   PAR_1_2_VDD075CPU   VDD075CPU
* VDD075CPU_00324   PAR_1_2_VDD075CPU   VDD075CPU
* VSS_02639   PAR_2_2_VSS   VSS
* VSS_02640   PAR_2_2_VSS   VSS
* VSS_02728   PAR_2_2_VSS   VSS
* VSS_02729   PAR_2_2_VSS   VSS
* VSS_02730   PAR_2_2_VSS   VSS
* VSS_02731   PAR_2_2_VSS   VSS
* VSS_02642   PAR_2_2_VSS   VSS
* VSS_02641   PAR_2_2_VSS   VSS
* VSS_02551   PAR_2_2_VSS   VSS
* VSS_02550   PAR_2_2_VSS   VSS
* VSS_02549   PAR_2_2_VSS   VSS
* VSS_02461   PAR_2_2_VSS   VSS
* VSS_02460   PAR_2_2_VSS   VSS
* VSS_02459   PAR_2_2_VSS   VSS
* VSS_02458   PAR_2_2_VSS   VSS
* VSS_02552   PAR_2_2_VSS   VSS
* VDD075CPU_00505   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00503   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00504   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00531   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00532   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00533   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00559   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00560   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00587   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00588   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00589   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00615   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00561   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00616   PAR_2_2_VDD075CPU   VDD075CPU
* VDD075CPU_00617   PAR_2_2_VDD075CPU   VDD075CPU
* VSS_00808   PAR_0_3_VSS   VSS
* VSS_00893   PAR_0_3_VSS   VSS
* VSS_00809   PAR_0_3_VSS   VSS
* VSS_00810   PAR_0_3_VSS   VSS
* VSS_00811   PAR_0_3_VSS   VSS
* VSS_00888   PAR_0_3_VSS   VSS
* VSS_00889   PAR_0_3_VSS   VSS
* VSS_00890   PAR_0_3_VSS   VSS
* VSS_00891   PAR_0_3_VSS   VSS
* VSS_00892   PAR_0_3_VSS   VSS
* VSS_00807   PAR_0_3_VSS   VSS
* VSS_00806   PAR_0_3_VSS   VSS
* VSS_00805   PAR_0_3_VSS   VSS
* VSS_00804   PAR_0_3_VSS   VSS
* VSS_00803   PAR_0_3_VSS   VSS
* VSS_00802   PAR_0_3_VSS   VSS
* VSS_00801   PAR_0_3_VSS   VSS
* VSS_00800   PAR_0_3_VSS   VSS
* VSS_00989   PAR_0_3_VSS   VSS
* VSS_00799   PAR_0_3_VSS   VSS
* VSS_00980   PAR_0_3_VSS   VSS
* VSS_00525   PAR_0_3_VSS   VSS
* VSS_00988   PAR_0_3_VSS   VSS
* VSS_00987   PAR_0_3_VSS   VSS
* VSS_00986   PAR_0_3_VSS   VSS
* VSS_00985   PAR_0_3_VSS   VSS
* VSS_00984   PAR_0_3_VSS   VSS
* VSS_00983   PAR_0_3_VSS   VSS
* VSS_00982   PAR_0_3_VSS   VSS
* VSS_00981   PAR_0_3_VSS   VSS
* VSS_00894   PAR_0_3_VSS   VSS
* VSS_00979   PAR_0_3_VSS   VSS
* VSS_00978   PAR_0_3_VSS   VSS
* VSS_00900   PAR_0_3_VSS   VSS
* VSS_00899   PAR_0_3_VSS   VSS
* VSS_00898   PAR_0_3_VSS   VSS
* VSS_00897   PAR_0_3_VSS   VSS
* VSS_00896   PAR_0_3_VSS   VSS
* VSS_00895   PAR_0_3_VSS   VSS
* VSS_00534   PAR_0_3_VSS   VSS
* VSS_00618   PAR_0_3_VSS   VSS
* VSS_00617   PAR_0_3_VSS   VSS
* VSS_00616   PAR_0_3_VSS   VSS
* VSS_00615   PAR_0_3_VSS   VSS
* VSS_00614   PAR_0_3_VSS   VSS
* VSS_00613   PAR_0_3_VSS   VSS
* VSS_00537   PAR_0_3_VSS   VSS
* VSS_00536   PAR_0_3_VSS   VSS
* VSS_00535   PAR_0_3_VSS   VSS
* VSS_00619   PAR_0_3_VSS   VSS
* VSS_00533   PAR_0_3_VSS   VSS
* VSS_00532   PAR_0_3_VSS   VSS
* VSS_00531   PAR_0_3_VSS   VSS
* VSS_00530   PAR_0_3_VSS   VSS
* VSS_00529   PAR_0_3_VSS   VSS
* VSS_00528   PAR_0_3_VSS   VSS
* VSS_00527   PAR_0_3_VSS   VSS
* VSS_00526   PAR_0_3_VSS   VSS
* VSS_00709   PAR_0_3_VSS   VSS
* VSS_00718   PAR_0_3_VSS   VSS
* VSS_00717   PAR_0_3_VSS   VSS
* VSS_00716   PAR_0_3_VSS   VSS
* VSS_00715   PAR_0_3_VSS   VSS
* VSS_00714   PAR_0_3_VSS   VSS
* VSS_00713   PAR_0_3_VSS   VSS
* VSS_00712   PAR_0_3_VSS   VSS
* VSS_00711   PAR_0_3_VSS   VSS
* VSS_00710   PAR_0_3_VSS   VSS
* VSS_00719   PAR_0_3_VSS   VSS
* VSS_00708   PAR_0_3_VSS   VSS
* VSS_00707   PAR_0_3_VSS   VSS
* VSS_00625   PAR_0_3_VSS   VSS
* VSS_00624   PAR_0_3_VSS   VSS
* VSS_00623   PAR_0_3_VSS   VSS
* VSS_00622   PAR_0_3_VSS   VSS
* VSS_00621   PAR_0_3_VSS   VSS
* VSS_00620   PAR_0_3_VSS   VSS
* VSS_01439   PAR_0_3_VSS   VSS
* VSS_01528   PAR_0_3_VSS   VSS
* VSS_01527   PAR_0_3_VSS   VSS
* VSS_01526   PAR_0_3_VSS   VSS
* VSS_01447   PAR_0_3_VSS   VSS
* VSS_01446   PAR_0_3_VSS   VSS
* VSS_01445   PAR_0_3_VSS   VSS
* VSS_01444   PAR_0_3_VSS   VSS
* VSS_01443   PAR_0_3_VSS   VSS
* VSS_01442   PAR_0_3_VSS   VSS
* VSS_01441   PAR_0_3_VSS   VSS
* VSS_01440   PAR_0_3_VSS   VSS
* VSS_01529   PAR_0_3_VSS   VSS
* VSS_01438   PAR_0_3_VSS   VSS
* VSS_01437   PAR_0_3_VSS   VSS
* VSS_01436   PAR_0_3_VSS   VSS
* VSS_01357   PAR_0_3_VSS   VSS
* VSS_01356   PAR_0_3_VSS   VSS
* VSS_01355   PAR_0_3_VSS   VSS
* VSS_01354   PAR_0_3_VSS   VSS
* VSS_01353   PAR_0_3_VSS   VSS
* VSS_01352   PAR_0_3_VSS   VSS
* VSS_01351   PAR_0_3_VSS   VSS
* VSS_01618   PAR_0_3_VSS   VSS
* VSS_01629   PAR_0_3_VSS   VSS
* VSS_01628   PAR_0_3_VSS   VSS
* VSS_01627   PAR_0_3_VSS   VSS
* VSS_01626   PAR_0_3_VSS   VSS
* VSS_01625   PAR_0_3_VSS   VSS
* VSS_01624   PAR_0_3_VSS   VSS
* VSS_01623   PAR_0_3_VSS   VSS
* VSS_01622   PAR_0_3_VSS   VSS
* VSS_01621   PAR_0_3_VSS   VSS
* VSS_01620   PAR_0_3_VSS   VSS
* VSS_01619   PAR_0_3_VSS   VSS
* VSS_01350   PAR_0_3_VSS   VSS
* VSS_01617   PAR_0_3_VSS   VSS
* VSS_01538   PAR_0_3_VSS   VSS
* VSS_01537   PAR_0_3_VSS   VSS
* VSS_01536   PAR_0_3_VSS   VSS
* VSS_01535   PAR_0_3_VSS   VSS
* VSS_01534   PAR_0_3_VSS   VSS
* VSS_01533   PAR_0_3_VSS   VSS
* VSS_01532   PAR_0_3_VSS   VSS
* VSS_01531   PAR_0_3_VSS   VSS
* VSS_01530   PAR_0_3_VSS   VSS
* VSS_01081   PAR_0_3_VSS   VSS
* VSS_01169   PAR_0_3_VSS   VSS
* VSS_01168   PAR_0_3_VSS   VSS
* VSS_01167   PAR_0_3_VSS   VSS
* VSS_01166   PAR_0_3_VSS   VSS
* VSS_01165   PAR_0_3_VSS   VSS
* VSS_01164   PAR_0_3_VSS   VSS
* VSS_01163   PAR_0_3_VSS   VSS
* VSS_01162   PAR_0_3_VSS   VSS
* VSS_01161   PAR_0_3_VSS   VSS
* VSS_01083   PAR_0_3_VSS   VSS
* VSS_01082   PAR_0_3_VSS   VSS
* VSS_01170   PAR_0_3_VSS   VSS
* VSS_01080   PAR_0_3_VSS   VSS
* VSS_01079   PAR_0_3_VSS   VSS
* VSS_01078   PAR_0_3_VSS   VSS
* VSS_01077   PAR_0_3_VSS   VSS
* VSS_01076   PAR_0_3_VSS   VSS
* VSS_01075   PAR_0_3_VSS   VSS
* VSS_01074   PAR_0_3_VSS   VSS
* VSS_01073   PAR_0_3_VSS   VSS
* VSS_01072   PAR_0_3_VSS   VSS
* VSS_01071   PAR_0_3_VSS   VSS
* VSS_01260   PAR_0_3_VSS   VSS
* VSS_01349   PAR_0_3_VSS   VSS
* VSS_01348   PAR_0_3_VSS   VSS
* VSS_01347   PAR_0_3_VSS   VSS
* VSS_01346   PAR_0_3_VSS   VSS
* VSS_01345   PAR_0_3_VSS   VSS
* VSS_01285   PAR_0_3_VSS   VSS
* VSS_01265   PAR_0_3_VSS   VSS
* VSS_01264   PAR_0_3_VSS   VSS
* VSS_01263   PAR_0_3_VSS   VSS
* VSS_01262   PAR_0_3_VSS   VSS
* VSS_01261   PAR_0_3_VSS   VSS
* VSS_00990   PAR_0_3_VSS   VSS
* VSS_01259   PAR_0_3_VSS   VSS
* VSS_01258   PAR_0_3_VSS   VSS
* VSS_01257   PAR_0_3_VSS   VSS
* VSS_01256   PAR_0_3_VSS   VSS
* VSS_01255   PAR_0_3_VSS   VSS
* VSS_01254   PAR_0_3_VSS   VSS
* VSS_01253   PAR_0_3_VSS   VSS
* VSS_01173   PAR_0_3_VSS   VSS
* VSS_01172   PAR_0_3_VSS   VSS
* VSS_01171   PAR_0_3_VSS   VSS
* VDD075CPU_00179   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00096   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00169   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00170   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00171   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00172   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00173   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00174   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00175   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00176   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00177   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00178   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00214   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00083   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00082   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00081   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00080   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00079   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00078   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00077   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00076   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00075   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00074   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00073   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00101   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00225   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00224   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00223   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00222   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00221   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00107   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00106   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00105   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00104   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00103   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00102   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00201   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00100   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00099   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00098   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00097   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00220   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00219   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00218   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00217   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00216   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00215   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00035   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00024   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00025   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00026   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00027   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00028   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00029   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00030   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00031   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00032   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00033   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00034   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00192   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00058   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00057   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00056   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00055   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00054   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00053   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00052   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00051   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00050   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00049   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00048   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00004   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00200   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00199   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00198   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00197   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00196   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00195   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00072   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00000   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00001   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00002   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00003   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00155   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00005   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00006   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00007   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00008   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00009   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00010   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00011   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00059   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00194   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00193   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00125   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00239   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00240   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00241   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00242   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00243   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00244   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00245   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00246   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00121   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00122   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00123   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00124   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00238   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00146   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00126   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00127   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00128   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00129   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00145   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00272   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00271   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00247   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00248   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00249   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00120   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00270   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00144   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00262   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00263   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00264   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00265   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00266   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00267   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00268   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00269   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00273   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00131   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00130   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00154   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00153   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00152   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00151   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00150   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00149   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00148   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00147   PAR_0_3_VDD075CPU   VDD075CPU
* VDD075CPU_00168   PAR_0_3_VDD075CPU   VDD075CPU
* VSS_01182   PAR_1_3_VSS   VSS
* VSS_01180   PAR_1_3_VSS   VSS
* VSS_01181   PAR_1_3_VSS   VSS
* VSS_01449   PAR_1_3_VSS   VSS
* VSS_01183   PAR_1_3_VSS   VSS
* VSS_01448   PAR_1_3_VSS   VSS
* VSS_01094   PAR_1_3_VSS   VSS
* VSS_01365   PAR_1_3_VSS   VSS
* VSS_01636   PAR_1_3_VSS   VSS
* VSS_01358   PAR_1_3_VSS   VSS
* VSS_01359   PAR_1_3_VSS   VSS
* VSS_01360   PAR_1_3_VSS   VSS
* VSS_01361   PAR_1_3_VSS   VSS
* VSS_01362   PAR_1_3_VSS   VSS
* VSS_01363   PAR_1_3_VSS   VSS
* VSS_01364   PAR_1_3_VSS   VSS
* VSS_01179   PAR_1_3_VSS   VSS
* VSS_01366   PAR_1_3_VSS   VSS
* VSS_01367   PAR_1_3_VSS   VSS
* VSS_01368   PAR_1_3_VSS   VSS
* VSS_01369   PAR_1_3_VSS   VSS
* VSS_01176   PAR_1_3_VSS   VSS
* VSS_01177   PAR_1_3_VSS   VSS
* VSS_01178   PAR_1_3_VSS   VSS
* VSS_01269   PAR_1_3_VSS   VSS
* VSS_01266   PAR_1_3_VSS   VSS
* VSS_01277   PAR_1_3_VSS   VSS
* VSS_01276   PAR_1_3_VSS   VSS
* VSS_01630   PAR_1_3_VSS   VSS
* VSS_01267   PAR_1_3_VSS   VSS
* VSS_01631   PAR_1_3_VSS   VSS
* VSS_01632   PAR_1_3_VSS   VSS
* VSS_01633   PAR_1_3_VSS   VSS
* VSS_01634   PAR_1_3_VSS   VSS
* VSS_01635   PAR_1_3_VSS   VSS
* VSS_01268   PAR_1_3_VSS   VSS
* VSS_01550   PAR_1_3_VSS   VSS
* VSS_01270   PAR_1_3_VSS   VSS
* VSS_01271   PAR_1_3_VSS   VSS
* VSS_01272   PAR_1_3_VSS   VSS
* VSS_01273   PAR_1_3_VSS   VSS
* VSS_01274   PAR_1_3_VSS   VSS
* VSS_01275   PAR_1_3_VSS   VSS
* VSS_01641   PAR_1_3_VSS   VSS
* VSS_01640   PAR_1_3_VSS   VSS
* VSS_01639   PAR_1_3_VSS   VSS
* VSS_01638   PAR_1_3_VSS   VSS
* VSS_01637   PAR_1_3_VSS   VSS
* VSS_01539   PAR_1_3_VSS   VSS
* VSS_01184   PAR_1_3_VSS   VSS
* VSS_01185   PAR_1_3_VSS   VSS
* VSS_01451   PAR_1_3_VSS   VSS
* VSS_01452   PAR_1_3_VSS   VSS
* VSS_01453   PAR_1_3_VSS   VSS
* VSS_01454   PAR_1_3_VSS   VSS
* VSS_01455   PAR_1_3_VSS   VSS
* VSS_01456   PAR_1_3_VSS   VSS
* VSS_01457   PAR_1_3_VSS   VSS
* VSS_01458   PAR_1_3_VSS   VSS
* VSS_01459   PAR_1_3_VSS   VSS
* VSS_01450   PAR_1_3_VSS   VSS
* VSS_01540   PAR_1_3_VSS   VSS
* VSS_01541   PAR_1_3_VSS   VSS
* VSS_01542   PAR_1_3_VSS   VSS
* VSS_01543   PAR_1_3_VSS   VSS
* VSS_01544   PAR_1_3_VSS   VSS
* VSS_01545   PAR_1_3_VSS   VSS
* VSS_01546   PAR_1_3_VSS   VSS
* VSS_01547   PAR_1_3_VSS   VSS
* VSS_01548   PAR_1_3_VSS   VSS
* VSS_01549   PAR_1_3_VSS   VSS
* VSS_00816   PAR_1_3_VSS   VSS
* VSS_00723   PAR_1_3_VSS   VSS
* VSS_00724   PAR_1_3_VSS   VSS
* VSS_00725   PAR_1_3_VSS   VSS
* VSS_00726   PAR_1_3_VSS   VSS
* VSS_00727   PAR_1_3_VSS   VSS
* VSS_00728   PAR_1_3_VSS   VSS
* VSS_00729   PAR_1_3_VSS   VSS
* VSS_00730   PAR_1_3_VSS   VSS
* VSS_00731   PAR_1_3_VSS   VSS
* VSS_00812   PAR_1_3_VSS   VSS
* VSS_00813   PAR_1_3_VSS   VSS
* VSS_00814   PAR_1_3_VSS   VSS
* VSS_00815   PAR_1_3_VSS   VSS
* VSS_00722   PAR_1_3_VSS   VSS
* VSS_00817   PAR_1_3_VSS   VSS
* VSS_00818   PAR_1_3_VSS   VSS
* VSS_00819   PAR_1_3_VSS   VSS
* VSS_00820   PAR_1_3_VSS   VSS
* VSS_00821   PAR_1_3_VSS   VSS
* VSS_00822   PAR_1_3_VSS   VSS
* VSS_00823   PAR_1_3_VSS   VSS
* VSS_00901   PAR_1_3_VSS   VSS
* VSS_00902   PAR_1_3_VSS   VSS
* VSS_00903   PAR_1_3_VSS   VSS
* VSS_00904   PAR_1_3_VSS   VSS
* VSS_00905   PAR_1_3_VSS   VSS
* VSS_00906   PAR_1_3_VSS   VSS
* VSS_00627   PAR_1_3_VSS   VSS
* VSS_00538   PAR_1_3_VSS   VSS
* VSS_00539   PAR_1_3_VSS   VSS
* VSS_00540   PAR_1_3_VSS   VSS
* VSS_00541   PAR_1_3_VSS   VSS
* VSS_00542   PAR_1_3_VSS   VSS
* VSS_00543   PAR_1_3_VSS   VSS
* VSS_00544   PAR_1_3_VSS   VSS
* VSS_00545   PAR_1_3_VSS   VSS
* VSS_00546   PAR_1_3_VSS   VSS
* VSS_00547   PAR_1_3_VSS   VSS
* VSS_00548   PAR_1_3_VSS   VSS
* VSS_00549   PAR_1_3_VSS   VSS
* VSS_00626   PAR_1_3_VSS   VSS
* VSS_01174   PAR_1_3_VSS   VSS
* VSS_00628   PAR_1_3_VSS   VSS
* VSS_00629   PAR_1_3_VSS   VSS
* VSS_00630   PAR_1_3_VSS   VSS
* VSS_00631   PAR_1_3_VSS   VSS
* VSS_00632   PAR_1_3_VSS   VSS
* VSS_00633   PAR_1_3_VSS   VSS
* VSS_00634   PAR_1_3_VSS   VSS
* VSS_00635   PAR_1_3_VSS   VSS
* VSS_00636   PAR_1_3_VSS   VSS
* VSS_00637   PAR_1_3_VSS   VSS
* VSS_00720   PAR_1_3_VSS   VSS
* VSS_00721   PAR_1_3_VSS   VSS
* VSS_01092   PAR_1_3_VSS   VSS
* VSS_01090   PAR_1_3_VSS   VSS
* VSS_01091   PAR_1_3_VSS   VSS
* VSS_00992   PAR_1_3_VSS   VSS
* VSS_00993   PAR_1_3_VSS   VSS
* VSS_00994   PAR_1_3_VSS   VSS
* VSS_00995   PAR_1_3_VSS   VSS
* VSS_00996   PAR_1_3_VSS   VSS
* VSS_00997   PAR_1_3_VSS   VSS
* VSS_00991   PAR_1_3_VSS   VSS
* VSS_01093   PAR_1_3_VSS   VSS
* VSS_00998   PAR_1_3_VSS   VSS
* VSS_00999   PAR_1_3_VSS   VSS
* VSS_01000   PAR_1_3_VSS   VSS
* VSS_01001   PAR_1_3_VSS   VSS
* VSS_01002   PAR_1_3_VSS   VSS
* VSS_01084   PAR_1_3_VSS   VSS
* VSS_01095   PAR_1_3_VSS   VSS
* VSS_01089   PAR_1_3_VSS   VSS
* VSS_00908   PAR_1_3_VSS   VSS
* VSS_00909   PAR_1_3_VSS   VSS
* VSS_00910   PAR_1_3_VSS   VSS
* VSS_00911   PAR_1_3_VSS   VSS
* VSS_00912   PAR_1_3_VSS   VSS
* VSS_00907   PAR_1_3_VSS   VSS
* VSS_01085   PAR_1_3_VSS   VSS
* VSS_01086   PAR_1_3_VSS   VSS
* VSS_01087   PAR_1_3_VSS   VSS
* VSS_01088   PAR_1_3_VSS   VSS
* VSS_01175   PAR_1_3_VSS   VSS
* VDD075CPU_00181   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00157   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00158   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00159   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00285   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00260   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00284   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00156   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00160   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00261   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00274   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00283   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00282   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00281   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00280   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00279   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00278   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00277   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00276   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00275   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00191   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00182   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00183   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00184   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00185   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00186   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00187   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00188   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00189   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00190   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00212   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00206   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00207   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00237   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00236   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00235   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00234   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00208   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00209   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00210   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00211   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00205   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00233   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00232   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00231   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00230   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00229   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00228   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00227   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00226   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00213   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00256   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00162   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00163   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00164   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00165   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00166   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00167   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00180   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00259   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00258   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00257   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00161   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00255   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00254   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00253   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00252   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00251   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00250   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00202   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00203   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00204   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00062   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00041   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00042   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00043   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00044   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00045   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00046   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00047   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00060   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00061   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00040   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00063   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00064   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00065   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00066   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00067   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00068   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00069   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00070   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00019   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00143   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00012   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00013   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00014   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00015   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00016   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00017   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00018   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00142   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00020   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00021   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00022   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00023   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00036   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00037   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00038   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00039   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00134   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00114   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00115   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00116   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00117   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00118   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00119   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00132   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00133   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00084   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00135   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00136   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00137   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00138   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00139   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00140   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00141   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00071   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00112   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00113   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00085   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00086   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00087   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00088   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00089   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00090   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00091   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00093   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00094   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00095   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00108   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00109   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00110   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00111   PAR_1_3_VDD075CPU   VDD075CPU
* VDD075CPU_00092   PAR_1_3_VDD075CPU   VDD075CPU
* VSS_04401   PAR_0_0_VSS   VSS
* VSS_04402   PAR_0_0_VSS   VSS
* VSS_04403   PAR_0_0_VSS   VSS
* VSS_04404   PAR_0_0_VSS   VSS
* VSS_04405   PAR_0_0_VSS   VSS
* VSS_04406   PAR_0_0_VSS   VSS
* VSS_04407   PAR_0_0_VSS   VSS
* VSS_04408   PAR_0_0_VSS   VSS
* VSS_04409   PAR_0_0_VSS   VSS
* VSS_04410   PAR_0_0_VSS   VSS
* VSS_04400   PAR_0_0_VSS   VSS
* VSS_04314   PAR_0_0_VSS   VSS
* VSS_04313   PAR_0_0_VSS   VSS
* VSS_04312   PAR_0_0_VSS   VSS
* VSS_04311   PAR_0_0_VSS   VSS
* VSS_04310   PAR_0_0_VSS   VSS
* VSS_04309   PAR_0_0_VSS   VSS
* VSS_04308   PAR_0_0_VSS   VSS
* VSS_04307   PAR_0_0_VSS   VSS
* VSS_04306   PAR_0_0_VSS   VSS
* VSS_04305   PAR_0_0_VSS   VSS
* VSS_04503   PAR_0_0_VSS   VSS
* VSS_04593   PAR_0_0_VSS   VSS
* VSS_04017   PAR_0_0_VSS   VSS
* VSS_04592   PAR_0_0_VSS   VSS
* VSS_04591   PAR_0_0_VSS   VSS
* VSS_04590   PAR_0_0_VSS   VSS
* VSS_04589   PAR_0_0_VSS   VSS
* VSS_04588   PAR_0_0_VSS   VSS
* VSS_04587   PAR_0_0_VSS   VSS
* VSS_04586   PAR_0_0_VSS   VSS
* VSS_04504   PAR_0_0_VSS   VSS
* VSS_04411   PAR_0_0_VSS   VSS
* VSS_04502   PAR_0_0_VSS   VSS
* VSS_04501   PAR_0_0_VSS   VSS
* VSS_04500   PAR_0_0_VSS   VSS
* VSS_04499   PAR_0_0_VSS   VSS
* VSS_04498   PAR_0_0_VSS   VSS
* VSS_04497   PAR_0_0_VSS   VSS
* VSS_04496   PAR_0_0_VSS   VSS
* VSS_04495   PAR_0_0_VSS   VSS
* VSS_04412   PAR_0_0_VSS   VSS
* VSS_04027   PAR_0_0_VSS   VSS
* VSS_04119   PAR_0_0_VSS   VSS
* VSS_04118   PAR_0_0_VSS   VSS
* VSS_04117   PAR_0_0_VSS   VSS
* VSS_04116   PAR_0_0_VSS   VSS
* VSS_04115   PAR_0_0_VSS   VSS
* VSS_04114   PAR_0_0_VSS   VSS
* VSS_04113   PAR_0_0_VSS   VSS
* VSS_04112   PAR_0_0_VSS   VSS
* VSS_04029   PAR_0_0_VSS   VSS
* VSS_04028   PAR_0_0_VSS   VSS
* VSS_04120   PAR_0_0_VSS   VSS
* VSS_04026   PAR_0_0_VSS   VSS
* VSS_04025   PAR_0_0_VSS   VSS
* VSS_04024   PAR_0_0_VSS   VSS
* VSS_04023   PAR_0_0_VSS   VSS
* VSS_04022   PAR_0_0_VSS   VSS
* VSS_04021   PAR_0_0_VSS   VSS
* VSS_04020   PAR_0_0_VSS   VSS
* VSS_04019   PAR_0_0_VSS   VSS
* VSS_04018   PAR_0_0_VSS   VSS
* VSS_04212   PAR_0_0_VSS   VSS
* VSS_04303   PAR_0_0_VSS   VSS
* VSS_04302   PAR_0_0_VSS   VSS
* VSS_04219   PAR_0_0_VSS   VSS
* VSS_04218   PAR_0_0_VSS   VSS
* VSS_04217   PAR_0_0_VSS   VSS
* VSS_04216   PAR_0_0_VSS   VSS
* VSS_04215   PAR_0_0_VSS   VSS
* VSS_04214   PAR_0_0_VSS   VSS
* VSS_04213   PAR_0_0_VSS   VSS
* VSS_04304   PAR_0_0_VSS   VSS
* VSS_04211   PAR_0_0_VSS   VSS
* VSS_04210   PAR_0_0_VSS   VSS
* VSS_04209   PAR_0_0_VSS   VSS
* VSS_04208   PAR_0_0_VSS   VSS
* VSS_04207   PAR_0_0_VSS   VSS
* VSS_04124   PAR_0_0_VSS   VSS
* VSS_04123   PAR_0_0_VSS   VSS
* VSS_04122   PAR_0_0_VSS   VSS
* VSS_04121   PAR_0_0_VSS   VSS
* VSS_04975   PAR_0_0_VSS   VSS
* VSS_05067   PAR_0_0_VSS   VSS
* VSS_05066   PAR_0_0_VSS   VSS
* VSS_05065   PAR_0_0_VSS   VSS
* VSS_05064   PAR_0_0_VSS   VSS
* VSS_05063   PAR_0_0_VSS   VSS
* VSS_04980   PAR_0_0_VSS   VSS
* VSS_04979   PAR_0_0_VSS   VSS
* VSS_04978   PAR_0_0_VSS   VSS
* VSS_04977   PAR_0_0_VSS   VSS
* VSS_04976   PAR_0_0_VSS   VSS
* VSS_05068   PAR_0_0_VSS   VSS
* VSS_04974   PAR_0_0_VSS   VSS
* VSS_04973   PAR_0_0_VSS   VSS
* VSS_04972   PAR_0_0_VSS   VSS
* VSS_04971   PAR_0_0_VSS   VSS
* VSS_04970   PAR_0_0_VSS   VSS
* VSS_04969   PAR_0_0_VSS   VSS
* VSS_04968   PAR_0_0_VSS   VSS
* VSS_04884   PAR_0_0_VSS   VSS
* VSS_04883   PAR_0_0_VSS   VSS
* VSS_05160   PAR_0_0_VSS   VSS
* VSS_05170   PAR_0_0_VSS   VSS
* VSS_05169   PAR_0_0_VSS   VSS
* VSS_05168   PAR_0_0_VSS   VSS
* VSS_05167   PAR_0_0_VSS   VSS
* VSS_05166   PAR_0_0_VSS   VSS
* VSS_05165   PAR_0_0_VSS   VSS
* VSS_05164   PAR_0_0_VSS   VSS
* VSS_05163   PAR_0_0_VSS   VSS
* VSS_05162   PAR_0_0_VSS   VSS
* VSS_05161   PAR_0_0_VSS   VSS
* VSS_04882   PAR_0_0_VSS   VSS
* VSS_05159   PAR_0_0_VSS   VSS
* VSS_05158   PAR_0_0_VSS   VSS
* VSS_05075   PAR_0_0_VSS   VSS
* VSS_05074   PAR_0_0_VSS   VSS
* VSS_05073   PAR_0_0_VSS   VSS
* VSS_05072   PAR_0_0_VSS   VSS
* VSS_05071   PAR_0_0_VSS   VSS
* VSS_05070   PAR_0_0_VSS   VSS
* VSS_05069   PAR_0_0_VSS   VSS
* VSS_04687   PAR_0_0_VSS   VSS
* VSS_04779   PAR_0_0_VSS   VSS
* VSS_04778   PAR_0_0_VSS   VSS
* VSS_04777   PAR_0_0_VSS   VSS
* VSS_04694   PAR_0_0_VSS   VSS
* VSS_04693   PAR_0_0_VSS   VSS
* VSS_04692   PAR_0_0_VSS   VSS
* VSS_04691   PAR_0_0_VSS   VSS
* VSS_04690   PAR_0_0_VSS   VSS
* VSS_04689   PAR_0_0_VSS   VSS
* VSS_04688   PAR_0_0_VSS   VSS
* VSS_04780   PAR_0_0_VSS   VSS
* VSS_04686   PAR_0_0_VSS   VSS
* VSS_04685   PAR_0_0_VSS   VSS
* VSS_04684   PAR_0_0_VSS   VSS
* VSS_04683   PAR_0_0_VSS   VSS
* VSS_04682   PAR_0_0_VSS   VSS
* VSS_04598   PAR_0_0_VSS   VSS
* VSS_04597   PAR_0_0_VSS   VSS
* VSS_04596   PAR_0_0_VSS   VSS
* VSS_04595   PAR_0_0_VSS   VSS
* VSS_04872   PAR_0_0_VSS   VSS
* VSS_04881   PAR_0_0_VSS   VSS
* VSS_04880   PAR_0_0_VSS   VSS
* VSS_04879   PAR_0_0_VSS   VSS
* VSS_04878   PAR_0_0_VSS   VSS
* VSS_04877   PAR_0_0_VSS   VSS
* VSS_04876   PAR_0_0_VSS   VSS
* VSS_04875   PAR_0_0_VSS   VSS
* VSS_04874   PAR_0_0_VSS   VSS
* VSS_04873   PAR_0_0_VSS   VSS
* VSS_04594   PAR_0_0_VSS   VSS
* VSS_04789   PAR_0_0_VSS   VSS
* VSS_04788   PAR_0_0_VSS   VSS
* VSS_04787   PAR_0_0_VSS   VSS
* VSS_04786   PAR_0_0_VSS   VSS
* VSS_04785   PAR_0_0_VSS   VSS
* VSS_04784   PAR_0_0_VSS   VSS
* VSS_04783   PAR_0_0_VSS   VSS
* VSS_04782   PAR_0_0_VSS   VSS
* VSS_04781   PAR_0_0_VSS   VSS

* No connection to global ground (Spice node 0) *
C0_1 PAR_0_0_VDD075CPU PAR_0_0_VSS 4.96053796593e-10
R_1_1 PAR_0_0_VDD075CPU n23 0.00130390726399
C_1_1 n23 PAR_0_0_VSS 1.35730155806e-08
R_2_1 PAR_0_0_VDD075CPU n24 0.00291206667173
C_2_1 n24 PAR_0_0_VSS 1.7469973393e-08
R_3_1 PAR_0_0_VDD075CPU n25 0.00195919055181
C_3_1 n25 PAR_0_0_VSS 4.97689573803e-08
R_4_1 PAR_0_0_VDD075CPU n26 0.633217809169
R_7_1 PAR_0_0_VDD075CPU n26 1688000
C_4_1 n26 PAR_0_0_VSS 3.81303525783e-10
R_5_1 PAR_0_0_VDD075CPU n27 2.78389763143
R_8_1 PAR_0_0_VDD075CPU n27 1778000
C_5_1 n27 PAR_0_0_VSS 3.61271928927e-10
R_6_1 PAR_0_0_VDD075CPU n28 27.4575065597
R_9_1 PAR_0_0_VDD075CPU n28 1889000
C_6_1 n28 PAR_0_0_VSS 1.99930614495e-10
G0_2 PAR_1_0_VSS PAR_0_0_VDD075CPU PAR_1_0_VSS PAR_0_0_VDD075CPU -2.15929114107
C0_2 PAR_1_0_VSS PAR_0_0_VDD075CPU 1.94819817883e-10
R_1_2 PAR_1_0_VSS n29 0.0389713812778
C_1_2 n29 PAR_0_0_VDD075CPU 4.98634888543e-10
R_2_2 PAR_1_0_VSS n30 0.113441747708
C_2_2 n30 PAR_0_0_VDD075CPU 5.66389527938e-10
R_3_2 PAR_1_0_VSS n31 0.0605333208254
C_3_2 n31 PAR_0_0_VDD075CPU 1.93856886381e-09
L_4_2 PAR_1_0_VSS n32 8.4222007075e-11
R_4_2 n32 PAR_0_0_VDD075CPU 0.478956075551
L_5_2 PAR_1_0_VSS n33 2.95490403732e-08
R_5_2 n33 PAR_0_0_VDD075CPU 16.0529286525
L_6_2 PAR_1_0_VSS n34 1.37130276903e-06
R_6_2 n34 PAR_0_0_VDD075CPU 109.612064237
R0_3 PAR_1_0_VSS PAR_0_0_VSS 0.00309801277074
R_1_3 PAR_1_0_VSS n35 0.0835978956757
C_1_3 n35 PAR_0_0_VSS 7.60618894085e-10
L_2_3 PAR_1_0_VSS n36 2.81472675652e-12
R_2_3 n36 PAR_0_0_VSS 0.0300270026145
R_3_3 PAR_1_0_VSS n37 0.0515873344
C_3_3 n37 PAR_0_0_VSS 3.38326535732e-09
L_4_3 PAR_1_0_VSS n38 1.0571862507e-10
R_4_3 n38 PAR_0_0_VSS 0.177479318888
L_5_3 PAR_1_0_VSS n39 1.06445740411e-09
R_5_3 n39 PAR_0_0_VSS 0.785745988494
R_6_3 PAR_1_0_VSS n40 6.67349628053
R_10_3 PAR_1_0_VSS n40 1666000
C_6_3 n40 PAR_0_0_VSS 1.5635426314e-09
R0_4 PAR_1_0_VDD075CPU PAR_0_0_VDD075CPU 0.00377083931658
C0_4 PAR_1_0_VDD075CPU PAR_0_0_VDD075CPU 5.61118462081e-11
L_1_4 PAR_1_0_VDD075CPU n41 4.26843747744e-13
R_1_4 n41 PAR_0_0_VDD075CPU 0.0252221904093
L_2_4 PAR_1_0_VDD075CPU n42 2.65877016186e-12
R_2_4 n42 PAR_0_0_VDD075CPU 0.0560136144529
L_3_4 PAR_1_0_VDD075CPU n43 3.41584319156e-12
R_3_4 n43 PAR_0_0_VDD075CPU 0.0327150507036
L_4_4 PAR_1_0_VDD075CPU n44 1.47072187487e-08
R_4_4 n44 PAR_0_0_VDD075CPU 32.0877397253
L_5_4 PAR_1_0_VDD075CPU n45 4.75696015681e-07
R_5_4 n45 PAR_0_0_VDD075CPU 237.974646806
L_6_4 PAR_1_0_VDD075CPU n46 5.57305619362e-05
R_6_4 n46 PAR_0_0_VDD075CPU 1702.44427048
G0_5 PAR_1_0_VDD075CPU PAR_1_0_VSS PAR_1_0_VDD075CPU PAR_1_0_VSS -0.0434495291161
C0_5 PAR_1_0_VDD075CPU PAR_1_0_VSS 1.29582666091e-09
R_1_5 PAR_1_0_VDD075CPU n47 0.0018914432404
C_1_5 n47 PAR_1_0_VSS 8.39525864326e-09
R_2_5 PAR_1_0_VDD075CPU n48 0.0033536931412
C_2_5 n48 PAR_1_0_VSS 1.57129373792e-08
R_3_5 PAR_1_0_VDD075CPU n49 0.00278965637502
C_3_5 n49 PAR_1_0_VSS 3.52231196821e-08
R_4_5 PAR_1_0_VDD075CPU n50 0.861196377161
C_4_5 n50 PAR_1_0_VSS 3.00337790385e-10
L_5_5 PAR_1_0_VDD075CPU n51 9.5734735734e-08
R_5_5 n51 PAR_1_0_VSS 23.0152078506
G0_6 PAR_1_0_VDD075CPU PAR_0_0_VSS PAR_1_0_VDD075CPU PAR_0_0_VSS -1.47959001681
C0_6 PAR_1_0_VDD075CPU PAR_0_0_VSS 3.02667489955e-10
R_1_6 PAR_1_0_VDD075CPU n52 0.00813901461702
C_1_6 n52 PAR_0_0_VSS 1.83031345522e-09
R_2_6 PAR_1_0_VDD075CPU n53 0.0449752661448
C_2_6 n53 PAR_0_0_VSS 1.1239568466e-09
R_3_6 PAR_1_0_VDD075CPU n54 0.0251607304292
C_3_6 n54 PAR_0_0_VSS 4.14725095142e-09
L_4_6 PAR_1_0_VDD075CPU n55 1.27315119803e-10
R_4_6 n55 PAR_0_0_VSS 0.675862899057
R_5_6 PAR_1_0_VDD075CPU n56 5.0120045578
C_5_6 n56 PAR_0_0_VSS 1.92083288234e-10
R_6_6 PAR_1_0_VDD075CPU n57 50.0826129531
C_6_6 n57 PAR_0_0_VSS 1.51481424901e-10
G0_7 PAR_2_0_VSS PAR_0_0_VDD075CPU PAR_2_0_VSS PAR_0_0_VDD075CPU -0.185935281097
C0_7 PAR_2_0_VSS PAR_0_0_VDD075CPU 2.44877549462e-10
R_1_7 PAR_2_0_VSS n58 2.4279039782
C_1_7 n58 PAR_0_0_VDD075CPU 4.47958871846e-11
R_2_7 PAR_2_0_VSS n59 3.3692378002
C_2_7 n59 PAR_0_0_VDD075CPU 1.81515720959e-10
L_3_7 PAR_2_0_VSS n60 8.25652814532e-09
R_3_7 n60 PAR_0_0_VDD075CPU 6.90008281729
L_4_7 PAR_2_0_VSS n61 9.37379545623e-08
R_4_7 n61 PAR_0_0_VDD075CPU 31.6024786943
L_5_7 PAR_2_0_VSS n62 1.41130382949e-06
R_5_7 n62 PAR_0_0_VDD075CPU 106.764613976
R0_8 PAR_2_0_VSS PAR_1_0_VSS 0.00378223518045
C0_8 PAR_2_0_VSS PAR_1_0_VSS 2.38856388885e-11
L_1_8 PAR_2_0_VSS n63 1.1094401385e-12
R_1_8 n63 PAR_1_0_VSS 0.0338691895787
L_2_8 PAR_2_0_VSS n64 3.02850676813e-12
R_2_8 n64 PAR_1_0_VSS 0.0321248424894
L_3_8 PAR_2_0_VSS n65 3.01138234038e-11
R_3_8 n65 PAR_1_0_VSS 0.131398832235
L_4_8 PAR_2_0_VSS n66 1.52198370337e-10
R_4_8 n66 PAR_1_0_VSS 0.18364947494
L_5_8 PAR_2_0_VSS n67 5.95458476255e-10
R_5_8 n67 PAR_1_0_VSS 0.354896418248
L_6_8 PAR_2_0_VSS n68 4.84390447541e-08
R_6_8 n68 PAR_1_0_VSS 4.60098372097
G0_9 PAR_2_0_VSS PAR_1_0_VDD075CPU PAR_2_0_VSS PAR_1_0_VDD075CPU -0.0951128229023
C0_9 PAR_2_0_VSS PAR_1_0_VDD075CPU 3.43912783647e-10
R_1_9 PAR_2_0_VSS n69 0.0214355261252
C_1_9 n69 PAR_1_0_VDD075CPU 1.49420098657e-09
R_2_9 PAR_2_0_VSS n70 0.0189676958283
C_2_9 n70 PAR_1_0_VDD075CPU 4.98514114182e-09
R_3_9 PAR_2_0_VSS n71 0.54419020717
C_3_9 n71 PAR_1_0_VDD075CPU 3.49131326205e-10
R_4_9 PAR_2_0_VSS n72 5.4589968732
C_4_9 n72 PAR_1_0_VDD075CPU 1.43985609705e-10
L_5_9 PAR_2_0_VSS n73 2.83059560199e-08
R_5_9 n73 PAR_1_0_VDD075CPU 10.513829186
R0_10 PAR_2_0_VSS PAR_0_0_VSS 2.88907907536
C0_10 PAR_2_0_VSS PAR_0_0_VSS 3.4542850749e-10
R_1_10 PAR_2_0_VSS n74 0.0220261664233
C_1_10 n74 PAR_0_0_VSS 8.63693503137e-10
R_2_10 PAR_2_0_VSS n75 0.154380184888
C_2_10 n75 PAR_0_0_VSS 4.26521150654e-10
R_3_10 PAR_2_0_VSS n76 0.172721248161
C_3_10 n76 PAR_0_0_VSS 1.28015683566e-09
R_4_10 PAR_2_0_VSS n77 0.0756764989001
C_4_10 n77 PAR_0_0_VSS 1.38003944812e-08
R_5_10 PAR_2_0_VSS n78 3.51348225761
C_5_10 n78 PAR_0_0_VSS 1.61323779104e-09
R_6_10 PAR_2_0_VSS n79 15.3306272776
C_6_10 n79 PAR_0_0_VSS 1.16723693388e-09
G0_11 PAR_2_0_VDD075CPU PAR_0_0_VDD075CPU PAR_2_0_VDD075CPU PAR_0_0_VDD075CPU -3.3666808249
C0_11 PAR_2_0_VDD075CPU PAR_0_0_VDD075CPU 1.49377590254e-10
R_1_11 PAR_2_0_VDD075CPU n80 0.554618150185
C_1_11 n80 PAR_0_0_VDD075CPU 4.5454773727e-11
L_2_11 PAR_2_0_VDD075CPU n81 4.50966142918e-11
R_2_11 n81 PAR_0_0_VDD075CPU 0.386595987771
R_3_11 PAR_2_0_VDD075CPU n82 0.734361339351
C_3_11 n82 PAR_0_0_VDD075CPU 3.56334794541e-10
L_4_11 PAR_2_0_VDD075CPU n83 9.03326326799e-10
R_4_11 n83 PAR_0_0_VDD075CPU 1.48055551025
R_5_11 PAR_2_0_VDD075CPU n84 4.95267618988
C_5_11 n84 PAR_0_0_VDD075CPU 6.56537002671e-10
L_6_11 PAR_2_0_VDD075CPU n85 8.19481919469e-08
R_6_11 n85 PAR_0_0_VDD075CPU 9.37601455519
G0_12 PAR_2_0_VDD075CPU PAR_1_0_VSS PAR_2_0_VDD075CPU PAR_1_0_VSS -0.626576726205
C0_12 PAR_2_0_VDD075CPU PAR_1_0_VSS 2.15126202549e-10
R_1_12 PAR_2_0_VDD075CPU n86 0.0449776646703
C_1_12 n86 PAR_1_0_VSS 4.71292952326e-10
R_2_12 PAR_2_0_VDD075CPU n87 0.0772166056442
C_2_12 n87 PAR_1_0_VSS 8.3682610166e-10
R_3_12 PAR_2_0_VDD075CPU n88 0.0542586183205
C_3_12 n88 PAR_1_0_VSS 2.08825392076e-09
L_4_12 PAR_2_0_VDD075CPU n89 4.03441249436e-10
R_4_12 n89 PAR_1_0_VSS 1.79855776959
L_5_12 PAR_2_0_VDD075CPU n90 3.21541407332e-08
R_5_12 n90 PAR_1_0_VSS 16.5055081628
L_6_12 PAR_2_0_VDD075CPU n91 1.37166163524e-06
R_6_12 n91 PAR_1_0_VSS 100.101623675
R0_13 PAR_2_0_VDD075CPU PAR_1_0_VDD075CPU 0.00375329317061
C0_13 PAR_2_0_VDD075CPU PAR_1_0_VDD075CPU 9.8193442637e-11
L_1_13 PAR_2_0_VDD075CPU n92 4.29167646748e-13
R_1_13 n92 PAR_1_0_VDD075CPU 0.0255217251869
L_2_13 PAR_2_0_VDD075CPU n93 2.54934331426e-12
R_2_13 n93 PAR_1_0_VDD075CPU 0.0505700496785
L_3_13 PAR_2_0_VDD075CPU n94 3.14136871479e-12
R_3_13 n94 PAR_1_0_VDD075CPU 0.0300384855622
L_4_13 PAR_2_0_VDD075CPU n95 7.4856998746e-09
R_4_13 n95 PAR_1_0_VDD075CPU 19.3058127814
L_5_13 PAR_2_0_VDD075CPU n96 1.45443642166e-07
R_5_13 n96 PAR_1_0_VDD075CPU 117.545691233
L_6_13 PAR_2_0_VDD075CPU n97 8.9546762945e-06
R_6_13 n97 PAR_1_0_VDD075CPU 800.701150717
G0_14 PAR_2_0_VDD075CPU PAR_2_0_VSS PAR_2_0_VDD075CPU PAR_2_0_VSS -0.057711649137
C0_14 PAR_2_0_VDD075CPU PAR_2_0_VSS 7.16883385448e-10
R_1_14 PAR_2_0_VDD075CPU n98 0.000956851202835
C_1_14 n98 PAR_2_0_VSS 1.71569410917e-08
R_2_14 PAR_2_0_VDD075CPU n99 0.00377712577852
C_2_14 n99 PAR_2_0_VSS 1.42757523124e-08
R_3_14 PAR_2_0_VDD075CPU n100 0.00160133993858
C_3_14 n100 PAR_2_0_VSS 6.34465159375e-08
R_4_14 PAR_2_0_VDD075CPU n101 1.47822560007
C_4_14 n101 PAR_2_0_VSS 2.82494192406e-10
R_5_14 PAR_2_0_VDD075CPU n102 3.77426174974
C_5_14 n102 PAR_2_0_VSS 2.39135912106e-10
L_6_14 PAR_2_0_VDD075CPU n103 7.36601353142e-08
R_6_14 n103 PAR_2_0_VSS 17.3275234936
G0_15 PAR_2_0_VDD075CPU PAR_0_0_VSS PAR_2_0_VDD075CPU PAR_0_0_VSS -0.599098610647
C0_15 PAR_2_0_VDD075CPU PAR_0_0_VSS 2.93630108382e-10
R_1_15 PAR_2_0_VDD075CPU n104 0.0150416980177
C_1_15 n104 PAR_0_0_VSS 9.09829198479e-10
R_2_15 PAR_2_0_VDD075CPU n105 0.304804873632
C_2_15 n105 PAR_0_0_VSS 2.55271758402e-10
L_3_15 PAR_2_0_VDD075CPU n106 4.55187229436e-10
R_3_15 n106 PAR_0_0_VSS 1.66917428573
R_4_15 PAR_2_0_VDD075CPU n107 8.79657689277
C_4_15 n107 PAR_0_0_VSS 9.07603786141e-11
R_5_15 PAR_2_0_VDD075CPU n108 43.96929905
C_5_15 n108 PAR_0_0_VSS 1.02409703002e-10
R_6_15 PAR_2_0_VDD075CPU n109 145.106882624
C_6_15 n109 PAR_0_0_VSS 1.10011264161e-10
G0_16 PAR_0_1_VSS PAR_0_0_VDD075CPU PAR_0_1_VSS PAR_0_0_VDD075CPU -0.0937306635146
C0_16 PAR_0_1_VSS PAR_0_0_VDD075CPU 1.7165145143e-10
R_1_16 PAR_0_1_VSS n110 0.0323103903056
C_1_16 n110 PAR_0_0_VDD075CPU 4.87961935102e-10
R_2_16 PAR_0_1_VSS n111 0.0311016249579
C_2_16 n111 PAR_0_0_VDD075CPU 1.65636593714e-09
R_3_16 PAR_0_1_VSS n112 0.0227681308123
C_3_16 n112 PAR_0_0_VDD075CPU 4.57247584822e-09
L_4_16 PAR_0_1_VSS n113 6.18657324247e-09
R_4_16 n113 PAR_0_0_VDD075CPU 10.6688668881
R_5_16 PAR_0_1_VSS n114 27.9957280176
C_5_16 n114 PAR_0_0_VDD075CPU 1.89239034327e-10
R_6_16 PAR_0_1_VSS n115 67.4493748962
C_6_16 n115 PAR_0_0_VDD075CPU 2.36560901271e-10
R0_17 PAR_0_1_VSS PAR_1_0_VSS 0.124606911989
C0_17 PAR_0_1_VSS PAR_1_0_VSS 1.76878829751e-10
R_1_17 PAR_0_1_VSS n116 0.414444283623
C_1_17 n116 PAR_1_0_VSS 7.62310911401e-11
R_2_17 PAR_0_1_VSS n117 0.102398436047
C_2_17 n117 PAR_1_0_VSS 2.0739939734e-09
R_3_17 PAR_0_1_VSS n118 0.414285391976
C_3_17 n118 PAR_1_0_VSS 7.60405817274e-10
R_4_17 PAR_0_1_VSS n119 0.335151229618
C_4_17 n119 PAR_1_0_VSS 2.46064973221e-09
R_5_17 PAR_0_1_VSS n120 1.54760005299
C_5_17 n120 PAR_1_0_VSS 2.69355118562e-09
R_6_17 PAR_0_1_VSS n121 3.36173913486
C_6_17 n121 PAR_1_0_VSS 4.22465927142e-09
G0_18 PAR_0_1_VSS PAR_1_0_VDD075CPU PAR_0_1_VSS PAR_1_0_VDD075CPU -0.25370974966
C0_18 PAR_0_1_VSS PAR_1_0_VDD075CPU 2.21828186408e-10
R_1_18 PAR_0_1_VSS n122 0.0892839163844
C_1_18 n122 PAR_1_0_VDD075CPU 2.80114115934e-10
R_2_18 PAR_0_1_VSS n123 0.199423100788
C_2_18 n123 PAR_1_0_VDD075CPU 3.74052338238e-10
L_3_18 PAR_0_1_VSS n124 1.65897479962e-09
R_3_18 n124 PAR_1_0_VDD075CPU 3.94151186866
R_4_18 PAR_0_1_VSS n125 23.2042390928
C_4_18 n125 PAR_1_0_VDD075CPU 3.21452468414e-10
R_5_18 PAR_0_1_VSS n126 190.690743346
C_5_18 n126 PAR_1_0_VDD075CPU 1.31663315509e-10
R0_19 PAR_0_1_VSS PAR_2_0_VSS 1468.38737402
C0_19 PAR_0_1_VSS PAR_2_0_VSS 2.36899363965e-10
R_1_19 PAR_0_1_VSS n127 0.202816417626
C_1_19 n127 PAR_2_0_VSS 1.56453371127e-10
R_2_19 PAR_0_1_VSS n128 0.665726093607
C_2_19 n128 PAR_2_0_VSS 1.56762311053e-10
R_3_19 PAR_0_1_VSS n129 0.398475158068
C_3_19 n129 PAR_2_0_VSS 6.86446828466e-10
R_4_19 PAR_0_1_VSS n130 0.179370024699
C_4_19 n130 PAR_2_0_VSS 4.68772664033e-09
R_5_19 PAR_0_1_VSS n131 1.38458894228
C_5_19 n131 PAR_2_0_VSS 3.07900660823e-09
R_6_19 PAR_0_1_VSS n132 3.01085399081
C_6_19 n132 PAR_2_0_VSS 4.74390791308e-09
G0_20 PAR_0_1_VSS PAR_2_0_VDD075CPU PAR_0_1_VSS PAR_2_0_VDD075CPU -0.1702782382
C0_20 PAR_0_1_VSS PAR_2_0_VDD075CPU 2.30582618775e-10
R_1_20 PAR_0_1_VSS n133 0.157138621904
C_1_20 n133 PAR_2_0_VDD075CPU 1.58839911535e-10
R_2_20 PAR_0_1_VSS n134 0.342575802289
C_2_20 n134 PAR_2_0_VDD075CPU 2.7109575684e-10
L_3_20 PAR_0_1_VSS n135 3.44489287708e-09
R_3_20 n135 PAR_2_0_VDD075CPU 5.87274096174
R_4_20 PAR_0_1_VSS n136 33.2522257501
C_4_20 n136 PAR_2_0_VDD075CPU 1.30797430471e-10
R_5_20 PAR_0_1_VSS n137 32.1703848881
C_5_20 n137 PAR_2_0_VDD075CPU 4.04180902142e-10
R0_21 PAR_0_1_VSS PAR_0_0_VSS 0.00414292496765
C0_21 PAR_0_1_VSS PAR_0_0_VSS 3.0152208436e-10
R_1_21 PAR_0_1_VSS n138 0.214057335734
C_1_21 n138 PAR_0_0_VSS 2.44039242493e-09
L_2_21 PAR_0_1_VSS n139 5.17070801617e-09
R_2_21 n139 PAR_0_0_VSS 0.404071767304
R0_22 PAR_0_1_VDD075CPU PAR_0_0_VDD075CPU 0.00642102539441
C0_22 PAR_0_1_VDD075CPU PAR_0_0_VDD075CPU 6.64296160007e-11
L_1_22 PAR_0_1_VDD075CPU n140 1.2820348962e-12
R_1_22 n140 PAR_0_0_VDD075CPU 0.0674276633354
L_2_22 PAR_0_1_VDD075CPU n141 3.34288418026e-12
R_2_22 n141 PAR_0_0_VDD075CPU 0.0595995388154
L_3_22 PAR_0_1_VDD075CPU n142 3.79561873444e-12
R_3_22 n142 PAR_0_0_VDD075CPU 0.0354971566435
L_4_22 PAR_0_1_VDD075CPU n143 1.38725697468e-08
R_4_22 n143 PAR_0_0_VDD075CPU 35.5453110442
L_5_22 PAR_0_1_VDD075CPU n144 2.50817085092e-07
R_5_22 n144 PAR_0_0_VDD075CPU 192.985187743
L_6_22 PAR_0_1_VDD075CPU n145 1.11753478619e-05
R_6_22 n145 PAR_0_0_VDD075CPU 1287.4939985
G0_23 PAR_0_1_VDD075CPU PAR_1_0_VSS PAR_0_1_VDD075CPU PAR_1_0_VSS -0.336222629524
C0_23 PAR_0_1_VDD075CPU PAR_1_0_VSS 1.7259942517e-10
R_1_23 PAR_0_1_VDD075CPU n146 0.28668813499
C_1_23 n146 PAR_1_0_VSS 9.87276214503e-11
R_2_23 PAR_0_1_VDD075CPU n147 0.676745121122
C_2_23 n147 PAR_1_0_VSS 1.50884102964e-10
L_3_23 PAR_0_1_VDD075CPU n148 1.20741455585e-09
R_3_23 n148 PAR_1_0_VSS 3.85378764559
L_4_23 PAR_0_1_VDD075CPU n149 2.71049708434e-08
R_4_23 n149 PAR_1_0_VSS 15.0622854471
L_5_23 PAR_0_1_VDD075CPU n150 1.06203984068e-06
R_5_23 n150 PAR_1_0_VSS 96.649477669
R0_24 PAR_0_1_VDD075CPU PAR_1_0_VDD075CPU 0.734165253428
C0_24 PAR_0_1_VDD075CPU PAR_1_0_VDD075CPU 1.69926072917e-10
L_1_24 PAR_0_1_VDD075CPU n151 5.00145631388e-12
R_1_24 n151 PAR_1_0_VDD075CPU 0.221736535841
L_2_24 PAR_0_1_VDD075CPU n152 3.53008420322e-11
R_2_24 n152 PAR_1_0_VDD075CPU 0.562638202449
L_3_24 PAR_0_1_VDD075CPU n153 3.86372017523e-10
R_3_24 n153 PAR_1_0_VDD075CPU 2.76679228653
L_4_24 PAR_0_1_VDD075CPU n154 2.40019907834e-08
R_4_24 n154 PAR_1_0_VDD075CPU 45.2589757019
L_5_24 PAR_0_1_VDD075CPU n155 1.30306918486e-06
R_5_24 n155 PAR_1_0_VDD075CPU 409.953688472
G0_25 PAR_0_1_VDD075CPU PAR_2_0_VSS PAR_0_1_VDD075CPU PAR_2_0_VSS -0.083859338916
C0_25 PAR_0_1_VDD075CPU PAR_2_0_VSS 1.92431688798e-10
R_1_25 PAR_0_1_VDD075CPU n156 3.12271630866
C_1_25 n156 PAR_2_0_VSS 3.57695977581e-11
R_2_25 PAR_0_1_VDD075CPU n157 4.3996992599
C_2_25 n157 PAR_2_0_VSS 1.12661441131e-10
L_3_25 PAR_0_1_VDD075CPU n158 2.77945914093e-08
R_3_25 n158 PAR_2_0_VSS 13.5646962706
L_4_25 PAR_0_1_VDD075CPU n159 1.19292594225e-06
R_4_25 n159 PAR_2_0_VSS 98.6333301758
G0_26 PAR_0_1_VDD075CPU PAR_2_0_VDD075CPU PAR_0_1_VDD075CPU PAR_2_0_VDD075CPU -3.57694388939
C0_26 PAR_0_1_VDD075CPU PAR_2_0_VDD075CPU 1.38157317655e-10
R_1_26 PAR_0_1_VDD075CPU n160 0.379033188374
C_1_26 n160 PAR_2_0_VDD075CPU 5.02445618041e-11
L_2_26 PAR_0_1_VDD075CPU n161 1.92652712013e-11
R_2_26 n161 PAR_2_0_VDD075CPU 0.359893827069
R_3_26 PAR_0_1_VDD075CPU n162 1.75667047938
C_3_26 n162 PAR_2_0_VDD075CPU 7.07785961104e-11
L_4_26 PAR_0_1_VDD075CPU n163 4.36978802401e-10
R_4_26 n163 PAR_2_0_VDD075CPU 1.58971743695
R_5_26 PAR_0_1_VDD075CPU n164 3.11540945015
C_5_26 n164 PAR_2_0_VDD075CPU 1.87323942936e-10
L_6_26 PAR_0_1_VDD075CPU n165 9.0042992719e-09
R_6_26 n165 PAR_2_0_VDD075CPU 6.43172541066
R_7_26 PAR_0_1_VDD075CPU n166 20.6574563941
C_7_26 n166 PAR_2_0_VDD075CPU 1.99887387758e-10
L_8_26 PAR_0_1_VDD075CPU n167 1.01920339716e-06
R_8_26 n167 PAR_2_0_VDD075CPU 71.1093706094
C0_27 PAR_0_1_VDD075CPU PAR_0_1_VSS 7.29831548902e-10
R_1_27 PAR_0_1_VDD075CPU n168 0.000954652034099
C_1_27 n168 PAR_0_1_VSS 1.78890338715e-08
R_2_27 PAR_0_1_VDD075CPU n169 0.0023371353717
C_2_27 n169 PAR_0_1_VSS 2.18829045807e-08
R_3_27 PAR_0_1_VDD075CPU n170 0.00228114412101
C_3_27 n170 PAR_0_1_VSS 4.28614223804e-08
R_4_27 PAR_0_1_VDD075CPU n171 0.504111082258
C_4_27 n171 PAR_0_1_VSS 4.11660993898e-10
R_5_27 PAR_0_1_VDD075CPU n172 27.9834545592
C_5_27 n172 PAR_0_1_VSS 5.84969571949e-11
R_6_27 PAR_0_1_VDD075CPU n173 27.5196218454
C_6_27 n173 PAR_0_1_VSS 3.33181156074e-10
G0_28 PAR_0_1_VDD075CPU PAR_0_0_VSS PAR_0_1_VDD075CPU PAR_0_0_VSS -0.847738369945
C0_28 PAR_0_1_VDD075CPU PAR_0_0_VSS 2.25651226824e-10
R_1_28 PAR_0_1_VDD075CPU n174 0.0195487494609
C_1_28 n174 PAR_0_0_VSS 7.99955770617e-10
R_2_28 PAR_0_1_VDD075CPU n175 0.122724686994
C_2_28 n175 PAR_0_0_VSS 5.48816655004e-10
R_3_28 PAR_0_1_VDD075CPU n176 0.0762112580306
C_3_28 n176 PAR_0_0_VSS 1.51454446801e-09
L_4_28 PAR_0_1_VDD075CPU n177 2.56846167091e-10
R_4_28 n177 PAR_0_0_VSS 1.17960921943
R_5_28 PAR_0_1_VDD075CPU n178 9.05621197817
C_5_28 n178 PAR_0_0_VSS 1.15536962535e-10
R_6_28 PAR_0_1_VDD075CPU n179 63.5568568794
C_6_28 n179 PAR_0_0_VSS 1.25820725423e-10
G0_29 PAR_1_1_VSS PAR_0_0_VDD075CPU PAR_1_1_VSS PAR_0_0_VDD075CPU -0.786002122851
C0_29 PAR_1_1_VSS PAR_0_0_VDD075CPU 1.19155369698e-10
L_1_29 PAR_1_1_VSS n180 3.05449766539e-11
R_1_29 n180 PAR_0_0_VDD075CPU 1.47367590068
R_2_29 PAR_1_1_VSS n181 1.41053062625
C_2_29 n181 PAR_0_0_VDD075CPU 3.35222084571e-11
R_3_29 PAR_1_1_VSS n182 24.5279510005
C_3_29 n182 PAR_0_0_VDD075CPU 5.04927461622e-12
L_4_29 PAR_1_1_VSS n183 3.70159911141e-09
R_4_29 n183 PAR_0_0_VDD075CPU 10.8760184486
R_5_29 PAR_1_1_VSS n184 29.0520415958
C_5_29 n184 PAR_0_0_VDD075CPU 2.899202419e-11
L_6_29 PAR_1_1_VSS n185 1.85871322043e-07
R_6_29 n185 PAR_0_0_VDD075CPU 64.5933996972
R_7_29 PAR_1_1_VSS n186 538.137068009
C_7_29 n186 PAR_0_0_VDD075CPU 2.42313722093e-11
R0_30 PAR_1_1_VSS PAR_1_0_VSS 0.00618777936227
C0_30 PAR_1_1_VSS PAR_1_0_VSS 4.14022732804e-11
L_1_30 PAR_1_1_VSS n187 1.6671843137e-12
R_1_30 n187 PAR_1_0_VSS 0.0752455940686
L_2_30 PAR_1_1_VSS n188 2.78635056047e-12
R_2_30 n188 PAR_1_0_VSS 0.052550276395
L_3_30 PAR_1_1_VSS n189 5.83850215663e-09
R_3_30 n189 PAR_1_0_VSS 14.8819563023
L_4_30 PAR_1_1_VSS n190 6.18336034797e-08
R_4_30 n190 PAR_1_0_VSS 29.9071854054
L_5_30 PAR_1_1_VSS n191 2.49374715404e-06
R_5_30 n191 PAR_1_0_VSS 197.21425446
G0_31 PAR_1_1_VSS PAR_1_0_VDD075CPU PAR_1_1_VSS PAR_1_0_VDD075CPU -0.065924505533
C0_31 PAR_1_1_VSS PAR_1_0_VDD075CPU 2.14160001903e-10
R_1_31 PAR_1_1_VSS n192 0.0467198009344
C_1_31 n192 PAR_1_0_VDD075CPU 3.42857223153e-10
R_2_31 PAR_1_1_VSS n193 0.0229473426528
C_2_31 n193 PAR_1_0_VDD075CPU 1.74364029994e-09
R_3_31 PAR_1_1_VSS n194 0.0524983696717
C_3_31 n194 PAR_1_0_VDD075CPU 1.14043312108e-09
L_4_31 PAR_1_1_VSS n195 3.5139158613e-09
R_4_31 n195 PAR_1_0_VDD075CPU 17.7053185721
L_5_31 PAR_1_1_VSS n196 8.37932921985e-08
R_5_31 n196 PAR_1_0_VDD075CPU 116.913917982
L_6_31 PAR_1_1_VSS n197 6.76088159711e-06
R_6_31 n197 PAR_1_0_VDD075CPU 1122.33122335
R0_32 PAR_1_1_VSS PAR_2_0_VSS 0.361033913153
C0_32 PAR_1_1_VSS PAR_2_0_VSS 1.54356248065e-10
L_1_32 PAR_1_1_VSS n198 5.09119302788e-12
R_1_32 n198 PAR_2_0_VSS 0.322933009406
L_2_32 PAR_1_1_VSS n199 2.54102011158e-11
R_2_32 n199 PAR_2_0_VSS 0.403107597387
R_3_32 PAR_1_1_VSS n200 14.2267721656
C_3_32 n200 PAR_2_0_VSS 1.27645332508e-11
R_4_32 PAR_1_1_VSS n201 7.47194914237
C_4_32 n201 PAR_2_0_VSS 7.51931782086e-11
L_5_32 PAR_1_1_VSS n202 3.94432805635e-08
R_5_32 n202 PAR_2_0_VSS 21.2943587839
L_6_32 PAR_1_1_VSS n203 1.57745090264e-06
R_6_32 n203 PAR_2_0_VSS 144.535429175
G0_33 PAR_1_1_VSS PAR_2_0_VDD075CPU PAR_1_1_VSS PAR_2_0_VDD075CPU -1.4293609722
C0_33 PAR_1_1_VSS PAR_2_0_VDD075CPU 1.28875824745e-10
L_1_33 PAR_1_1_VSS n204 1.01845470482e-11
R_1_33 n204 PAR_2_0_VDD075CPU 0.785779542036
R_2_33 PAR_1_1_VSS n205 0.793999740156
C_2_33 n205 PAR_2_0_VDD075CPU 7.6235773527e-11
R_3_33 PAR_1_1_VSS n206 8.16850502852
C_3_33 n206 PAR_2_0_VDD075CPU 1.56602712771e-11
L_4_33 PAR_1_1_VSS n207 2.30494285932e-09
R_4_33 n207 PAR_2_0_VDD075CPU 7.20753149882
R_5_33 PAR_1_1_VSS n208 21.9832096466
C_5_33 n208 PAR_2_0_VDD075CPU 3.3796221926e-11
L_6_33 PAR_1_1_VSS n209 1.51621505009e-07
R_6_33 n209 PAR_2_0_VDD075CPU 55.5690146037
R_7_33 PAR_1_1_VSS n210 498.994131028
C_7_33 n210 PAR_2_0_VDD075CPU 2.5677649857e-11
R0_34 PAR_1_1_VSS PAR_0_1_VSS 0.00382164766635
L_1_34 PAR_1_1_VSS n211 4.35996563148e-13
R_1_34 n211 PAR_0_1_VSS 0.0183636028397
L_2_34 PAR_1_1_VSS n212 2.67741251915e-12
R_2_34 n212 PAR_0_1_VSS 0.0438194591958
L_3_34 PAR_1_1_VSS n213 1.85678263293e-10
R_3_34 n213 PAR_0_1_VSS 1.30145802581
R_4_34 PAR_1_1_VSS n214 32.0067542838
C_4_34 n214 PAR_0_1_VSS 2.33623194441e-11
R_5_34 PAR_1_1_VSS n215 44.1781838327
C_5_34 n215 PAR_0_1_VSS 1.65245752358e-10
G0_35 PAR_1_1_VSS PAR_0_1_VDD075CPU PAR_1_1_VSS PAR_0_1_VDD075CPU -0.0168846490174
C0_35 PAR_1_1_VSS PAR_0_1_VDD075CPU 1.10605638454e-10
R_1_35 PAR_1_1_VSS n216 0.043675489759
C_1_35 n216 PAR_0_1_VDD075CPU 4.77200811276e-10
R_2_35 PAR_1_1_VSS n217 0.0600701467565
C_2_35 n217 PAR_0_1_VDD075CPU 8.17497407243e-10
R_3_35 PAR_1_1_VSS n218 0.222126472398
C_3_35 n218 PAR_0_1_VDD075CPU 3.61617051632e-10
L_4_35 PAR_1_1_VSS n219 2.8147934266e-08
R_4_35 n219 PAR_0_1_VDD075CPU 70.397926366
L_5_35 PAR_1_1_VSS n220 6.23490180287e-07
R_5_35 n220 PAR_0_1_VDD075CPU 442.701078445
L_6_35 PAR_1_1_VSS n221 2.29666448343e-05
R_6_35 n221 PAR_0_1_VDD075CPU 2376.27378312
R0_36 PAR_1_1_VSS PAR_0_0_VSS 0.175315789621
C0_36 PAR_1_1_VSS PAR_0_0_VSS 1.11709784576e-10
R_1_36 PAR_1_1_VSS n222 0.0184467953886
C_1_36 n222 PAR_0_0_VSS 4.71774791896e-10
L_2_36 PAR_1_1_VSS n223 2.91376870128e-11
R_2_36 n223 PAR_0_0_VSS 0.475139423028
L_3_36 PAR_1_1_VSS n224 1.08725978272e-09
R_3_36 n224 PAR_0_0_VSS 4.80264324802
R_4_36 PAR_1_1_VSS n225 14.8273350762
C_4_36 n225 PAR_0_0_VSS 7.33811465416e-11
R_5_36 PAR_1_1_VSS n226 115.903398876
C_5_36 n226 PAR_0_0_VSS 7.15935601156e-11
R0_37 PAR_1_1_VDD075CPU PAR_0_0_VDD075CPU 0.606964086843
C0_37 PAR_1_1_VDD075CPU PAR_0_0_VDD075CPU 1.3607899057e-10
L_1_37 PAR_1_1_VDD075CPU n227 5.27382455478e-12
R_1_37 n227 PAR_0_0_VDD075CPU 0.225830213092
L_2_37 PAR_1_1_VDD075CPU n228 3.43396098472e-11
R_2_37 n228 PAR_0_0_VDD075CPU 0.57038010266
L_3_37 PAR_1_1_VDD075CPU n229 6.17841823928e-10
R_3_37 n229 PAR_0_0_VDD075CPU 4.62067770062
L_4_37 PAR_1_1_VDD075CPU n230 2.56334085525e-08
R_4_37 n230 PAR_0_0_VDD075CPU 55.4838358736
L_5_37 PAR_1_1_VDD075CPU n231 6.90694291374e-07
R_5_37 n231 PAR_0_0_VDD075CPU 375.22090496
L_6_37 PAR_1_1_VDD075CPU n232 4.45253474252e-05
R_6_37 n232 PAR_0_0_VDD075CPU 2400.49039816
G0_38 PAR_1_1_VDD075CPU PAR_1_0_VSS PAR_1_1_VDD075CPU PAR_1_0_VSS -0.290781966165
C0_38 PAR_1_1_VDD075CPU PAR_1_0_VSS 1.60081945955e-10
R_1_38 PAR_1_1_VDD075CPU n233 0.106285732062
C_1_38 n233 PAR_1_0_VSS 2.25546011799e-10
R_2_38 PAR_1_1_VDD075CPU n234 0.0886367090596
C_2_38 n234 PAR_1_0_VSS 6.22745664761e-10
R_3_38 PAR_1_1_VDD075CPU n235 1.42581832124
C_3_38 n235 PAR_1_0_VSS 9.61414508437e-11
L_4_38 PAR_1_1_VDD075CPU n236 1.09948059921e-09
R_4_38 n236 PAR_1_0_VSS 4.27565466672
L_5_38 PAR_1_1_VDD075CPU n237 3.58629408953e-08
R_5_38 n237 PAR_1_0_VSS 20.5515489401
L_6_38 PAR_1_1_VDD075CPU n238 1.27412698424e-06
R_6_38 n238 PAR_1_0_VSS 121.336792068
R0_39 PAR_1_1_VDD075CPU PAR_1_0_VDD075CPU 0.00646677738992
C0_39 PAR_1_1_VDD075CPU PAR_1_0_VDD075CPU 4.33084971233e-11
L_1_39 PAR_1_1_VDD075CPU n239 9.07470864565e-13
R_1_39 n239 PAR_1_0_VDD075CPU 0.0495930356237
L_2_39 PAR_1_1_VDD075CPU n240 1.50294296351e-12
R_2_39 n240 PAR_1_0_VDD075CPU 0.0318790753645
L_3_39 PAR_1_1_VDD075CPU n241 2.58600053455e-11
R_3_39 n241 PAR_1_0_VDD075CPU 0.321833641116
L_4_39 PAR_1_1_VDD075CPU n242 6.37186245979e-09
R_4_39 n242 PAR_1_0_VDD075CPU 23.7060931565
L_5_39 PAR_1_1_VDD075CPU n243 1.23926249648e-07
R_5_39 n243 PAR_1_0_VDD075CPU 137.58868701
L_6_39 PAR_1_1_VDD075CPU n244 7.90631068507e-06
R_6_39 n244 PAR_1_0_VDD075CPU 1097.36263731
G0_40 PAR_1_1_VDD075CPU PAR_2_0_VSS PAR_1_1_VDD075CPU PAR_2_0_VSS -0.0438103406561
C0_40 PAR_1_1_VDD075CPU PAR_2_0_VSS 1.5592934328e-10
R_1_40 PAR_1_1_VDD075CPU n245 0.58622512514
C_1_40 n245 PAR_2_0_VSS 1.16309981925e-10
R_2_40 PAR_1_1_VDD075CPU n246 5.0746890019
C_2_40 n246 PAR_2_0_VSS 8.29495487991e-11
L_3_40 PAR_1_1_VDD075CPU n247 7.67773862432e-08
R_3_40 n247 PAR_2_0_VSS 22.8256600979
C0_41 PAR_1_1_VDD075CPU PAR_2_0_VDD075CPU 1.5135107399e-10
L_1_41 PAR_1_1_VDD075CPU n248 3.23295584193e-12
R_1_41 n248 PAR_2_0_VDD075CPU 0.188498893211
L_2_41 PAR_1_1_VDD075CPU n249 2.49071339255e-11
R_2_41 n249 PAR_2_0_VDD075CPU 0.418350904011
L_3_41 PAR_1_1_VDD075CPU n250 5.85040325259e-10
R_3_41 n250 PAR_2_0_VDD075CPU 4.50137529803
L_4_41 PAR_1_1_VDD075CPU n251 9.21393085377e-09
R_4_41 n251 PAR_2_0_VDD075CPU 23.3461426421
L_5_41 PAR_1_1_VDD075CPU n252 3.43628431532e-06
R_5_41 n252 PAR_2_0_VDD075CPU 2862.51273707
L_6_41 PAR_1_1_VDD075CPU n253 3.89137051059e-06
R_6_41 n253 PAR_2_0_VDD075CPU 465.399343108
G0_42 PAR_1_1_VDD075CPU PAR_0_1_VSS PAR_1_1_VDD075CPU PAR_0_1_VSS -0.0582727156659
C0_42 PAR_1_1_VDD075CPU PAR_0_1_VSS 2.25454215463e-10
R_1_42 PAR_1_1_VDD075CPU n254 0.0108659151034
C_1_42 n254 PAR_0_1_VSS 1.86754720613e-09
R_2_42 PAR_1_1_VDD075CPU n255 0.0227527342011
C_2_42 n255 PAR_0_1_VSS 2.39639198121e-09
R_3_42 PAR_1_1_VDD075CPU n256 0.204455544621
C_3_42 n256 PAR_0_1_VSS 4.77798879734e-10
L_4_42 PAR_1_1_VDD075CPU n257 8.91960086545e-09
R_4_42 n257 PAR_0_1_VSS 17.1606890916
R_5_42 PAR_1_1_VDD075CPU n258 31.4486325423
C_5_42 n258 PAR_0_1_VSS 2.4693897983e-10
R0_43 PAR_1_1_VDD075CPU PAR_0_1_VDD075CPU 0.00449240814966
C0_43 PAR_1_1_VDD075CPU PAR_0_1_VDD075CPU 2.85602435421e-12
L_1_43 PAR_1_1_VDD075CPU n259 3.61602711007e-13
R_1_43 n259 PAR_0_1_VDD075CPU 0.01848730864
L_2_43 PAR_1_1_VDD075CPU n260 1.69479194567e-12
R_2_43 n260 PAR_0_1_VDD075CPU 0.033508808423
L_3_43 PAR_1_1_VDD075CPU n261 1.56405548166e-11
R_3_43 n261 PAR_0_1_VDD075CPU 0.175917094732
L_4_43 PAR_1_1_VDD075CPU n262 9.03004024225e-09
R_4_43 n262 PAR_0_1_VDD075CPU 29.8493814516
L_5_43 PAR_1_1_VDD075CPU n263 3.12086185914e-07
R_5_43 n263 PAR_0_1_VDD075CPU 238.900756672
L_6_43 PAR_1_1_VDD075CPU n264 9.47309075963e-05
R_6_43 n264 PAR_0_1_VDD075CPU 4639.76068302
G0_44 PAR_1_1_VDD075CPU PAR_1_1_VSS PAR_1_1_VDD075CPU PAR_1_1_VSS -0.0074657374646
C0_44 PAR_1_1_VDD075CPU PAR_1_1_VSS 3.44432247418e-10
R_1_44 PAR_1_1_VDD075CPU n265 0.000880678038436
C_1_44 n265 PAR_1_1_VSS 1.32061354983e-08
R_2_44 PAR_1_1_VDD075CPU n266 0.0018960547037
C_2_44 n266 PAR_1_1_VSS 1.5826372757e-08
R_3_44 PAR_1_1_VDD075CPU n267 0.00358563369228
C_3_44 n267 PAR_1_1_VSS 1.55618609428e-08
R_4_44 PAR_1_1_VDD075CPU n268 0.0116393794218
C_4_44 n268 PAR_1_1_VSS 8.02068820895e-09
L_5_44 PAR_1_1_VDD075CPU n269 9.06542071097e-08
R_5_44 n269 PAR_1_1_VSS 147.617454155
L_6_44 PAR_1_1_VDD075CPU n270 7.14348497621e-06
R_6_44 n270 PAR_1_1_VSS 1446.18797926
G0_45 PAR_1_1_VDD075CPU PAR_0_0_VSS PAR_1_1_VDD075CPU PAR_0_0_VSS -0.215624106389
C0_45 PAR_1_1_VDD075CPU PAR_0_0_VSS 1.87079167157e-10
R_1_45 PAR_1_1_VDD075CPU n271 0.0240156688224
C_1_45 n271 PAR_0_0_VSS 5.17926096787e-10
R_2_45 PAR_1_1_VDD075CPU n272 0.882098664494
C_2_45 n272 PAR_0_0_VSS 6.67102133527e-11
L_3_45 PAR_1_1_VDD075CPU n273 1.2851246403e-09
R_3_45 n273 PAR_0_0_VSS 4.63770032368
R_4_45 PAR_1_1_VDD075CPU n274 10.6773476741
C_4_45 n274 PAR_0_0_VSS 8.72676685053e-11
R_5_45 PAR_1_1_VDD075CPU n275 86.9268275311
C_5_45 n275 PAR_0_0_VSS 5.09522180945e-11
R_6_45 PAR_1_1_VDD075CPU n276 265.676756268
C_6_45 n276 PAR_0_0_VSS 5.80736670196e-11
G0_46 PAR_2_1_VSS PAR_0_0_VDD075CPU PAR_2_1_VSS PAR_0_0_VDD075CPU -1.57334440423
C0_46 PAR_2_1_VSS PAR_0_0_VDD075CPU 1.33221135017e-10
R_1_46 PAR_2_1_VSS n277 2.03581420002
C_1_46 n277 PAR_0_0_VDD075CPU 1.3297666991e-11
L_2_46 PAR_2_1_VSS n278 1.07459968232e-10
R_2_46 n278 PAR_0_0_VDD075CPU 0.807186547584
R_3_46 PAR_2_1_VSS n279 1.01137909461
C_3_46 n279 PAR_0_0_VDD075CPU 2.06891618559e-10
L_4_46 PAR_2_1_VSS n280 2.46557284128e-09
R_4_46 n280 PAR_0_0_VDD075CPU 3.37319505794
R_5_46 PAR_2_1_VSS n281 10.7076113915
C_5_46 n281 PAR_0_0_VDD075CPU 2.50018853197e-10
L_6_46 PAR_2_1_VSS n282 3.23064472369e-07
R_6_46 n282 PAR_0_0_VDD075CPU 26.3029330659
R0_47 PAR_2_1_VSS PAR_1_0_VSS 0.17907171236
C0_47 PAR_2_1_VSS PAR_1_0_VSS 1.64961727667e-10
R_1_47 PAR_2_1_VSS n283 0.473714602388
C_1_47 n283 PAR_1_0_VSS 3.58086703367e-11
L_2_47 PAR_2_1_VSS n284 3.61807140524e-11
R_2_47 n284 PAR_1_0_VSS 0.515161440967
R_3_47 PAR_2_1_VSS n285 0.435603020982
C_3_47 n285 PAR_1_0_VSS 5.07631617533e-10
R_4_47 PAR_2_1_VSS n286 1.11151322175
C_4_47 n286 PAR_1_0_VSS 6.72169132872e-10
L_5_47 PAR_2_1_VSS n287 3.00576262324e-08
R_5_47 n287 PAR_1_0_VSS 8.36268774098
L_6_47 PAR_2_1_VSS n288 3.1221078081e-07
R_6_47 n288 PAR_1_0_VSS 22.9816077475
G0_48 PAR_2_1_VSS PAR_1_0_VDD075CPU PAR_2_1_VSS PAR_1_0_VDD075CPU -0.111143516258
C0_48 PAR_2_1_VSS PAR_1_0_VDD075CPU 1.83547661967e-10
R_1_48 PAR_2_1_VSS n289 0.230067374025
C_1_48 n289 PAR_1_0_VDD075CPU 2.28989943062e-10
R_2_48 PAR_2_1_VSS n290 0.854714965837
C_2_48 n290 PAR_1_0_VDD075CPU 9.73687496416e-11
L_3_48 PAR_2_1_VSS n291 3.43066928765e-09
R_3_48 n291 PAR_1_0_VDD075CPU 13.3424401936
L_4_48 PAR_2_1_VSS n292 3.31724344138e-08
R_4_48 n292 PAR_1_0_VDD075CPU 40.4328966428
L_5_48 PAR_2_1_VSS n293 3.981882961e-07
R_5_48 n293 PAR_1_0_VDD075CPU 122.447356404
L_6_48 PAR_2_1_VSS n294 3.96359196668e-06
R_6_48 n294 PAR_1_0_VDD075CPU 303.435008761
R0_49 PAR_2_1_VSS PAR_2_0_VSS 0.00633883681869
C0_49 PAR_2_1_VSS PAR_2_0_VSS 1.25444406711e-10
L_1_49 PAR_2_1_VSS n295 4.676058016e-13
R_1_49 n295 PAR_2_0_VSS 0.0237350772655
L_2_49 PAR_2_1_VSS n296 4.8056210426e-12
R_2_49 n296 PAR_2_0_VSS 0.0467083904877
R_3_49 PAR_2_1_VSS n297 0.602751333083
C_3_49 n297 PAR_2_0_VSS 1.22332971895e-09
L_4_49 PAR_2_1_VSS n298 4.28961975198e-08
R_4_49 n298 PAR_2_0_VSS 6.65613608616
G0_50 PAR_2_1_VSS PAR_2_0_VDD075CPU PAR_2_1_VSS PAR_2_0_VDD075CPU -0.0576523244936
C0_50 PAR_2_1_VSS PAR_2_0_VDD075CPU 1.49510256948e-10
R_1_50 PAR_2_1_VSS n299 0.0115508429002
C_1_50 n299 PAR_2_0_VDD075CPU 1.41026462201e-09
R_2_50 PAR_2_1_VSS n300 0.0974951901073
C_2_50 n300 PAR_2_0_VDD075CPU 5.19486285377e-10
R_3_50 PAR_2_1_VSS n301 0.0255180120061
C_3_50 n301 PAR_2_0_VDD075CPU 4.09317585767e-09
L_4_50 PAR_2_1_VSS n302 1.63922907148e-08
R_4_50 n302 PAR_2_0_VDD075CPU 25.1300454164
L_5_50 PAR_2_1_VSS n303 1.82226778978e-07
R_5_50 n303 PAR_2_0_VDD075CPU 77.7507155254
L_6_50 PAR_2_1_VSS n304 2.25968497396e-06
R_6_50 n304 PAR_2_0_VDD075CPU 200.091843439
R0_51 PAR_2_1_VSS PAR_0_1_VSS 126603.284989
C0_51 PAR_2_1_VSS PAR_0_1_VSS 1.74841548134e-10
R_1_51 PAR_2_1_VSS n305 0.247254728459
C_1_51 n305 PAR_0_1_VSS 1.08643412883e-10
R_2_51 PAR_2_1_VSS n306 0.557364750136
C_2_51 n306 PAR_0_1_VSS 3.4241212634e-10
R_3_51 PAR_2_1_VSS n307 0.790131064169
C_3_51 n307 PAR_0_1_VSS 4.88601988956e-10
R_4_51 PAR_2_1_VSS n308 2.13223877735
C_4_51 n308 PAR_0_1_VSS 4.66200487282e-10
R_5_51 PAR_2_1_VSS n309 3.38133902923
C_5_51 n309 PAR_0_1_VSS 1.14474597793e-09
R_6_51 PAR_2_1_VSS n310 9.02969107983
C_6_51 n310 PAR_0_1_VSS 1.54482794269e-09
G0_52 PAR_2_1_VSS PAR_0_1_VDD075CPU PAR_2_1_VSS PAR_0_1_VDD075CPU -2.74032878782
C0_52 PAR_2_1_VSS PAR_0_1_VDD075CPU 1.14880458296e-10
R_1_52 PAR_2_1_VSS n311 1.06680957336
C_1_52 n311 PAR_0_1_VDD075CPU 1.82472500137e-11
L_2_52 PAR_2_1_VSS n312 3.10891653121e-11
R_2_52 n312 PAR_0_1_VDD075CPU 0.459599630207
R_3_52 PAR_2_1_VSS n313 0.603933739823
C_3_52 n313 PAR_0_1_VDD075CPU 1.75895108712e-10
L_4_52 PAR_2_1_VSS n314 4.52602306406e-10
R_4_52 n314 PAR_0_1_VDD075CPU 2.11722140213
R_5_52 PAR_2_1_VSS n315 8.00803807784
C_5_52 n315 PAR_0_1_VDD075CPU 7.15150731428e-11
L_6_52 PAR_2_1_VSS n316 1.74457507881e-08
R_6_52 n316 PAR_0_1_VDD075CPU 12.1239751059
R_7_52 PAR_2_1_VSS n317 44.9053606746
C_7_52 n317 PAR_0_1_VDD075CPU 9.17937160748e-11
L_8_52 PAR_2_1_VSS n318 1.46027081675e-06
R_8_52 n318 PAR_0_1_VDD075CPU 102.842219808
R0_53 PAR_2_1_VSS PAR_1_1_VSS 0.00485917844921
C0_53 PAR_2_1_VSS PAR_1_1_VSS 2.38267679943e-11
L_1_53 PAR_2_1_VSS n319 2.54039145528e-13
R_1_53 n319 PAR_1_1_VSS 0.0125186676337
L_2_53 PAR_2_1_VSS n320 2.19681157585e-12
R_2_53 n320 PAR_1_1_VSS 0.040416824622
L_3_53 PAR_2_1_VSS n321 8.27708525021e-12
R_3_53 n321 PAR_1_1_VSS 0.08503521595
L_4_53 PAR_2_1_VSS n322 2.28427260441e-08
R_4_53 n322 PAR_1_1_VSS 53.8831750137
L_5_53 PAR_2_1_VSS n323 2.39014623564e-07
R_5_53 n323 PAR_1_1_VSS 139.767613704
L_6_53 PAR_2_1_VSS n324 3.57187373453e-06
R_6_53 n324 PAR_1_1_VSS 374.45570166
G0_54 PAR_2_1_VSS PAR_1_1_VDD075CPU PAR_2_1_VSS PAR_1_1_VDD075CPU -0.0191266237518
C0_54 PAR_2_1_VSS PAR_1_1_VDD075CPU 1.12950961305e-10
R_1_54 PAR_2_1_VSS n325 0.00781956803086
C_1_54 n325 PAR_1_1_VDD075CPU 2.45599867972e-09
R_2_54 PAR_2_1_VSS n326 0.0302800069405
C_2_54 n326 PAR_1_1_VDD075CPU 1.7457468222e-09
R_3_54 PAR_2_1_VSS n327 0.0659577420819
C_3_54 n327 PAR_1_1_VDD075CPU 1.43793027525e-09
L_4_54 PAR_2_1_VSS n328 6.1804153016e-08
R_4_54 n328 PAR_1_1_VDD075CPU 83.6630299251
L_5_54 PAR_2_1_VSS n329 6.19946092957e-07
R_5_54 n329 PAR_1_1_VDD075CPU 195.227099046
L_6_54 PAR_2_1_VSS n330 6.29142542693e-06
R_6_54 n330 PAR_1_1_VDD075CPU 487.40646702
R0_55 PAR_2_1_VSS PAR_0_0_VSS 542938.032846
C0_55 PAR_2_1_VSS PAR_0_0_VSS 2.49503397437e-10
R_1_55 PAR_2_1_VSS n331 0.0244924388719
C_1_55 n331 PAR_0_0_VSS 6.23467044988e-10
R_2_55 PAR_2_1_VSS n332 0.276443081583
C_2_55 n332 PAR_0_0_VSS 6.61201906815e-10
R_3_55 PAR_2_1_VSS n333 0.622255421563
C_3_55 n333 PAR_0_0_VSS 5.97288231886e-10
R_4_55 PAR_2_1_VSS n334 0.526829921341
C_4_55 n334 PAR_0_0_VSS 2.03797680075e-09
R_5_55 PAR_2_1_VSS n335 1.78661692727
C_5_55 n335 PAR_0_0_VSS 1.4742744145e-09
R_6_55 PAR_2_1_VSS n336 21.7985908427
C_6_55 n336 PAR_0_0_VSS 5.86980225826e-10
G0_56 PAR_2_1_VDD075CPU PAR_0_0_VDD075CPU PAR_2_1_VDD075CPU PAR_0_0_VDD075CPU -1.50862676482
C0_56 PAR_2_1_VDD075CPU PAR_0_0_VDD075CPU 1.00094719388e-10
R_1_56 PAR_2_1_VDD075CPU n337 0.918602417685
C_1_56 n337 PAR_0_0_VDD075CPU 2.64894997594e-11
L_2_56 PAR_2_1_VDD075CPU n338 9.71819426107e-11
R_2_56 n338 PAR_0_0_VDD075CPU 0.779698549632
R_3_56 PAR_2_1_VDD075CPU n339 2.54967574448
C_3_56 n339 PAR_0_0_VDD075CPU 1.7041228404e-10
L_4_56 PAR_2_1_VDD075CPU n340 6.15998346647e-09
R_4_56 n340 PAR_0_0_VDD075CPU 4.42328025522
R_5_56 PAR_2_1_VDD075CPU n341 35.9585629145
C_5_56 n341 PAR_0_0_VDD075CPU 2.48381685309e-10
G0_57 PAR_2_1_VDD075CPU PAR_1_0_VSS PAR_2_1_VDD075CPU PAR_1_0_VSS -0.434624701574
C0_57 PAR_2_1_VDD075CPU PAR_1_0_VSS 1.62164065416e-10
R_1_57 PAR_2_1_VDD075CPU n342 0.353258267855
C_1_57 n342 PAR_1_0_VSS 7.99306767763e-11
R_2_57 PAR_2_1_VDD075CPU n343 0.461326778037
C_2_57 n343 PAR_1_0_VSS 2.14050852978e-10
L_3_57 PAR_2_1_VDD075CPU n344 8.44833089065e-10
R_3_57 n344 PAR_1_0_VSS 2.82371103721
L_4_57 PAR_2_1_VDD075CPU n345 2.36289339548e-08
R_4_57 n345 PAR_1_0_VSS 14.2327218157
L_5_57 PAR_2_1_VDD075CPU n346 1.02434750024e-06
R_5_57 n346 PAR_1_0_VSS 97.8455585959
R0_58 PAR_2_1_VDD075CPU PAR_1_0_VDD075CPU 1.15706428935
C0_58 PAR_2_1_VDD075CPU PAR_1_0_VDD075CPU 1.62016949441e-10
L_1_58 PAR_2_1_VDD075CPU n347 4.24364907862e-12
R_1_58 n347 PAR_1_0_VDD075CPU 0.210491545946
L_2_58 PAR_2_1_VDD075CPU n348 3.2891087828e-11
R_2_58 n348 PAR_1_0_VDD075CPU 0.530433132776
L_3_58 PAR_2_1_VDD075CPU n349 2.5929945852e-10
R_3_58 n349 PAR_1_0_VDD075CPU 1.96109064702
L_4_58 PAR_2_1_VDD075CPU n350 2.33541006039e-08
R_4_58 n350 PAR_1_0_VDD075CPU 46.603170444
L_5_58 PAR_2_1_VDD075CPU n351 8.72852553529e-07
R_5_58 n351 PAR_1_0_VDD075CPU 373.752307606
L_6_58 PAR_2_1_VDD075CPU n352 6.58919320108e-05
R_6_58 n352 PAR_1_0_VDD075CPU 2289.69278334
G0_59 PAR_2_1_VDD075CPU PAR_2_0_VSS PAR_2_1_VDD075CPU PAR_2_0_VSS -0.102798376386
C0_59 PAR_2_1_VDD075CPU PAR_2_0_VSS 1.54888138013e-10
R_1_59 PAR_2_1_VDD075CPU n353 0.0511041302243
C_1_59 n353 PAR_2_0_VSS 4.31004347541e-10
R_2_59 PAR_2_1_VDD075CPU n354 0.674634918727
C_2_59 n354 PAR_2_0_VSS 1.01365226278e-10
R_3_59 PAR_2_1_VDD075CPU n355 0.0718352577989
C_3_59 n355 PAR_2_0_VSS 1.52915010504e-09
R_4_59 PAR_2_1_VDD075CPU n356 5.21335047362
C_4_59 n356 PAR_2_0_VSS 1.08133968727e-10
L_5_59 PAR_2_1_VDD075CPU n357 1.84294799193e-08
R_5_59 n357 PAR_2_0_VSS 10.9625281566
L_6_59 PAR_2_1_VDD075CPU n358 8.97520957947e-07
R_6_59 n358 PAR_2_0_VSS 86.3666394317
R0_60 PAR_2_1_VDD075CPU PAR_2_0_VDD075CPU 0.00743106565858
C0_60 PAR_2_1_VDD075CPU PAR_2_0_VDD075CPU 1.15402665617e-10
L_1_60 PAR_2_1_VDD075CPU n359 3.51044871528e-13
R_1_60 n359 PAR_2_0_VDD075CPU 0.0193009506274
L_2_60 PAR_2_1_VDD075CPU n360 9.79627871611e-12
R_2_60 n360 PAR_2_0_VDD075CPU 0.178162270406
L_3_60 PAR_2_1_VDD075CPU n361 3.86906992649e-12
R_3_60 n361 PAR_2_0_VDD075CPU 0.0361217455753
L_4_60 PAR_2_1_VDD075CPU n362 8.152471535e-09
R_4_60 n362 PAR_2_0_VDD075CPU 22.7205720064
L_5_60 PAR_2_1_VDD075CPU n363 1.45389943285e-07
R_5_60 n363 PAR_2_0_VDD075CPU 133.685546421
L_6_60 PAR_2_1_VDD075CPU n364 7.13276458253e-06
R_6_60 n364 PAR_2_0_VDD075CPU 910.431598717
G0_61 PAR_2_1_VDD075CPU PAR_0_1_VSS PAR_2_1_VDD075CPU PAR_0_1_VSS -0.235083426456
C0_61 PAR_2_1_VDD075CPU PAR_0_1_VSS 1.52926795705e-10
R_1_61 PAR_2_1_VDD075CPU n365 0.202023805349
C_1_61 n365 PAR_0_1_VSS 9.99689205674e-11
R_2_61 PAR_2_1_VDD075CPU n366 0.408270094669
C_2_61 n366 PAR_0_1_VSS 2.15500620609e-10
L_3_61 PAR_2_1_VDD075CPU n367 1.67935697479e-09
R_3_61 n367 PAR_0_1_VSS 4.25380897286
R_4_61 PAR_2_1_VDD075CPU n368 29.2976113465
C_4_61 n368 PAR_0_1_VSS 3.04190907029e-10
G0_62 PAR_2_1_VDD075CPU PAR_0_1_VDD075CPU PAR_2_1_VDD075CPU PAR_0_1_VDD075CPU -2.00552979228
C0_62 PAR_2_1_VDD075CPU PAR_0_1_VDD075CPU 9.49496702295e-11
R_1_62 PAR_2_1_VDD075CPU n369 0.526877342246
C_1_62 n369 PAR_0_1_VDD075CPU 3.69564924576e-11
L_2_62 PAR_2_1_VDD075CPU n370 2.75521662017e-11
R_2_62 n370 PAR_0_1_VDD075CPU 0.561069091901
R_3_62 PAR_2_1_VDD075CPU n371 49.1817445374
C_3_62 n371 PAR_0_1_VDD075CPU 2.60200710284e-12
L_4_62 PAR_2_1_VDD075CPU n372 1.89612624616e-09
R_4_62 n372 PAR_0_1_VDD075CPU 5.32514359365
R_5_62 PAR_2_1_VDD075CPU n373 12.1620422601
C_5_62 n373 PAR_0_1_VDD075CPU 7.30506494313e-11
L_6_62 PAR_2_1_VDD075CPU n374 8.46625066742e-08
R_6_62 n374 PAR_0_1_VDD075CPU 28.3934490008
R_7_62 PAR_2_1_VDD075CPU n375 200.037738994
C_7_62 n375 PAR_0_1_VDD075CPU 6.56692465283e-11
G0_63 PAR_2_1_VDD075CPU PAR_1_1_VSS PAR_2_1_VDD075CPU PAR_1_1_VSS -0.0183018553785
C0_63 PAR_2_1_VDD075CPU PAR_1_1_VSS 7.20515548552e-11
R_1_63 PAR_2_1_VDD075CPU n376 0.0238110361167
C_1_63 n376 PAR_1_1_VSS 9.78020024667e-10
R_2_63 PAR_2_1_VDD075CPU n377 0.0904025228076
C_2_63 n377 PAR_1_1_VSS 6.39274326846e-10
R_3_63 PAR_2_1_VDD075CPU n378 0.164496358824
C_3_63 n378 PAR_1_1_VSS 5.8941466328e-10
L_4_63 PAR_2_1_VDD075CPU n379 2.30004058165e-08
R_4_63 n379 PAR_1_1_VSS 65.7306164894
L_5_63 PAR_2_1_VDD075CPU n380 4.24433511997e-07
R_5_63 n380 PAR_1_1_VSS 379.215417902
L_6_63 PAR_2_1_VDD075CPU n381 1.90288749065e-05
R_6_63 n381 PAR_1_1_VSS 2216.19633142
R0_64 PAR_2_1_VDD075CPU PAR_1_1_VDD075CPU 0.00519092338245
C0_64 PAR_2_1_VDD075CPU PAR_1_1_VDD075CPU 4.30806693832e-11
L_1_64 PAR_2_1_VDD075CPU n382 2.43602498945e-13
R_1_64 n382 PAR_1_1_VDD075CPU 0.0118342551808
L_2_64 PAR_2_1_VDD075CPU n383 3.07750439338e-12
R_2_64 n383 PAR_1_1_VDD075CPU 0.0553309149764
L_3_64 PAR_2_1_VDD075CPU n384 1.24964618136e-11
R_3_64 n384 PAR_1_1_VDD075CPU 0.128133545175
L_4_64 PAR_2_1_VDD075CPU n385 1.49672524823e-08
R_4_64 n385 PAR_1_1_VDD075CPU 42.2722803563
L_5_64 PAR_2_1_VDD075CPU n386 4.04751462451e-07
R_5_64 n386 PAR_1_1_VDD075CPU 273.341487283
L_6_64 PAR_2_1_VDD075CPU n387 5.41988279437e-05
R_6_64 n387 PAR_1_1_VDD075CPU 2490.32189585
G0_65 PAR_2_1_VDD075CPU PAR_2_1_VSS PAR_2_1_VDD075CPU PAR_2_1_VSS -0.00164315312782
C0_65 PAR_2_1_VDD075CPU PAR_2_1_VSS 2.98762207882e-10
R_1_65 PAR_2_1_VDD075CPU n388 0.000696467104255
C_1_65 n388 PAR_2_1_VSS 2.35769089626e-08
R_2_65 PAR_2_1_VDD075CPU n389 0.00475334903745
C_2_65 n389 PAR_2_1_VSS 1.08661891386e-08
R_3_65 PAR_2_1_VDD075CPU n390 0.00262156431552
C_3_65 n390 PAR_2_1_VSS 3.88523932418e-08
R_4_65 PAR_2_1_VDD075CPU n391 0.440029435983
C_4_65 n391 PAR_2_1_VSS 5.26509723306e-10
R_5_65 PAR_2_1_VDD075CPU n392 2.37180696753
C_5_65 n392 PAR_2_1_VSS 6.21100123963e-10
L_6_65 PAR_2_1_VDD075CPU n393 1.31238791419e-05
R_6_65 n393 PAR_2_1_VSS 608.585080421
G0_66 PAR_2_1_VDD075CPU PAR_0_0_VSS PAR_2_1_VDD075CPU PAR_0_0_VSS -0.859048054364
C0_66 PAR_2_1_VDD075CPU PAR_0_0_VSS 1.87761779357e-10
R_1_66 PAR_2_1_VDD075CPU n394 0.0204765233455
C_1_66 n394 PAR_0_0_VSS 6.34461229823e-10
R_2_66 PAR_2_1_VDD075CPU n395 0.342764009115
C_2_66 n395 PAR_0_0_VSS 2.37009334331e-10
L_3_66 PAR_2_1_VDD075CPU n396 2.79004137791e-10
R_3_66 n396 PAR_0_0_VSS 1.16407922913
R_4_66 PAR_2_1_VDD075CPU n397 15.6011181698
C_4_66 n397 PAR_0_0_VSS 6.73721065156e-11
R_5_66 PAR_2_1_VDD075CPU n398 86.33335089
C_5_66 n398 PAR_0_0_VSS 1.07027704277e-10
G0_67 PAR_0_2_VSS PAR_0_0_VDD075CPU PAR_0_2_VSS PAR_0_0_VDD075CPU -0.356424303917
C0_67 PAR_0_2_VSS PAR_0_0_VDD075CPU 1.77783459581e-10
R_1_67 PAR_0_2_VSS n399 0.117452719302
C_1_67 n399 PAR_0_0_VDD075CPU 1.49693625377e-10
R_2_67 PAR_0_2_VSS n400 0.366350906281
C_2_67 n400 PAR_0_0_VDD075CPU 2.16405302777e-10
L_3_67 PAR_0_2_VSS n401 8.58800450478e-10
R_3_67 n401 PAR_0_0_VDD075CPU 3.44213908233
L_4_67 PAR_0_2_VSS n402 1.19718590284e-08
R_4_67 n402 PAR_0_0_VDD075CPU 15.1728299052
R_5_67 PAR_0_2_VSS n403 29.8178439809
C_5_67 n403 PAR_0_0_VDD075CPU 1.74548809288e-10
R_6_67 PAR_0_2_VSS n404 69.6808467889
C_6_67 n404 PAR_0_0_VDD075CPU 2.19780597827e-10
R0_68 PAR_0_2_VSS PAR_1_0_VSS 60.3559741841
C0_68 PAR_0_2_VSS PAR_1_0_VSS 1.76457499001e-10
R_1_68 PAR_0_2_VSS n405 0.284205275965
C_1_68 n405 PAR_1_0_VSS 1.2181132164e-10
R_2_68 PAR_0_2_VSS n406 0.3478970299
C_2_68 n406 PAR_1_0_VSS 4.40811216739e-10
R_3_68 PAR_0_2_VSS n407 0.120102046524
C_3_68 n407 PAR_1_0_VSS 2.01726837851e-09
R_4_68 PAR_0_2_VSS n408 0.320162303304
C_4_68 n408 PAR_1_0_VSS 2.52224638204e-09
R_5_68 PAR_0_2_VSS n409 1.5305476949
C_5_68 n409 PAR_1_0_VSS 2.94359200102e-09
R_6_68 PAR_0_2_VSS n410 3.61995766301
C_6_68 n410 PAR_1_0_VSS 3.94652590357e-09
G0_69 PAR_0_2_VSS PAR_1_0_VDD075CPU PAR_0_2_VSS PAR_1_0_VDD075CPU -0.267838927872
C0_69 PAR_0_2_VSS PAR_1_0_VDD075CPU 2.00193726743e-10
R_1_69 PAR_0_2_VSS n411 0.188642782805
C_1_69 n411 PAR_1_0_VDD075CPU 1.13865828951e-10
R_2_69 PAR_0_2_VSS n412 0.343225422593
C_2_69 n412 PAR_1_0_VDD075CPU 2.33616951353e-10
L_3_69 PAR_0_2_VSS n413 1.34700675259e-09
R_3_69 n413 PAR_1_0_VDD075CPU 4.07933139289
L_4_69 PAR_0_2_VSS n414 7.00484023577e-08
R_4_69 n414 PAR_1_0_VDD075CPU 44.0514669019
R_5_69 PAR_0_2_VSS n415 18.189792175
C_5_69 n415 PAR_1_0_VDD075CPU 3.94576724616e-10
R0_70 PAR_0_2_VSS PAR_2_0_VSS 3490.09148369
C0_70 PAR_0_2_VSS PAR_2_0_VSS 2.22691160557e-10
R_1_70 PAR_0_2_VSS n416 0.23456727038
C_1_70 n416 PAR_2_0_VSS 1.30749120901e-10
R_2_70 PAR_0_2_VSS n417 0.605001105193
C_2_70 n417 PAR_2_0_VSS 1.58934016311e-10
R_3_70 PAR_0_2_VSS n418 0.463281668475
C_3_70 n418 PAR_2_0_VSS 5.50997055297e-10
R_4_70 PAR_0_2_VSS n419 0.188561672577
C_4_70 n419 PAR_2_0_VSS 4.53847580328e-09
R_5_70 PAR_0_2_VSS n420 1.42679892091
C_5_70 n420 PAR_2_0_VSS 3.29324892717e-09
R_6_70 PAR_0_2_VSS n421 3.51428755351
C_6_70 n421 PAR_2_0_VSS 4.13829638545e-09
G0_71 PAR_0_2_VSS PAR_2_0_VDD075CPU PAR_0_2_VSS PAR_2_0_VDD075CPU -0.12116343972
C0_71 PAR_0_2_VSS PAR_2_0_VDD075CPU 2.14097884515e-10
R_1_71 PAR_0_2_VSS n422 0.172082931645
C_1_71 n422 PAR_2_0_VDD075CPU 1.35506356322e-10
R_2_71 PAR_0_2_VSS n423 0.343049109844
C_2_71 n423 PAR_2_0_VDD075CPU 2.51890758125e-10
L_3_71 PAR_0_2_VSS n424 5.1296349708e-09
R_3_71 n424 PAR_2_0_VDD075CPU 8.25331452265
R_4_71 PAR_0_2_VSS n425 21.7724297109
C_4_71 n425 PAR_2_0_VDD075CPU 2.78844961842e-10
R_5_71 PAR_0_2_VSS n426 74.669581611
C_5_71 n426 PAR_2_0_VDD075CPU 2.30114817779e-10
R0_72 PAR_0_2_VSS PAR_0_1_VSS 0.00481653905856
L_1_72 PAR_0_2_VSS n427 4.68527487456e-12
R_1_72 n427 PAR_0_1_VSS 0.0489619243562
L_2_72 PAR_0_2_VSS n428 2.31755618691e-10
R_2_72 n428 PAR_0_1_VSS 0.245339245001
L_3_72 PAR_0_2_VSS n429 1.18175208038e-09
R_3_72 n429 PAR_0_1_VSS 0.30738415642
L_4_72 PAR_0_2_VSS n430 2.52120717145e-08
R_4_72 n430 PAR_0_1_VSS 2.01906378175
G0_73 PAR_0_2_VSS PAR_0_1_VDD075CPU PAR_0_2_VSS PAR_0_1_VDD075CPU -0.0566736518668
C0_73 PAR_0_2_VSS PAR_0_1_VDD075CPU 1.56314094473e-10
R_1_73 PAR_0_2_VSS n431 0.135485450751
C_1_73 n431 PAR_0_1_VDD075CPU 1.70046202555e-10
R_2_73 PAR_0_2_VSS n432 0.0586665919115
C_2_73 n432 PAR_0_1_VDD075CPU 1.80753293857e-09
L_3_73 PAR_0_2_VSS n433 6.83511945502e-09
R_3_73 n433 PAR_0_1_VDD075CPU 17.6448828957
R_4_73 PAR_0_2_VSS n434 28.6306974444
C_4_73 n434 PAR_0_1_VDD075CPU 1.89861283111e-10
R_5_73 PAR_0_2_VSS n435 91.4460146561
C_5_73 n435 PAR_0_1_VDD075CPU 1.79165555381e-10
R0_74 PAR_0_2_VSS PAR_1_1_VSS 0.141678167332
C0_74 PAR_0_2_VSS PAR_1_1_VSS 1.19732124955e-10
R_1_74 PAR_0_2_VSS n436 0.447569126139
C_1_74 n436 PAR_1_1_VSS 4.46036375659e-11
R_2_74 PAR_0_2_VSS n437 1.29936927092
C_2_74 n437 PAR_1_1_VSS 4.11652212476e-11
L_3_74 PAR_0_2_VSS n438 1.06614229381e-10
R_3_74 n438 PAR_1_1_VSS 0.997957118749
L_4_74 PAR_0_2_VSS n439 2.87454766895e-08
R_4_74 n439 PAR_1_1_VSS 44.0156562085
R_5_74 PAR_0_2_VSS n440 51.8588154557
C_5_74 n440 PAR_1_1_VSS 9.95079831306e-11
R_6_74 PAR_0_2_VSS n441 133.91962976
C_6_74 n441 PAR_1_1_VSS 1.16592759349e-10
G0_75 PAR_0_2_VSS PAR_1_1_VDD075CPU PAR_0_2_VSS PAR_1_1_VDD075CPU -0.0307514315381
C0_75 PAR_0_2_VSS PAR_1_1_VDD075CPU 1.3648021945e-10
R_1_75 PAR_0_2_VSS n442 0.344231606017
C_1_75 n442 PAR_1_1_VDD075CPU 7.60877962218e-11
R_2_75 PAR_0_2_VSS n443 0.464192816726
C_2_75 n443 PAR_1_1_VDD075CPU 2.1303065537e-10
L_3_75 PAR_0_2_VSS n444 2.16904367927e-08
R_3_75 n444 PAR_1_1_VDD075CPU 32.5188084423
R_4_75 PAR_0_2_VSS n445 41.0286210767
C_4_75 n445 PAR_1_1_VDD075CPU 1.26356199592e-10
R_5_75 PAR_0_2_VSS n446 108.449293138
C_5_75 n446 PAR_1_1_VDD075CPU 1.45342439766e-10
R0_76 PAR_0_2_VSS PAR_2_1_VSS 68506.692799
C0_76 PAR_0_2_VSS PAR_2_1_VSS 1.65868630785e-10
R_1_76 PAR_0_2_VSS n447 0.286641417567
C_1_76 n447 PAR_2_1_VSS 9.82166251613e-11
R_2_76 PAR_0_2_VSS n448 0.633889059424
C_2_76 n448 PAR_2_1_VSS 2.84766445808e-10
R_3_76 PAR_0_2_VSS n449 0.85167468678
C_3_76 n449 PAR_2_1_VSS 4.42602189103e-10
R_4_76 PAR_0_2_VSS n450 1.94972128832
C_4_76 n450 PAR_2_1_VSS 4.9458858678e-10
R_5_76 PAR_0_2_VSS n451 3.55662698003
C_5_76 n451 PAR_2_1_VSS 1.14446575635e-09
R_6_76 PAR_0_2_VSS n452 9.72575139314
C_6_76 n452 PAR_2_1_VSS 1.41340132324e-09
G0_77 PAR_0_2_VSS PAR_2_1_VDD075CPU PAR_0_2_VSS PAR_2_1_VDD075CPU -0.228350242063
C0_77 PAR_0_2_VSS PAR_2_1_VDD075CPU 1.45822484258e-10
R_1_77 PAR_0_2_VSS n453 0.239160000825
C_1_77 n453 PAR_2_1_VDD075CPU 8.75760017339e-11
R_2_77 PAR_0_2_VSS n454 0.431556932141
C_2_77 n454 PAR_2_1_VDD075CPU 1.98638588837e-10
L_3_77 PAR_0_2_VSS n455 1.59373328125e-09
R_3_77 n455 PAR_2_1_VDD075CPU 4.72638281239
L_4_77 PAR_0_2_VSS n456 9.55934460969e-08
R_4_77 n456 PAR_2_1_VDD075CPU 59.6233469971
R_5_77 PAR_0_2_VSS n457 24.5374454314
C_5_77 n457 PAR_2_1_VDD075CPU 2.98451645697e-10
R0_78 PAR_0_2_VSS PAR_0_0_VSS 0.23107087874
C0_78 PAR_0_2_VSS PAR_0_0_VSS 2.15802306548e-10
R_1_78 PAR_0_2_VSS n458 0.0297793495978
C_1_78 n458 PAR_0_0_VSS 1.23225206064e-09
R_2_78 PAR_0_2_VSS n459 0.0551621452152
C_2_78 n459 PAR_0_0_VSS 2.27459570837e-09
R_3_78 PAR_0_2_VSS n460 0.078894209704
C_3_78 n460 PAR_0_0_VSS 3.63868623353e-09
R_4_78 PAR_0_2_VSS n461 0.158006543371
C_4_78 n461 PAR_0_0_VSS 6.5335027436e-09
R_5_78 PAR_0_2_VSS n462 0.402804982679
C_5_78 n462 PAR_0_0_VSS 9.202196097e-09
R_6_78 PAR_0_2_VSS n463 0.973230488495
C_6_78 n463 PAR_0_0_VSS 1.47568870231e-08
G0_79 PAR_0_2_VDD075CPU PAR_0_0_VDD075CPU PAR_0_2_VDD075CPU PAR_0_0_VDD075CPU -6.77933726032
C0_79 PAR_0_2_VDD075CPU PAR_0_0_VDD075CPU 1.30362353916e-10
R_1_79 PAR_0_2_VDD075CPU n464 0.394991094025
C_1_79 n464 PAR_0_0_VDD075CPU 7.47290325691e-11
L_2_79 PAR_0_2_VDD075CPU n465 1.7419146971e-11
R_2_79 n465 PAR_0_0_VDD075CPU 0.177891547402
R_3_79 PAR_0_2_VDD075CPU n466 0.265418229724
C_3_79 n466 PAR_0_0_VDD075CPU 5.33632301508e-10
L_4_79 PAR_0_2_VDD075CPU n467 3.88492310809e-10
R_4_79 n467 PAR_0_0_VDD075CPU 1.00388207433
R_5_79 PAR_0_2_VDD075CPU n468 2.19827000607
C_5_79 n468 PAR_0_0_VDD075CPU 4.22689439566e-10
L_6_79 PAR_0_2_VDD075CPU n469 1.93591243462e-08
R_6_79 n469 PAR_0_0_VDD075CPU 6.18222751636
R_7_79 PAR_0_2_VDD075CPU n470 39.8522061056
C_7_79 n470 PAR_0_0_VDD075CPU 3.31927856568e-10
G0_80 PAR_0_2_VDD075CPU PAR_1_0_VSS PAR_0_2_VDD075CPU PAR_1_0_VSS -0.491026640593
C0_80 PAR_0_2_VDD075CPU PAR_1_0_VSS 1.88987413731e-10
R_1_80 PAR_0_2_VDD075CPU n471 0.236576146158
C_1_80 n471 PAR_1_0_VSS 1.058286348e-10
R_2_80 PAR_0_2_VDD075CPU n472 0.705147361415
C_2_80 n472 PAR_1_0_VSS 1.45011649336e-10
L_3_80 PAR_0_2_VDD075CPU n473 7.20776221577e-10
R_3_80 n473 PAR_1_0_VSS 2.4810631744
L_4_80 PAR_0_2_VDD075CPU n474 2.17373022978e-08
R_4_80 n474 PAR_1_0_VSS 13.1946595458
L_5_80 PAR_0_2_VDD075CPU n475 8.20818679856e-07
R_5_80 n475 PAR_1_0_VSS 82.0655095927
G0_81 PAR_0_2_VDD075CPU PAR_1_0_VDD075CPU PAR_0_2_VDD075CPU PAR_1_0_VDD075CPU -3.73338293258
C0_81 PAR_0_2_VDD075CPU PAR_1_0_VDD075CPU 1.43433785254e-10
R_1_81 PAR_0_2_VDD075CPU n476 0.339522503539
C_1_81 n476 PAR_1_0_VDD075CPU 6.1160964518e-11
L_2_81 PAR_0_2_VDD075CPU n477 1.80411614026e-11
R_2_81 n477 PAR_1_0_VDD075CPU 0.313925901317
R_3_81 PAR_0_2_VDD075CPU n478 1.70171707213
C_3_81 n478 PAR_1_0_VDD075CPU 7.03514850075e-11
L_4_81 PAR_0_2_VDD075CPU n479 6.08648563081e-10
R_4_81 n479 PAR_1_0_VDD075CPU 2.08125565243
R_5_81 PAR_0_2_VDD075CPU n480 5.26373150389
C_5_81 n480 PAR_1_0_VDD075CPU 1.2743608227e-10
L_6_81 PAR_0_2_VDD075CPU n481 3.5257584972e-08
R_6_81 n481 PAR_1_0_VDD075CPU 15.3366954397
R_7_81 PAR_0_2_VDD075CPU n482 95.7028042311
C_7_81 n482 PAR_1_0_VDD075CPU 1.20769490879e-10
L_8_81 PAR_0_2_VDD075CPU n483 0.0155329587949
R_8_81 n483 PAR_1_0_VDD075CPU 425.772987646
G0_82 PAR_0_2_VDD075CPU PAR_2_0_VSS PAR_0_2_VDD075CPU PAR_2_0_VSS -0.117529860111
C0_82 PAR_0_2_VDD075CPU PAR_2_0_VSS 2.19380010451e-10
R_1_82 PAR_0_2_VDD075CPU n484 3.37550910325
C_1_82 n484 PAR_2_0_VSS 1.24991072667e-11
R_2_82 PAR_0_2_VDD075CPU n485 4.52065134713
C_2_82 n485 PAR_2_0_VSS 2.9104364337e-11
R_3_82 PAR_0_2_VDD075CPU n486 4.72197110057
C_3_82 n486 PAR_2_0_VSS 1.20793943171e-10
L_4_82 PAR_0_2_VDD075CPU n487 1.58544204195e-08
R_4_82 n487 PAR_2_0_VSS 10.3478274529
L_5_82 PAR_0_2_VDD075CPU n488 3.31211232174e-07
R_5_82 n488 PAR_2_0_VSS 69.7768997738
L_6_82 PAR_0_2_VDD075CPU n489 2.26982633849e-06
R_6_82 n489 PAR_2_0_VSS 152.442986826
G0_83 PAR_0_2_VDD075CPU PAR_2_0_VDD075CPU PAR_0_2_VDD075CPU PAR_2_0_VDD075CPU -3.79676078189
C0_83 PAR_0_2_VDD075CPU PAR_2_0_VDD075CPU 1.56009061894e-10
R_1_83 PAR_0_2_VDD075CPU n490 0.319441915483
C_1_83 n490 PAR_2_0_VDD075CPU 6.61117680118e-11
L_2_83 PAR_0_2_VDD075CPU n491 1.70935985154e-11
R_2_83 n491 PAR_2_0_VDD075CPU 0.306242625973
R_3_83 PAR_0_2_VDD075CPU n492 2.08339822011
C_3_83 n492 PAR_2_0_VDD075CPU 5.9292851591e-11
L_4_83 PAR_0_2_VDD075CPU n493 6.49430149493e-10
R_4_83 n493 PAR_2_0_VDD075CPU 2.12626385193
R_5_83 PAR_0_2_VDD075CPU n494 5.59548440299
C_5_83 n494 PAR_2_0_VDD075CPU 1.24638134251e-10
L_6_83 PAR_0_2_VDD075CPU n495 4.13281488732e-08
R_6_83 n495 PAR_2_0_VDD075CPU 16.3983921909
R_7_83 PAR_0_2_VDD075CPU n496 131.568064579
C_7_83 n496 PAR_2_0_VDD075CPU 9.2362203906e-11
G0_84 PAR_0_2_VDD075CPU PAR_0_1_VSS PAR_0_2_VDD075CPU PAR_0_1_VSS -0.0342870164517
C0_84 PAR_0_2_VDD075CPU PAR_0_1_VSS 1.79198548429e-10
R_1_84 PAR_0_2_VDD075CPU n497 0.0527145214051
C_1_84 n497 PAR_0_1_VSS 2.71068993508e-10
R_2_84 PAR_0_2_VDD075CPU n498 0.106475709056
C_2_84 n498 PAR_0_1_VSS 4.36401058396e-10
R_3_84 PAR_0_2_VDD075CPU n499 0.0228553105165
C_3_84 n499 PAR_0_1_VSS 4.43301205782e-09
L_4_84 PAR_0_2_VDD075CPU n500 1.53863404329e-08
R_4_84 n500 PAR_0_1_VSS 29.1655566291
R_5_84 PAR_0_2_VDD075CPU n501 26.9281278009
C_5_84 n501 PAR_0_1_VSS 1.52684524497e-10
R_6_84 PAR_0_2_VDD075CPU n502 54.8376001505
C_6_84 n502 PAR_0_1_VSS 2.56319452408e-10
R0_85 PAR_0_2_VDD075CPU PAR_0_1_VDD075CPU 0.00586625090786
C0_85 PAR_0_2_VDD075CPU PAR_0_1_VDD075CPU 4.75556803258e-11
L_1_85 PAR_0_2_VDD075CPU n503 1.43305506522e-12
R_1_85 n503 PAR_0_1_VDD075CPU 0.0925128490814
L_2_85 PAR_0_2_VDD075CPU n504 9.25890016161e-12
R_2_85 n504 PAR_0_1_VDD075CPU 0.195013544553
L_3_85 PAR_0_2_VDD075CPU n505 3.47360740477e-12
R_3_85 n505 PAR_0_1_VDD075CPU 0.0337850258666
L_4_85 PAR_0_2_VDD075CPU n506 2.23782833039e-08
R_4_85 n506 PAR_0_1_VDD075CPU 45.6913978982
L_5_85 PAR_0_2_VDD075CPU n507 1.40124615801e-06
R_5_85 n507 PAR_0_1_VDD075CPU 441.586210734
G0_86 PAR_0_2_VDD075CPU PAR_1_1_VSS PAR_0_2_VDD075CPU PAR_1_1_VSS -2.23878071967
C0_86 PAR_0_2_VDD075CPU PAR_1_1_VSS 9.96187252199e-11
R_1_86 PAR_0_2_VDD075CPU n508 2.27531929011
C_1_86 n508 PAR_1_1_VSS 6.90619304127e-12
L_2_86 PAR_0_2_VDD075CPU n509 2.50231730847e-11
R_2_86 n509 PAR_1_1_VSS 0.538410127986
R_3_86 PAR_0_2_VDD075CPU n510 0.589542018573
C_3_86 n510 PAR_1_1_VSS 1.76619322125e-10
L_4_86 PAR_0_2_VDD075CPU n511 5.60895671017e-10
R_4_86 n511 PAR_1_1_VSS 2.98710763971
R_5_86 PAR_0_2_VDD075CPU n512 10.8984398867
C_5_86 n512 PAR_1_1_VSS 4.04788774953e-11
L_6_86 PAR_0_2_VDD075CPU n513 2.5048336626e-08
R_6_86 n513 PAR_1_1_VSS 23.1995394404
R_7_86 PAR_0_2_VDD075CPU n514 88.5443651526
C_7_86 n514 PAR_1_1_VSS 3.94355634876e-11
L_8_86 PAR_0_2_VDD075CPU n515 3.84087877832e-06
R_8_86 n515 PAR_1_1_VSS 278.999957249
R0_87 PAR_0_2_VDD075CPU PAR_1_1_VDD075CPU 0.33715892405
C0_87 PAR_0_2_VDD075CPU PAR_1_1_VDD075CPU 1.23417458362e-10
L_1_87 PAR_0_2_VDD075CPU n516 5.06001696106e-12
R_1_87 n516 PAR_1_1_VDD075CPU 0.286783632071
L_2_87 PAR_0_2_VDD075CPU n517 9.25784964039e-11
R_2_87 n517 PAR_1_1_VDD075CPU 1.53985643633
L_3_87 PAR_0_2_VDD075CPU n518 6.13317153798e-11
R_3_87 n518 PAR_1_1_VDD075CPU 0.569361217875
L_4_87 PAR_0_2_VDD075CPU n519 2.10035492123e-08
R_4_87 n519 PAR_1_1_VDD075CPU 52.6634597533
L_5_87 PAR_0_2_VDD075CPU n520 5.07653336955e-07
R_5_87 n520 PAR_1_1_VDD075CPU 345.616257927
L_6_87 PAR_0_2_VDD075CPU n521 2.17661602436e-05
R_6_87 n521 PAR_1_1_VDD075CPU 1919.75424607
G0_88 PAR_0_2_VDD075CPU PAR_2_1_VSS PAR_0_2_VDD075CPU PAR_2_1_VSS -1.32324939607
C0_88 PAR_0_2_VDD075CPU PAR_2_1_VSS 1.25282210633e-10
R_1_88 PAR_0_2_VDD075CPU n522 1.60662970664
C_1_88 n522 PAR_2_1_VSS 1.36746557552e-11
L_2_88 PAR_0_2_VDD075CPU n523 1.0044650193e-10
R_2_88 n523 PAR_2_1_VSS 1.20030165659
R_3_88 PAR_0_2_VDD075CPU n524 2.09024201716
C_3_88 n524 PAR_2_1_VSS 1.07706273744e-10
L_4_88 PAR_0_2_VDD075CPU n525 1.45944835165e-09
R_4_88 n525 PAR_2_1_VSS 2.57046295595
R_5_88 PAR_0_2_VDD075CPU n526 4.83271890741
C_5_88 n526 PAR_2_1_VSS 2.98040921352e-10
L_6_88 PAR_0_2_VDD075CPU n527 4.13185179606e-08
R_6_88 n527 PAR_2_1_VSS 9.89212457502
R_7_88 PAR_0_2_VDD075CPU n528 64.549102582
C_7_88 n528 PAR_2_1_VSS 2.20636232668e-10
G0_89 PAR_0_2_VDD075CPU PAR_2_1_VDD075CPU PAR_0_2_VDD075CPU PAR_2_1_VDD075CPU -2.45970019813
C0_89 PAR_0_2_VDD075CPU PAR_2_1_VDD075CPU 1.07566999834e-10
R_1_89 PAR_0_2_VDD075CPU n529 0.434205783279
C_1_89 n529 PAR_2_1_VDD075CPU 4.98803282939e-11
L_2_89 PAR_0_2_VDD075CPU n530 2.34191000329e-11
R_2_89 n530 PAR_2_1_VDD075CPU 0.453244136065
R_3_89 PAR_0_2_VDD075CPU n531 20.1116571989
C_3_89 n531 PAR_2_1_VDD075CPU 6.19374135268e-12
L_4_89 PAR_0_2_VDD075CPU n532 1.78314584372e-09
R_4_89 n532 PAR_2_1_VDD075CPU 4.81344984693
R_5_89 PAR_0_2_VDD075CPU n533 10.1892099555
C_5_89 n533 PAR_2_1_VDD075CPU 9.22746103862e-11
L_6_89 PAR_0_2_VDD075CPU n534 7.20903317184e-08
R_6_89 n534 PAR_2_1_VDD075CPU 22.7596971237
R_7_89 PAR_0_2_VDD075CPU n535 113.904360169
C_7_89 n535 PAR_2_1_VDD075CPU 1.17057027714e-10
L_8_89 PAR_0_2_VDD075CPU n536 0.0243497818825
R_8_89 n536 PAR_2_1_VDD075CPU 542.866832645
C0_90 PAR_0_2_VDD075CPU PAR_0_2_VSS 2.25484535946e-10
R_1_90 PAR_0_2_VDD075CPU n537 0.00144166038323
C_1_90 n537 PAR_0_2_VSS 1.39076681527e-08
R_2_90 PAR_0_2_VDD075CPU n538 0.000819926062675
C_2_90 n538 PAR_0_2_VSS 4.73783009406e-08
R_3_90 PAR_0_2_VDD075CPU n539 0.00356045721808
C_3_90 n539 PAR_0_2_VSS 2.71451909962e-08
R_4_90 PAR_0_2_VDD075CPU n540 0.820914742475
C_4_90 n540 PAR_0_2_VSS 3.35661239235e-10
R_5_90 PAR_0_2_VDD075CPU n541 12.4149966998
C_5_90 n541 PAR_0_2_VSS 9.45028414109e-11
R_6_90 PAR_0_2_VDD075CPU n542 23.7226630167
C_6_90 n542 PAR_0_2_VSS 3.44822442363e-10
G0_91 PAR_0_2_VDD075CPU PAR_0_0_VSS PAR_0_2_VDD075CPU PAR_0_0_VSS -0.934406822118
C0_91 PAR_0_2_VDD075CPU PAR_0_0_VSS 2.31279955209e-10
R_1_91 PAR_0_2_VDD075CPU n543 0.0171143553403
C_1_91 n543 PAR_0_0_VSS 8.61217060097e-10
R_2_91 PAR_0_2_VDD075CPU n544 0.8697663411
C_2_91 n544 PAR_0_0_VSS 7.12827650003e-11
L_3_91 PAR_0_2_VDD075CPU n545 2.52530822661e-10
R_3_91 n545 PAR_0_0_VSS 1.07019766269
R_4_91 PAR_0_2_VDD075CPU n546 14.173192481
C_4_91 n546 PAR_0_0_VSS 8.09649622756e-11
R_5_91 PAR_0_2_VDD075CPU n547 87.7703323089
C_5_91 n547 PAR_0_0_VSS 1.07029649908e-10
G0_92 PAR_1_2_VSS PAR_0_0_VDD075CPU PAR_1_2_VSS PAR_0_0_VDD075CPU -0.803101940207
C0_92 PAR_1_2_VSS PAR_0_0_VDD075CPU 1.43445191696e-10
R_1_92 PAR_1_2_VSS n548 0.115511116085
C_1_92 n548 PAR_0_0_VDD075CPU 4.85382260503e-11
R_2_92 PAR_1_2_VSS n549 1.01243352442
C_2_92 n549 PAR_0_0_VDD075CPU 5.23240167911e-11
R_3_92 PAR_1_2_VSS n550 1.51407937859
C_3_92 n550 PAR_0_0_VDD075CPU 1.09242515486e-10
L_4_92 PAR_1_2_VSS n551 2.34551645698e-10
R_4_92 n551 PAR_0_0_VDD075CPU 1.28670160925
R_5_92 PAR_1_2_VSS n552 17.4276302497
C_5_92 n552 PAR_0_0_VDD075CPU 3.79449564719e-11
L_6_92 PAR_1_2_VSS n553 2.26607147649e-07
R_6_92 n553 PAR_0_0_VDD075CPU 54.381381661
L_7_92 PAR_1_2_VSS n554 1.87684789413e-06
R_7_92 n554 PAR_0_0_VDD075CPU 132.761050956
G0_93 PAR_1_2_VSS PAR_1_0_VSS PAR_1_2_VSS PAR_1_0_VSS -0.339375632033
C0_93 PAR_1_2_VSS PAR_1_0_VSS 1.70007521837e-10
R_1_93 PAR_1_2_VSS n555 0.327756461696
C_1_93 n555 PAR_1_0_VSS 1.347315529e-10
R_2_93 PAR_1_2_VSS n556 0.703273412338
C_2_93 n556 PAR_1_0_VSS 2.01951623041e-10
R_3_93 PAR_1_2_VSS n557 0.347569853095
C_3_93 n557 PAR_1_0_VSS 6.45896512378e-10
R_4_93 PAR_1_2_VSS n558 0.37772974527
C_4_93 n558 PAR_1_0_VSS 2.64064701706e-09
L_5_93 PAR_1_2_VSS n559 2.11552197763e-08
R_5_93 n559 PAR_1_0_VSS 4.09164695662
L_6_93 PAR_1_2_VSS n560 1.6088458232e-07
R_6_93 n560 PAR_1_0_VSS 10.5290467836
G0_94 PAR_1_2_VSS PAR_1_0_VDD075CPU PAR_1_2_VSS PAR_1_0_VDD075CPU -0.228233462774
C0_94 PAR_1_2_VSS PAR_1_0_VDD075CPU 1.77394909501e-10
R_1_94 PAR_1_2_VSS n561 0.842800648578
C_1_94 n561 PAR_1_0_VDD075CPU 5.48121910444e-11
R_2_94 PAR_1_2_VSS n562 3.28551555423
C_2_94 n562 PAR_1_0_VDD075CPU 3.05816908748e-11
L_3_94 PAR_1_2_VSS n563 1.03612573009e-09
R_3_94 n563 PAR_1_0_VDD075CPU 4.89268704261
R_4_94 PAR_1_2_VSS n564 16.3334510499
C_4_94 n564 PAR_1_0_VDD075CPU 4.18329618461e-11
L_5_94 PAR_1_2_VSS n565 2.92528171848e-07
R_5_94 n565 PAR_1_0_VDD075CPU 59.1806700585
L_6_94 PAR_1_2_VSS n566 2.16493405066e-06
R_6_94 n566 PAR_1_0_VDD075CPU 143.897558561
G0_95 PAR_1_2_VSS PAR_2_0_VSS PAR_1_2_VSS PAR_2_0_VSS -0.798517718533
C0_95 PAR_1_2_VSS PAR_2_0_VSS 1.98754002106e-10
R_1_95 PAR_1_2_VSS n567 0.46333512947
C_1_95 n567 PAR_2_0_VSS 1.00901285275e-10
R_2_95 PAR_1_2_VSS n568 1.05259000686
C_2_95 n568 PAR_2_0_VSS 1.62478385363e-10
R_3_95 PAR_1_2_VSS n569 0.257466274123
C_3_95 n569 PAR_2_0_VSS 4.50114487319e-09
L_4_95 PAR_1_2_VSS n570 4.28327992794e-09
R_4_95 n570 PAR_2_0_VSS 1.65771181904
L_5_95 PAR_1_2_VSS n571 5.93903121779e-08
R_5_95 n571 PAR_2_0_VSS 5.12094149951
G0_96 PAR_1_2_VSS PAR_2_0_VDD075CPU PAR_1_2_VSS PAR_2_0_VDD075CPU -0.036786241754
C0_96 PAR_1_2_VSS PAR_2_0_VDD075CPU 1.92345065599e-10
R_1_96 PAR_1_2_VSS n572 0.694482157719
C_1_96 n572 PAR_2_0_VDD075CPU 7.9143060805e-11
R_2_96 PAR_1_2_VSS n573 19.3657808419
C_2_96 n573 PAR_2_0_VDD075CPU 5.9486369148e-11
L_3_96 PAR_1_2_VSS n574 1.44736455499e-07
R_3_96 n574 PAR_2_0_VDD075CPU 27.1840745869
R0_97 PAR_1_2_VSS PAR_0_1_VSS 0.123785961561
C0_97 PAR_1_2_VSS PAR_0_1_VSS 1.60127311906e-10
R_1_97 PAR_1_2_VSS n575 0.278064437794
C_1_97 n575 PAR_0_1_VSS 1.75787138906e-10
R_2_97 PAR_1_2_VSS n576 0.326834215634
C_2_97 n576 PAR_0_1_VSS 5.37801629899e-10
R_3_97 PAR_1_2_VSS n577 0.659470146978
C_3_97 n577 PAR_0_1_VSS 5.70511615393e-10
R_4_97 PAR_1_2_VSS n578 0.558307551107
C_4_97 n578 PAR_0_1_VSS 1.87933550215e-09
R_5_97 PAR_1_2_VSS n579 0.915535426194
C_5_97 n579 PAR_0_1_VSS 4.04525024307e-09
R_6_97 PAR_1_2_VSS n580 2.94963409779
C_6_97 n580 PAR_0_1_VSS 4.65501593935e-09
G0_98 PAR_1_2_VSS PAR_0_1_VDD075CPU PAR_1_2_VSS PAR_0_1_VDD075CPU -0.0275569743297
C0_98 PAR_1_2_VSS PAR_0_1_VDD075CPU 1.39028720157e-10
R_1_98 PAR_1_2_VSS n581 0.932344663353
C_1_98 n581 PAR_0_1_VDD075CPU 3.31284596363e-11
R_2_98 PAR_1_2_VSS n582 1.15491429906
C_2_98 n582 PAR_0_1_VDD075CPU 8.01785187582e-11
R_3_98 PAR_1_2_VSS n583 25.177362109
C_3_98 n583 PAR_0_1_VDD075CPU 5.27654641844e-11
L_4_98 PAR_1_2_VSS n584 1.96921294964e-07
R_4_98 n584 PAR_0_1_VDD075CPU 36.2884512653
R0_99 PAR_1_2_VSS PAR_1_1_VSS 0.00605155316325
C0_99 PAR_1_2_VSS PAR_1_1_VSS 7.52440640938e-12
L_1_99 PAR_1_2_VSS n585 1.95832559308e-12
R_1_99 n585 PAR_1_1_VSS 0.133342404264
L_2_99 PAR_1_2_VSS n586 1.55434810905e-10
R_2_99 n586 PAR_1_1_VSS 2.65479066948
L_3_99 PAR_1_2_VSS n587 5.59706832147e-12
R_3_99 n587 PAR_1_1_VSS 0.0538633214303
R_4_99 PAR_1_2_VSS n588 33.8661992693
C_4_99 n588 PAR_1_1_VSS 2.21834169607e-11
L_5_99 PAR_1_2_VSS n589 5.94821862127e-07
R_5_99 n589 PAR_1_1_VSS 118.397647693
L_6_99 PAR_1_2_VSS n590 4.78697622246e-06
R_6_99 n590 PAR_1_1_VSS 309.437645508
G0_100 PAR_1_2_VSS PAR_1_1_VDD075CPU PAR_1_2_VSS PAR_1_1_VDD075CPU -0.0150457184579
C0_100 PAR_1_2_VSS PAR_1_1_VDD075CPU 1.23183886518e-10
R_1_100 PAR_1_2_VSS n591 0.314945268321
C_1_100 n591 PAR_1_1_VDD075CPU 8.25887895379e-11
R_2_100 PAR_1_2_VSS n592 0.0753596989232
C_2_100 n592 PAR_1_1_VDD075CPU 1.39055193494e-09
R_3_100 PAR_1_2_VSS n593 28.2009607936
C_3_100 n593 PAR_1_1_VDD075CPU 3.28745574383e-11
L_4_100 PAR_1_2_VSS n594 4.52425230553e-07
R_4_100 n594 PAR_1_1_VDD075CPU 66.4640815086
R0_101 PAR_1_2_VSS PAR_2_1_VSS 1.7983778067
C0_101 PAR_1_2_VSS PAR_2_1_VSS 1.37366070454e-10
R_1_101 PAR_1_2_VSS n595 1.08239914123
C_1_101 n595 PAR_2_1_VSS 4.24378073427e-11
L_2_101 PAR_1_2_VSS n596 2.3610679026e-11
R_2_101 n596 PAR_2_1_VSS 0.156944433032
R_3_101 PAR_1_2_VSS n597 0.138579228034
C_3_101 n597 PAR_2_1_VSS 1.40070044462e-09
L_4_101 PAR_1_2_VSS n598 2.76338429306e-10
R_4_101 n598 PAR_2_1_VSS 0.448071301838
L_5_101 PAR_1_2_VSS n599 8.0790092772e-10
R_5_101 n599 PAR_2_1_VSS 0.6829495994
L_6_101 PAR_1_2_VSS n600 2.71782654199e-08
R_6_101 n600 PAR_2_1_VSS 6.86027617156
L_7_101 PAR_1_2_VSS n601 3.38140733381e-07
R_7_101 n601 PAR_2_1_VSS 24.0799472798
G0_102 PAR_1_2_VSS PAR_2_1_VDD075CPU PAR_1_2_VSS PAR_2_1_VDD075CPU -1.14462662796
C0_102 PAR_1_2_VSS PAR_2_1_VDD075CPU 1.30464562192e-10
R_1_102 PAR_1_2_VSS n602 1.18141304558
C_1_102 n602 PAR_2_1_VDD075CPU 3.58125715087e-11
R_2_102 PAR_1_2_VSS n603 0.493862406032
C_2_102 n603 PAR_2_1_VDD075CPU 2.72952461806e-10
L_3_102 PAR_1_2_VSS n604 1.66692213719e-10
R_3_102 n604 PAR_2_1_VDD075CPU 0.884086535856
R_4_102 PAR_1_2_VSS n605 7.241289978
C_4_102 n605 PAR_2_1_VDD075CPU 1.07198910744e-10
L_5_102 PAR_1_2_VSS n606 6.65273751669e-07
R_5_102 n606 PAR_2_1_VDD075CPU 73.9883760781
R0_103 PAR_1_2_VSS PAR_0_2_VSS 0.00387436069848
L_1_103 PAR_1_2_VSS n607 7.67628811718e-13
R_1_103 n607 PAR_0_2_VSS 0.0244601689327
L_2_103 PAR_1_2_VSS n608 7.39652813295e-12
R_2_103 n608 PAR_0_2_VSS 0.0799763682914
R_3_103 PAR_1_2_VSS n609 0.46967540487
C_3_103 n609 PAR_0_2_VSS 5.97261383511e-10
R_4_103 PAR_1_2_VSS n610 0.521500517726
C_4_103 n610 PAR_0_2_VSS 1.90506975718e-09
R_5_103 PAR_1_2_VSS n611 0.963456664776
C_5_103 n611 PAR_0_2_VSS 3.89330958558e-09
R_6_103 PAR_1_2_VSS n612 2.97575143829
C_6_103 n612 PAR_0_2_VSS 4.43567586768e-09
G0_104 PAR_1_2_VSS PAR_0_2_VDD075CPU PAR_1_2_VSS PAR_0_2_VDD075CPU -0.021596066111
C0_104 PAR_1_2_VSS PAR_0_2_VDD075CPU 1.68979660067e-10
R_1_104 PAR_1_2_VSS n613 0.0342399022335
C_1_104 n613 PAR_0_2_VDD075CPU 1.01070758482e-09
R_2_104 PAR_1_2_VSS n614 0.0917877582928
C_2_104 n614 PAR_0_2_VDD075CPU 1.09621677288e-09
R_3_104 PAR_1_2_VSS n615 42.718002961
C_3_104 n615 PAR_0_2_VDD075CPU 3.45351658031e-11
L_4_104 PAR_1_2_VSS n616 4.02931030026e-07
R_4_104 n616 PAR_0_2_VDD075CPU 46.3047246095
R0_105 PAR_1_2_VSS PAR_0_0_VSS 47929.1493764
C0_105 PAR_1_2_VSS PAR_0_0_VSS 2.6561331623e-10
R_1_105 PAR_1_2_VSS n617 0.0365201730577
C_1_105 n617 PAR_0_0_VSS 7.31845820601e-10
R_2_105 PAR_1_2_VSS n618 0.119756969806
C_2_105 n618 PAR_0_0_VSS 6.77311876519e-10
R_3_105 PAR_1_2_VSS n619 0.165514575802
C_3_105 n619 PAR_0_0_VSS 1.28360029738e-09
R_4_105 PAR_1_2_VSS n620 0.208579023405
C_4_105 n620 PAR_0_0_VSS 5.49679069501e-09
R_5_105 PAR_1_2_VSS n621 0.331075847408
C_5_105 n621 PAR_0_0_VSS 7.38616550371e-09
R_6_105 PAR_1_2_VSS n622 6.21643858683
C_6_105 n622 PAR_0_0_VSS 1.87101928604e-09
G0_106 PAR_1_2_VDD075CPU PAR_0_0_VDD075CPU PAR_1_2_VDD075CPU PAR_0_0_VDD075CPU -4.95010367129
C0_106 PAR_1_2_VDD075CPU PAR_0_0_VDD075CPU 1.27022794937e-10
R_1_106 PAR_1_2_VDD075CPU n623 0.37048143233
C_1_106 n623 PAR_0_0_VDD075CPU 6.85789698024e-11
L_2_106 PAR_1_2_VDD075CPU n624 1.84794633188e-11
R_2_106 n624 PAR_0_0_VDD075CPU 0.242209821857
R_3_106 PAR_1_2_VDD075CPU n625 0.524185834121
C_3_106 n625 PAR_0_0_VDD075CPU 2.49848592521e-10
L_4_106 PAR_1_2_VDD075CPU n626 5.14441066062e-10
R_4_106 n626 PAR_0_0_VDD075CPU 1.42253076263
R_5_106 PAR_1_2_VDD075CPU n627 3.06073806438
C_5_106 n627 PAR_0_0_VDD075CPU 2.82278101524e-10
L_6_106 PAR_1_2_VDD075CPU n628 2.43881249845e-08
R_6_106 n628 PAR_0_0_VDD075CPU 8.42659611737
R_7_106 PAR_1_2_VDD075CPU n629 60.7013219838
C_7_106 n629 PAR_0_0_VDD075CPU 2.14310704887e-10
G0_107 PAR_1_2_VDD075CPU PAR_1_0_VSS PAR_1_2_VDD075CPU PAR_1_0_VSS -0.313926047527
C0_107 PAR_1_2_VDD075CPU PAR_1_0_VSS 1.93620677266e-10
R_1_107 PAR_1_2_VDD075CPU n630 0.322643245386
C_1_107 n630 PAR_1_0_VSS 8.2198410627e-11
R_2_107 PAR_1_2_VDD075CPU n631 0.974668548479
C_2_107 n631 PAR_1_0_VSS 1.16323106203e-10
L_3_107 PAR_1_2_VDD075CPU n632 1.32330693991e-09
R_3_107 n632 PAR_1_0_VSS 4.35153029924
L_4_107 PAR_1_2_VDD075CPU n633 2.37506158896e-08
R_4_107 n633 PAR_1_0_VSS 13.7016741557
L_5_107 PAR_1_2_VDD075CPU n634 9.60363137532e-07
R_5_107 n634 PAR_1_0_VSS 89.7822940015
G0_108 PAR_1_2_VDD075CPU PAR_1_0_VDD075CPU PAR_1_2_VDD075CPU PAR_1_0_VDD075CPU -4.24419613475
C0_108 PAR_1_2_VDD075CPU PAR_1_0_VDD075CPU 1.40244845484e-10
R_1_108 PAR_1_2_VDD075CPU n635 0.334523451799
C_1_108 n635 PAR_1_0_VDD075CPU 5.0013179453e-11
L_2_108 PAR_1_2_VDD075CPU n636 1.56589997741e-11
R_2_108 n636 PAR_1_0_VDD075CPU 0.300927501523
R_3_108 PAR_1_2_VDD075CPU n637 1.10667379438
C_3_108 n637 PAR_1_0_VDD075CPU 1.06385649573e-10
L_4_108 PAR_1_2_VDD075CPU n638 3.04108813608e-10
R_4_108 n638 PAR_1_0_VDD075CPU 1.31624206721
R_5_108 PAR_1_2_VDD075CPU n639 3.24494705077
C_5_108 n639 PAR_1_0_VDD075CPU 1.62350263306e-10
L_6_108 PAR_1_2_VDD075CPU n640 8.37044197516e-09
R_6_108 n640 PAR_1_0_VDD075CPU 6.70517227313
R_7_108 PAR_1_2_VDD075CPU n641 23.2077693463
C_7_108 n641 PAR_1_0_VDD075CPU 1.63946176004e-10
L_8_108 PAR_1_2_VDD075CPU n642 1.16107801352e-06
R_8_108 n642 PAR_1_0_VDD075CPU 82.3826987677
G0_109 PAR_1_2_VDD075CPU PAR_2_0_VSS PAR_1_2_VDD075CPU PAR_2_0_VSS -0.427096170162
C0_109 PAR_1_2_VDD075CPU PAR_2_0_VSS 2.11314823748e-10
L_1_109 PAR_1_2_VDD075CPU n643 2.08221295285e-11
R_1_109 n643 PAR_2_0_VSS 3.23610614916
R_2_109 PAR_1_2_VDD075CPU n644 6.7453502733
C_2_109 n644 PAR_2_0_VSS 2.25394375135e-11
R_3_109 PAR_1_2_VDD075CPU n645 3.58621016057
C_3_109 n645 PAR_2_0_VSS 1.50394598284e-10
L_4_109 PAR_1_2_VDD075CPU n646 1.68278889814e-08
R_4_109 n646 PAR_2_0_VSS 9.22465999044
L_5_109 PAR_1_2_VDD075CPU n647 1.13770122335e-06
R_5_109 n647 PAR_2_0_VSS 103.329873557
G0_110 PAR_1_2_VDD075CPU PAR_2_0_VDD075CPU PAR_1_2_VDD075CPU PAR_2_0_VDD075CPU -4.33552628806
C0_110 PAR_1_2_VDD075CPU PAR_2_0_VDD075CPU 1.52203946349e-10
R_1_110 PAR_1_2_VDD075CPU n648 0.321818809581
C_1_110 n648 PAR_2_0_VDD075CPU 5.22086633137e-11
L_2_110 PAR_1_2_VDD075CPU n649 1.52991410181e-11
R_2_110 n649 PAR_2_0_VDD075CPU 0.297805704929
R_3_110 PAR_1_2_VDD075CPU n650 1.26939960571
C_3_110 n650 PAR_2_0_VDD075CPU 9.62683553517e-11
L_4_110 PAR_1_2_VDD075CPU n651 3.26120583839e-10
R_4_110 n651 PAR_2_0_VDD075CPU 1.28325316355
R_5_110 PAR_1_2_VDD075CPU n652 2.54480661348
C_5_110 n652 PAR_2_0_VDD075CPU 2.09069083102e-10
L_6_110 PAR_1_2_VDD075CPU n653 6.36947857632e-09
R_6_110 n653 PAR_2_0_VDD075CPU 5.39656950776
R_7_110 PAR_1_2_VDD075CPU n654 21.0719056735
C_7_110 n654 PAR_2_0_VDD075CPU 1.71595639687e-10
L_8_110 PAR_1_2_VDD075CPU n655 1.05788761458e-06
R_8_110 n655 PAR_2_0_VDD075CPU 76.838857278
G0_111 PAR_1_2_VDD075CPU PAR_0_1_VSS PAR_1_2_VDD075CPU PAR_0_1_VSS -0.09734685759
C0_111 PAR_1_2_VDD075CPU PAR_0_1_VSS 1.9758971558e-10
R_1_111 PAR_1_2_VDD075CPU n656 0.155049263877
C_1_111 n656 PAR_0_1_VSS 1.66538199447e-10
R_2_111 PAR_1_2_VDD075CPU n657 0.217554864944
C_2_111 n657 PAR_0_1_VSS 4.58741377484e-10
L_3_111 PAR_1_2_VDD075CPU n658 5.91831308194e-09
R_3_111 n658 PAR_0_1_VSS 10.27254502
R_4_111 PAR_1_2_VDD075CPU n659 29.7075446916
C_4_111 n659 PAR_0_1_VSS 1.84526140988e-10
R_5_111 PAR_1_2_VDD075CPU n660 81.3464961603
C_5_111 n660 PAR_0_1_VSS 2.07635510528e-10
R0_112 PAR_1_2_VDD075CPU PAR_0_1_VDD075CPU 0.336621295623
C0_112 PAR_1_2_VDD075CPU PAR_0_1_VDD075CPU 1.48035883098e-10
L_1_112 PAR_1_2_VDD075CPU n661 5.97713499834e-12
R_1_112 n661 PAR_0_1_VDD075CPU 0.283732843103
L_2_112 PAR_1_2_VDD075CPU n662 7.17396524338e-11
R_2_112 n662 PAR_0_1_VDD075CPU 0.897715876079
L_3_112 PAR_1_2_VDD075CPU n663 8.38542869879e-11
R_3_112 n663 PAR_0_1_VDD075CPU 0.705699591856
L_4_112 PAR_1_2_VDD075CPU n664 2.40381799303e-08
R_4_112 n664 PAR_0_1_VDD075CPU 47.2592283588
L_5_112 PAR_1_2_VDD075CPU n665 1.19728425648e-06
R_5_112 n665 PAR_0_1_VDD075CPU 410.04468114
L_6_112 PAR_1_2_VDD075CPU n666 0.000469352105924
R_6_112 n666 PAR_0_1_VDD075CPU 2784.53707916
G0_113 PAR_1_2_VDD075CPU PAR_1_1_VSS PAR_1_2_VDD075CPU PAR_1_1_VSS -0.0176446748112
C0_113 PAR_1_2_VDD075CPU PAR_1_1_VSS 1.42450891029e-10
R_1_113 PAR_1_2_VDD075CPU n667 0.0764479016671
C_1_113 n667 PAR_1_1_VSS 1.51441314031e-10
R_2_113 PAR_1_2_VDD075CPU n668 0.128387654401
C_2_113 n668 PAR_1_1_VSS 3.94319976916e-10
R_3_113 PAR_1_2_VDD075CPU n669 0.0291237816826
C_3_113 n669 PAR_1_1_VSS 3.44101929275e-09
L_4_113 PAR_1_2_VDD075CPU n670 2.74557964147e-08
R_4_113 n670 PAR_1_1_VSS 67.7675514418
L_5_113 PAR_1_2_VDD075CPU n671 5.64320378101e-07
R_5_113 n671 PAR_1_1_VSS 407.611974853
L_6_113 PAR_1_2_VDD075CPU n672 2.2210747811e-05
R_6_113 n672 PAR_1_1_VSS 2298.6478252
R0_114 PAR_1_2_VDD075CPU PAR_1_1_VDD075CPU 0.0057171066167
C0_114 PAR_1_2_VDD075CPU PAR_1_1_VDD075CPU 3.05655419297e-11
L_1_114 PAR_1_2_VDD075CPU n673 8.42375582558e-13
R_1_114 n673 PAR_1_1_VDD075CPU 0.064323400611
L_2_114 PAR_1_2_VDD075CPU n674 8.29701718622e-12
R_2_114 n674 PAR_1_1_VDD075CPU 0.169995773317
L_3_114 PAR_1_2_VDD075CPU n675 3.95691376681e-12
R_3_114 n675 PAR_1_1_VDD075CPU 0.0388696104919
L_4_114 PAR_1_2_VDD075CPU n676 2.30291202994e-08
R_4_114 n676 PAR_1_1_VDD075CPU 53.3046290106
L_5_114 PAR_1_2_VDD075CPU n677 7.03110494024e-07
R_5_114 n677 PAR_1_1_VDD075CPU 381.719003272
L_6_114 PAR_1_2_VDD075CPU n678 9.62100124426e-05
R_6_114 n678 PAR_1_1_VDD075CPU 4875.33613937
G0_115 PAR_1_2_VDD075CPU PAR_2_1_VSS PAR_1_2_VDD075CPU PAR_2_1_VSS -5.51332987274
C0_115 PAR_1_2_VDD075CPU PAR_2_1_VSS 1.57325533589e-10
L_1_115 PAR_1_2_VDD075CPU n679 6.64783607365e-12
R_1_115 n679 PAR_2_1_VSS 0.371152097236
L_2_115 PAR_1_2_VDD075CPU n680 3.13090536726e-11
R_2_115 n680 PAR_2_1_VSS 0.370555633404
R_3_115 PAR_1_2_VDD075CPU n681 0.14334240579
C_3_115 n681 PAR_2_1_VSS 7.19066488768e-10
L_4_115 PAR_1_2_VDD075CPU n682 1.75370153527e-09
R_4_115 n682 PAR_2_1_VSS 9.04559611136
L_5_115 PAR_1_2_VDD075CPU n683 4.53745138665e-07
R_5_115 n683 PAR_2_1_VSS 146.587832309
L_6_115 PAR_1_2_VDD075CPU n684 4.21756277361e-06
R_6_115 n684 PAR_2_1_VSS 334.038057697
R0_116 PAR_1_2_VDD075CPU PAR_2_1_VDD075CPU 0.340946711696
C0_116 PAR_1_2_VDD075CPU PAR_2_1_VDD075CPU 1.40365110098e-10
L_1_116 PAR_1_2_VDD075CPU n685 6.27248450309e-12
R_1_116 n685 PAR_2_1_VDD075CPU 0.307438974175
L_2_116 PAR_1_2_VDD075CPU n686 4.13495510295e-11
R_2_116 n686 PAR_2_1_VDD075CPU 0.373059341509
L_3_116 PAR_1_2_VDD075CPU n687 1.83883703961e-08
R_3_116 n687 PAR_2_1_VDD075CPU 46.4123481662
L_4_116 PAR_1_2_VDD075CPU n688 1.94297258587e-07
R_4_116 n688 PAR_2_1_VDD075CPU 186.973371389
L_5_116 PAR_1_2_VDD075CPU n689 5.58056264736e-06
R_5_116 n689 PAR_2_1_VDD075CPU 949.583249268
R_6_116 PAR_1_2_VDD075CPU n690 9286.3307524
C_6_116 n690 PAR_2_1_VDD075CPU 1.52098125976e-10
G0_117 PAR_1_2_VDD075CPU PAR_0_2_VSS PAR_1_2_VDD075CPU PAR_0_2_VSS -0.0677015718821
C0_117 PAR_1_2_VDD075CPU PAR_0_2_VSS 1.81327000523e-10
R_1_117 PAR_1_2_VDD075CPU n691 0.0248556557961
C_1_117 n691 PAR_0_2_VSS 6.21114489926e-10
R_2_117 PAR_1_2_VDD075CPU n692 0.0187975930924
C_2_117 n692 PAR_0_2_VSS 2.00421485561e-09
R_3_117 PAR_1_2_VDD075CPU n693 0.0383984906355
C_3_117 n693 PAR_0_2_VSS 2.61408075301e-09
L_4_117 PAR_1_2_VDD075CPU n694 8.44006807703e-09
R_4_117 n694 PAR_0_2_VSS 14.7707052772
R_5_117 PAR_1_2_VDD075CPU n695 30.5734650872
C_5_117 n695 PAR_0_2_VSS 1.90501784404e-10
R_6_117 PAR_1_2_VDD075CPU n696 91.7223108445
C_6_117 n696 PAR_0_2_VSS 1.79262526117e-10
R0_118 PAR_1_2_VDD075CPU PAR_0_2_VDD075CPU 0.00396624737025
C0_118 PAR_1_2_VDD075CPU PAR_0_2_VDD075CPU 4.85046402829e-11
L_1_118 PAR_1_2_VDD075CPU n697 6.38112046193e-13
R_1_118 n697 PAR_0_2_VDD075CPU 0.0394021112582
L_2_118 PAR_1_2_VDD075CPU n698 1.00659810397e-12
R_2_118 n698 PAR_0_2_VDD075CPU 0.0258157997967
L_3_118 PAR_1_2_VDD075CPU n699 5.40262790444e-12
R_3_118 n699 PAR_0_2_VDD075CPU 0.0524158681228
L_4_118 PAR_1_2_VDD075CPU n700 2.08340241695e-08
R_4_118 n700 PAR_0_2_VDD075CPU 42.6342252671
L_5_118 PAR_1_2_VDD075CPU n701 1.505757339e-06
R_5_118 n701 PAR_0_2_VDD075CPU 471.729770563
G0_119 PAR_1_2_VDD075CPU PAR_1_2_VSS PAR_1_2_VDD075CPU PAR_1_2_VSS -0.0163956497709
C0_119 PAR_1_2_VDD075CPU PAR_1_2_VSS 5.69350118611e-11
R_1_119 PAR_1_2_VDD075CPU n702 0.00175919087879
C_1_119 n702 PAR_1_2_VSS 9.76337018155e-09
R_2_119 PAR_1_2_VDD075CPU n703 0.000804044322002
C_2_119 n703 PAR_1_2_VSS 4.65124133283e-08
R_3_119 PAR_1_2_VDD075CPU n704 0.00375977767407
C_3_119 n704 PAR_1_2_VSS 2.48975486701e-08
R_4_119 PAR_1_2_VDD075CPU n705 0.250583262158
C_4_119 n705 PAR_1_2_VSS 5.59054244184e-10
R_5_119 PAR_1_2_VDD075CPU n706 9.75425023683
C_5_119 n706 PAR_1_2_VSS 7.85689917028e-11
L_6_119 PAR_1_2_VDD075CPU n707 5.14051518838e-07
R_6_119 n707 PAR_1_2_VSS 60.9917813997
G0_120 PAR_1_2_VDD075CPU PAR_0_0_VSS PAR_1_2_VDD075CPU PAR_0_0_VSS -0.401631010361
C0_120 PAR_1_2_VDD075CPU PAR_0_0_VSS 2.45085239798e-10
R_1_120 PAR_1_2_VDD075CPU n708 0.0175327924123
C_1_120 n708 PAR_0_0_VSS 7.70300888219e-10
L_2_120 PAR_1_2_VDD075CPU n709 7.04743750741e-10
R_2_120 n709 PAR_0_0_VSS 2.48984756804
R_3_120 PAR_1_2_VDD075CPU n710 7.62061742853
C_3_120 n710 PAR_0_0_VSS 1.13692044081e-10
R_4_120 PAR_1_2_VDD075CPU n711 62.0529061307
C_4_120 n711 PAR_0_0_VSS 1.25465026775e-10
G0_121 PAR_2_2_VSS PAR_0_0_VDD075CPU PAR_2_2_VSS PAR_0_0_VDD075CPU -0.0243527622441
C0_121 PAR_2_2_VSS PAR_0_0_VDD075CPU 2.79577428879e-11
R_1_121 PAR_2_2_VSS n712 0.131067738483
C_1_121 n712 PAR_0_0_VDD075CPU 1.14006768291e-10
R_2_121 PAR_2_2_VSS n713 1.75176268417
C_2_121 n713 PAR_0_0_VDD075CPU 4.42917436893e-11
L_3_121 PAR_2_2_VSS n714 1.75195945614e-07
R_3_121 n714 PAR_0_0_VDD075CPU 48.4499016949
L_4_121 PAR_2_2_VSS n715 5.27806490746e-06
R_4_121 n715 PAR_0_0_VDD075CPU 269.332134859
G0_122 PAR_2_2_VSS PAR_1_0_VSS PAR_2_2_VSS PAR_1_0_VSS -0.272028155874
C0_122 PAR_2_2_VSS PAR_1_0_VSS 3.28809773802e-11
R_1_122 PAR_2_2_VSS n716 0.294136190479
C_1_122 n716 PAR_1_0_VSS 1.17439644702e-10
R_2_122 PAR_2_2_VSS n717 1.53086869578
C_2_122 n717 PAR_1_0_VSS 8.50261265475e-11
R_3_122 PAR_2_2_VSS n718 0.350894982992
C_3_122 n718 PAR_1_0_VSS 7.20602932483e-10
R_4_122 PAR_2_2_VSS n719 0.484680458036
C_4_122 n719 PAR_1_0_VSS 1.7677879005e-09
L_5_122 PAR_2_2_VSS n720 2.25028844838e-08
R_5_122 n720 PAR_1_0_VSS 5.06970530547
L_6_122 PAR_2_2_VSS n721 1.95335240363e-07
R_6_122 n721 PAR_1_0_VSS 13.3729062158
G0_123 PAR_2_2_VSS PAR_1_0_VDD075CPU PAR_2_2_VSS PAR_1_0_VDD075CPU -0.0273497313864
C0_123 PAR_2_2_VSS PAR_1_0_VDD075CPU 4.06771147408e-11
R_1_123 PAR_2_2_VSS n722 0.176689972624
C_1_123 n722 PAR_1_0_VDD075CPU 9.70847943838e-11
R_2_123 PAR_2_2_VSS n723 1.54402874804
C_2_123 n723 PAR_1_0_VDD075CPU 5.371417171e-11
R_3_123 PAR_2_2_VSS n724 87.9671243179
C_3_123 n724 PAR_1_0_VDD075CPU 7.10251738355e-12
L_4_123 PAR_2_2_VSS n725 1.28714133541e-07
R_4_123 n725 PAR_1_0_VDD075CPU 58.1037958836
L_5_123 PAR_2_2_VSS n726 1.00382304973e-06
R_5_123 n726 PAR_1_0_VDD075CPU 98.6275556185
G0_124 PAR_2_2_VSS PAR_2_0_VSS PAR_2_2_VSS PAR_2_0_VSS -0.384247550171
C0_124 PAR_2_2_VSS PAR_2_0_VSS 5.62249447549e-11
R_1_124 PAR_2_2_VSS n727 0.279149557638
C_1_124 n727 PAR_2_0_VSS 1.14647453619e-10
R_2_124 PAR_2_2_VSS n728 1.77519239291
C_2_124 n728 PAR_2_0_VSS 9.76076356798e-11
R_3_124 PAR_2_2_VSS n729 0.324869792753
C_3_124 n729 PAR_2_0_VSS 2.88441693476e-09
L_4_124 PAR_2_2_VSS n730 1.28213978533e-08
R_4_124 n730 PAR_2_0_VSS 3.48358186244
L_5_124 PAR_2_2_VSS n731 1.40994390076e-07
R_5_124 n731 PAR_2_0_VSS 10.2894620339
G0_125 PAR_2_2_VSS PAR_2_0_VDD075CPU PAR_2_2_VSS PAR_2_0_VDD075CPU -0.0326498361456
C0_125 PAR_2_2_VSS PAR_2_0_VDD075CPU 4.59944673214e-11
R_1_125 PAR_2_2_VSS n732 0.176344415866
C_1_125 n732 PAR_2_0_VDD075CPU 1.06142894304e-10
R_2_125 PAR_2_2_VSS n733 1.57548218813
C_2_125 n733 PAR_2_0_VDD075CPU 5.85191000845e-11
R_3_125 PAR_2_2_VSS n734 13.0371512956
C_3_125 n734 PAR_2_0_VDD075CPU 2.39462809435e-11
L_4_125 PAR_2_2_VSS n735 1.07673011042e-07
R_4_125 n735 PAR_2_0_VDD075CPU 46.9872955903
L_5_125 PAR_2_2_VSS n736 9.22445653985e-07
R_5_125 n736 PAR_2_0_VDD075CPU 87.9701673223
R0_126 PAR_2_2_VSS PAR_0_1_VSS 76523.200227
C0_126 PAR_2_2_VSS PAR_0_1_VSS 2.58878259959e-11
R_1_126 PAR_2_2_VSS n737 0.303037679874
C_1_126 n737 PAR_0_1_VSS 1.43954802993e-10
R_2_126 PAR_2_2_VSS n738 0.438760125206
C_2_126 n738 PAR_0_1_VSS 3.70221481384e-10
R_3_126 PAR_2_2_VSS n739 0.424335969484
C_3_126 n739 PAR_0_1_VSS 8.91808701137e-10
R_4_126 PAR_2_2_VSS n740 0.754004254325
C_4_126 n740 PAR_0_1_VSS 1.30045154417e-09
R_5_126 PAR_2_2_VSS n741 1.44673399631
C_5_126 n741 PAR_0_1_VSS 2.56815897957e-09
R_6_126 PAR_2_2_VSS n742 4.26163170813
C_6_126 n742 PAR_0_1_VSS 3.21551731931e-09
G0_127 PAR_2_2_VSS PAR_0_1_VDD075CPU PAR_2_2_VSS PAR_0_1_VDD075CPU -0.0181385772258
C0_127 PAR_2_2_VSS PAR_0_1_VDD075CPU 3.32746926039e-11
R_1_127 PAR_2_2_VSS n743 0.226025366154
C_1_127 n743 PAR_0_1_VDD075CPU 8.37523029052e-11
R_2_127 PAR_2_2_VSS n744 2.93663053091
C_2_127 n744 PAR_0_1_VDD075CPU 3.1233270925e-11
R_3_127 PAR_2_2_VSS n745 37.6079968445
C_3_127 n745 PAR_0_1_VDD075CPU 1.0069518689e-11
L_4_127 PAR_2_2_VSS n746 2.74563729938e-07
R_4_127 n746 PAR_0_1_VDD075CPU 75.2914301081
L_5_127 PAR_2_2_VSS n747 2.91831234016e-06
R_5_127 n747 PAR_0_1_VDD075CPU 205.894533159
R0_128 PAR_2_2_VSS PAR_1_1_VSS 0.179805582476
C0_128 PAR_2_2_VSS PAR_1_1_VSS 1.79999658431e-11
R_1_128 PAR_2_2_VSS n748 0.253007379358
C_1_128 n748 PAR_1_1_VSS 5.10668849033e-11
R_2_128 PAR_2_2_VSS n749 0.811149310596
C_2_128 n749 PAR_1_1_VSS 1.01773460393e-10
L_3_128 PAR_2_2_VSS n750 3.9551118303e-11
R_3_128 n750 PAR_1_1_VSS 0.364646356034
R_4_128 PAR_2_2_VSS n751 50.229191077
C_4_128 n751 PAR_1_1_VSS 7.31180393005e-12
L_5_128 PAR_2_2_VSS n752 4.38421919645e-07
R_5_128 n752 PAR_1_1_VSS 133.50232667
L_6_128 PAR_2_2_VSS n753 3.64805614686e-06
R_6_128 n753 PAR_1_1_VSS 288.348316927
G0_129 PAR_2_2_VSS PAR_1_1_VDD075CPU PAR_2_2_VSS PAR_1_1_VDD075CPU -0.0124943783976
C0_129 PAR_2_2_VSS PAR_1_1_VDD075CPU 1.68901430704e-11
R_1_129 PAR_2_2_VSS n754 0.190522809848
C_1_129 n754 PAR_1_1_VDD075CPU 6.25721121177e-11
R_2_129 PAR_2_2_VSS n755 0.531325296458
C_2_129 n755 PAR_1_1_VDD075CPU 2.26394063207e-10
R_3_129 PAR_2_2_VSS n756 65.5552539534
C_3_129 n756 PAR_1_1_VDD075CPU 9.55296975661e-12
L_4_129 PAR_2_2_VSS n757 4.53859756329e-07
R_4_129 n757 PAR_1_1_VDD075CPU 80.035979724
R0_130 PAR_2_2_VSS PAR_2_1_VSS 0.021441548448
L_1_130 PAR_2_2_VSS n758 1.69731429884e-11
R_1_130 n758 PAR_2_1_VSS 0.388438893401
L_2_130 PAR_2_2_VSS n759 1.88401680108e-11
R_2_130 n759 PAR_2_1_VSS 0.152459353983
L_3_130 PAR_2_2_VSS n760 4.17520682194e-11
R_3_130 n760 PAR_2_1_VSS 0.141085630515
L_4_130 PAR_2_2_VSS n761 1.95187828985e-10
R_4_130 n761 PAR_2_1_VSS 0.291864115033
L_5_130 PAR_2_2_VSS n762 2.62030630638e-09
R_5_130 n762 PAR_2_1_VSS 1.6156287342
L_6_130 PAR_2_2_VSS n763 1.81354133038e-07
R_6_130 n763 PAR_2_1_VSS 18.8189254552
G0_131 PAR_2_2_VSS PAR_2_1_VDD075CPU PAR_2_2_VSS PAR_2_1_VDD075CPU -0.0096147258011
C0_131 PAR_2_2_VSS PAR_2_1_VDD075CPU 3.23818582305e-11
R_1_131 PAR_2_2_VSS n764 0.224205494698
C_1_131 n764 PAR_2_1_VDD075CPU 8.98675438065e-11
R_2_131 PAR_2_2_VSS n765 0.443572271913
C_2_131 n765 PAR_2_1_VDD075CPU 1.89825413596e-10
R_3_131 PAR_2_2_VSS n766 0.970967398028
C_3_131 n766 PAR_2_1_VDD075CPU 1.94812489779e-10
R_4_131 PAR_2_2_VSS n767 2.69000955929
C_4_131 n767 PAR_2_1_VDD075CPU 1.49480582248e-10
R_5_131 PAR_2_2_VSS n768 17.8673068152
C_5_131 n768 PAR_2_1_VDD075CPU 5.37969957313e-11
L_6_131 PAR_2_2_VSS n769 9.01668134732e-07
R_6_131 n769 PAR_2_1_VDD075CPU 104.007100721
R0_132 PAR_2_2_VSS PAR_0_2_VSS 1637.63584614
C0_132 PAR_2_2_VSS PAR_0_2_VSS 2.59721941112e-11
R_1_132 PAR_2_2_VSS n770 0.339653953731
C_1_132 n770 PAR_0_2_VSS 1.31166667139e-10
R_2_132 PAR_2_2_VSS n771 0.452245033952
C_2_132 n771 PAR_0_2_VSS 3.45969521611e-10
R_3_132 PAR_2_2_VSS n772 0.493508452723
C_3_132 n772 PAR_0_2_VSS 7.74051422197e-10
R_4_132 PAR_2_2_VSS n773 0.753738769522
C_4_132 n773 PAR_0_2_VSS 1.31816544813e-09
R_5_132 PAR_2_2_VSS n774 1.55791798732
C_5_132 n774 PAR_0_2_VSS 2.53400453363e-09
R_6_132 PAR_2_2_VSS n775 4.61319295247
C_6_132 n775 PAR_0_2_VSS 2.93641106558e-09
G0_133 PAR_2_2_VSS PAR_0_2_VDD075CPU PAR_2_2_VSS PAR_0_2_VDD075CPU -0.020847360414
C0_133 PAR_2_2_VSS PAR_0_2_VDD075CPU 3.22596764222e-11
R_1_133 PAR_2_2_VSS n776 0.174419116471
C_1_133 n776 PAR_0_2_VDD075CPU 1.02863845061e-10
R_2_133 PAR_2_2_VSS n777 2.4570039832
C_2_133 n777 PAR_0_2_VDD075CPU 3.11982227146e-11
L_3_133 PAR_2_2_VSS n778 2.18787659015e-07
R_3_133 n778 PAR_0_2_VDD075CPU 75.0502322062
L_4_133 PAR_2_2_VSS n779 1.46420937779e-06
R_4_133 n779 PAR_0_2_VDD075CPU 149.509946184
L_5_133 PAR_2_2_VSS n780 3.04484984482e-05
R_5_133 n780 PAR_0_2_VDD075CPU 1198.4149611
R0_134 PAR_2_2_VSS PAR_1_2_VSS 0.0113566919992
L_1_134 PAR_2_2_VSS n781 3.68004742262e-12
R_1_134 n781 PAR_1_2_VSS 0.079894940087
L_2_134 PAR_2_2_VSS n782 6.95764647654e-12
R_2_134 n782 PAR_1_2_VSS 0.0584451056987
L_3_134 PAR_2_2_VSS n783 1.17182303966e-10
R_3_134 n783 PAR_1_2_VSS 0.305557019094
L_4_134 PAR_2_2_VSS n784 1.51854869825e-10
R_4_134 n784 PAR_1_2_VSS 0.172450855334
L_5_134 PAR_2_2_VSS n785 1.72056609841e-09
R_5_134 n785 PAR_1_2_VSS 0.809238568879
L_6_134 PAR_2_2_VSS n786 9.88001994032e-08
R_6_134 n786 PAR_1_2_VSS 9.38570493023
G0_135 PAR_2_2_VSS PAR_1_2_VDD075CPU PAR_2_2_VSS PAR_1_2_VDD075CPU -0.0143760102761
C0_135 PAR_2_2_VSS PAR_1_2_VDD075CPU 3.32874054238e-11
R_1_135 PAR_2_2_VSS n787 0.184683261728
C_1_135 n787 PAR_1_2_VDD075CPU 1.09392804621e-10
R_2_135 PAR_2_2_VSS n788 0.0434839840413
C_2_135 n788 PAR_1_2_VDD075CPU 2.36222973386e-09
R_3_135 PAR_2_2_VSS n789 3.29436525643
C_3_135 n789 PAR_1_2_VDD075CPU 4.95108437309e-11
R_4_135 PAR_2_2_VSS n790 13.7019122189
C_4_135 n790 PAR_1_2_VDD075CPU 4.37500085697e-11
L_5_135 PAR_2_2_VSS n791 4.67727381389e-07
R_5_135 n791 PAR_1_2_VDD075CPU 94.4136744603
L_6_135 PAR_2_2_VSS n792 4.11225479368e-06
R_6_135 n792 PAR_1_2_VDD075CPU 264.247832956
R0_136 PAR_2_2_VSS PAR_0_0_VSS 164961.356152
R_1_136 PAR_2_2_VSS n793 0.053203181771
C_1_136 n793 PAR_0_0_VSS 6.90058809496e-10
R_2_136 PAR_2_2_VSS n794 0.179829069879
C_2_136 n794 PAR_0_0_VSS 7.51838447182e-10
R_3_136 PAR_2_2_VSS n795 0.29803979651
C_3_136 n795 PAR_0_0_VSS 1.03074889714e-09
R_4_136 PAR_2_2_VSS n796 0.22604714823
C_4_136 n796 PAR_0_0_VSS 4.69085769288e-09
R_5_136 PAR_2_2_VSS n797 0.640251652521
C_5_136 n797 PAR_0_0_VSS 3.79497403165e-09
R_6_136 PAR_2_2_VSS n798 6.56403689415
C_6_136 n798 PAR_0_0_VSS 1.7857314902e-09
G0_137 PAR_2_2_VDD075CPU PAR_0_0_VDD075CPU PAR_2_2_VDD075CPU PAR_0_0_VDD075CPU -0.393018733893
C0_137 PAR_2_2_VDD075CPU PAR_0_0_VDD075CPU 1.96259008371e-11
R_1_137 PAR_2_2_VDD075CPU n799 4.25906143317
C_1_137 n799 PAR_0_0_VDD075CPU 5.95317557489e-12
L_2_137 PAR_2_2_VDD075CPU n800 3.5799726537e-10
R_2_137 n800 PAR_0_0_VDD075CPU 3.32155994314
R_3_137 PAR_2_2_VDD075CPU n801 8.20791691028
C_3_137 n801 PAR_0_0_VDD075CPU 2.62929130061e-11
L_4_137 PAR_2_2_VDD075CPU n802 5.69443529828e-09
R_4_137 n802 PAR_0_0_VDD075CPU 12.4146548725
R_5_137 PAR_2_2_VDD075CPU n803 28.9239399709
C_5_137 n803 PAR_0_0_VDD075CPU 3.62549336772e-11
L_6_137 PAR_2_2_VDD075CPU n804 3.03524296732e-07
R_6_137 n804 PAR_0_0_VDD075CPU 87.803208095
R_7_137 PAR_2_2_VDD075CPU n805 549.997066128
C_7_137 n805 PAR_0_0_VDD075CPU 2.51546822992e-11
G0_138 PAR_2_2_VDD075CPU PAR_1_0_VSS PAR_2_2_VDD075CPU PAR_1_0_VSS -0.125226411476
C0_138 PAR_2_2_VDD075CPU PAR_1_0_VSS 2.20848916907e-11
R_1_138 PAR_2_2_VDD075CPU n806 1.69363354026
C_1_138 n806 PAR_1_0_VSS 1.80058867216e-11
R_2_138 PAR_2_2_VDD075CPU n807 2.37865047239
C_2_138 n807 PAR_1_0_VSS 3.69190126411e-11
L_3_138 PAR_2_2_VDD075CPU n808 2.68012934522e-09
R_3_138 n808 PAR_1_0_VSS 9.55921660136
L_4_138 PAR_2_2_VDD075CPU n809 6.48753570093e-08
R_4_138 n809 PAR_1_0_VSS 54.4925258364
L_5_138 PAR_2_2_VDD075CPU n810 2.81444936574e-06
R_5_138 n810 PAR_1_0_VSS 618.689668282
L_6_138 PAR_2_2_VDD075CPU n811 2.37976150281e-05
R_6_138 n811 PAR_1_0_VSS 1543.51690825
G0_139 PAR_2_2_VDD075CPU PAR_1_0_VDD075CPU PAR_2_2_VDD075CPU PAR_1_0_VDD075CPU -0.171590675443
C0_139 PAR_2_2_VDD075CPU PAR_1_0_VDD075CPU 2.08466795961e-11
R_1_139 PAR_2_2_VDD075CPU n812 5.87968052926
C_1_139 n812 PAR_1_0_VDD075CPU 1.54459937993e-12
L_2_139 PAR_2_2_VDD075CPU n813 6.77230022394e-10
R_2_139 n813 PAR_1_0_VDD075CPU 5.9421003358
R_3_139 PAR_2_2_VDD075CPU n814 876.32245917
C_3_139 n814 PAR_1_0_VDD075CPU 5.16689677625e-13
L_4_139 PAR_2_2_VDD075CPU n815 5.8669971095e-07
R_4_139 n815 PAR_1_0_VDD075CPU 316.070850813
R_5_139 PAR_2_2_VDD075CPU n816 2686.1849946
C_5_139 n816 PAR_1_0_VDD075CPU 5.70285164234e-12
L_6_139 PAR_2_2_VDD075CPU n817 0.259193602994
R_6_139 n817 PAR_1_0_VDD075CPU 6058.67091637
G0_140 PAR_2_2_VDD075CPU PAR_2_0_VSS PAR_2_2_VDD075CPU PAR_2_0_VSS -0.0298621530693
C0_140 PAR_2_2_VDD075CPU PAR_2_0_VSS 2.59941356407e-11
R_1_140 PAR_2_2_VDD075CPU n818 3.91884391791
C_1_140 n818 PAR_2_0_VSS 9.32315128553e-12
R_2_140 PAR_2_2_VDD075CPU n819 9.88365880734
C_2_140 n819 PAR_2_0_VSS 8.28286905101e-12
R_3_140 PAR_2_2_VDD075CPU n820 35.1933165003
C_3_140 n820 PAR_2_0_VSS 1.69889428277e-11
L_4_140 PAR_2_2_VDD075CPU n821 4.39081230584e-08
R_4_140 n821 PAR_2_0_VSS 37.5139187335
L_5_140 PAR_2_2_VDD075CPU n822 1.55559094514e-06
R_5_140 n822 PAR_2_0_VSS 428.272943537
L_6_140 PAR_2_2_VDD075CPU n823 1.63250195644e-05
R_6_140 n823 PAR_2_0_VSS 1148.86634908
G0_141 PAR_2_2_VDD075CPU PAR_2_0_VDD075CPU PAR_2_2_VDD075CPU PAR_2_0_VDD075CPU -0.175721579352
C0_141 PAR_2_2_VDD075CPU PAR_2_0_VDD075CPU 2.24630434806e-11
R_1_141 PAR_2_2_VDD075CPU n824 5.73415400752
C_1_141 n824 PAR_2_0_VDD075CPU 1.88239481299e-12
L_2_141 PAR_2_2_VDD075CPU n825 6.77751775248e-10
R_2_141 n825 PAR_2_0_VDD075CPU 5.87299671159
R_3_141 PAR_2_2_VDD075CPU n826 859.436640459
C_3_141 n826 PAR_2_0_VDD075CPU 4.00121446997e-13
L_4_141 PAR_2_2_VDD075CPU n827 1.76939453786e-07
R_4_141 n827 PAR_2_0_VDD075CPU 183.206177495
R_5_141 PAR_2_2_VDD075CPU n828 6083.29308923
C_5_141 n828 PAR_2_0_VDD075CPU 1.43626541124e-12
G0_142 PAR_2_2_VDD075CPU PAR_0_1_VSS PAR_2_2_VDD075CPU PAR_0_1_VSS -0.113477578097
C0_142 PAR_2_2_VDD075CPU PAR_0_1_VSS 2.1041813023e-11
R_1_142 PAR_2_2_VDD075CPU n829 1.31801007168
C_1_142 n829 PAR_0_1_VSS 1.95694044538e-11
R_2_142 PAR_2_2_VDD075CPU n830 1.41504573476
C_2_142 n830 PAR_0_1_VSS 5.28772291141e-11
L_3_142 PAR_2_2_VDD075CPU n831 2.87884084817e-09
R_3_142 n831 PAR_0_1_VSS 11.2284039105
L_4_142 PAR_2_2_VDD075CPU n832 2.90545886485e-08
R_4_142 n832 PAR_0_1_VSS 40.9538517451
R_5_142 PAR_2_2_VDD075CPU n833 339.068323373
C_5_142 n833 PAR_0_1_VSS 1.76532872774e-11
R_6_142 PAR_2_2_VDD075CPU n834 670.416863319
C_6_142 n834 PAR_0_1_VSS 2.42134163319e-11
G0_143 PAR_2_2_VDD075CPU PAR_0_1_VDD075CPU PAR_2_2_VDD075CPU PAR_0_1_VDD075CPU -0.477544334368
C0_143 PAR_2_2_VDD075CPU PAR_0_1_VDD075CPU 1.43392600108e-11
R_1_143 PAR_2_2_VDD075CPU n835 3.2822105186
C_1_143 n835 PAR_0_1_VDD075CPU 1.46984379874e-11
L_2_143 PAR_2_2_VDD075CPU n836 2.53707555282e-10
R_2_143 n836 PAR_0_1_VDD075CPU 2.4069203999
R_3_143 PAR_2_2_VDD075CPU n837 6.38506142309
C_3_143 n837 PAR_0_1_VDD075CPU 3.25872860301e-11
L_4_143 PAR_2_2_VDD075CPU n838 9.7060815281e-09
R_4_143 n838 PAR_0_1_VDD075CPU 17.4190323
R_5_143 PAR_2_2_VDD075CPU n839 61.5155525467
C_5_143 n839 PAR_0_1_VDD075CPU 3.23011731726e-11
L_6_143 PAR_2_2_VDD075CPU n840 2.50683866648e-06
R_6_143 n840 PAR_0_1_VDD075CPU 214.494674554
G0_144 PAR_2_2_VDD075CPU PAR_1_1_VSS PAR_2_2_VDD075CPU PAR_1_1_VSS -0.618981876797
C0_144 PAR_2_2_VDD075CPU PAR_1_1_VSS 1.16912242338e-11
L_1_144 PAR_2_2_VDD075CPU n841 1.25557949096e-10
R_1_144 n841 PAR_1_1_VSS 1.70156883518
R_2_144 PAR_2_2_VDD075CPU n842 0.380106893165
C_2_144 n842 PAR_1_1_VSS 2.93270676698e-10
L_3_144 PAR_2_2_VDD075CPU n843 6.62616862578e-09
R_3_144 n843 PAR_1_1_VSS 32.3625733166
L_4_144 PAR_2_2_VDD075CPU n844 5.00725058434e-06
R_4_144 n844 PAR_1_1_VSS 2570.41327893
R0_145 PAR_2_2_VDD075CPU PAR_1_1_VDD075CPU 0.175124347376
C0_145 PAR_2_2_VDD075CPU PAR_1_1_VDD075CPU 9.61298283135e-12
L_1_145 PAR_2_2_VDD075CPU n845 6.8868614251e-11
R_1_145 n845 PAR_1_1_VDD075CPU 2.90344944373
R_2_145 PAR_2_2_VDD075CPU n846 1.15360942195
C_2_145 n846 PAR_1_1_VDD075CPU 7.15709046782e-11
L_3_145 PAR_2_2_VDD075CPU n847 3.27440414637e-11
R_3_145 n847 PAR_1_1_VDD075CPU 0.305007035559
L_4_145 PAR_2_2_VDD075CPU n848 4.04139026889e-07
R_4_145 n848 PAR_1_1_VDD075CPU 569.991785483
G0_146 PAR_2_2_VDD075CPU PAR_2_1_VSS PAR_2_2_VDD075CPU PAR_2_1_VSS -0.000486248042813
C0_146 PAR_2_2_VDD075CPU PAR_2_1_VSS 2.34055423277e-11
R_1_146 PAR_2_2_VDD075CPU n849 0.17438020785
C_1_146 n849 PAR_2_1_VSS 7.11685562993e-11
R_2_146 PAR_2_2_VDD075CPU n850 0.507146311272
C_2_146 n850 PAR_2_1_VSS 1.23526363703e-10
R_3_146 PAR_2_2_VDD075CPU n851 0.137566351159
C_3_146 n851 PAR_2_1_VSS 7.29377332432e-10
R_4_146 PAR_2_2_VDD075CPU n852 9.11338271237
C_4_146 n852 PAR_2_1_VSS 3.54740163199e-11
R_5_146 PAR_2_2_VDD075CPU n853 39.1631454835
C_5_146 n853 PAR_2_1_VSS 1.89826006679e-11
L_6_146 PAR_2_2_VDD075CPU n854 2.09516201607e-05
R_6_146 n854 PAR_2_1_VSS 2056.55369297
R0_147 PAR_2_2_VDD075CPU PAR_2_1_VDD075CPU 0.0268064312373
L_1_147 PAR_2_2_VDD075CPU n855 2.74724173306e-12
R_1_147 n855 PAR_2_1_VDD075CPU 0.210350012334
L_2_147 PAR_2_2_VDD075CPU n856 7.1903708519e-11
R_2_147 n856 PAR_2_1_VDD075CPU 1.13075991219
L_3_147 PAR_2_2_VDD075CPU n857 2.31681953801e-11
R_3_147 n857 PAR_2_1_VDD075CPU 0.232757560821
R_4_147 PAR_2_2_VDD075CPU n858 647.815671653
C_4_147 n858 PAR_2_1_VDD075CPU 5.16729636772e-13
L_5_147 PAR_2_2_VDD075CPU n859 2.60633741744e-07
R_5_147 n859 PAR_2_1_VDD075CPU 210.668788417
R_6_147 PAR_2_2_VDD075CPU n860 1218.12396915
C_6_147 n860 PAR_2_1_VDD075CPU 3.24545627579e-11
G0_148 PAR_2_2_VDD075CPU PAR_0_2_VSS PAR_2_2_VDD075CPU PAR_0_2_VSS -0.108766168296
C0_148 PAR_2_2_VDD075CPU PAR_0_2_VSS 1.97677209004e-11
R_1_148 PAR_2_2_VDD075CPU n861 1.52938627637
C_1_148 n861 PAR_0_2_VSS 1.5940835728e-11
R_2_148 PAR_2_2_VDD075CPU n862 1.41910510851
C_2_148 n862 PAR_0_2_VSS 5.08974748364e-11
L_3_148 PAR_2_2_VDD075CPU n863 2.73055456126e-09
R_3_148 n863 PAR_0_2_VSS 11.4043935572
L_4_148 PAR_2_2_VDD075CPU n864 3.46350468357e-08
R_4_148 n864 PAR_0_2_VSS 47.4368300507
R_5_148 PAR_2_2_VDD075CPU n865 310.890315135
C_5_148 n865 PAR_0_2_VSS 2.09317344101e-11
R_6_148 PAR_2_2_VDD075CPU n866 910.542750141
C_6_148 n866 PAR_0_2_VSS 1.90823883542e-11
G0_149 PAR_2_2_VDD075CPU PAR_0_2_VDD075CPU PAR_2_2_VDD075CPU PAR_0_2_VDD075CPU -0.184010154504
C0_149 PAR_2_2_VDD075CPU PAR_0_2_VDD075CPU 1.97594232078e-11
R_1_149 PAR_2_2_VDD075CPU n867 5.29313681096
C_1_149 n867 PAR_0_2_VDD075CPU 1.52077818106e-12
L_2_149 PAR_2_2_VDD075CPU n868 7.2094875383e-10
R_2_149 n868 PAR_0_2_VDD075CPU 8.43588348373
L_3_149 PAR_2_2_VDD075CPU n869 2.05045677271e-09
R_3_149 n869 PAR_0_2_VDD075CPU 16.0137731738
L_4_149 PAR_2_2_VDD075CPU n870 1.74163776718e-07
R_4_149 n870 PAR_0_2_VDD075CPU 370.132862597
L_5_149 PAR_2_2_VDD075CPU n871 3.8147491494e-06
R_5_149 n871 PAR_0_2_VDD075CPU 2165.91753138
G0_150 PAR_2_2_VDD075CPU PAR_1_2_VSS PAR_2_2_VDD075CPU PAR_1_2_VSS -2.14725097236
C0_150 PAR_2_2_VDD075CPU PAR_1_2_VSS 1.6005835216e-11
L_1_150 PAR_2_2_VDD075CPU n872 2.6443527185e-11
R_1_150 n872 PAR_1_2_VSS 0.46595559678
R_2_150 PAR_2_2_VDD075CPU n873 0.0794972534429
C_2_150 n873 PAR_1_2_VSS 1.33003810838e-09
R_3_150 PAR_2_2_VDD075CPU n874 3.95016292447
C_3_150 n874 PAR_1_2_VSS 5.55057685367e-11
R_4_150 PAR_2_2_VDD075CPU n875 15.8969933569
C_4_150 n875 PAR_1_2_VSS 5.25117582553e-11
L_5_150 PAR_2_2_VDD075CPU n876 1.12878914611e-05
R_5_150 n876 PAR_1_2_VSS 889.891899047
R0_151 PAR_2_2_VDD075CPU PAR_1_2_VDD075CPU 0.0095842890722
C0_151 PAR_2_2_VDD075CPU PAR_1_2_VDD075CPU 3.2425852145e-11
L_1_151 PAR_2_2_VDD075CPU n877 1.84233533763e-12
R_1_151 n877 PAR_1_2_VDD075CPU 0.108026030297
L_2_151 PAR_2_2_VDD075CPU n878 6.28095878395e-12
R_2_151 n878 PAR_1_2_VDD075CPU 0.0569943671008
R_3_151 PAR_2_2_VDD075CPU n879 3.57317574269
C_3_151 n879 PAR_1_2_VDD075CPU 1.31897486997e-10
L_4_151 PAR_2_2_VDD075CPU n880 9.83249799264e-08
R_4_151 n880 PAR_1_2_VDD075CPU 22.749449362
R_1_152 PAR_2_2_VDD075CPU n881 0.158836135071
C_1_152 n881 PAR_2_2_VSS 5.15204254742e-11
R_2_152 PAR_2_2_VDD075CPU n882 0.0584928600919
C_2_152 n882 PAR_2_2_VSS 1.32711930128e-09
R_3_152 PAR_2_2_VDD075CPU n883 0.0170250220461
C_3_152 n883 PAR_2_2_VSS 5.83468479743e-09
R_4_152 PAR_2_2_VDD075CPU n884 4.29148673618
C_4_152 n884 PAR_2_2_VSS 7.68646097994e-11
R_5_152 PAR_2_2_VDD075CPU n885 29.5910691639
C_5_152 n885 PAR_2_2_VSS 2.70535162288e-11
R_6_152 PAR_2_2_VDD075CPU n886 373.46908563
C_6_152 n886 PAR_2_2_VSS 2.8314631054e-11
G0_153 PAR_2_2_VDD075CPU PAR_0_0_VSS PAR_2_2_VDD075CPU PAR_0_0_VSS -0.304784840094
C0_153 PAR_2_2_VDD075CPU PAR_0_0_VSS 2.64343455892e-11
R_1_153 PAR_2_2_VDD075CPU n887 0.168141845089
C_1_153 n887 PAR_0_0_VSS 9.63547008136e-11
R_2_153 PAR_2_2_VDD075CPU n888 0.599468999155
C_2_153 n888 PAR_0_0_VSS 8.58101825329e-11
L_3_153 PAR_2_2_VDD075CPU n889 7.62037341386e-10
R_3_153 n889 PAR_0_0_VSS 3.48110983644
L_4_153 PAR_2_2_VDD075CPU n890 5.64630522787e-08
R_4_153 n890 PAR_0_0_VSS 57.0771865307
R_5_153 PAR_2_2_VDD075CPU n891 1738.83687256
C_5_153 n891 PAR_0_0_VSS 1.08039378357e-11
G0_154 PAR_0_3_VSS PAR_0_0_VDD075CPU PAR_0_3_VSS PAR_0_0_VDD075CPU -0.199878523726
C0_154 PAR_0_3_VSS PAR_0_0_VDD075CPU 2.01689466742e-10
R_1_154 PAR_0_3_VSS n892 0.0671589059373
C_1_154 n892 PAR_0_0_VDD075CPU 2.67538644294e-10
R_2_154 PAR_0_3_VSS n893 0.220889476208
C_2_154 n893 PAR_0_0_VDD075CPU 3.36671871169e-10
R_3_154 PAR_0_3_VSS n894 1.48502648078
C_3_154 n894 PAR_0_0_VDD075CPU 9.44768888656e-11
L_4_154 PAR_0_3_VSS n895 4.02886665757e-09
R_4_154 n895 PAR_0_0_VDD075CPU 5.00303868592
R_5_154 PAR_0_3_VSS n896 26.8094441564
C_5_154 n896 PAR_0_0_VDD075CPU 2.53296946231e-10
R_6_154 PAR_0_3_VSS n897 132.206932735
C_6_154 n897 PAR_0_0_VDD075CPU 1.49804754302e-10
R0_155 PAR_0_3_VSS PAR_1_0_VSS 70.3421394369
C0_155 PAR_0_3_VSS PAR_1_0_VSS 2.02196620549e-10
R_1_155 PAR_0_3_VSS n898 0.269497160336
C_1_155 n898 PAR_1_0_VSS 1.51457279093e-10
R_2_155 PAR_0_3_VSS n899 0.121500341626
C_2_155 n899 PAR_1_0_VSS 1.79033026857e-09
R_3_155 PAR_0_3_VSS n900 0.104672099491
C_3_155 n900 PAR_1_0_VSS 2.89291187212e-09
R_4_155 PAR_0_3_VSS n901 0.157750930777
C_4_155 n901 PAR_1_0_VSS 4.86187871005e-09
R_5_155 PAR_0_3_VSS n902 1.48576906688
C_5_155 n902 PAR_1_0_VSS 3.5018825887e-09
R_6_155 PAR_0_3_VSS n903 3.76421365499
C_6_155 n903 PAR_1_0_VSS 3.97651635482e-09
G0_156 PAR_0_3_VSS PAR_1_0_VDD075CPU PAR_0_3_VSS PAR_1_0_VDD075CPU -0.196511145976
C0_156 PAR_0_3_VSS PAR_1_0_VDD075CPU 2.31704274723e-10
R_1_156 PAR_0_3_VSS n904 0.0942415837456
C_1_156 n904 PAR_1_0_VDD075CPU 2.11344805328e-10
R_2_156 PAR_0_3_VSS n905 0.210890123734
C_2_156 n905 PAR_1_0_VDD075CPU 3.5438417143e-10
R_3_156 PAR_0_3_VSS n906 1.07003388339
C_3_156 n906 PAR_1_0_VDD075CPU 1.35217239715e-10
L_4_156 PAR_0_3_VSS n907 4.11421155724e-09
R_4_156 n907 PAR_1_0_VDD075CPU 5.08876980528
R_5_156 PAR_0_3_VSS n908 25.2123217117
C_5_156 n908 PAR_1_0_VDD075CPU 2.14178601925e-10
R_6_156 PAR_0_3_VSS n909 59.7530112954
C_6_156 n909 PAR_1_0_VDD075CPU 2.52008060306e-10
R0_157 PAR_0_3_VSS PAR_2_0_VSS 4067.51100724
C0_157 PAR_0_3_VSS PAR_2_0_VSS 2.56581815791e-10
R_1_157 PAR_0_3_VSS n910 0.149837938225
C_1_157 n910 PAR_2_0_VSS 1.68367962099e-10
R_2_157 PAR_0_3_VSS n911 0.342211631876
C_2_157 n911 PAR_2_0_VSS 2.21638363621e-10
R_3_157 PAR_0_3_VSS n912 0.438509417303
C_3_157 n912 PAR_2_0_VSS 6.55744349066e-10
R_4_157 PAR_0_3_VSS n913 0.086141392369
C_4_157 n913 PAR_2_0_VSS 9.3477041032e-09
R_5_157 PAR_0_3_VSS n914 1.40288010518
C_5_157 n914 PAR_2_0_VSS 4.01608713309e-09
R_6_157 PAR_0_3_VSS n915 4.2408298175
C_6_157 n915 PAR_2_0_VSS 3.70251404639e-09
G0_158 PAR_0_3_VSS PAR_2_0_VDD075CPU PAR_0_3_VSS PAR_2_0_VDD075CPU -0.27624846132
C0_158 PAR_0_3_VSS PAR_2_0_VDD075CPU 2.62336148505e-10
R_1_158 PAR_0_3_VSS n916 0.096726153372
C_1_158 n916 PAR_2_0_VDD075CPU 2.6591499348e-10
R_2_158 PAR_0_3_VSS n917 0.216442722877
C_2_158 n917 PAR_2_0_VDD075CPU 4.16065461021e-10
R_3_158 PAR_0_3_VSS n918 1.29605446319
C_3_158 n918 PAR_2_0_VDD075CPU 1.87605324075e-10
L_4_158 PAR_0_3_VSS n919 2.72311059839e-09
R_4_158 n919 PAR_2_0_VDD075CPU 3.61992962902
R_5_158 PAR_0_3_VSS n920 17.1672315279
C_5_158 n920 PAR_2_0_VDD075CPU 4.92059854485e-10
R0_159 PAR_0_3_VSS PAR_0_1_VSS 0.213371965059
C0_159 PAR_0_3_VSS PAR_0_1_VSS 1.7670094253e-10
R_1_159 PAR_0_3_VSS n921 0.337362158221
C_1_159 n921 PAR_0_1_VSS 2.56357094662e-10
R_2_159 PAR_0_3_VSS n922 0.108504833173
C_2_159 n922 PAR_0_1_VSS 1.76456260153e-09
R_3_159 PAR_0_3_VSS n923 0.0752898635516
C_3_159 n923 PAR_0_1_VSS 5.08496481332e-09
R_4_159 PAR_0_3_VSS n924 0.296624502662
C_4_159 n924 PAR_0_1_VSS 2.72974369185e-09
R_5_159 PAR_0_3_VSS n925 0.90010310985
C_5_159 n925 PAR_0_1_VSS 3.41120757497e-09
R_6_159 PAR_0_3_VSS n926 3.98384544283
C_6_159 n926 PAR_0_1_VSS 4.37766875975e-09
G0_160 PAR_0_3_VSS PAR_0_1_VDD075CPU PAR_0_3_VSS PAR_0_1_VDD075CPU -0.1715634902
C0_160 PAR_0_3_VSS PAR_0_1_VDD075CPU 1.92138300576e-10
R_1_160 PAR_0_3_VSS n927 0.118914316434
C_1_160 n927 PAR_0_1_VDD075CPU 2.20765476314e-10
R_2_160 PAR_0_3_VSS n928 0.338390138016
C_2_160 n928 PAR_0_1_VDD075CPU 2.5958271439e-10
R_3_160 PAR_0_3_VSS n929 2.70240590287
C_3_160 n929 PAR_0_1_VDD075CPU 9.01513784001e-11
L_4_160 PAR_0_3_VSS n930 3.94626961235e-09
R_4_160 n930 PAR_0_1_VDD075CPU 5.82874586553
R_5_160 PAR_0_3_VSS n931 25.1406769982
C_5_160 n931 PAR_0_1_VDD075CPU 3.40357738927e-10
G0_161 PAR_0_3_VSS PAR_1_1_VSS PAR_0_3_VSS PAR_1_1_VSS -0.0902770958577
C0_161 PAR_0_3_VSS PAR_1_1_VSS 1.58692086843e-10
R_1_161 PAR_0_3_VSS n932 0.192219803758
C_1_161 n932 PAR_1_1_VSS 1.32265674647e-10
R_2_161 PAR_0_3_VSS n933 1.09488529473
C_2_161 n933 PAR_1_1_VSS 7.47640209712e-11
R_3_161 PAR_0_3_VSS n934 3.93116165295
C_3_161 n934 PAR_1_1_VSS 7.16818141318e-11
L_4_161 PAR_0_3_VSS n935 7.2138612034e-09
R_4_161 n935 PAR_1_1_VSS 11.076632192
R_5_161 PAR_0_3_VSS n936 41.1132757118
C_5_161 n936 PAR_1_1_VSS 2.05422811527e-10
G0_162 PAR_0_3_VSS PAR_1_1_VDD075CPU PAR_0_3_VSS PAR_1_1_VDD075CPU -0.100823366915
C0_162 PAR_0_3_VSS PAR_1_1_VDD075CPU 1.66418213361e-10
R_1_162 PAR_0_3_VSS n937 0.175646786014
C_1_162 n937 PAR_1_1_VDD075CPU 1.49836824021e-10
R_2_162 PAR_0_3_VSS n938 0.635775688644
C_2_162 n938 PAR_1_1_VDD075CPU 1.36472926135e-10
R_3_162 PAR_0_3_VSS n939 2.7774831799
C_3_162 n939 PAR_1_1_VDD075CPU 9.30180239583e-11
L_4_162 PAR_0_3_VSS n940 6.90534961936e-09
R_4_162 n940 PAR_1_1_VDD075CPU 9.91833544645
R_5_162 PAR_0_3_VSS n941 32.7487351517
C_5_162 n941 PAR_1_1_VDD075CPU 2.57342942699e-10
R0_163 PAR_0_3_VSS PAR_2_1_VSS 429.903104164
C0_163 PAR_0_3_VSS PAR_2_1_VSS 2.01926649209e-10
R_1_163 PAR_0_3_VSS n942 0.157782249358
C_1_163 n942 PAR_2_1_VSS 1.83141755808e-10
R_2_163 PAR_0_3_VSS n943 0.510085280302
C_2_163 n943 PAR_2_1_VSS 3.80583894879e-10
R_3_163 PAR_0_3_VSS n944 0.335933698233
C_3_163 n944 PAR_2_1_VSS 1.19419002476e-09
R_4_163 PAR_0_3_VSS n945 1.13737466028
C_4_163 n945 PAR_2_1_VSS 8.8673090171e-10
R_5_163 PAR_0_3_VSS n946 3.07531649632
C_5_163 n946 PAR_2_1_VSS 1.28870945801e-09
R_6_163 PAR_0_3_VSS n947 8.5470317301
C_6_163 n947 PAR_2_1_VSS 1.54243529413e-09
G0_164 PAR_0_3_VSS PAR_2_1_VDD075CPU PAR_0_3_VSS PAR_2_1_VDD075CPU -0.172313883195
C0_164 PAR_0_3_VSS PAR_2_1_VDD075CPU 1.70309572723e-10
R_1_164 PAR_0_3_VSS n948 0.125660591744
C_1_164 n948 PAR_2_1_VDD075CPU 1.62911418982e-10
R_2_164 PAR_0_3_VSS n949 0.299036660392
C_2_164 n949 PAR_2_1_VDD075CPU 2.64690459376e-10
R_3_164 PAR_0_3_VSS n950 1.00780742565
C_3_164 n950 PAR_2_1_VDD075CPU 1.34569852409e-10
L_4_164 PAR_0_3_VSS n951 4.38523724697e-09
R_4_164 n951 PAR_2_1_VDD075CPU 5.80336282715
R_5_164 PAR_0_3_VSS n952 31.3193358289
C_5_164 n952 PAR_2_1_VDD075CPU 2.11551380991e-10
R_6_164 PAR_0_3_VSS n953 138.885790959
C_6_164 n953 PAR_2_1_VDD075CPU 1.37186166369e-10
R0_165 PAR_0_3_VSS PAR_0_2_VSS 0.00640112886876
C0_165 PAR_0_3_VSS PAR_0_2_VSS 1.1498168509e-10
L_1_165 PAR_0_3_VSS n954 4.47950918137e-13
R_1_165 n954 PAR_0_2_VSS 0.0128140443343
R_2_165 PAR_0_3_VSS n955 0.115143522448
C_2_165 n955 PAR_0_2_VSS 2.28247327478e-09
L_3_165 PAR_0_3_VSS n956 1.14860658021e-09
R_3_165 n956 PAR_0_2_VSS 0.393953801236
L_4_165 PAR_0_3_VSS n957 3.70056668924e-09
R_4_165 n957 PAR_0_2_VSS 0.353936664815
G0_166 PAR_0_3_VSS PAR_0_2_VDD075CPU PAR_0_3_VSS PAR_0_2_VDD075CPU -0.0976122232978
C0_166 PAR_0_3_VSS PAR_0_2_VDD075CPU 2.45572499453e-10
R_1_166 PAR_0_3_VSS n958 0.00848270517595
C_1_166 n958 PAR_0_2_VDD075CPU 3.27109135324e-09
R_2_166 PAR_0_3_VSS n959 0.0279316528516
C_2_166 n959 PAR_0_2_VDD075CPU 1.78291393639e-09
R_3_166 PAR_0_3_VSS n960 0.650347072917
C_3_166 n960 PAR_0_2_VDD075CPU 2.56646412724e-10
L_4_166 PAR_0_3_VSS n961 8.11589124065e-09
R_4_166 n961 PAR_0_2_VDD075CPU 10.2446183206
R_5_166 PAR_0_3_VSS n962 20.9626202203
C_5_166 n962 PAR_0_2_VDD075CPU 3.71395028711e-10
R0_167 PAR_0_3_VSS PAR_1_2_VSS 0.127488330877
C0_167 PAR_0_3_VSS PAR_1_2_VSS 1.78373838123e-10
R_1_167 PAR_0_3_VSS n963 0.238323108782
C_1_167 n963 PAR_1_2_VSS 3.55623380835e-10
R_2_167 PAR_0_3_VSS n964 0.218301067563
C_2_167 n964 PAR_1_2_VSS 1.03219395947e-09
R_3_167 PAR_0_3_VSS n965 0.293137481185
C_3_167 n965 PAR_1_2_VSS 2.12149284486e-09
R_4_167 PAR_0_3_VSS n966 0.389766244225
C_4_167 n966 PAR_1_2_VSS 3.58346741305e-09
R_5_167 PAR_0_3_VSS n967 0.95831677377
C_5_167 n967 PAR_1_2_VSS 4.61024294798e-09
R_6_167 PAR_0_3_VSS n968 3.42303381672
C_6_167 n968 PAR_1_2_VSS 4.13045862654e-09
G0_168 PAR_0_3_VSS PAR_1_2_VDD075CPU PAR_0_3_VSS PAR_1_2_VDD075CPU -0.140334004081
C0_168 PAR_0_3_VSS PAR_1_2_VDD075CPU 2.24886603014e-10
R_1_168 PAR_0_3_VSS n969 0.0613900280729
C_1_168 n969 PAR_1_2_VDD075CPU 4.5342602221e-10
R_2_168 PAR_0_3_VSS n970 0.326908319296
C_2_168 n970 PAR_1_2_VDD075CPU 2.37052090454e-10
R_3_168 PAR_0_3_VSS n971 1.86310381929
C_3_168 n971 PAR_1_2_VDD075CPU 1.21692760143e-10
L_4_168 PAR_0_3_VSS n972 5.48454946445e-09
R_4_168 n972 PAR_1_2_VDD075CPU 7.12585656098
R_5_168 PAR_0_3_VSS n973 23.8716507427
C_5_168 n973 PAR_1_2_VDD075CPU 3.5594094029e-10
R0_169 PAR_0_3_VSS PAR_2_2_VSS 128.207722433
C0_169 PAR_0_3_VSS PAR_2_2_VSS 1.60650550955e-11
R_1_169 PAR_0_3_VSS n974 0.275035048219
C_1_169 n974 PAR_2_2_VSS 2.04605740928e-10
R_2_169 PAR_0_3_VSS n975 0.396164056178
C_2_169 n975 PAR_2_2_VSS 4.71261435954e-10
R_3_169 PAR_0_3_VSS n976 0.215490358528
C_3_169 n976 PAR_2_2_VSS 2.13290984729e-09
R_4_169 PAR_0_3_VSS n977 0.456815863385
C_4_169 n977 PAR_2_2_VSS 2.45129809973e-09
R_5_169 PAR_0_3_VSS n978 1.36509793971
C_5_169 n978 PAR_2_2_VSS 2.93934139823e-09
R_6_169 PAR_0_3_VSS n979 4.30351281015
C_6_169 n979 PAR_2_2_VSS 3.09548910794e-09
G0_170 PAR_0_3_VSS PAR_2_2_VDD075CPU PAR_0_3_VSS PAR_2_2_VDD075CPU -0.0869787853211
C0_170 PAR_0_3_VSS PAR_2_2_VDD075CPU 2.36120576341e-11
R_1_170 PAR_0_3_VSS n980 0.973429314777
C_1_170 n980 PAR_2_2_VDD075CPU 2.81779736313e-11
R_2_170 PAR_0_3_VSS n981 0.886534619049
C_2_170 n981 PAR_2_2_VDD075CPU 8.53952909249e-11
L_3_170 PAR_0_3_VSS n982 8.00809587564e-09
R_3_170 n982 PAR_2_2_VDD075CPU 19.6913059811
L_4_170 PAR_0_3_VSS n983 2.35141321989e-08
R_4_170 n983 PAR_2_2_VDD075CPU 27.628160119
R_5_170 PAR_0_3_VSS n984 244.68537144
C_5_170 n984 PAR_2_2_VDD075CPU 3.86973049874e-11
R0_171 PAR_0_3_VSS PAR_0_0_VSS 0.292327359511
C0_171 PAR_0_3_VSS PAR_0_0_VSS 1.54407474726e-10
R_1_171 PAR_0_3_VSS n985 0.0232785987884
C_1_171 n985 PAR_0_0_VSS 1.9089989039e-09
R_2_171 PAR_0_3_VSS n986 0.0426045699828
C_2_171 n986 PAR_0_0_VSS 3.25604907913e-09
R_3_171 PAR_0_3_VSS n987 0.0400096202864
C_3_171 n987 PAR_0_0_VSS 8.37420246934e-09
R_4_171 PAR_0_3_VSS n988 0.0775197343627
C_4_171 n988 PAR_0_0_VSS 1.36024207447e-08
R_5_171 PAR_0_3_VSS n989 0.217993620129
C_5_171 n989 PAR_0_0_VSS 1.97043912134e-08
R_6_171 PAR_0_3_VSS n990 0.282935858753
C_6_171 n990 PAR_0_0_VSS 5.33033787171e-08
G0_172 PAR_0_3_VDD075CPU PAR_0_0_VDD075CPU PAR_0_3_VDD075CPU PAR_0_0_VDD075CPU -10.131691707
C0_172 PAR_0_3_VDD075CPU PAR_0_0_VDD075CPU 1.31876374946e-10
R_1_172 PAR_0_3_VDD075CPU n991 0.317149103881
C_1_172 n991 PAR_0_0_VDD075CPU 1.31244631639e-10
L_2_172 PAR_0_3_VDD075CPU n992 1.34079268755e-11
R_2_172 n992 PAR_0_0_VDD075CPU 0.118190454289
R_3_172 PAR_0_3_VDD075CPU n993 0.157073975326
C_3_172 n993 PAR_0_0_VDD075CPU 9.97172097615e-10
L_4_172 PAR_0_3_VDD075CPU n994 2.74848503889e-10
R_4_172 n994 PAR_0_0_VDD075CPU 0.692027334625
R_5_172 PAR_0_3_VDD075CPU n995 1.75014149014
C_5_172 n995 PAR_0_0_VDD075CPU 6.13655321373e-10
L_6_172 PAR_0_3_VDD075CPU n996 1.57807599014e-08
R_6_172 n996 PAR_0_0_VDD075CPU 4.43326134778
R_7_172 PAR_0_3_VDD075CPU n997 24.5150494667
C_7_172 n997 PAR_0_0_VDD075CPU 5.58043571434e-10
G0_173 PAR_0_3_VDD075CPU PAR_1_0_VSS PAR_0_3_VDD075CPU PAR_1_0_VSS -1.00982518971
C0_173 PAR_0_3_VDD075CPU PAR_1_0_VSS 1.69188594697e-10
R_1_173 PAR_0_3_VDD075CPU n998 0.158924650215
C_1_173 n998 PAR_1_0_VSS 1.67262615075e-10
R_2_173 PAR_0_3_VDD075CPU n999 0.555595837908
C_2_173 n999 PAR_1_0_VSS 2.13855596501e-10
L_3_173 PAR_0_3_VDD075CPU n1000 3.18484991794e-10
R_3_173 n1000 PAR_1_0_VSS 1.10782080444
L_4_173 PAR_0_3_VDD075CPU n1001 1.36945412042e-08
R_4_173 n1001 PAR_1_0_VSS 10.5905603693
L_5_173 PAR_0_3_VDD075CPU n1002 6.51339693371e-07
R_5_173 n1002 PAR_1_0_VSS 78.5643576184
G0_174 PAR_0_3_VDD075CPU PAR_1_0_VDD075CPU PAR_0_3_VDD075CPU PAR_1_0_VDD075CPU -6.05226690164
C0_174 PAR_0_3_VDD075CPU PAR_1_0_VDD075CPU 1.39814609888e-10
R_1_174 PAR_0_3_VDD075CPU n1003 0.215600952385
C_1_174 n1003 PAR_1_0_VDD075CPU 1.77244210097e-10
L_2_174 PAR_0_3_VDD075CPU n1004 1.25374897452e-11
R_2_174 n1004 PAR_1_0_VDD075CPU 0.187394193687
R_3_174 PAR_0_3_VDD075CPU n1005 0.891148777651
C_3_174 n1005 PAR_1_0_VDD075CPU 1.55516753931e-10
L_4_174 PAR_0_3_VDD075CPU n1006 6.0387024333e-10
R_4_174 n1006 PAR_1_0_VDD075CPU 1.64040400974
R_5_174 PAR_0_3_VDD075CPU n1007 3.63796354318
C_5_174 n1007 PAR_1_0_VDD075CPU 2.56935756034e-10
L_6_174 PAR_0_3_VDD075CPU n1008 2.98030964108e-08
R_6_174 n1008 PAR_1_0_VDD075CPU 9.38931920066
R_7_174 PAR_0_3_VDD075CPU n1009 58.6774411735
C_7_174 n1009 PAR_1_0_VDD075CPU 2.22115700818e-10
G0_175 PAR_0_3_VDD075CPU PAR_2_0_VSS PAR_0_3_VDD075CPU PAR_2_0_VSS -0.0913724532617
C0_175 PAR_0_3_VDD075CPU PAR_2_0_VSS 2.01037994795e-10
R_1_175 PAR_0_3_VDD075CPU n1010 0.406708178189
C_1_175 n1010 PAR_2_0_VSS 5.57675036412e-11
R_2_175 PAR_0_3_VDD075CPU n1011 2.70613914297
C_2_175 n1011 PAR_2_0_VSS 5.50590391237e-11
L_3_175 PAR_0_3_VDD075CPU n1012 2.33051439763e-08
R_3_175 n1012 PAR_2_0_VSS 11.4950129468
L_4_175 PAR_0_3_VDD075CPU n1013 5.76843422898e-06
R_4_175 n1013 PAR_2_0_VSS 228.40392684
G0_176 PAR_0_3_VDD075CPU PAR_2_0_VDD075CPU PAR_0_3_VDD075CPU PAR_2_0_VDD075CPU -6.76974087376
C0_176 PAR_0_3_VDD075CPU PAR_2_0_VDD075CPU 1.36465221822e-10
R_1_176 PAR_0_3_VDD075CPU n1014 0.377572458743
C_1_176 n1014 PAR_2_0_VDD075CPU 1.23099854251e-10
L_2_176 PAR_0_3_VDD075CPU n1015 2.40839154651e-11
R_2_176 n1015 PAR_2_0_VDD075CPU 0.18521039594
R_3_176 PAR_0_3_VDD075CPU n1016 0.262574795183
C_3_176 n1016 PAR_2_0_VDD075CPU 8.27971055054e-10
L_4_176 PAR_0_3_VDD075CPU n1017 3.95636281977e-10
R_4_176 n1017 PAR_2_0_VDD075CPU 0.787885729645
R_5_176 PAR_0_3_VDD075CPU n1018 3.2610416216
C_5_176 n1018 PAR_2_0_VDD075CPU 5.86156794248e-10
L_6_176 PAR_0_3_VDD075CPU n1019 9.3589323149e-08
R_6_176 n1019 PAR_2_0_VDD075CPU 9.87286382756
R_7_176 PAR_0_3_VDD075CPU n1020 162.509895295
C_7_176 n1020 PAR_2_0_VDD075CPU 1.26164578267e-09
G0_177 PAR_0_3_VDD075CPU PAR_0_1_VSS PAR_0_3_VDD075CPU PAR_0_1_VSS -0.748129310261
C0_177 PAR_0_3_VDD075CPU PAR_0_1_VSS 1.65193232601e-10
R_1_177 PAR_0_3_VDD075CPU n1021 0.113290960851
C_1_177 n1021 PAR_0_1_VSS 2.48836096933e-10
R_2_177 PAR_0_3_VDD075CPU n1022 0.461246201526
C_2_177 n1022 PAR_0_1_VSS 2.14228046345e-10
L_3_177 PAR_0_3_VDD075CPU n1023 4.91048903019e-10
R_3_177 n1023 PAR_0_1_VSS 1.52088049943
L_4_177 PAR_0_3_VDD075CPU n1024 7.9487875969e-09
R_4_177 n1024 PAR_0_1_VSS 11.0356447037
R_5_177 PAR_0_3_VDD075CPU n1025 31.2198937002
C_5_177 n1025 PAR_0_1_VSS 2.56697956709e-10
G0_178 PAR_0_3_VDD075CPU PAR_0_1_VDD075CPU PAR_0_3_VDD075CPU PAR_0_1_VDD075CPU -8.35300475006
C0_178 PAR_0_3_VDD075CPU PAR_0_1_VDD075CPU 9.91524620606e-11
R_1_178 PAR_0_3_VDD075CPU n1026 0.4347938192
C_1_178 n1026 PAR_0_1_VDD075CPU 1.10083306467e-10
L_2_178 PAR_0_3_VDD075CPU n1027 2.29152776539e-11
R_2_178 n1027 PAR_0_1_VDD075CPU 0.174401585907
R_3_178 PAR_0_3_VDD075CPU n1028 0.18937688122
C_3_178 n1028 PAR_0_1_VDD075CPU 1.12575909116e-09
L_4_178 PAR_0_3_VDD075CPU n1029 1.75075160611e-10
R_4_178 n1029 PAR_0_1_VDD075CPU 0.426104108181
R_5_178 PAR_0_3_VDD075CPU n1030 1.37952341278
C_5_178 n1030 PAR_0_1_VDD075CPU 8.18342405282e-10
L_6_178 PAR_0_3_VDD075CPU n1031 1.31752793747e-08
R_6_178 n1031 PAR_0_1_VDD075CPU 3.67120728558
R_7_178 PAR_0_3_VDD075CPU n1032 20.9641710715
C_7_178 n1032 PAR_0_1_VDD075CPU 6.48419636692e-10
G0_179 PAR_0_3_VDD075CPU PAR_1_1_VSS PAR_0_3_VDD075CPU PAR_1_1_VSS -3.17196722623
C0_179 PAR_0_3_VDD075CPU PAR_1_1_VSS 8.31678786085e-11
R_1_179 PAR_0_3_VDD075CPU n1033 0.40996391878
C_1_179 n1033 PAR_1_1_VSS 4.72035233235e-11
L_2_179 PAR_0_3_VDD075CPU n1034 1.84513997488e-11
R_2_179 n1034 PAR_1_1_VSS 0.384226890658
R_3_179 PAR_0_3_VDD075CPU n1035 1.96907777459
C_3_179 n1035 PAR_1_1_VSS 6.46911101775e-11
L_4_179 PAR_0_3_VDD075CPU n1036 4.82995312591e-10
R_4_179 n1036 PAR_1_1_VSS 2.03657997297
R_5_179 PAR_0_3_VDD075CPU n1037 4.94417396806
C_5_179 n1037 PAR_1_1_VSS 9.58596619235e-11
L_6_179 PAR_0_3_VDD075CPU n1038 1.76749280147e-08
R_6_179 n1038 PAR_1_1_VSS 13.9585254783
R_7_179 PAR_0_3_VDD075CPU n1039 44.2126440434
C_7_179 n1039 PAR_1_1_VSS 8.85300849998e-11
L_8_179 PAR_0_3_VDD075CPU n1040 2.10304874308e-06
R_8_179 n1040 PAR_1_1_VSS 149.739044225
G0_180 PAR_0_3_VDD075CPU PAR_1_1_VDD075CPU PAR_0_3_VDD075CPU PAR_1_1_VDD075CPU -2.64572486153
C0_180 PAR_0_3_VDD075CPU PAR_1_1_VDD075CPU 9.06841224361e-11
R_1_180 PAR_0_3_VDD075CPU n1041 0.425198029236
C_1_180 n1041 PAR_1_1_VDD075CPU 5.25338205089e-11
L_2_180 PAR_0_3_VDD075CPU n1042 2.15498304158e-11
R_2_180 n1042 PAR_1_1_VDD075CPU 0.421465895007
R_3_180 PAR_0_3_VDD075CPU n1043 4.83989317441
C_3_180 n1043 PAR_1_1_VDD075CPU 2.8536539749e-11
L_4_180 PAR_0_3_VDD075CPU n1044 1.26979675663e-09
R_4_180 n1044 PAR_1_1_VDD075CPU 4.16015493523
R_5_180 PAR_0_3_VDD075CPU n1045 12.1367347586
C_5_180 n1045 PAR_1_1_VDD075CPU 6.59477896411e-11
L_6_180 PAR_0_3_VDD075CPU n1046 8.6439330904e-08
R_6_180 n1046 PAR_1_1_VDD075CPU 30.8578890963
R_7_180 PAR_0_3_VDD075CPU n1047 205.384552122
C_7_180 n1047 PAR_1_1_VDD075CPU 6.1108070969e-11
G0_181 PAR_0_3_VDD075CPU PAR_2_1_VSS PAR_0_3_VDD075CPU PAR_2_1_VSS -2.99092156366
C0_181 PAR_0_3_VDD075CPU PAR_2_1_VSS 1.28367330664e-10
R_1_181 PAR_0_3_VDD075CPU n1048 1.31183952182
C_1_181 n1048 PAR_2_1_VSS 3.86424293699e-11
L_2_181 PAR_0_3_VDD075CPU n1049 6.49906935256e-11
R_2_181 n1049 PAR_2_1_VSS 0.487232973637
R_3_181 PAR_0_3_VDD075CPU n1050 0.51939230768
C_3_181 n1050 PAR_2_1_VSS 3.91843585134e-10
L_4_181 PAR_0_3_VDD075CPU n1051 5.68034874531e-10
R_4_181 n1051 PAR_2_1_VSS 1.2225158552
R_5_181 PAR_0_3_VDD075CPU n1052 3.54168817784
C_5_181 n1052 PAR_2_1_VSS 3.51830852539e-10
L_6_181 PAR_0_3_VDD075CPU n1053 3.34064174256e-08
R_6_181 n1053 PAR_2_1_VSS 8.2966885415
R_7_181 PAR_0_3_VDD075CPU n1054 47.7212158582
C_7_181 n1054 PAR_2_1_VSS 2.9440208042e-10
G0_182 PAR_0_3_VDD075CPU PAR_2_1_VDD075CPU PAR_0_3_VDD075CPU PAR_2_1_VDD075CPU -2.4912755235
C0_182 PAR_0_3_VDD075CPU PAR_2_1_VDD075CPU 9.09716253926e-11
R_1_182 PAR_0_3_VDD075CPU n1055 0.70386227904
C_1_182 n1055 PAR_2_1_VDD075CPU 6.29422345895e-11
L_2_182 PAR_0_3_VDD075CPU n1056 7.01772368119e-11
R_2_182 n1056 PAR_2_1_VDD075CPU 0.512357438502
R_3_182 PAR_0_3_VDD075CPU n1057 1.14708264613
C_3_182 n1057 PAR_2_1_VDD075CPU 3.13154042783e-10
L_4_182 PAR_0_3_VDD075CPU n1058 2.46151539432e-09
R_4_182 n1058 PAR_2_1_VDD075CPU 2.14642339795
R_5_182 PAR_0_3_VDD075CPU n1059 5.03103446547
C_5_182 n1059 PAR_2_1_VDD075CPU 8.95118918647e-10
L_6_182 PAR_0_3_VDD075CPU n1060 2.09000913769e-07
R_6_182 n1060 PAR_2_1_VDD075CPU 13.5842895228
C0_183 PAR_0_3_VDD075CPU PAR_0_2_VSS 1.45490701062e-10
R_1_183 PAR_0_3_VDD075CPU n1061 0.0262580465612
C_1_183 n1061 PAR_0_2_VSS 1.2998104593e-09
R_2_183 PAR_0_3_VDD075CPU n1062 0.151199994141
C_2_183 n1062 PAR_0_2_VSS 3.71368138355e-10
R_3_183 PAR_0_3_VDD075CPU n1063 1.69743365424
C_3_183 n1063 PAR_0_2_VSS 1.02528479188e-10
R_4_183 PAR_0_3_VDD075CPU n1064 17.7539417209
C_4_183 n1064 PAR_0_2_VSS 3.99701167432e-11
R_5_183 PAR_0_3_VDD075CPU n1065 27.2259108919
C_5_183 n1065 PAR_0_2_VSS 1.19574388362e-10
R_6_183 PAR_0_3_VDD075CPU n1066 51.4778987346
C_6_183 n1066 PAR_0_2_VSS 2.31841410639e-10
R0_184 PAR_0_3_VDD075CPU PAR_0_2_VDD075CPU 0.00821422136485
C0_184 PAR_0_3_VDD075CPU PAR_0_2_VDD075CPU 8.34772665482e-11
L_1_184 PAR_0_3_VDD075CPU n1067 7.39282791662e-13
R_1_184 n1067 PAR_0_2_VDD075CPU 0.0348947713135
L_2_184 PAR_0_3_VDD075CPU n1068 7.93401301502e-13
R_2_184 n1068 PAR_0_2_VDD075CPU 0.0203365568695
L_3_184 PAR_0_3_VDD075CPU n1069 7.81231076746e-11
R_3_184 n1069 PAR_0_2_VDD075CPU 0.594375613458
L_4_184 PAR_0_3_VDD075CPU n1070 3.81692356023e-09
R_4_184 n1070 PAR_0_2_VDD075CPU 14.0325280921
L_5_184 PAR_0_3_VDD075CPU n1071 2.28859560421e-07
R_5_184 n1071 PAR_0_2_VDD075CPU 217.929288416
L_6_184 PAR_0_3_VDD075CPU n1072 8.70094684338e-06
R_6_184 n1072 PAR_0_2_VDD075CPU 1183.4463351
G0_185 PAR_0_3_VDD075CPU PAR_1_2_VSS PAR_0_3_VDD075CPU PAR_1_2_VSS -0.3345672681
C0_185 PAR_0_3_VDD075CPU PAR_1_2_VSS 1.42023224721e-10
R_1_185 PAR_0_3_VDD075CPU n1073 0.233842948493
C_1_185 n1073 PAR_1_2_VSS 1.37092702446e-10
R_2_185 PAR_0_3_VDD075CPU n1074 3.54930525884
C_2_185 n1074 PAR_1_2_VSS 3.38819444918e-11
L_3_185 PAR_0_3_VDD075CPU n1075 7.84205952823e-10
R_3_185 n1075 PAR_1_2_VSS 3.23959643916
L_4_185 PAR_0_3_VDD075CPU n1076 1.5825902516e-07
R_4_185 n1076 PAR_1_2_VSS 64.9066866849
L_5_185 PAR_0_3_VDD075CPU n1077 9.60118235511e-07
R_5_185 n1077 PAR_1_2_VSS 95.4188095805
R0_186 PAR_0_3_VDD075CPU PAR_1_2_VDD075CPU 0.401482240089
C0_186 PAR_0_3_VDD075CPU PAR_1_2_VDD075CPU 1.57028347009e-10
L_1_186 PAR_0_3_VDD075CPU n1078 8.08542567319e-12
R_1_186 n1078 PAR_1_2_VDD075CPU 0.215832365293
L_2_186 PAR_0_3_VDD075CPU n1079 1.54794746865e-10
R_2_186 n1079 PAR_1_2_VDD075CPU 1.97198902666
L_3_186 PAR_0_3_VDD075CPU n1080 6.60750838077e-10
R_3_186 n1080 PAR_1_2_VDD075CPU 3.9945744578
L_4_186 PAR_0_3_VDD075CPU n1081 4.34787104027e-08
R_4_186 n1081 PAR_1_2_VDD075CPU 77.327314856
L_5_186 PAR_0_3_VDD075CPU n1082 2.87884586301e-06
R_5_186 n1082 PAR_1_2_VDD075CPU 690.057679303
L_6_186 PAR_0_3_VDD075CPU n1083 0.0019656837274
R_6_186 n1083 PAR_1_2_VDD075CPU 4984.50462902
G0_187 PAR_0_3_VDD075CPU PAR_2_2_VSS PAR_0_3_VDD075CPU PAR_2_2_VSS -0.185207159753
C0_187 PAR_0_3_VDD075CPU PAR_2_2_VSS 3.02454387134e-11
R_1_187 PAR_0_3_VDD075CPU n1084 0.17692372962
C_1_187 n1084 PAR_2_2_VSS 1.30838046602e-10
R_2_187 PAR_0_3_VDD075CPU n1085 2.67644402436
C_2_187 n1085 PAR_2_2_VSS 4.35435139987e-11
L_3_187 PAR_0_3_VDD075CPU n1086 2.31007927814e-09
R_3_187 n1086 PAR_2_2_VSS 7.58901880127
L_4_187 PAR_0_3_VDD075CPU n1087 2.24557515017e-08
R_4_187 n1087 PAR_2_2_VSS 27.6732186803
L_5_187 PAR_0_3_VDD075CPU n1088 2.64733699847e-07
R_5_187 n1088 PAR_2_2_VSS 79.7687124828
L_6_187 PAR_0_3_VDD075CPU n1089 2.63494480875e-06
R_6_187 n1089 PAR_2_2_VSS 209.839017454
G0_188 PAR_0_3_VDD075CPU PAR_2_2_VDD075CPU PAR_0_3_VDD075CPU PAR_2_2_VDD075CPU -0.242473928223
C0_188 PAR_0_3_VDD075CPU PAR_2_2_VDD075CPU 1.81214225897e-11
R_1_188 PAR_0_3_VDD075CPU n1090 2.47738324619
C_1_188 n1090 PAR_2_2_VDD075CPU 7.30940599529e-12
L_2_188 PAR_0_3_VDD075CPU n1091 5.07377508395e-10
R_2_188 n1091 PAR_2_2_VDD075CPU 6.84462972648
L_3_188 PAR_0_3_VDD075CPU n1092 1.41225959477e-09
R_3_188 n1092 PAR_2_2_VDD075CPU 10.4737859375
L_4_188 PAR_0_3_VDD075CPU n1093 8.14475860934e-07
R_4_188 n1093 PAR_2_2_VDD075CPU 1319.79193624
L_5_188 PAR_0_3_VDD075CPU n1094 3.71517654885e-05
R_5_188 n1094 PAR_2_2_VDD075CPU 8227.81765351
R_1_189 PAR_0_3_VDD075CPU n1095 0.00067517335272
C_1_189 n1095 PAR_0_3_VSS 2.89028179015e-08
R_2_189 PAR_0_3_VDD075CPU n1096 0.000646920309506
C_2_189 n1096 PAR_0_3_VSS 5.93043808698e-08
R_3_189 PAR_0_3_VDD075CPU n1097 0.0550662979999
C_3_189 n1097 PAR_0_3_VSS 2.58971889822e-09
R_4_189 PAR_0_3_VDD075CPU n1098 0.249642204989
C_4_189 n1098 PAR_0_3_VSS 1.21144285564e-09
R_5_189 PAR_0_3_VDD075CPU n1099 3.84683789549
C_5_189 n1099 PAR_0_3_VSS 2.77907998244e-10
R_6_189 PAR_0_3_VDD075CPU n1100 16.3084281032
C_6_189 n1100 PAR_0_3_VSS 4.36095876241e-10
G0_190 PAR_0_3_VDD075CPU PAR_0_0_VSS PAR_0_3_VDD075CPU PAR_0_0_VSS -2.15709267362
C0_190 PAR_0_3_VDD075CPU PAR_0_0_VSS 2.10783687757e-10
R_1_190 PAR_0_3_VDD075CPU n1101 0.0178014117789
C_1_190 n1101 PAR_0_0_VSS 1.05700404469e-09
R_2_190 PAR_0_3_VDD075CPU n1102 0.844042493521
C_2_190 n1102 PAR_0_0_VSS 1.72486472486e-10
L_3_190 PAR_0_3_VDD075CPU n1103 1.20498378944e-10
R_3_190 n1103 PAR_0_0_VSS 0.482965646938
L_4_190 PAR_0_3_VDD075CPU n1104 8.29293187449e-09
R_4_190 n1104 PAR_0_0_VSS 11.5537432641
R_5_190 PAR_0_3_VDD075CPU n1105 565.926390034
C_5_190 n1105 PAR_0_0_VSS 3.45361092361e-11
G0_191 PAR_1_3_VSS PAR_0_0_VDD075CPU PAR_1_3_VSS PAR_0_0_VDD075CPU -0.0802824274004
C0_191 PAR_1_3_VSS PAR_0_0_VDD075CPU 1.8920135235e-10
R_1_191 PAR_1_3_VSS n1106 0.146329861153
C_1_191 n1106 PAR_0_0_VDD075CPU 2.2993971438e-10
R_2_191 PAR_1_3_VSS n1107 0.430361263849
C_2_191 n1107 PAR_0_0_VDD075CPU 2.20990859953e-10
R_3_191 PAR_1_3_VSS n1108 4.57739679448
C_3_191 n1108 PAR_0_0_VDD075CPU 6.50125672612e-11
R_4_191 PAR_1_3_VSS n1109 10.811107402
C_4_191 n1109 PAR_0_0_VDD075CPU 2.18153334794e-10
L_5_191 PAR_1_3_VSS n1110 9.76858540139e-08
R_5_191 n1110 PAR_0_0_VDD075CPU 12.4560255475
G0_192 PAR_1_3_VSS PAR_1_0_VSS PAR_1_3_VSS PAR_1_0_VSS -0.735103856456
C0_192 PAR_1_3_VSS PAR_1_0_VSS 1.60537338302e-10
R_1_192 PAR_1_3_VSS n1111 0.385136917311
C_1_192 n1111 PAR_1_0_VSS 2.45926434605e-10
R_2_192 PAR_1_3_VSS n1112 0.0867840329915
C_2_192 n1112 PAR_1_0_VSS 3.61340286003e-09
R_3_192 PAR_1_3_VSS n1113 0.150120033109
C_3_192 n1113 PAR_1_0_VSS 8.38209337955e-09
L_4_192 PAR_1_3_VSS n1114 1.68209541221e-08
R_4_192 n1114 PAR_1_0_VSS 1.36029067135
G0_193 PAR_1_3_VSS PAR_1_0_VDD075CPU PAR_1_3_VSS PAR_1_0_VDD075CPU -0.0878379170289
C0_193 PAR_1_3_VSS PAR_1_0_VDD075CPU 1.99787573388e-10
R_1_193 PAR_1_3_VSS n1115 0.178581119819
C_1_193 n1115 PAR_1_0_VDD075CPU 2.16711608786e-10
R_2_193 PAR_1_3_VSS n1116 0.427813870116
C_2_193 n1116 PAR_1_0_VDD075CPU 2.29904831119e-10
R_3_193 PAR_1_3_VSS n1117 3.31129347449
C_3_193 n1117 PAR_1_0_VDD075CPU 8.06983408826e-11
R_4_193 PAR_1_3_VSS n1118 8.38089034972
C_4_193 n1118 PAR_1_0_VDD075CPU 2.76015738438e-10
L_5_193 PAR_1_3_VSS n1119 8.71846884243e-08
R_5_193 n1119 PAR_1_0_VDD075CPU 11.3846047637
G0_194 PAR_1_3_VSS PAR_2_0_VSS PAR_1_3_VSS PAR_2_0_VSS -1.53309104696
C0_194 PAR_1_3_VSS PAR_2_0_VSS 2.11134441076e-10
R_1_194 PAR_1_3_VSS n1120 0.266454294352
C_1_194 n1120 PAR_2_0_VSS 1.87336674931e-10
R_2_194 PAR_1_3_VSS n1121 1.19990975644
C_2_194 n1121 PAR_2_0_VSS 9.05550772579e-11
R_3_194 PAR_1_3_VSS n1122 0.189539890417
C_3_194 n1122 PAR_2_0_VSS 3.73624612237e-09
R_4_194 PAR_1_3_VSS n1123 0.137322840383
C_4_194 n1123 PAR_2_0_VSS 1.13810787358e-08
L_5_194 PAR_1_3_VSS n1124 4.42354153627e-09
R_5_194 n1124 PAR_2_0_VSS 0.89710728706
L_6_194 PAR_1_3_VSS n1125 3.54028282521e-08
R_6_194 n1125 PAR_2_0_VSS 2.39007015465
G0_195 PAR_1_3_VSS PAR_2_0_VDD075CPU PAR_1_3_VSS PAR_2_0_VDD075CPU -0.0946822409661
C0_195 PAR_1_3_VSS PAR_2_0_VDD075CPU 2.09331801671e-10
R_1_195 PAR_1_3_VSS n1126 0.168704463135
C_1_195 n1126 PAR_2_0_VDD075CPU 2.12651422256e-10
R_2_195 PAR_1_3_VSS n1127 0.369349567743
C_2_195 n1127 PAR_2_0_VDD075CPU 2.49710261537e-10
R_3_195 PAR_1_3_VSS n1128 1.31296060812
C_3_195 n1128 PAR_2_0_VDD075CPU 1.91851833603e-10
R_4_195 PAR_1_3_VSS n1129 7.82196170721
C_4_195 n1129 PAR_2_0_VDD075CPU 2.77271450043e-10
L_5_195 PAR_1_3_VSS n1130 8.46825515344e-08
R_5_195 n1130 PAR_2_0_VDD075CPU 10.561642403
R0_196 PAR_1_3_VSS PAR_0_1_VSS 99.5332185535
C0_196 PAR_1_3_VSS PAR_0_1_VSS 1.14089881752e-10
R_1_196 PAR_1_3_VSS n1131 0.23238450857
C_1_196 n1131 PAR_0_1_VSS 5.12154208641e-10
R_2_196 PAR_1_3_VSS n1132 0.0886453632787
C_2_196 n1132 PAR_0_1_VSS 3.76575240092e-09
R_3_196 PAR_1_3_VSS n1133 0.289122655757
C_3_196 n1133 PAR_0_1_VSS 2.94545675799e-09
R_4_196 PAR_1_3_VSS n1134 0.19054085571
C_4_196 n1134 PAR_0_1_VSS 1.76986468044e-08
R_5_196 PAR_1_3_VSS n1135 0.714533049455
C_5_196 n1135 PAR_0_1_VSS 1.82725388262e-08
G0_197 PAR_1_3_VSS PAR_0_1_VDD075CPU PAR_1_3_VSS PAR_0_1_VDD075CPU -0.0676683020442
C0_197 PAR_1_3_VSS PAR_0_1_VDD075CPU 1.53450572312e-10
R_1_197 PAR_1_3_VSS n1136 0.198552173517
C_1_197 n1136 PAR_0_1_VDD075CPU 1.81047115329e-10
R_2_197 PAR_1_3_VSS n1137 0.629386127638
C_2_197 n1137 PAR_0_1_VDD075CPU 1.46993234079e-10
R_3_197 PAR_1_3_VSS n1138 2.52079642254
C_3_197 n1138 PAR_0_1_VDD075CPU 9.864600114e-11
R_4_197 PAR_1_3_VSS n1139 9.18311499236
C_4_197 n1139 PAR_0_1_VDD075CPU 2.18444630578e-10
L_5_197 PAR_1_3_VSS n1140 1.16337182917e-07
R_5_197 n1140 PAR_0_1_VDD075CPU 14.7779673718
G0_198 PAR_1_3_VSS PAR_1_1_VSS PAR_1_3_VSS PAR_1_1_VSS -0.0367220833258
C0_198 PAR_1_3_VSS PAR_1_1_VSS 1.24225972154e-10
R_1_198 PAR_1_3_VSS n1141 0.31454937561
C_1_198 n1141 PAR_1_1_VSS 1.1573458894e-10
R_2_198 PAR_1_3_VSS n1142 3.89436820043
C_2_198 n1142 PAR_1_1_VSS 2.87538540821e-11
R_3_198 PAR_1_3_VSS n1143 4.54448694863
C_3_198 n1143 PAR_1_1_VSS 6.40262654352e-11
R_4_198 PAR_1_3_VSS n1144 14.8163572025
C_4_198 n1144 PAR_1_1_VSS 1.3029340783e-10
L_5_198 PAR_1_3_VSS n1145 2.06400996062e-07
R_5_198 n1145 PAR_1_1_VSS 25.8370162202
G0_199 PAR_1_3_VSS PAR_1_1_VDD075CPU PAR_1_3_VSS PAR_1_1_VDD075CPU -0.0458489744278
C0_199 PAR_1_3_VSS PAR_1_1_VDD075CPU 1.29526986899e-10
R_1_199 PAR_1_3_VSS n1146 0.291731195745
C_1_199 n1146 PAR_1_1_VDD075CPU 1.21329153207e-10
R_2_199 PAR_1_3_VSS n1147 1.22990749965
C_2_199 n1147 PAR_1_1_VDD075CPU 7.25458181551e-11
R_3_199 PAR_1_3_VSS n1148 2.81561021617
C_3_199 n1148 PAR_1_1_VDD075CPU 9.30946711852e-11
R_4_199 PAR_1_3_VSS n1149 11.3124665628
C_4_199 n1149 PAR_1_1_VDD075CPU 1.5998101083e-10
L_5_199 PAR_1_3_VSS n1150 1.8095676939e-07
R_5_199 n1150 PAR_1_1_VDD075CPU 21.8107374234
R0_200 PAR_1_3_VSS PAR_2_1_VSS 2.49963126697
C0_200 PAR_1_3_VSS PAR_2_1_VSS 1.57081504827e-10
R_1_200 PAR_1_3_VSS n1151 0.276906799635
C_1_200 n1151 PAR_2_1_VSS 1.33958954092e-10
R_2_200 PAR_1_3_VSS n1152 1.8129342286
C_2_200 n1152 PAR_2_1_VSS 1.06883711383e-10
R_3_200 PAR_1_3_VSS n1153 0.271675594089
C_3_200 n1153 PAR_2_1_VSS 1.59317307664e-09
L_4_200 PAR_1_3_VSS n1154 4.04455846438e-09
R_4_200 n1154 PAR_2_1_VSS 2.60712263713
L_5_200 PAR_1_3_VSS n1155 8.08127425436e-09
R_5_200 n1155 PAR_2_1_VSS 1.8814671179
L_6_200 PAR_1_3_VSS n1156 1.022646296e-07
R_6_200 n1156 PAR_2_1_VSS 7.07350099665
G0_201 PAR_1_3_VSS PAR_2_1_VDD075CPU PAR_1_3_VSS PAR_2_1_VDD075CPU -0.0557780995941
C0_201 PAR_1_3_VSS PAR_2_1_VDD075CPU 1.52349526234e-10
R_1_201 PAR_1_3_VSS n1157 0.230729114111
C_1_201 n1157 PAR_2_1_VDD075CPU 1.96591694533e-10
R_2_201 PAR_1_3_VSS n1158 0.63899072508
C_2_201 n1158 PAR_2_1_VDD075CPU 2.0505013255e-10
R_3_201 PAR_1_3_VSS n1159 11.3637114864
C_3_201 n1159 PAR_2_1_VDD075CPU 2.8149551039e-10
L_4_201 PAR_1_3_VSS n1160 2.52303492861e-07
R_4_201 n1160 PAR_2_1_VDD075CPU 17.9281825426
R0_202 PAR_1_3_VSS PAR_0_2_VSS 0.508940399129
C0_202 PAR_1_3_VSS PAR_0_2_VSS 1.48995898452e-10
L_1_202 PAR_1_3_VSS n1161 4.24239818794e-12
R_1_202 n1161 PAR_0_2_VSS 0.165047859328
R_2_202 PAR_1_3_VSS n1162 0.173084762147
C_2_202 n1162 PAR_0_2_VSS 7.60615731882e-10
R_3_202 PAR_1_3_VSS n1163 0.0992516018258
C_3_202 n1163 PAR_0_2_VSS 3.96866096203e-09
R_4_202 PAR_1_3_VSS n1164 0.398846754279
C_4_202 n1164 PAR_0_2_VSS 3.30696470664e-09
R_5_202 PAR_1_3_VSS n1165 0.22474385364
C_5_202 n1165 PAR_0_2_VSS 1.70229520096e-08
R_6_202 PAR_1_3_VSS n1166 0.849802720883
C_6_202 n1166 PAR_0_2_VSS 1.58027450735e-08
G0_203 PAR_1_3_VSS PAR_0_2_VDD075CPU PAR_1_3_VSS PAR_0_2_VDD075CPU -0.232604466056
C0_203 PAR_1_3_VSS PAR_0_2_VDD075CPU 1.75891010843e-10
R_1_203 PAR_1_3_VSS n1167 0.100399709687
C_1_203 n1167 PAR_0_2_VDD075CPU 3.92869794442e-10
R_2_203 PAR_1_3_VSS n1168 0.809896028577
C_2_203 n1168 PAR_0_2_VDD075CPU 1.50864767761e-10
R_3_203 PAR_1_3_VSS n1169 12.0602709157
C_3_203 n1169 PAR_0_2_VDD075CPU 3.78479150635e-11
R_4_203 PAR_1_3_VSS n1170 4.12402787717
C_4_203 n1170 PAR_0_2_VDD075CPU 9.20598250896e-10
L_5_203 PAR_1_3_VSS n1171 2.32950683197e-08
R_5_203 n1171 PAR_0_2_VDD075CPU 4.29914354089
R0_204 PAR_1_3_VSS PAR_1_2_VSS 0.00746474964779
C0_204 PAR_1_3_VSS PAR_1_2_VSS 6.15999751368e-11
L_1_204 PAR_1_3_VSS n1172 5.6203216904e-13
R_1_204 n1172 PAR_1_2_VSS 0.0138839187466
L_2_204 PAR_1_3_VSS n1173 5.61601389798e-11
R_2_204 n1173 PAR_1_2_VSS 0.245147825508
R_3_204 PAR_1_3_VSS n1174 0.537114122663
C_3_204 n1174 PAR_1_2_VSS 1.00977628809e-09
L_4_204 PAR_1_3_VSS n1175 3.01946214941e-10
R_4_204 n1175 PAR_1_2_VSS 0.157136123213
L_5_204 PAR_1_3_VSS n1176 6.31916838156e-09
R_5_204 n1176 PAR_1_2_VSS 0.778196400278
G0_205 PAR_1_3_VSS PAR_1_2_VDD075CPU PAR_1_3_VSS PAR_1_2_VDD075CPU -0.0607220865784
C0_205 PAR_1_3_VSS PAR_1_2_VDD075CPU 1.80126944448e-10
R_1_205 PAR_1_3_VSS n1177 0.0100391478389
C_1_205 n1177 PAR_1_2_VDD075CPU 2.95941914493e-09
R_2_205 PAR_1_3_VSS n1178 0.0198635099975
C_2_205 n1178 PAR_1_2_VDD075CPU 2.31793371918e-09
R_3_205 PAR_1_3_VSS n1179 1.36343450947
C_3_205 n1179 PAR_1_2_VDD075CPU 1.68718004536e-10
R_4_205 PAR_1_3_VSS n1180 7.33231099596
C_4_205 n1180 PAR_1_2_VDD075CPU 2.38280499667e-10
L_5_205 PAR_1_3_VSS n1181 1.416935327e-07
R_5_205 n1181 PAR_1_2_VDD075CPU 16.4684716639
R0_206 PAR_1_3_VSS PAR_2_2_VSS 0.638390545383
C0_206 PAR_1_3_VSS PAR_2_2_VSS 1.70072110719e-11
R_1_206 PAR_1_3_VSS n1182 0.307736282051
C_1_206 n1182 PAR_2_2_VSS 2.86156522617e-10
R_2_206 PAR_1_3_VSS n1183 0.200959783867
C_2_206 n1183 PAR_2_2_VSS 2.43250477132e-09
L_3_206 PAR_1_3_VSS n1184 7.09879739995e-10
R_3_206 n1184 PAR_2_2_VSS 0.452098011273
L_4_206 PAR_1_3_VSS n1185 3.1983527778e-09
R_4_206 n1185 PAR_2_2_VSS 0.771947257762
L_5_206 PAR_1_3_VSS n1186 4.91206884598e-08
R_5_206 n1186 PAR_2_2_VSS 3.41535864614
C0_207 PAR_1_3_VSS PAR_2_2_VDD075CPU 2.09415525882e-11
R_1_207 PAR_1_3_VSS n1187 0.835288460953
C_1_207 n1187 PAR_2_2_VDD075CPU 7.38732231836e-11
R_2_207 PAR_1_3_VSS n1188 1315.03560416
C_2_207 n1188 PAR_2_2_VDD075CPU 1.60790924498e-11
R0_208 PAR_1_3_VSS PAR_0_3_VSS 0.00439652877915
L_1_208 PAR_1_3_VSS n1189 3.09384003233e-13
R_1_208 n1189 PAR_0_3_VSS 0.00977685518214
R_2_208 PAR_1_3_VSS n1190 0.0645466623715
C_2_208 n1190 PAR_0_3_VSS 4.52450366289e-09
L_3_208 PAR_1_3_VSS n1191 7.22682656568e-11
R_3_208 n1191 PAR_0_3_VSS 0.143571866495
R_4_208 PAR_1_3_VSS n1192 0.139720331085
C_4_208 n1192 PAR_0_3_VSS 1.44988852421e-08
R_5_208 PAR_1_3_VSS n1193 0.293428262387
C_5_208 n1193 PAR_0_3_VSS 1.6561955315e-08
R_6_208 PAR_1_3_VSS n1194 1.0000230122
C_6_208 n1194 PAR_0_3_VSS 1.46285103779e-08
G0_209 PAR_1_3_VSS PAR_0_3_VDD075CPU PAR_1_3_VSS PAR_0_3_VDD075CPU -0.0318487916914
C0_209 PAR_1_3_VSS PAR_0_3_VDD075CPU 1.39375999235e-10
R_1_209 PAR_1_3_VSS n1195 0.0148250614851
C_1_209 n1195 PAR_0_3_VDD075CPU 2.24760422187e-09
R_2_209 PAR_1_3_VSS n1196 0.265147127284
C_2_209 n1196 PAR_0_3_VDD075CPU 3.46323509887e-10
L_3_209 PAR_1_3_VSS n1197 4.00951022414e-07
R_3_209 n1197 PAR_0_3_VDD075CPU 331.133411008
L_4_209 PAR_1_3_VSS n1198 3.22784647853e-07
R_4_209 n1198 PAR_0_3_VDD075CPU 34.6874581126
R0_210 PAR_1_3_VSS PAR_0_0_VSS 126.454410783
C0_210 PAR_1_3_VSS PAR_0_0_VSS 1.63724356156e-10
R_1_210 PAR_1_3_VSS n1199 0.0357771923235
C_1_210 n1199 PAR_0_0_VSS 1.54073206094e-09
R_2_210 PAR_1_3_VSS n1200 0.0775200070694
C_2_210 n1200 PAR_0_0_VSS 1.83485270436e-09
R_3_210 PAR_1_3_VSS n1201 0.0568857053181
C_3_210 n1201 PAR_0_0_VSS 6.41825534797e-09
R_4_210 PAR_1_3_VSS n1202 0.188315006209
C_4_210 n1202 PAR_0_0_VSS 6.68116243478e-09
R_5_210 PAR_1_3_VSS n1203 0.0626935740551
C_5_210 n1203 PAR_0_0_VSS 4.01445201806e-08
R_6_210 PAR_1_3_VSS n1204 1.84276337478
C_6_210 n1204 PAR_0_0_VSS 6.78994965234e-09
G0_211 PAR_1_3_VDD075CPU PAR_0_0_VDD075CPU PAR_1_3_VDD075CPU PAR_0_0_VDD075CPU -6.76022723786
C0_211 PAR_1_3_VDD075CPU PAR_0_0_VDD075CPU 1.167749708e-10
R_1_211 PAR_1_3_VDD075CPU n1205 0.280959572497
C_1_211 n1205 PAR_0_0_VDD075CPU 1.34004837716e-10
L_2_211 PAR_1_3_VDD075CPU n1206 1.50501699091e-11
R_2_211 n1206 PAR_0_0_VDD075CPU 0.178819283693
R_3_211 PAR_1_3_VDD075CPU n1207 0.359484847758
C_3_211 n1207 PAR_0_0_VDD075CPU 4.1864071567e-10
L_4_211 PAR_1_3_VDD075CPU n1208 3.60518675956e-10
R_4_211 n1208 PAR_0_0_VDD075CPU 1.00996657524
R_5_211 PAR_1_3_VDD075CPU n1209 2.53170955554
C_5_211 n1209 PAR_0_0_VDD075CPU 4.13151598252e-10
L_6_211 PAR_1_3_VDD075CPU n1210 1.67145415977e-08
R_6_211 n1210 PAR_0_0_VDD075CPU 5.6185255675
R_7_211 PAR_1_3_VDD075CPU n1211 41.2407209752
C_7_211 n1211 PAR_0_0_VDD075CPU 3.23353189027e-10
G0_212 PAR_1_3_VDD075CPU PAR_1_0_VSS PAR_1_3_VDD075CPU PAR_1_0_VSS -0.405138231726
C0_212 PAR_1_3_VDD075CPU PAR_1_0_VSS 1.6335130063e-10
R_1_212 PAR_1_3_VDD075CPU n1212 0.199985304206
C_1_212 n1212 PAR_1_0_VSS 1.43026325017e-10
R_2_212 PAR_1_3_VDD075CPU n1213 1.85073934605
C_2_212 n1213 PAR_1_0_VSS 6.01621834139e-11
L_3_212 PAR_1_3_VDD075CPU n1214 1.02431847558e-09
R_3_212 n1214 PAR_1_0_VSS 3.03404971765
L_4_212 PAR_1_3_VDD075CPU n1215 2.42284142731e-08
R_4_212 n1215 PAR_1_0_VSS 15.1323821405
L_5_212 PAR_1_3_VDD075CPU n1216 9.7384860015e-07
R_5_212 n1216 PAR_1_0_VSS 107.664582456
L_6_212 PAR_1_3_VDD075CPU n1217 0.00130229917278
R_6_212 n1217 PAR_1_0_VSS 5740.84874774
G0_213 PAR_1_3_VDD075CPU PAR_1_0_VDD075CPU PAR_1_3_VDD075CPU PAR_1_0_VDD075CPU -4.42299741746
C0_213 PAR_1_3_VDD075CPU PAR_1_0_VDD075CPU 1.30949751448e-10
R_1_213 PAR_1_3_VDD075CPU n1218 0.326608459244
C_1_213 n1218 PAR_1_0_VDD075CPU 6.96817185086e-11
L_2_213 PAR_1_3_VDD075CPU n1219 1.6565340854e-11
R_2_213 n1219 PAR_1_0_VDD075CPU 0.275404600941
R_3_213 PAR_1_3_VDD075CPU n1220 0.985881789923
C_3_213 n1220 PAR_1_0_VDD075CPU 1.18456989191e-10
L_4_213 PAR_1_3_VDD075CPU n1221 3.94578299317e-10
R_4_213 n1221 PAR_1_0_VDD075CPU 1.49225139452
R_5_213 PAR_1_3_VDD075CPU n1222 3.26327627585
C_5_213 n1222 PAR_1_0_VDD075CPU 1.59645633825e-10
L_6_213 PAR_1_3_VDD075CPU n1223 1.43048930684e-08
R_6_213 n1223 PAR_1_0_VDD075CPU 9.19671429193
R_7_213 PAR_1_3_VDD075CPU n1224 24.7118114834
C_7_213 n1224 PAR_1_0_VDD075CPU 1.960148206e-10
L_8_213 PAR_1_3_VDD075CPU n1225 1.17995104664e-06
R_8_213 n1225 PAR_1_0_VDD075CPU 76.9450682322
G0_214 PAR_1_3_VDD075CPU PAR_2_0_VSS PAR_1_3_VDD075CPU PAR_2_0_VSS -0.431252454154
C0_214 PAR_1_3_VDD075CPU PAR_2_0_VSS 1.89450646432e-10
R_1_214 PAR_1_3_VDD075CPU n1226 0.703199013995
C_1_214 n1226 PAR_2_0_VSS 3.93676711736e-11
L_2_214 PAR_1_3_VDD075CPU n1227 2.49204111163e-10
R_2_214 n1227 PAR_2_0_VSS 2.90188668848
R_3_214 PAR_1_3_VDD075CPU n1228 5.45075274918
C_3_214 n1228 PAR_2_0_VSS 2.82668495503e-11
R_4_214 PAR_1_3_VDD075CPU n1229 7.60730881705
C_4_214 n1229 PAR_2_0_VSS 6.36408276295e-11
L_5_214 PAR_1_3_VDD075CPU n1230 2.27847116638e-08
R_5_214 n1230 PAR_2_0_VSS 12.8338162283
L_6_214 PAR_1_3_VDD075CPU n1231 1.25693151443e-06
R_6_214 n1231 PAR_2_0_VSS 114.548622132
G0_215 PAR_1_3_VDD075CPU PAR_2_0_VDD075CPU PAR_1_3_VDD075CPU PAR_2_0_VDD075CPU -4.18510622162
C0_215 PAR_1_3_VDD075CPU PAR_2_0_VDD075CPU 1.41902127468e-10
R_1_215 PAR_1_3_VDD075CPU n1232 0.309609636223
C_1_215 n1232 PAR_2_0_VDD075CPU 7.541624356e-11
L_2_215 PAR_1_3_VDD075CPU n1233 1.62978514238e-11
R_2_215 n1233 PAR_2_0_VDD075CPU 0.277747807969
R_3_215 PAR_1_3_VDD075CPU n1234 1.36866213452
C_3_215 n1234 PAR_2_0_VDD075CPU 8.79708667361e-11
L_4_215 PAR_1_3_VDD075CPU n1235 5.63872995928e-10
R_4_215 n1235 PAR_2_0_VDD075CPU 1.93916161568
R_5_215 PAR_1_3_VDD075CPU n1236 4.703092467
C_5_215 n1236 PAR_2_0_VDD075CPU 1.2828529054e-10
L_6_215 PAR_1_3_VDD075CPU n1237 2.98337908633e-08
R_6_215 n1237 PAR_2_0_VDD075CPU 15.2960614383
R_7_215 PAR_1_3_VDD075CPU n1238 83.5699414678
C_7_215 n1238 PAR_2_0_VDD075CPU 1.21553918677e-10
L_8_215 PAR_1_3_VDD075CPU n1239 2.29695103036e-05
R_8_215 n1239 PAR_2_0_VDD075CPU 274.328016949
G0_216 PAR_1_3_VDD075CPU PAR_0_1_VSS PAR_1_3_VDD075CPU PAR_0_1_VSS -0.2423650587
C0_216 PAR_1_3_VDD075CPU PAR_0_1_VSS 1.59192563975e-10
R_1_216 PAR_1_3_VDD075CPU n1240 0.139667595161
C_1_216 n1240 PAR_0_1_VSS 1.97805002414e-10
R_2_216 PAR_1_3_VDD075CPU n1241 0.797648775411
C_2_216 n1241 PAR_0_1_VSS 8.04259651492e-11
L_3_216 PAR_1_3_VDD075CPU n1242 1.86224427813e-09
R_3_216 n1242 PAR_0_1_VSS 4.12600724927
R_4_216 PAR_1_3_VDD075CPU n1243 36.9879979105
C_4_216 n1243 PAR_0_1_VSS 2.44364076202e-10
G0_217 PAR_1_3_VDD075CPU PAR_0_1_VDD075CPU PAR_1_3_VDD075CPU PAR_0_1_VDD075CPU -4.19772610484
C0_217 PAR_1_3_VDD075CPU PAR_0_1_VDD075CPU 1.02009393901e-10
R_1_217 PAR_1_3_VDD075CPU n1244 0.309220624397
C_1_217 n1244 PAR_0_1_VDD075CPU 9.19329119435e-11
L_2_217 PAR_1_3_VDD075CPU n1245 1.54678444188e-11
R_2_217 n1245 PAR_0_1_VDD075CPU 0.269285576986
R_3_217 PAR_1_3_VDD075CPU n1246 1.28939674824
C_3_217 n1246 PAR_0_1_VDD075CPU 9.36864278113e-11
L_4_217 PAR_1_3_VDD075CPU n1247 7.01357443433e-10
R_4_217 n1247 PAR_0_1_VDD075CPU 2.35712348311
R_5_217 PAR_1_3_VDD075CPU n1248 5.49066140705
C_5_217 n1248 PAR_0_1_VDD075CPU 1.20382851101e-10
L_6_217 PAR_1_3_VDD075CPU n1249 3.32778427136e-08
R_6_217 n1249 PAR_0_1_VDD075CPU 16.7341080488
R_7_217 PAR_1_3_VDD075CPU n1250 163.793019664
C_7_217 n1250 PAR_0_1_VDD075CPU 6.66151336268e-11
G0_218 PAR_1_3_VDD075CPU PAR_1_1_VSS PAR_1_3_VDD075CPU PAR_1_1_VSS -3.48709236
C0_218 PAR_1_3_VDD075CPU PAR_1_1_VSS 7.91799171317e-11
R_1_218 PAR_1_3_VDD075CPU n1251 0.42087130552
C_1_218 n1251 PAR_1_1_VSS 3.14625354888e-11
L_2_218 PAR_1_3_VDD075CPU n1252 1.48152160614e-11
R_2_218 n1252 PAR_1_1_VSS 0.337366766724
R_3_218 PAR_1_3_VDD075CPU n1253 1.09682654829
C_3_218 n1253 PAR_1_1_VSS 7.03676841092e-11
L_4_218 PAR_1_3_VDD075CPU n1254 3.72119867362e-10
R_4_218 n1254 PAR_1_1_VSS 2.41088313391
R_5_218 PAR_1_3_VDD075CPU n1255 6.09695592033
C_5_218 n1255 PAR_1_1_VSS 5.39681854823e-11
L_6_218 PAR_1_3_VDD075CPU n1256 6.67898832016e-09
R_6_218 n1256 PAR_1_1_VSS 10.4419601771
R_7_218 PAR_1_3_VDD075CPU n1257 29.5885745328
C_7_218 n1257 PAR_1_1_VSS 5.14707607079e-11
L_8_218 PAR_1_3_VDD075CPU n1258 3.24538154758e-07
R_8_218 n1258 PAR_1_1_VSS 80.6058984865
R_9_218 PAR_1_3_VDD075CPU n1259 651.534572236
C_9_218 n1259 PAR_1_1_VSS 2.18765953984e-11
G0_219 PAR_1_3_VDD075CPU PAR_1_1_VDD075CPU PAR_1_3_VDD075CPU PAR_1_1_VDD075CPU -2.6659855136
C0_219 PAR_1_3_VDD075CPU PAR_1_1_VDD075CPU 8.53257297157e-11
R_1_219 PAR_1_3_VDD075CPU n1260 0.491556558623
C_1_219 n1260 PAR_1_1_VDD075CPU 2.89125148234e-11
L_2_219 PAR_1_3_VDD075CPU n1261 2.14414234657e-11
R_2_219 n1261 PAR_1_1_VDD075CPU 0.439544928118
R_3_219 PAR_1_3_VDD075CPU n1262 1.96664939807
C_3_219 n1262 PAR_1_1_VDD075CPU 5.03786162376e-11
L_4_219 PAR_1_3_VDD075CPU n1263 5.69160532012e-10
R_4_219 n1263 PAR_1_1_VDD075CPU 2.88828321342
R_5_219 PAR_1_3_VDD075CPU n1264 9.16978414915
C_5_219 n1264 PAR_1_1_VDD075CPU 4.28581479347e-11
L_6_219 PAR_1_3_VDD075CPU n1265 2.88576220946e-08
R_6_219 n1265 PAR_1_1_VDD075CPU 24.5117861555
R_7_219 PAR_1_3_VDD075CPU n1266 70.9282448385
C_7_219 n1266 PAR_1_1_VDD075CPU 4.57849263885e-11
L_8_219 PAR_1_3_VDD075CPU n1267 3.31463180028e-06
R_8_219 n1267 PAR_1_1_VDD075CPU 242.640576171
G0_220 PAR_1_3_VDD075CPU PAR_2_1_VSS PAR_1_3_VDD075CPU PAR_2_1_VSS -1.4275317294
C0_220 PAR_1_3_VDD075CPU PAR_2_1_VSS 1.14757611772e-10
R_1_220 PAR_1_3_VDD075CPU n1268 1.24179051664
C_1_220 n1268 PAR_2_1_VSS 2.09636020787e-11
L_2_220 PAR_1_3_VDD075CPU n1269 8.22434191934e-11
R_2_220 n1269 PAR_2_1_VSS 1.08316769848
R_3_220 PAR_1_3_VDD075CPU n1270 2.18186300159
C_3_220 n1270 PAR_2_1_VSS 1.22037063942e-10
L_4_220 PAR_1_3_VDD075CPU n1271 1.16831174128e-09
R_4_220 n1271 PAR_2_1_VSS 2.34673219678
R_5_220 PAR_1_3_VDD075CPU n1272 6.6112638763
C_5_220 n1272 PAR_2_1_VSS 2.22668952269e-10
L_6_220 PAR_1_3_VDD075CPU n1273 5.41508600184e-08
R_6_220 n1273 PAR_2_1_VSS 12.7894916823
R_7_220 PAR_1_3_VDD075CPU n1274 78.9764771163
C_7_220 n1274 PAR_2_1_VSS 1.81003956179e-10
G0_221 PAR_1_3_VDD075CPU PAR_2_1_VDD075CPU PAR_1_3_VDD075CPU PAR_2_1_VDD075CPU -2.77362893107
C0_221 PAR_1_3_VDD075CPU PAR_2_1_VDD075CPU 9.68896162338e-11
R_1_221 PAR_1_3_VDD075CPU n1275 0.436866245356
C_1_221 n1275 PAR_2_1_VDD075CPU 5.6584149605e-11
L_2_221 PAR_1_3_VDD075CPU n1276 2.37445484859e-11
R_2_221 n1276 PAR_2_1_VDD075CPU 0.404525818923
R_3_221 PAR_1_3_VDD075CPU n1277 2.68238592853
C_3_221 n1277 PAR_2_1_VDD075CPU 4.5106710201e-11
L_4_221 PAR_1_3_VDD075CPU n1278 1.26138607633e-09
R_4_221 n1278 PAR_2_1_VDD075CPU 3.98264269991
R_5_221 PAR_1_3_VDD075CPU n1279 9.58803808595
C_5_221 n1279 PAR_2_1_VDD075CPU 9.11789630896e-11
L_6_221 PAR_1_3_VDD075CPU n1280 5.00157490907e-08
R_6_221 n1280 PAR_2_1_VDD075CPU 20.4332469786
R_7_221 PAR_1_3_VDD075CPU n1281 133.337940002
C_7_221 n1281 PAR_2_1_VDD075CPU 9.18794558702e-11
L_8_221 PAR_1_3_VDD075CPU n1282 0.000441271408254
R_8_221 n1282 PAR_2_1_VDD075CPU 633.008128784
G0_222 PAR_1_3_VDD075CPU PAR_0_2_VSS PAR_1_3_VDD075CPU PAR_0_2_VSS -0.229888573048
C0_222 PAR_1_3_VDD075CPU PAR_0_2_VSS 1.56785141387e-10
R_1_222 PAR_1_3_VDD075CPU n1283 0.116310084219
C_1_222 n1283 PAR_0_2_VSS 2.79796374344e-10
R_2_222 PAR_1_3_VDD075CPU n1284 1.08366513475
C_2_222 n1284 PAR_0_2_VSS 5.88180902315e-11
L_3_222 PAR_1_3_VDD075CPU n1285 1.86803646472e-09
R_3_222 n1285 PAR_0_2_VSS 4.6075940567
L_4_222 PAR_1_3_VDD075CPU n1286 1.97719899215e-07
R_4_222 n1286 PAR_0_2_VSS 77.7873097577
R_5_222 PAR_1_3_VDD075CPU n1287 29.7077566079
C_5_222 n1287 PAR_0_2_VSS 2.50404078764e-10
R0_223 PAR_1_3_VDD075CPU PAR_0_2_VDD075CPU 0.393186324355
C0_223 PAR_1_3_VDD075CPU PAR_0_2_VDD075CPU 1.46132748874e-10
L_1_223 PAR_1_3_VDD075CPU n1288 8.44817672378e-12
R_1_223 n1288 PAR_0_2_VDD075CPU 0.22351302258
L_2_223 PAR_1_3_VDD075CPU n1289 9.01495870317e-11
R_2_223 n1289 PAR_0_2_VDD075CPU 1.2126962109
L_3_223 PAR_1_3_VDD075CPU n1290 1.49589682049e-09
R_3_223 n1290 PAR_0_2_VDD075CPU 8.8984974188
L_4_223 PAR_1_3_VDD075CPU n1291 3.07212801891e-08
R_4_223 n1291 PAR_0_2_VDD075CPU 64.6452338128
L_5_223 PAR_1_3_VDD075CPU n1292 1.33449605725e-06
R_5_223 n1292 PAR_0_2_VDD075CPU 510.584668551
L_6_223 PAR_1_3_VDD075CPU n1293 0.000180210870759
R_6_223 n1293 PAR_0_2_VDD075CPU 3977.03284009
G0_224 PAR_1_3_VDD075CPU PAR_1_2_VSS PAR_1_3_VDD075CPU PAR_1_2_VSS -0.263290696223
C0_224 PAR_1_3_VDD075CPU PAR_1_2_VSS 1.21436890656e-10
R_1_224 PAR_1_3_VDD075CPU n1294 0.0271215412552
C_1_224 n1294 PAR_1_2_VSS 1.48032574684e-09
L_2_224 PAR_1_3_VDD075CPU n1295 3.7064698297e-10
R_2_224 n1295 PAR_1_2_VSS 3.90896596122
R_3_224 PAR_1_3_VDD075CPU n1296 77.5765260785
C_3_224 n1296 PAR_1_2_VSS 9.75100446602e-12
L_4_224 PAR_1_3_VDD075CPU n1297 1.28464362594e-06
R_4_224 n1297 PAR_1_2_VSS 133.894476531
R0_225 PAR_1_3_VDD075CPU PAR_1_2_VDD075CPU 0.00816258125167
C0_225 PAR_1_3_VDD075CPU PAR_1_2_VDD075CPU 8.7043621023e-11
L_1_225 PAR_1_3_VDD075CPU n1298 1.25736759207e-12
R_1_225 n1298 PAR_1_2_VDD075CPU 0.0583113922918
L_2_225 PAR_1_3_VDD075CPU n1299 6.54130533944e-13
R_2_225 n1299 PAR_1_2_VDD075CPU 0.0165087299293
L_3_225 PAR_1_3_VDD075CPU n1300 5.02327452706e-10
R_3_225 n1300 PAR_1_2_VDD075CPU 4.17191536395
L_4_225 PAR_1_3_VDD075CPU n1301 1.14181078849e-08
R_4_225 n1301 PAR_1_2_VDD075CPU 31.4731185895
L_5_225 PAR_1_3_VDD075CPU n1302 5.72776475135e-07
R_5_225 n1302 PAR_1_2_VDD075CPU 325.588525774
L_6_225 PAR_1_3_VDD075CPU n1303 9.92603997967e-05
R_6_225 n1303 PAR_1_2_VDD075CPU 4925.51795808
G0_226 PAR_1_3_VDD075CPU PAR_2_2_VSS PAR_1_3_VDD075CPU PAR_2_2_VSS -0.0374184717637
C0_226 PAR_1_3_VDD075CPU PAR_2_2_VSS 2.75858017318e-11
R_1_226 PAR_1_3_VDD075CPU n1304 0.187168877424
C_1_226 n1304 PAR_2_2_VSS 1.15103160107e-10
L_2_226 PAR_1_3_VDD075CPU n1305 2.36360161693e-08
R_2_226 n1305 PAR_2_2_VSS 111.376900584
L_3_226 PAR_1_3_VDD075CPU n1306 4.68863647039e-08
R_3_226 n1306 PAR_2_2_VSS 47.5421305704
L_4_226 PAR_1_3_VDD075CPU n1307 1.25632415382e-06
R_4_226 n1307 PAR_2_2_VSS 135.026085255
G0_227 PAR_1_3_VDD075CPU PAR_2_2_VDD075CPU PAR_1_3_VDD075CPU PAR_2_2_VDD075CPU -0.236380670577
C0_227 PAR_1_3_VDD075CPU PAR_2_2_VDD075CPU 1.72746754093e-11
R_1_227 PAR_1_3_VDD075CPU n1308 4.2304643504
C_1_227 n1308 PAR_2_2_VDD075CPU 4.80421793914e-12
L_2_227 PAR_1_3_VDD075CPU n1309 3.57000535168e-10
R_2_227 n1309 PAR_2_2_VDD075CPU 4.59162560944
L_3_227 PAR_1_3_VDD075CPU n1310 1.0602416379e-08
R_3_227 n1310 PAR_2_2_VDD075CPU 61.8672818169
L_4_227 PAR_1_3_VDD075CPU n1311 2.15728042726e-07
R_4_227 n1311 PAR_2_2_VDD075CPU 447.341348073
L_5_227 PAR_1_3_VDD075CPU n1312 1.78890715672e-05
R_5_227 n1312 PAR_2_2_VDD075CPU 5695.11071761
G0_228 PAR_1_3_VDD075CPU PAR_0_3_VSS PAR_1_3_VDD075CPU PAR_0_3_VSS -0.03112948025
C0_228 PAR_1_3_VDD075CPU PAR_0_3_VSS 1.89398037872e-10
R_1_228 PAR_1_3_VDD075CPU n1313 0.00862565939458
C_1_228 n1313 PAR_0_3_VSS 2.56512195566e-09
R_2_228 PAR_1_3_VDD075CPU n1314 0.0174866186031
C_2_228 n1314 PAR_0_3_VSS 2.41504679093e-09
R_3_228 PAR_1_3_VDD075CPU n1315 1.9882467211
C_3_228 n1315 PAR_0_3_VSS 7.79886563205e-11
L_4_228 PAR_1_3_VDD075CPU n1316 4.38929487849e-08
R_4_228 n1316 PAR_0_3_VSS 32.1238872372
R_5_228 PAR_1_3_VDD075CPU n1317 34.1442895831
C_5_228 n1317 PAR_0_3_VSS 2.51822402618e-10
R0_229 PAR_1_3_VDD075CPU PAR_0_3_VDD075CPU 0.00494720058231
C0_229 PAR_1_3_VDD075CPU PAR_0_3_VDD075CPU 4.14819886507e-11
L_1_229 PAR_1_3_VDD075CPU n1318 3.8471993067e-13
R_1_229 n1318 PAR_0_3_VDD075CPU 0.0168900839414
L_2_229 PAR_1_3_VDD075CPU n1319 8.35396696058e-13
R_2_229 n1319 PAR_0_3_VDD075CPU 0.0206761766957
L_3_229 PAR_1_3_VDD075CPU n1320 3.13903115039e-10
R_3_229 n1320 PAR_0_3_VDD075CPU 2.50676694137
L_4_229 PAR_1_3_VDD075CPU n1321 7.80018455358e-09
R_4_229 n1321 PAR_0_3_VDD075CPU 24.9880932571
L_5_229 PAR_1_3_VDD075CPU n1322 4.53865976114e-07
R_5_229 n1322 PAR_0_3_VDD075CPU 372.842019837
L_6_229 PAR_1_3_VDD075CPU n1323 1.39985286656e-05
R_6_229 n1323 PAR_0_3_VDD075CPU 1820.87855404
G0_230 PAR_1_3_VDD075CPU PAR_1_3_VSS PAR_1_3_VDD075CPU PAR_1_3_VSS -0.0319825071506
R_1_230 PAR_1_3_VDD075CPU n1324 0.000759917038625
C_1_230 n1324 PAR_1_3_VSS 2.36097191315e-08
R_2_230 PAR_1_3_VDD075CPU n1325 0.000636873758641
C_2_230 n1325 PAR_1_3_VSS 5.93842474675e-08
R_3_230 PAR_1_3_VDD075CPU n1326 0.178529750752
C_3_230 n1326 PAR_1_3_VSS 5.64595506606e-10
R_4_230 PAR_1_3_VDD075CPU n1327 0.642503674096
C_4_230 n1327 PAR_1_3_VSS 5.45795763748e-10
R_5_230 PAR_1_3_VDD075CPU n1328 4.67210636348
C_5_230 n1328 PAR_1_3_VSS 3.11393579858e-10
L_6_230 PAR_1_3_VDD075CPU n1329 3.33610082668e-07
R_6_230 n1329 PAR_1_3_VSS 31.2670895547
G0_231 PAR_1_3_VDD075CPU PAR_0_0_VSS PAR_1_3_VDD075CPU PAR_0_0_VSS -2.67367634653
C0_231 PAR_1_3_VDD075CPU PAR_0_0_VSS 2.29210548948e-10
R_1_231 PAR_1_3_VDD075CPU n1330 0.0206473420835
C_1_231 n1330 PAR_0_0_VSS 9.04376991514e-10
L_2_231 PAR_1_3_VDD075CPU n1331 4.29711076081e-11
R_2_231 n1331 PAR_0_0_VSS 0.474651414194
L_3_231 PAR_1_3_VDD075CPU n1332 5.68216420223e-10
R_3_231 n1332 PAR_0_0_VSS 1.76408198463
R_4_231 PAR_1_3_VDD075CPU n1333 20.3173875792
C_4_231 n1333 PAR_0_0_VSS 3.5610039915e-11
R_5_231 PAR_1_3_VDD075CPU n1334 214.37327046
C_5_231 n1334 PAR_0_0_VSS 7.6046097436e-11
.ENDS
