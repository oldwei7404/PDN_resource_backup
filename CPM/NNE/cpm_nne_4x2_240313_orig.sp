********************************************
* Ansys RedHawk-SC Chip Power Model [ Ver 2.00 ]
* Generated at Mar 08 11:59:16 2024
* Version: 2023 R1.2p1  RHEL7 (Mar 21 00:06:37 2023)
* Run directory:  /fs/mm_imp48/MM/PI/R0.7/RedHawk-SC/03_240203_wDFT_for_STAPI/MAMMOTH/v2023_R1.3_20230801/CPM_VDD075NNE_4x2_Flat/gp/asim_power_scratch.gv_rmv.240308033705.0j356unl
* CPM Options:
* perform powermodel -nx 4 -ny 2 -no_afs -noglobal_gnd -pincurrent -emi -plocnames
* Copyright (c) 2002-2023 ANSYS, Inc.
* Presimulation time  0.000000ps
********************************************

* Partitioning of flip chip bump pad area - Die Top View
* ------------------------------------
* | (0 Ny) | (1 Ny) | .... | (Nx Ny) |
* ------------------------------------
* | (0 ..) | (1 ..) | .... | (Nx ..) |
* ------------------------------------
* | (0  1) | (1  1) | .... | (Nx  1) |
* ------------------------------------
* | (0  0) | (1  0) | .... | (Nx  0) |
* ------------------------------------
* Begin Chip Package Protocol --->

* Start Units
*   Length um
* End Units
* VDD075NNE_02114	 :   (2172.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02106	 :   (700.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02107	 :   (884.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02108	 :   (1068.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02109	 :   (1252.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02110	 :   (1436.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02111	 :   (1620.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02112	 :   (1804.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02113	 :   (1988.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02105	 :   (516.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02115	 :   (2356.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02116	 :   (2540.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01456	 :   (148.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01457	 :   (332.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01458	 :   (516.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01459	 :   (700.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01460	 :   (884.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01461	 :   (1068.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01946	 :   (1068.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01954	 :   (2540.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01953	 :   (2356.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01952	 :   (2172.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01951	 :   (1988.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01950	 :   (1804.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01949	 :   (1620.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01948	 :   (1436.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01947	 :   (1252.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01462	 :   (1252.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01945	 :   (884.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01944	 :   (700.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01943	 :   (516.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01942	 :   (332.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01941	 :   (148.000000 4230.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02103	 :   (148.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02104	 :   (332.000000 3678.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02161	 :   (884.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01466	 :   (1988.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01467	 :   (2172.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01468	 :   (2356.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01469	 :   (2540.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02157	 :   (148.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02158	 :   (332.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02159	 :   (516.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02160	 :   (700.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01465	 :   (1804.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02162	 :   (1068.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02163	 :   (1252.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02164	 :   (1436.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02165	 :   (1620.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02166	 :   (1804.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02167	 :   (1988.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02168	 :   (2172.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02169	 :   (2356.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01893	 :   (1252.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01463	 :   (1436.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01900	 :   (2540.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01899	 :   (2356.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01898	 :   (2172.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01897	 :   (1988.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01896	 :   (1804.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01895	 :   (1620.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01894	 :   (1436.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01415	 :   (2540.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01892	 :   (1068.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01891	 :   (884.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01890	 :   (700.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01889	 :   (516.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01888	 :   (332.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01887	 :   (148.000000 4414.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01464	 :   (1620.000000 5886.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01359	 :   (2172.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02000	 :   (1068.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01999	 :   (884.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01998	 :   (700.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01997	 :   (516.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01996	 :   (332.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01995	 :   (148.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01357	 :   (1804.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01358	 :   (1988.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02001	 :   (1252.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01360	 :   (2356.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01361	 :   (2540.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01307	 :   (2540.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01306	 :   (2356.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01305	 :   (2172.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01304	 :   (1988.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01303	 :   (1804.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01302	 :   (1620.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01355	 :   (1436.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02002	 :   (1436.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02003	 :   (1620.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02004	 :   (1804.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02005	 :   (1988.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02006	 :   (2172.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02007	 :   (2356.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02008	 :   (2540.000000 4046.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01356	 :   (1620.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01301	 :   (1436.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01354	 :   (1252.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01353	 :   (1068.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01352	 :   (884.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01351	 :   (700.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01350	 :   (516.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01349	 :   (332.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01348	 :   (148.000000 6254.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01406	 :   (884.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02059	 :   (1988.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02060	 :   (2172.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02061	 :   (2356.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02062	 :   (2540.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01402	 :   (148.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01403	 :   (332.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01404	 :   (516.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01405	 :   (700.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02058	 :   (1804.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01407	 :   (1068.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01408	 :   (1252.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01409	 :   (1436.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01410	 :   (1620.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01411	 :   (1804.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01412	 :   (1988.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01413	 :   (2172.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01414	 :   (2356.000000 6070.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02050	 :   (332.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01300	 :   (1252.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01299	 :   (1068.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01298	 :   (884.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01297	 :   (700.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01296	 :   (516.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01295	 :   (332.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01294	 :   (148.000000 6438.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02049	 :   (148.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01510	 :   (148.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02051	 :   (516.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02052	 :   (700.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02053	 :   (884.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02054	 :   (1068.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02055	 :   (1252.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02056	 :   (1436.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02057	 :   (1620.000000 3862.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01620	 :   (516.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01784	 :   (1068.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01783	 :   (884.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01782	 :   (700.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01781	 :   (516.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01780	 :   (332.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01779	 :   (148.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01618	 :   (148.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01619	 :   (332.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01785	 :   (1252.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01621	 :   (700.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01622	 :   (884.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01623	 :   (1068.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01624	 :   (1252.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01625	 :   (1436.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01626	 :   (1620.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01627	 :   (1804.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01628	 :   (1988.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01786	 :   (1436.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01787	 :   (1620.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01788	 :   (1804.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01789	 :   (1988.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01790	 :   (2172.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01791	 :   (2356.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01792	 :   (2540.000000 4782.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01577	 :   (2540.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01576	 :   (2356.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01575	 :   (2172.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01574	 :   (1988.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01573	 :   (1804.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01572	 :   (1620.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02224	 :   (2540.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02223	 :   (2356.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01726	 :   (332.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01685	 :   (2540.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01684	 :   (2356.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01683	 :   (2172.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01682	 :   (1988.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01681	 :   (1804.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01680	 :   (1620.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01679	 :   (1436.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01678	 :   (1252.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01677	 :   (1068.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01676	 :   (884.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01675	 :   (700.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01674	 :   (516.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01673	 :   (332.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01672	 :   (148.000000 5150.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01725	 :   (148.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01511	 :   (332.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01727	 :   (516.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01728	 :   (700.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01729	 :   (884.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01730	 :   (1068.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01731	 :   (1252.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01732	 :   (1436.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01733	 :   (1620.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01734	 :   (1804.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01735	 :   (1988.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01736	 :   (2172.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01737	 :   (2356.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01738	 :   (2540.000000 4966.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01631	 :   (2540.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01630	 :   (2356.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01629	 :   (2172.000000 5334.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01833	 :   (148.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01841	 :   (1620.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01840	 :   (1436.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01839	 :   (1252.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01838	 :   (1068.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01837	 :   (884.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01836	 :   (700.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01835	 :   (516.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01834	 :   (332.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01842	 :   (1804.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01564	 :   (148.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01565	 :   (332.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01566	 :   (516.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01567	 :   (700.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01568	 :   (884.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01569	 :   (1068.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01570	 :   (1252.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01571	 :   (1436.000000 5518.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01519	 :   (1804.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02170	 :   (2540.000000 3494.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01512	 :   (516.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01513	 :   (700.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01514	 :   (884.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01515	 :   (1068.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01516	 :   (1252.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01517	 :   (1436.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01518	 :   (1620.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02221	 :   (1988.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01520	 :   (1988.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01521	 :   (2172.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01522	 :   (2356.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01523	 :   (2540.000000 5702.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01846	 :   (2540.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01845	 :   (2356.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01844	 :   (2172.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_01843	 :   (1988.000000 4598.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02213	 :   (516.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02211	 :   (148.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02217	 :   (1252.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02218	 :   (1436.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02216	 :   (1068.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02215	 :   (884.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02219	 :   (1620.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02214	 :   (700.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02212	 :   (332.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02220	 :   (1804.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VDD075NNE_02222	 :   (2172.000000 3310.000000)	 :   PAR_0_0_VDD075NNE	  = PAR_0_0_VDD075NNE
* VSS_02851	 :   (4472.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03122	 :   (3552.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03130	 :   (5024.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02854	 :   (5024.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02852	 :   (4656.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03029	 :   (3920.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03030	 :   (4104.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02853	 :   (4840.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03123	 :   (3736.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03035	 :   (5024.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02941	 :   (4656.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02942	 :   (4840.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02943	 :   (5024.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02570	 :   (2632.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02841	 :   (2632.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02842	 :   (2816.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02843	 :   (3000.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02844	 :   (3184.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02845	 :   (3368.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02846	 :   (3552.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02847	 :   (3736.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02848	 :   (3920.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02849	 :   (4104.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02850	 :   (4288.000000 5978.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02936	 :   (3736.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03023	 :   (2816.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03024	 :   (3000.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03025	 :   (3184.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03026	 :   (3368.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02940	 :   (4472.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02939	 :   (4288.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02938	 :   (4104.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02937	 :   (3920.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03022	 :   (2632.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02935	 :   (3552.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03125	 :   (4104.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03124	 :   (3920.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02934	 :   (3368.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02933	 :   (3184.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02932	 :   (3000.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02931	 :   (2816.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02930	 :   (2632.000000 5794.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03027	 :   (3552.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03028	 :   (3736.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03126	 :   (4288.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03127	 :   (4472.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03128	 :   (4656.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03129	 :   (4840.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03117	 :   (2632.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03118	 :   (2816.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03119	 :   (3000.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03120	 :   (3184.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03121	 :   (3368.000000 5426.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03031	 :   (4288.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03032	 :   (4472.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03033	 :   (4656.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03034	 :   (4840.000000 5610.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03790	 :   (3920.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03701	 :   (5024.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04173	 :   (4472.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04172	 :   (4288.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04171	 :   (4104.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04170	 :   (3920.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04169	 :   (3736.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03783	 :   (2632.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03784	 :   (2816.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03785	 :   (3000.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03786	 :   (3184.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03787	 :   (3368.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03788	 :   (3552.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03789	 :   (3736.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03700	 :   (4840.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03791	 :   (4104.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03792	 :   (4288.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03793	 :   (4472.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03794	 :   (4656.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03795	 :   (4840.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03796	 :   (5024.000000 4138.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04168	 :   (3552.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04167	 :   (3368.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04166	 :   (3184.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04165	 :   (3000.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04164	 :   (2816.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02659	 :   (2632.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03878	 :   (2632.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04175	 :   (4840.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03597	 :   (3368.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03598	 :   (3552.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03599	 :   (3736.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03601	 :   (4104.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03602	 :   (4288.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03603	 :   (4472.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03604	 :   (4656.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03605	 :   (4840.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03606	 :   (5024.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04260	 :   (3000.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04259	 :   (2816.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04258	 :   (2632.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04176	 :   (5024.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03879	 :   (2816.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04174	 :   (4656.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03688	 :   (2632.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03689	 :   (2816.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03690	 :   (3000.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03691	 :   (3184.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03692	 :   (3368.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03693	 :   (3552.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03694	 :   (3736.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03695	 :   (3920.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03696	 :   (4104.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03697	 :   (4288.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03698	 :   (4472.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03699	 :   (4656.000000 4322.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04069	 :   (2816.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02670	 :   (4656.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02671	 :   (4840.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02672	 :   (5024.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03978	 :   (3552.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03979	 :   (3736.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03980	 :   (3920.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03981	 :   (4104.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03982	 :   (4288.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03983	 :   (4472.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03984	 :   (4656.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03985	 :   (4840.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03986	 :   (5024.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04068	 :   (2632.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02669	 :   (4472.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04070	 :   (3000.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04071	 :   (3184.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04072	 :   (3368.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04073	 :   (3552.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04074	 :   (3736.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04075	 :   (3920.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04076	 :   (4104.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04077	 :   (4288.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04078	 :   (4472.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04079	 :   (4656.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04080	 :   (4840.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04081	 :   (5024.000000 3586.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04163	 :   (2632.000000 3402.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03974	 :   (2816.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03880	 :   (3000.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03881	 :   (3184.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03882	 :   (3368.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03883	 :   (3552.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03884	 :   (3736.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03885	 :   (3920.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03886	 :   (4104.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03887	 :   (4288.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03888	 :   (4472.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03889	 :   (4656.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03890	 :   (4840.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03891	 :   (5024.000000 3954.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03973	 :   (2632.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03600	 :   (3920.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03975	 :   (3000.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03976	 :   (3184.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03977	 :   (3368.000000 3770.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02660	 :   (2816.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02661	 :   (3000.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02662	 :   (3184.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02663	 :   (3368.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02664	 :   (3552.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02665	 :   (3736.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02666	 :   (3920.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02667	 :   (4104.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02668	 :   (4288.000000 6346.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03403	 :   (2632.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03309	 :   (2632.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03310	 :   (2816.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03311	 :   (3000.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03312	 :   (3184.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03313	 :   (3552.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03314	 :   (3736.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03315	 :   (3920.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03316	 :   (4104.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03317	 :   (4288.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03318	 :   (4472.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03319	 :   (4656.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03320	 :   (4840.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03321	 :   (5024.000000 5058.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03227	 :   (5024.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03404	 :   (2816.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03405	 :   (3000.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03406	 :   (3184.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03407	 :   (3368.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02763	 :   (5024.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02762	 :   (4840.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02761	 :   (4656.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02760	 :   (4472.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02759	 :   (4288.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02758	 :   (4104.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02757	 :   (3920.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02756	 :   (3736.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03214	 :   (2632.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02571	 :   (2816.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02572	 :   (3000.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02573	 :   (3184.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02574	 :   (3368.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02575	 :   (3552.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02576	 :   (3736.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02577	 :   (3920.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02578	 :   (4104.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02579	 :   (4288.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02580	 :   (4472.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02581	 :   (4656.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02582	 :   (4840.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02583	 :   (5024.000000 6530.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02751	 :   (2816.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03215	 :   (2816.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03216	 :   (3000.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03217	 :   (3184.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03218	 :   (3368.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03219	 :   (3552.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03220	 :   (3736.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03221	 :   (3920.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03222	 :   (4104.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03223	 :   (4288.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03224	 :   (4472.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03225	 :   (4656.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03226	 :   (4840.000000 5242.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03596	 :   (3184.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03413	 :   (4472.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03414	 :   (4656.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03415	 :   (4840.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03498	 :   (2632.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03499	 :   (2816.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03500	 :   (3000.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03501	 :   (3184.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02750	 :   (2632.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03502	 :   (3368.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03503	 :   (3552.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03504	 :   (3736.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03416	 :   (5024.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03595	 :   (3000.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03505	 :   (3920.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03506	 :   (4104.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03507	 :   (4288.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03508	 :   (4472.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03509	 :   (4656.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03510	 :   (4840.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03511	 :   (5024.000000 4690.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03593	 :   (2632.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03594	 :   (2816.000000 4506.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04265	 :   (3920.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02754	 :   (3368.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02753	 :   (3184.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02752	 :   (3000.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03408	 :   (3552.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03409	 :   (3736.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03410	 :   (3920.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04271	 :   (5024.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04270	 :   (4840.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04269	 :   (4656.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_02755	 :   (3552.000000 6162.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04268	 :   (4472.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04267	 :   (4288.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04266	 :   (4104.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03412	 :   (4288.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04264	 :   (3736.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04263	 :   (3552.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04262	 :   (3368.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_04261	 :   (3184.000000 3218.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VSS_03411	 :   (4104.000000 4874.000000)	 :   PAR_1_0_VSS	  = PAR_1_0_VSS
* VDD075NNE_01692	 :   (4012.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01532	 :   (4196.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01686	 :   (2724.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01687	 :   (2908.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01688	 :   (3092.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01528	 :   (3460.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01689	 :   (3460.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01690	 :   (3644.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01693	 :   (4196.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01691	 :   (3828.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01644	 :   (4932.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01643	 :   (4748.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01642	 :   (4564.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01639	 :   (4012.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01638	 :   (3828.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01637	 :   (3644.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01636	 :   (3460.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01635	 :   (3276.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01634	 :   (3092.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01633	 :   (2908.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01641	 :   (4380.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01632	 :   (2724.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01640	 :   (4196.000000 5334.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01419	 :   (3276.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01370	 :   (4196.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01371	 :   (4380.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01372	 :   (4564.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01373	 :   (4748.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01374	 :   (4932.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01308	 :   (2724.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01416	 :   (2724.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01417	 :   (2908.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01418	 :   (3092.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01369	 :   (4012.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01420	 :   (3460.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01421	 :   (3644.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01422	 :   (3828.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01423	 :   (4012.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01424	 :   (4196.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01425	 :   (4380.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01426	 :   (4564.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01427	 :   (4748.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01310	 :   (3092.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01319	 :   (4748.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01318	 :   (4564.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01317	 :   (4380.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01316	 :   (4196.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01315	 :   (4012.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01314	 :   (3828.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01313	 :   (3644.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01312	 :   (3460.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01311	 :   (3276.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01428	 :   (4932.000000 6070.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01309	 :   (2908.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01362	 :   (2724.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01363	 :   (2908.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01364	 :   (3092.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01365	 :   (3276.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01366	 :   (3460.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01367	 :   (3644.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01368	 :   (3828.000000 6254.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01581	 :   (3276.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01530	 :   (3828.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01531	 :   (4012.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01533	 :   (4380.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01534	 :   (4564.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01535	 :   (4748.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01536	 :   (4932.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01578	 :   (2724.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01579	 :   (2908.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01580	 :   (3092.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01529	 :   (3644.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01582	 :   (3460.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01583	 :   (3644.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01584	 :   (3828.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01585	 :   (4012.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01586	 :   (4196.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01587	 :   (4380.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01588	 :   (4564.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01589	 :   (4748.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01479	 :   (4380.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01470	 :   (2724.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01471	 :   (2908.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01472	 :   (3092.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01473	 :   (3276.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01474	 :   (3460.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01475	 :   (3644.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01476	 :   (3828.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01477	 :   (4012.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01478	 :   (4196.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01590	 :   (4932.000000 5518.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01480	 :   (4564.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01481	 :   (4748.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01482	 :   (4932.000000 5886.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01524	 :   (2724.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01525	 :   (2908.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01526	 :   (3092.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01527	 :   (3276.000000 5702.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01320	 :   (4932.000000 6438.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02128	 :   (4748.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01858	 :   (4748.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01859	 :   (4932.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02179	 :   (4196.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02178	 :   (4012.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02177	 :   (3828.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02176	 :   (3644.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02175	 :   (3460.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02174	 :   (3276.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02173	 :   (3092.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02172	 :   (2908.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02171	 :   (2724.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02129	 :   (4932.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01857	 :   (4564.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02127	 :   (4564.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02126	 :   (4380.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02125	 :   (4196.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01901	 :   (2724.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01902	 :   (2908.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01903	 :   (3092.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01904	 :   (3276.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01905	 :   (3460.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01906	 :   (3644.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01907	 :   (3828.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01908	 :   (4012.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02124	 :   (4012.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02183	 :   (4932.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01795	 :   (3092.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01796	 :   (3276.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01797	 :   (3460.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01798	 :   (3644.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01799	 :   (3828.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01800	 :   (4012.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01801	 :   (4196.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01802	 :   (4380.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01803	 :   (4564.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01804	 :   (4748.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01805	 :   (4932.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02225	 :   (2724.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02123	 :   (3828.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02182	 :   (4748.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02181	 :   (4564.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02180	 :   (4380.000000 3494.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01847	 :   (2724.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01848	 :   (2908.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01849	 :   (3092.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01851	 :   (3460.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01852	 :   (3644.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01853	 :   (3828.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01854	 :   (4012.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01855	 :   (4196.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01856	 :   (4380.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02021	 :   (4932.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01966	 :   (4748.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01967	 :   (4932.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02072	 :   (4380.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02071	 :   (4196.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02070	 :   (4012.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02069	 :   (3828.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02068	 :   (3644.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02067	 :   (3460.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02066	 :   (3276.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02065	 :   (3092.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02064	 :   (2908.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02063	 :   (2724.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01965	 :   (4564.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02020	 :   (4748.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02019	 :   (4564.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02018	 :   (4380.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02017	 :   (4196.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02016	 :   (4012.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02015	 :   (3828.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02014	 :   (3644.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02013	 :   (3460.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02012	 :   (3276.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02011	 :   (3092.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02010	 :   (2908.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02009	 :   (2724.000000 4046.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02075	 :   (4932.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02122	 :   (3644.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02121	 :   (3460.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02120	 :   (3276.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02119	 :   (3092.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01909	 :   (4196.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01910	 :   (4380.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01911	 :   (4564.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01912	 :   (4748.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01913	 :   (4932.000000 4414.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02118	 :   (2908.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02117	 :   (2724.000000 3678.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01694	 :   (4380.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01850	 :   (3276.000000 4598.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02074	 :   (4748.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02073	 :   (4564.000000 3862.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01955	 :   (2724.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01956	 :   (2908.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01957	 :   (3092.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01958	 :   (3276.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01959	 :   (3460.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01960	 :   (3644.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01961	 :   (3828.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01962	 :   (4012.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01963	 :   (4196.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01964	 :   (4380.000000 4230.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01747	 :   (4196.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02234	 :   (4380.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02235	 :   (4564.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01794	 :   (2908.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01793	 :   (2724.000000 4782.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02236	 :   (4748.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02237	 :   (4932.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01751	 :   (4932.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01750	 :   (4748.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01749	 :   (4564.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01748	 :   (4380.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01695	 :   (4564.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01724	 :   (3368.000000 5058.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01739	 :   (2724.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01740	 :   (2908.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01741	 :   (3092.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01742	 :   (3276.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01743	 :   (3460.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01744	 :   (3644.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01745	 :   (3828.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01746	 :   (4012.000000 4966.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01696	 :   (4748.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_01697	 :   (4932.000000 5150.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02226	 :   (2908.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02227	 :   (3092.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02228	 :   (3276.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02229	 :   (3460.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02230	 :   (3644.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02231	 :   (3828.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02233	 :   (4196.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VDD075NNE_02232	 :   (4012.000000 3310.000000)	 :   PAR_1_0_VDD075NNE	  = PAR_1_0_VDD075NNE
* VSS_04179	 :   (5576.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04180	 :   (5760.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03322	 :   (5208.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03323	 :   (5392.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03324	 :   (5576.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03325	 :   (5760.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03326	 :   (5944.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03327	 :   (6128.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03328	 :   (6312.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03239	 :   (7232.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03330	 :   (6680.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04181	 :   (5944.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04182	 :   (6128.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03240	 :   (7416.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04281	 :   (6864.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02764	 :   (5208.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03238	 :   (7048.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03237	 :   (6864.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03236	 :   (6680.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03235	 :   (6496.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03234	 :   (6312.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03233	 :   (6128.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04091	 :   (6864.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03426	 :   (6864.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04085	 :   (5760.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04086	 :   (5944.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04087	 :   (6128.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04088	 :   (6312.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04089	 :   (6496.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04284	 :   (7416.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04283	 :   (7232.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04282	 :   (7048.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04090	 :   (6680.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03331	 :   (6864.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04092	 :   (7048.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04093	 :   (7232.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04094	 :   (7416.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02673	 :   (5208.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04177	 :   (5208.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04178	 :   (5392.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03232	 :   (5944.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03334	 :   (7416.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03333	 :   (7232.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03332	 :   (7048.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02771	 :   (6496.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02586	 :   (5576.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02585	 :   (5392.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02584	 :   (5208.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04272	 :   (5208.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04273	 :   (5392.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04274	 :   (5576.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02765	 :   (5392.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02766	 :   (5576.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02767	 :   (5760.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02768	 :   (5944.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02769	 :   (6128.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02770	 :   (6312.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02587	 :   (5760.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02772	 :   (6680.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02773	 :   (6864.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02774	 :   (7048.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02775	 :   (7232.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02776	 :   (7416.000000 6162.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04275	 :   (5760.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04276	 :   (5944.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04277	 :   (6128.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04278	 :   (6312.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03143	 :   (7416.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03142	 :   (7232.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03141	 :   (7048.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04279	 :   (6496.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04183	 :   (6312.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04184	 :   (6496.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04185	 :   (6680.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04186	 :   (6864.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04187	 :   (7048.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04188	 :   (7232.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04189	 :   (7416.000000 3402.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02596	 :   (7416.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02595	 :   (7232.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02594	 :   (7048.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02593	 :   (6864.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04280	 :   (6680.000000 3218.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03140	 :   (6864.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03137	 :   (6312.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03138	 :   (6496.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03139	 :   (6680.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02592	 :   (6680.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02591	 :   (6496.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03231	 :   (5760.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03230	 :   (5576.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03229	 :   (5392.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03228	 :   (5208.000000 5242.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02590	 :   (6312.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02589	 :   (6128.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02588	 :   (5944.000000 6530.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03710	 :   (6680.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03805	 :   (6680.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03804	 :   (6496.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03803	 :   (6312.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03802	 :   (6128.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03801	 :   (5944.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03800	 :   (5760.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03799	 :   (5576.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03798	 :   (5392.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03797	 :   (5208.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03714	 :   (7416.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03713	 :   (7232.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03712	 :   (7048.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03711	 :   (6864.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03806	 :   (6864.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03709	 :   (6496.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03708	 :   (6312.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03707	 :   (6128.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03706	 :   (5944.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03705	 :   (5760.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03704	 :   (5576.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03703	 :   (5392.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03702	 :   (5208.000000 4322.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03987	 :   (5208.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03329	 :   (6496.000000 5058.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03988	 :   (5392.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03989	 :   (5576.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02676	 :   (5760.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03902	 :   (7048.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03903	 :   (7232.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03904	 :   (7416.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03900	 :   (6680.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03899	 :   (6496.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03898	 :   (6312.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03897	 :   (6128.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03896	 :   (5944.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03895	 :   (5760.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03894	 :   (5576.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03893	 :   (5392.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03892	 :   (5208.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03990	 :   (5760.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02677	 :   (5944.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02678	 :   (6128.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02679	 :   (6312.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02680	 :   (6496.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02681	 :   (6680.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02682	 :   (6864.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02683	 :   (7048.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02684	 :   (7232.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02685	 :   (7416.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03809	 :   (7416.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03808	 :   (7232.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03807	 :   (7048.000000 4138.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03512	 :   (5208.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03607	 :   (5208.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03524	 :   (7416.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03523	 :   (7232.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03522	 :   (7048.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03521	 :   (6864.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03520	 :   (6680.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03519	 :   (6496.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03518	 :   (6312.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03517	 :   (6128.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03516	 :   (5944.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03515	 :   (5760.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03514	 :   (5576.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03513	 :   (5392.000000 4690.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03608	 :   (5392.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03429	 :   (7416.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03428	 :   (7232.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03427	 :   (7048.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03901	 :   (6864.000000 3954.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03425	 :   (6680.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03424	 :   (6496.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03423	 :   (6312.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03422	 :   (6128.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03421	 :   (5944.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03420	 :   (5760.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03419	 :   (5576.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03418	 :   (5392.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04083	 :   (5392.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03991	 :   (5944.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03992	 :   (6128.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03993	 :   (6312.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03994	 :   (6496.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03995	 :   (6680.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03996	 :   (6864.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03997	 :   (7048.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03998	 :   (7232.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03999	 :   (7416.000000 3770.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02675	 :   (5576.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02674	 :   (5392.000000 6346.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04082	 :   (5208.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03417	 :   (5208.000000 4874.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_04084	 :   (5576.000000 3586.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03619	 :   (7416.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03618	 :   (7232.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03617	 :   (7048.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03616	 :   (6864.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03615	 :   (6680.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03614	 :   (6496.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03613	 :   (6312.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03612	 :   (6128.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03611	 :   (5944.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03610	 :   (5760.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03609	 :   (5576.000000 4506.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03041	 :   (6128.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03134	 :   (5760.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02953	 :   (6864.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02952	 :   (6680.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02950	 :   (6312.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02949	 :   (6128.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02948	 :   (5944.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03044	 :   (6680.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03045	 :   (6864.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02954	 :   (7048.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03135	 :   (5944.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03136	 :   (6128.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03043	 :   (6496.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03042	 :   (6312.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02951	 :   (6496.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03040	 :   (5944.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03039	 :   (5760.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02944	 :   (5208.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02945	 :   (5392.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03046	 :   (7048.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03047	 :   (7232.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03048	 :   (7416.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02946	 :   (5576.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02947	 :   (5760.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03038	 :   (5576.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03037	 :   (5392.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03036	 :   (5208.000000 5610.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03133	 :   (5576.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02956	 :   (7416.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02955	 :   (7232.000000 5794.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02855	 :   (5208.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02856	 :   (5392.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02857	 :   (5576.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02858	 :   (5760.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02859	 :   (5944.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02860	 :   (6128.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02861	 :   (6312.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02862	 :   (6496.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02863	 :   (6680.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02865	 :   (7048.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02866	 :   (7232.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02867	 :   (7416.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03132	 :   (5392.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_02864	 :   (6864.000000 5978.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VSS_03131	 :   (5208.000000 5426.000000)	 :   PAR_2_0_VSS	  = PAR_2_0_VSS
* VDD075NNE_01490	 :   (6404.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01698	 :   (5116.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02242	 :   (5852.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02241	 :   (5668.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01867	 :   (6404.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01483	 :   (5116.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01484	 :   (5300.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02240	 :   (5484.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02243	 :   (6036.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01491	 :   (6588.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01492	 :   (6772.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01493	 :   (6956.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01494	 :   (7140.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01485	 :   (5484.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01486	 :   (5668.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01487	 :   (5852.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01488	 :   (6036.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01489	 :   (6220.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01710	 :   (7324.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02089	 :   (7508.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01699	 :   (5300.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01700	 :   (5484.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01701	 :   (5668.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01702	 :   (5852.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01703	 :   (6036.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01873	 :   (7508.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01872	 :   (7324.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01704	 :   (6220.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01705	 :   (6404.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01706	 :   (6588.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01707	 :   (6772.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01708	 :   (6956.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01709	 :   (7140.000000 5150.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02139	 :   (6772.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01871	 :   (7140.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01870	 :   (6956.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01869	 :   (6772.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01868	 :   (6588.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02130	 :   (5116.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02131	 :   (5300.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02132	 :   (5484.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02133	 :   (5668.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02134	 :   (5852.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02135	 :   (6036.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02136	 :   (6220.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02137	 :   (6404.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02138	 :   (6588.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01651	 :   (6220.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01539	 :   (5484.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01538	 :   (5300.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01537	 :   (5116.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02189	 :   (6036.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02190	 :   (6220.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02191	 :   (6404.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02192	 :   (6588.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02193	 :   (6772.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01540	 :   (5668.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01860	 :   (5116.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01861	 :   (5300.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01862	 :   (5484.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01863	 :   (5668.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01864	 :   (5852.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01865	 :   (6036.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01866	 :   (6220.000000 4598.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02187	 :   (5668.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01650	 :   (6036.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01649	 :   (5852.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01648	 :   (5668.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01647	 :   (5484.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01646	 :   (5300.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02184	 :   (5116.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02185	 :   (5300.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02186	 :   (5484.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02194	 :   (6956.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02188	 :   (5852.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01546	 :   (6772.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01545	 :   (6588.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01544	 :   (6404.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01543	 :   (6220.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01542	 :   (6036.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01541	 :   (5852.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02140	 :   (6956.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01752	 :   (5116.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01753	 :   (5300.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01754	 :   (5484.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01755	 :   (5668.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01756	 :   (5852.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02143	 :   (7508.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02142	 :   (7324.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02141	 :   (7140.000000 3678.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01645	 :   (5116.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02251	 :   (7508.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02250	 :   (7324.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02249	 :   (7140.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02248	 :   (6956.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02247	 :   (6772.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02246	 :   (6588.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02245	 :   (6404.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01653	 :   (6588.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02195	 :   (7140.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02196	 :   (7324.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02197	 :   (7508.000000 3494.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01547	 :   (6956.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01548	 :   (7140.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01549	 :   (7324.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01550	 :   (7508.000000 5702.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01652	 :   (6404.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02244	 :   (6220.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01654	 :   (6772.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01655	 :   (6956.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01656	 :   (7140.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01657	 :   (7324.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01658	 :   (7508.000000 5334.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01496	 :   (7508.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01495	 :   (7324.000000 5886.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02029	 :   (6404.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01379	 :   (5852.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01378	 :   (5668.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01597	 :   (6220.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02035	 :   (7508.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02034	 :   (7324.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02033	 :   (7140.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02032	 :   (6956.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02031	 :   (6772.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02030	 :   (6588.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01380	 :   (6036.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02028	 :   (6220.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02027	 :   (6036.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02026	 :   (5852.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02025	 :   (5668.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02024	 :   (5484.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02023	 :   (5300.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02022	 :   (5116.000000 4046.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01377	 :   (5484.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01757	 :   (6036.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01972	 :   (5852.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01973	 :   (6036.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01974	 :   (6220.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01975	 :   (6404.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01976	 :   (6588.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01388	 :   (7508.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01387	 :   (7324.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01386	 :   (7140.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01376	 :   (5300.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01758	 :   (6220.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01595	 :   (5852.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01596	 :   (6036.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01385	 :   (6956.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01384	 :   (6772.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01383	 :   (6588.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01382	 :   (6404.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01381	 :   (6220.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01759	 :   (6404.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01600	 :   (6772.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01601	 :   (6956.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01602	 :   (7140.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01603	 :   (7324.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01978	 :   (6956.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01979	 :   (7140.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01980	 :   (7324.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01981	 :   (7508.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01604	 :   (7508.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01599	 :   (6588.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01760	 :   (6588.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02238	 :   (5116.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02239	 :   (5300.000000 3310.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01765	 :   (7508.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01764	 :   (7324.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01763	 :   (7140.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01762	 :   (6956.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01761	 :   (6772.000000 4966.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01327	 :   (6220.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01375	 :   (5116.000000 6254.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01977	 :   (6772.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01321	 :   (5116.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01322	 :   (5300.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01323	 :   (5484.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01324	 :   (5668.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01325	 :   (5852.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01326	 :   (6036.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01915	 :   (5300.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01328	 :   (6404.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01329	 :   (6588.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01330	 :   (6772.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01331	 :   (6956.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01332	 :   (7140.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01333	 :   (7324.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01334	 :   (7508.000000 6438.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01598	 :   (6404.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01431	 :   (5484.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01440	 :   (7140.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01439	 :   (6956.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01438	 :   (6772.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01437	 :   (6588.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01436	 :   (6404.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01435	 :   (6220.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01434	 :   (6036.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01433	 :   (5852.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01432	 :   (5668.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01441	 :   (7324.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01430	 :   (5300.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01429	 :   (5116.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02085	 :   (6772.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02084	 :   (6588.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02083	 :   (6404.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02082	 :   (6220.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02081	 :   (6036.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02080	 :   (5852.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01816	 :   (6956.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01914	 :   (5116.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01442	 :   (7508.000000 6070.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02088	 :   (7324.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02087	 :   (7140.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02086	 :   (6956.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01819	 :   (7508.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01818	 :   (7324.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01817	 :   (7140.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01970	 :   (5484.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01815	 :   (6772.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01814	 :   (6588.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01813	 :   (6404.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01812	 :   (6220.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01811	 :   (6036.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01810	 :   (5852.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01809	 :   (5668.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01808	 :   (5484.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02078	 :   (5484.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01971	 :   (5668.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01969	 :   (5300.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01968	 :   (5116.000000 4230.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01927	 :   (7508.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01926	 :   (7324.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01925	 :   (7140.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01924	 :   (6956.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01923	 :   (6772.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01922	 :   (6588.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01921	 :   (6404.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01920	 :   (6220.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01919	 :   (6036.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01593	 :   (5484.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01807	 :   (5300.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01918	 :   (5852.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01917	 :   (5668.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01806	 :   (5116.000000 4782.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01591	 :   (5116.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01592	 :   (5300.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01594	 :   (5668.000000 5518.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_01916	 :   (5484.000000 4414.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02076	 :   (5116.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02077	 :   (5300.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VDD075NNE_02079	 :   (5668.000000 3862.000000)	 :   PAR_2_0_VDD075NNE	  = PAR_2_0_VDD075NNE
* VSS_04001	 :   (7784.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02968	 :   (9624.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04013	 :   (9992.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04012	 :   (9808.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02967	 :   (9440.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04677	 :   (9808.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04003	 :   (8152.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04002	 :   (7968.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04011	 :   (9624.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04000	 :   (7600.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04004	 :   (8336.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04005	 :   (8520.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04006	 :   (8704.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04007	 :   (8888.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04008	 :   (9072.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04009	 :   (9256.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04010	 :   (9440.000000 3770.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04294_4669	 :   (9256.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04393	 :   (9440.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04392	 :   (9256.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04391	 :   (9072.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04390	 :   (8888.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04389	 :   (8704.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04388	 :   (8520.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04298	 :   (9992.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04297_4672	 :   (9808.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04297	 :   (9808.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04296_4671	 :   (9624.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04296	 :   (9624.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04295_4670	 :   (9440.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04295	 :   (9440.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04394	 :   (9624.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04294	 :   (9256.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04293_4668	 :   (9072.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04293	 :   (9072.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04292_4667	 :   (8888.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04292	 :   (8888.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04291_4666	 :   (8704.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04291	 :   (8704.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04290_4665	 :   (8520.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04290	 :   (8520.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04289	 :   (8336.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04288	 :   (8152.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04287	 :   (7968.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04577	 :   (9072.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02778	 :   (7784.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04676	 :   (9624.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04675	 :   (9440.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04674	 :   (9256.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04673	 :   (9072.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04672	 :   (8888.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04671	 :   (8704.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04670	 :   (8520.000000 2482.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04624	 :   (9716.000000 2574.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04581	 :   (9808.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04580	 :   (9624.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04579	 :   (9440.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04578	 :   (9256.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04286	 :   (7784.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04576	 :   (8888.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04575	 :   (8704.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04574	 :   (8520.000000 2666.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04490	 :   (9808.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04489	 :   (9624.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04488	 :   (9440.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04487	 :   (9256.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04486	 :   (9072.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04485	 :   (8888.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04484	 :   (8704.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04483	 :   (8520.000000 2850.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04395	 :   (9808.000000 3034.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04108	 :   (9992.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02598	 :   (7784.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02599	 :   (7968.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02600	 :   (8152.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02601	 :   (8336.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02602	 :   (8520.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02603	 :   (8704.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02604	 :   (8888.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02605	 :   (9072.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02606	 :   (9256.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02607	 :   (9440.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02608	 :   (9624.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02609	 :   (9808.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02610	 :   (9992.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02966	 :   (9256.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04107	 :   (9808.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04106	 :   (9624.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04105	 :   (9440.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04104	 :   (9256.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04103	 :   (9072.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04102	 :   (8888.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04101	 :   (8704.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04100	 :   (8520.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04099	 :   (8336.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04098	 :   (8152.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04097	 :   (7968.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04096	 :   (7784.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04197	 :   (8888.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04285	 :   (7600.000000 3218.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02957	 :   (7600.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02958	 :   (7784.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02959	 :   (7968.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02960	 :   (8152.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02597	 :   (7600.000000 6530.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04203	 :   (9992.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04202	 :   (9808.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04201	 :   (9624.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04200	 :   (9440.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04199	 :   (9256.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04198	 :   (9072.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04095	 :   (7600.000000 3586.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04196	 :   (8704.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04195	 :   (8520.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04194	 :   (8336.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04193	 :   (8152.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04192	 :   (7968.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04191	 :   (7784.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_04190	 :   (7600.000000 3402.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02961	 :   (8336.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02962	 :   (8520.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02963	 :   (8704.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02964	 :   (8888.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02965	 :   (9072.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03061	 :   (9808.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03436	 :   (8704.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03435	 :   (8520.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03434	 :   (8336.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03433	 :   (8152.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03432	 :   (7968.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03431	 :   (7784.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03430	 :   (7600.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03057	 :   (9072.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03058	 :   (9256.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03059	 :   (9440.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03060	 :   (9624.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03437	 :   (8888.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03062	 :   (9992.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03348	 :   (9992.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03347	 :   (9808.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03346	 :   (9624.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03345	 :   (9440.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03344	 :   (9256.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03343	 :   (9072.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03342	 :   (8888.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03341	 :   (8704.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03340	 :   (8520.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03529	 :   (8336.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02698	 :   (9808.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02699	 :   (9992.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03538	 :   (9992.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03537	 :   (9808.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03536	 :   (9624.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03535	 :   (9440.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03534	 :   (9256.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03533	 :   (9072.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03532	 :   (8888.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03531	 :   (8704.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03530	 :   (8520.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03339	 :   (8336.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03528	 :   (8152.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03527	 :   (7968.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03526	 :   (7784.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03525	 :   (7600.000000 4690.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03443	 :   (9992.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03442	 :   (9808.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03441	 :   (9624.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03440	 :   (9440.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03439	 :   (9256.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03438	 :   (9072.000000 4874.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02789	 :   (9808.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03152	 :   (9072.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03151	 :   (8888.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03150	 :   (8704.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02777	 :   (7600.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03149	 :   (8520.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03148	 :   (8336.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03147	 :   (8152.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03146	 :   (7968.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03145	 :   (7784.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03144	 :   (7600.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02790	 :   (9992.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03153	 :   (9256.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02788	 :   (9624.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02787	 :   (9440.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02786	 :   (9256.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02785	 :   (9072.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02784	 :   (8888.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02783	 :   (8704.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02782	 :   (8520.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02781	 :   (8336.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02780	 :   (8152.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02779	 :   (7968.000000 6162.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03247	 :   (8704.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03338	 :   (8152.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03337	 :   (7968.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03336	 :   (7784.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03335	 :   (7600.000000 5058.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03254	 :   (9992.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03253	 :   (9808.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03252	 :   (9624.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03251	 :   (9440.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03250	 :   (9256.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03249	 :   (9072.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03248	 :   (8888.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02697	 :   (9624.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03246	 :   (8520.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03245	 :   (8336.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03244	 :   (8152.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03243	 :   (7968.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03242	 :   (7784.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03241	 :   (7600.000000 5242.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03157	 :   (9992.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03156	 :   (9808.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03155	 :   (9624.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03154	 :   (9440.000000 5426.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03815	 :   (8520.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02686	 :   (7600.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02687	 :   (7784.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02688	 :   (7968.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03823	 :   (9992.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03822	 :   (9808.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03821	 :   (9624.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03820	 :   (9440.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03819	 :   (9256.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03818	 :   (9072.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03817	 :   (8888.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03816	 :   (8704.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02874	 :   (8704.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03814	 :   (8336.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03813	 :   (8152.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03812	 :   (7968.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03811	 :   (7784.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03810	 :   (7600.000000 4138.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02873	 :   (8520.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03728	 :   (9992.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03727	 :   (9808.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03726	 :   (9624.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03725	 :   (9440.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03910	 :   (8520.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02970	 :   (9992.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02881	 :   (9992.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02880	 :   (9808.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03918	 :   (9992.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03917	 :   (9808.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03916	 :   (9624.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03915	 :   (9440.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03914	 :   (9256.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03913	 :   (9072.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03912	 :   (8888.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03911	 :   (8704.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03724	 :   (9256.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03909	 :   (8336.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03908	 :   (8152.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03907	 :   (7968.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03906	 :   (7784.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03905	 :   (7600.000000 3954.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02879	 :   (9624.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02878	 :   (9440.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02877	 :   (9256.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02876	 :   (9072.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02875	 :   (8888.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03053	 :   (8336.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03626	 :   (8704.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03625	 :   (8520.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03624	 :   (8336.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03623	 :   (8152.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03622	 :   (7968.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03621	 :   (7784.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03620	 :   (7600.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03049	 :   (7600.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03050	 :   (7784.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03051	 :   (7968.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03052	 :   (8152.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03627	 :   (8888.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03054	 :   (8520.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03055	 :   (8704.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03056	 :   (8888.000000 5610.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02690	 :   (8336.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02691	 :   (8520.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02692	 :   (8704.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02693	 :   (8888.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02694	 :   (9072.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02695	 :   (9256.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02696	 :   (9440.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02870	 :   (7968.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03723	 :   (9072.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03722	 :   (8888.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03721	 :   (8704.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03720	 :   (8520.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03719	 :   (8336.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03718	 :   (8152.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03717	 :   (7968.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03716	 :   (7784.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03715	 :   (7600.000000 4322.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02872	 :   (8336.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02871	 :   (8152.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02969	 :   (9808.000000 5794.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02869	 :   (7784.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02868	 :   (7600.000000 5978.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_02689	 :   (8152.000000 6346.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03633	 :   (9992.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03632	 :   (9808.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03631	 :   (9624.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03630	 :   (9440.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03629	 :   (9256.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VSS_03628	 :   (9072.000000 4506.000000)	 :   PAR_3_0_VSS	  = PAR_3_0_VSS
* VDD075NNE_02309	 :   (9348.000000 2022.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02091	 :   (7876.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02099	 :   (9348.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02098	 :   (9164.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02097	 :   (8980.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02096	 :   (8796.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02095	 :   (8612.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02094	 :   (8428.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02093	 :   (8244.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02092	 :   (8060.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02100	 :   (9532.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02090	 :   (7692.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02048	 :   (9900.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02047	 :   (9716.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02046	 :   (9532.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02045	 :   (9348.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02044	 :   (9164.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02043	 :   (8980.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02042	 :   (8796.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02149	 :   (8612.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02198	 :   (7692.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02156	 :   (9900.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02155	 :   (9716.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02154	 :   (9532.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02153	 :   (9348.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02152	 :   (9164.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02151	 :   (8980.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02150	 :   (8796.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02041	 :   (8612.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02148	 :   (8428.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02147	 :   (8244.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02146	 :   (8060.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02145	 :   (7876.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02144	 :   (7692.000000 3678.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02102	 :   (9900.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02101	 :   (9716.000000 3862.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01933	 :   (8612.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01982	 :   (7692.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01940	 :   (9900.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01939	 :   (9716.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01938	 :   (9532.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01937	 :   (9348.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01936	 :   (9164.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01935	 :   (8980.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01934	 :   (8796.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01983	 :   (7876.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01932	 :   (8428.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01931	 :   (8244.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01930	 :   (8060.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01929	 :   (7876.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01928	 :   (7692.000000 4414.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01886	 :   (9900.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01885	 :   (9716.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01884	 :   (9532.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01991	 :   (9348.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02040	 :   (8428.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02039	 :   (8244.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02038	 :   (8060.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02037	 :   (7876.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02036	 :   (7692.000000 4046.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01994	 :   (9900.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01993	 :   (9716.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01992	 :   (9532.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02199	 :   (7876.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01990	 :   (9164.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01989	 :   (8980.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01988	 :   (8796.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01987	 :   (8612.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01986	 :   (8428.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01985	 :   (8244.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01984	 :   (8060.000000 4230.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02284	 :   (8612.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02292	 :   (8428.000000 2574.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02291	 :   (9900.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02290	 :   (9716.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02289	 :   (9532.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02288	 :   (9348.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02287	 :   (9164.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02286	 :   (8980.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02285	 :   (8796.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02293	 :   (8612.000000 2574.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02283	 :   (8428.000000 2758.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02282	 :   (9900.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02281	 :   (9716.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02280	 :   (9532.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02279	 :   (9348.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02278	 :   (9164.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02277	 :   (8980.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02276	 :   (8796.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02301	 :   (9348.000000 2390.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02310	 :   (9532.000000 2022.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02308	 :   (9164.000000 2022.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02307	 :   (8980.000000 2022.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02306	 :   (9532.000000 2206.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02305	 :   (9348.000000 2206.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02304	 :   (9164.000000 2206.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02303	 :   (8980.000000 2206.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02302	 :   (9532.000000 2390.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02275	 :   (8612.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02300	 :   (9164.000000 2390.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02299	 :   (8980.000000 2390.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02298	 :   (9532.000000 2574.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02297	 :   (9348.000000 2574.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02296	 :   (9164.000000 2574.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02295	 :   (8980.000000 2574.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02294	 :   (8796.000000 2574.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02208	 :   (9532.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02257	 :   (8612.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02256	 :   (8428.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02255	 :   (8244.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02254	 :   (8060.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02253	 :   (7876.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02252	 :   (7692.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02210	 :   (9900.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02209	 :   (9716.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02258	 :   (8796.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02207	 :   (9348.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02206	 :   (9164.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02205	 :   (8980.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02204	 :   (8796.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02203	 :   (8612.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02202	 :   (8428.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02201	 :   (8244.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02200	 :   (8060.000000 3494.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02266	 :   (8612.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02274	 :   (8428.000000 2942.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02273	 :   (9900.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02272	 :   (9716.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02271	 :   (9532.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02270	 :   (9348.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02269	 :   (9164.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02268	 :   (8980.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02267	 :   (8796.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01335	 :   (7692.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02265	 :   (8428.000000 3126.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02264	 :   (9900.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02263	 :   (9716.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02262	 :   (9532.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02261	 :   (9348.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02260	 :   (9164.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_02259	 :   (8980.000000 3310.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01502	 :   (8612.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01551	 :   (7692.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01509	 :   (9900.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01508	 :   (9716.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01507	 :   (9532.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01506	 :   (9348.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01505	 :   (9164.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01504	 :   (8980.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01503	 :   (8796.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01552	 :   (7876.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01501	 :   (8428.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01500	 :   (8244.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01499	 :   (8060.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01498	 :   (7876.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01497	 :   (7692.000000 5886.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01455	 :   (9900.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01454	 :   (9716.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01453	 :   (9532.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01560	 :   (9348.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01609	 :   (8428.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01608	 :   (8244.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01607	 :   (8060.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01606	 :   (7876.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01605	 :   (7692.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01563	 :   (9900.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01562	 :   (9716.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01561	 :   (9532.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01452	 :   (9348.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01559	 :   (9164.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01558	 :   (8980.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01557	 :   (8796.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01556	 :   (8612.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01555	 :   (8428.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01554	 :   (8244.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01553	 :   (8060.000000 5702.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01344	 :   (9348.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01393	 :   (8428.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01392	 :   (8244.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01391	 :   (8060.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01390	 :   (7876.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01389	 :   (7692.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01347	 :   (9900.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01346	 :   (9716.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01345	 :   (9532.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01394	 :   (8612.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01343	 :   (9164.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01342	 :   (8980.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01341	 :   (8796.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01340	 :   (8612.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01339	 :   (8428.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01338	 :   (8244.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01337	 :   (8060.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01336	 :   (7876.000000 6438.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01443	 :   (7692.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01451	 :   (9164.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01450	 :   (8980.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01449	 :   (8796.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01448	 :   (8612.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01447	 :   (8428.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01446	 :   (8244.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01445	 :   (8060.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01444	 :   (7876.000000 6070.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01882	 :   (9164.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01401	 :   (9900.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01400	 :   (9716.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01399	 :   (9532.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01398	 :   (9348.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01397	 :   (9164.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01396	 :   (8980.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01395	 :   (8796.000000 6254.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01775	 :   (9348.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01824	 :   (8428.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01823	 :   (8244.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01822	 :   (8060.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01821	 :   (7876.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01820	 :   (7692.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01778	 :   (9900.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01777	 :   (9716.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01776	 :   (9532.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01825	 :   (8612.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01774	 :   (9164.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01773	 :   (8980.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01772	 :   (8796.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01771	 :   (8612.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01770	 :   (8428.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01769	 :   (8244.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01768	 :   (8060.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01767	 :   (7876.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01874	 :   (7692.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01883	 :   (9348.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01881	 :   (8980.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01880	 :   (8796.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01879	 :   (8612.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01878	 :   (8428.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01877	 :   (8244.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01876	 :   (8060.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01875	 :   (7876.000000 4598.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01611	 :   (8796.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01832	 :   (9900.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01831	 :   (9716.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01830	 :   (9532.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01829	 :   (9348.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01828	 :   (9164.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01827	 :   (8980.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01826	 :   (8796.000000 4782.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01659	 :   (7692.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01667	 :   (9164.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01666	 :   (8980.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01665	 :   (8796.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01664	 :   (8612.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01663	 :   (8428.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01662	 :   (8244.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01661	 :   (8060.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01660	 :   (7876.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01723	 :   (9900.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01617	 :   (9900.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01616	 :   (9716.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01615	 :   (9532.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01614	 :   (9348.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01613	 :   (9164.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01612	 :   (8980.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01610	 :   (8612.000000 5518.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01669	 :   (9532.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01668	 :   (9348.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01766	 :   (7692.000000 4966.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01722	 :   (9716.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01721	 :   (9532.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01720	 :   (9348.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01719	 :   (9164.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01718	 :   (8980.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01717	 :   (8796.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01716	 :   (8612.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01715	 :   (8428.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01714	 :   (8244.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01713	 :   (8060.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01712	 :   (7876.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01711	 :   (7692.000000 5150.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01671	 :   (9900.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VDD075NNE_01670	 :   (9716.000000 5334.000000)	 :   PAR_3_0_VDD075NNE	  = PAR_3_0_VDD075NNE
* VSS_02386	 :   (2080.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02387	 :   (2264.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02388	 :   (2448.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02467	 :   (240.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02468	 :   (424.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02469	 :   (608.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02470	 :   (792.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02471	 :   (976.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02472	 :   (1160.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02473	 :   (1344.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02474	 :   (1528.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02475	 :   (1712.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02476	 :   (1896.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02477	 :   (2080.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02478	 :   (2264.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02479	 :   (2448.000000 6714.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02385	 :   (1896.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01025	 :   (2264.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01016	 :   (608.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01017	 :   (792.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01018	 :   (976.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01019	 :   (1160.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01020	 :   (1344.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01021	 :   (1528.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01022	 :   (1712.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01023	 :   (1896.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01024	 :   (2080.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01015	 :   (424.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01026	 :   (2448.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01104	 :   (240.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01105	 :   (424.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01106	 :   (608.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01107	 :   (792.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01108	 :   (976.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01109	 :   (1160.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01110	 :   (1344.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00926	 :   (1160.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00841	 :   (2080.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00842	 :   (2264.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00843	 :   (2448.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00921	 :   (240.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00922	 :   (424.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00923	 :   (608.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00924	 :   (792.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00925	 :   (976.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01111	 :   (1528.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00927	 :   (1344.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00928	 :   (1528.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00929	 :   (1712.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00930	 :   (1896.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00931	 :   (2080.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00932	 :   (2264.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00933	 :   (2448.000000 9842.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01014	 :   (240.000000 9658.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01297	 :   (1896.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01288	 :   (240.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01289	 :   (424.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01290	 :   (608.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01291	 :   (792.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01292	 :   (976.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01293	 :   (1160.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01294	 :   (1344.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01295	 :   (1528.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01296	 :   (1712.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01208	 :   (2448.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01298	 :   (2080.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01299	 :   (2264.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01300	 :   (2448.000000 9106.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01379	 :   (240.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01380	 :   (424.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01381	 :   (608.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01382	 :   (792.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01383	 :   (976.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01199	 :   (792.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01112	 :   (1712.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01113	 :   (1896.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01114	 :   (2080.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01115	 :   (2264.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01116	 :   (2448.000000 9474.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01196	 :   (240.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01197	 :   (424.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01198	 :   (608.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00840	 :   (1896.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01200	 :   (976.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01201	 :   (1160.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01202	 :   (1344.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01203	 :   (1528.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01204	 :   (1712.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01205	 :   (1896.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01206	 :   (2080.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01207	 :   (2264.000000 9290.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00558	 :   (608.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00474	 :   (1344.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00475	 :   (1528.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00476	 :   (1712.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00477	 :   (1896.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00478	 :   (2080.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00479	 :   (2264.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00480	 :   (2448.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00556	 :   (240.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00557	 :   (424.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00473	 :   (1160.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00559	 :   (792.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00560	 :   (976.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00561	 :   (1160.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00562	 :   (1344.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00563	 :   (1528.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00564	 :   (1712.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00565	 :   (1896.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00566	 :   (2080.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00385	 :   (1896.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00377	 :   (424.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00378	 :   (608.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00379	 :   (792.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00380	 :   (976.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00381	 :   (1160.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00382	 :   (1344.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00383	 :   (1528.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00384	 :   (1712.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00567	 :   (2264.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00386	 :   (2080.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00387	 :   (2264.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00388	 :   (2448.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00468	 :   (240.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00469	 :   (424.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00470	 :   (608.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00471	 :   (792.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00472	 :   (976.000000 10762.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00831	 :   (240.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00746	 :   (976.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00747	 :   (1160.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00748	 :   (1344.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00749	 :   (1528.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00750	 :   (1712.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00751	 :   (1896.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00752	 :   (2080.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00753	 :   (2264.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00754	 :   (2448.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00745	 :   (792.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00832	 :   (424.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00833	 :   (608.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00834	 :   (792.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00835	 :   (976.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00836	 :   (1160.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00837	 :   (1344.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00838	 :   (1528.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00839	 :   (1712.000000 10026.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00657	 :   (1528.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00568	 :   (2448.000000 10578.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00650	 :   (240.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00651	 :   (424.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00652	 :   (608.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00653	 :   (792.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00654	 :   (976.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00655	 :   (1160.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00656	 :   (1344.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01384	 :   (1160.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00658	 :   (1712.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00659	 :   (1896.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00660	 :   (2080.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00661	 :   (2264.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00662	 :   (2448.000000 10394.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00742	 :   (240.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00743	 :   (424.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00744	 :   (608.000000 10210.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02107	 :   (608.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02019	 :   (1344.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02020	 :   (1528.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02021	 :   (1712.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02022	 :   (1896.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02023	 :   (2080.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02024	 :   (2264.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02025	 :   (2448.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02105	 :   (240.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02106	 :   (424.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02018	 :   (1160.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02108	 :   (792.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02109	 :   (976.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02110	 :   (1160.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02111	 :   (1344.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02112	 :   (1528.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02113	 :   (1712.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02114	 :   (1896.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02115	 :   (2080.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01931	 :   (1896.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01923	 :   (424.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01924	 :   (608.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01925	 :   (792.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01926	 :   (976.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01927	 :   (1160.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01928	 :   (1344.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01929	 :   (1528.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01930	 :   (1712.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02116	 :   (2264.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01932	 :   (2080.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01933	 :   (2264.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01934	 :   (2448.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02013	 :   (240.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02014	 :   (424.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02015	 :   (608.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02016	 :   (792.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02017	 :   (976.000000 7634.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02376	 :   (240.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02290	 :   (976.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02291	 :   (1160.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02292	 :   (1344.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02293	 :   (1528.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02294	 :   (1712.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02295	 :   (1896.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02296	 :   (2080.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02297	 :   (2264.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02298	 :   (2448.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02289	 :   (792.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02377	 :   (424.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02378	 :   (608.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02379	 :   (792.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02380	 :   (976.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02381	 :   (1160.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02382	 :   (1344.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02383	 :   (1528.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02384	 :   (1712.000000 6898.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02203	 :   (1528.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02117	 :   (2448.000000 7450.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02196	 :   (240.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02197	 :   (424.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02198	 :   (608.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02199	 :   (792.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02200	 :   (976.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02201	 :   (1160.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02202	 :   (1344.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01922	 :   (240.000000 7818.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02204	 :   (1712.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02205	 :   (1896.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02206	 :   (2080.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02207	 :   (2264.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02208	 :   (2448.000000 7266.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02286	 :   (240.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02287	 :   (424.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_02288	 :   (608.000000 7082.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01567	 :   (1528.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01480	 :   (2264.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01481	 :   (2448.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01560	 :   (240.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01561	 :   (424.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01562	 :   (608.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01563	 :   (792.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01564	 :   (976.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01565	 :   (1160.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01566	 :   (1344.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01479	 :   (2080.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01568	 :   (1712.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01569	 :   (1896.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01570	 :   (2080.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01571	 :   (2264.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01572	 :   (2448.000000 8554.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01650	 :   (240.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01651	 :   (424.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01652	 :   (608.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01470	 :   (424.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01385	 :   (1344.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01386	 :   (1528.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01387	 :   (1712.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01388	 :   (1896.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01389	 :   (2080.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01390	 :   (2264.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01391	 :   (2448.000000 8922.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01469	 :   (240.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01653	 :   (792.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01471	 :   (608.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01472	 :   (792.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01473	 :   (976.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01474	 :   (1160.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01475	 :   (1344.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01476	 :   (1528.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01477	 :   (1712.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01478	 :   (1896.000000 8738.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01837	 :   (976.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01751	 :   (1896.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01752	 :   (2080.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01753	 :   (2264.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01754	 :   (2448.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01833	 :   (240.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01834	 :   (424.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01835	 :   (608.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01836	 :   (792.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01750	 :   (1712.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01838	 :   (1160.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01839	 :   (1344.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01840	 :   (1528.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01841	 :   (1712.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01842	 :   (1896.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01843	 :   (2080.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01844	 :   (2264.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01845	 :   (2448.000000 8002.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01662	 :   (2448.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01654	 :   (976.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01655	 :   (1160.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01656	 :   (1344.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01657	 :   (1528.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01658	 :   (1712.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01659	 :   (1896.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01660	 :   (2080.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01661	 :   (2264.000000 8370.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_00376	 :   (240.000000 10946.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01742	 :   (240.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01743	 :   (424.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01744	 :   (608.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01745	 :   (792.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01746	 :   (976.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01747	 :   (1160.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01748	 :   (1344.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VSS_01749	 :   (1528.000000 8186.000000)	 :   PAR_0_1_VSS	  = PAR_0_1_VSS
* VDD075NNE_00820	 :   (1804.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01144	 :   (1804.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01145	 :   (1988.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01146	 :   (2172.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01147	 :   (2356.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01148	 :   (2540.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01033	 :   (1252.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00824	 :   (2540.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00823	 :   (2356.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00822	 :   (2172.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00821	 :   (1988.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01143	 :   (1620.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00819	 :   (1620.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00818	 :   (1436.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00817	 :   (1252.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00816	 :   (1068.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00815	 :   (884.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00814	 :   (700.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00813	 :   (516.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00812	 :   (332.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00811	 :   (148.000000 8094.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01032	 :   (1068.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01036	 :   (1804.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00704	 :   (332.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00705	 :   (516.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00716	 :   (2540.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00715	 :   (2356.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00706	 :   (700.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00707	 :   (884.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01040	 :   (2540.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01039	 :   (2356.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01038	 :   (2172.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01037	 :   (1988.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01031	 :   (884.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01035	 :   (1620.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01034	 :   (1436.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01135	 :   (148.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01136	 :   (332.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01137	 :   (516.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01138	 :   (700.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01139	 :   (884.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01140	 :   (1068.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01141	 :   (1252.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01142	 :   (1436.000000 6990.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00489	 :   (148.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00335	 :   (1620.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00336	 :   (1804.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00709	 :   (1252.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00710	 :   (1436.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00337	 :   (1988.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00338	 :   (2172.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00339	 :   (2356.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00340	 :   (2540.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00711	 :   (1620.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00712	 :   (1804.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00334	 :   (1436.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00491	 :   (516.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00713	 :   (1988.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00714	 :   (2172.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00973	 :   (148.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00974	 :   (332.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00770	 :   (2540.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00769	 :   (2356.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00768	 :   (2172.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00767	 :   (1988.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00766	 :   (1804.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00446	 :   (2172.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01030	 :   (700.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01029	 :   (516.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01028	 :   (332.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01027	 :   (148.000000 7358.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00708	 :   (1068.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00448	 :   (2540.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00447	 :   (2356.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00595	 :   (148.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00596	 :   (332.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00597	 :   (516.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00703	 :   (148.000000 8462.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00445	 :   (1988.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00444	 :   (1804.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00327	 :   (148.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00328	 :   (332.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00329	 :   (516.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00330	 :   (700.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00331	 :   (884.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00332	 :   (1068.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00333	 :   (1252.000000 9750.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00653	 :   (884.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00277	 :   (884.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00662	 :   (2540.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00661	 :   (2356.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00660	 :   (2172.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00659	 :   (1988.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00658	 :   (1804.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00657	 :   (1620.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00656	 :   (1436.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00655	 :   (1252.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00654	 :   (1068.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00276	 :   (700.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00652	 :   (700.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00651	 :   (516.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00650	 :   (332.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00278	 :   (1068.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00279	 :   (1252.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00280	 :   (1436.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00281	 :   (1620.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00282	 :   (1804.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00283	 :   (1988.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00284	 :   (2172.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00929	 :   (1988.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00922	 :   (700.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00921	 :   (516.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00920	 :   (332.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00919	 :   (148.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00923	 :   (884.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00924	 :   (1068.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00925	 :   (1252.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00926	 :   (1436.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00927	 :   (1620.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00928	 :   (1804.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00285	 :   (2356.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00930	 :   (2172.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00931	 :   (2356.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00932	 :   (2540.000000 7726.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01081	 :   (148.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00543	 :   (148.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00544	 :   (332.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00545	 :   (516.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00273	 :   (148.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00274	 :   (332.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00275	 :   (516.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00175	 :   (1988.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00872	 :   (1436.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00871	 :   (1252.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00870	 :   (1068.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00869	 :   (884.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00868	 :   (700.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00867	 :   (516.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00866	 :   (332.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00865	 :   (148.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00177	 :   (2356.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00176	 :   (2172.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00873	 :   (1620.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00174	 :   (1804.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00173	 :   (1620.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00172	 :   (1436.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00171	 :   (1252.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00170	 :   (1068.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00169	 :   (884.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00168	 :   (700.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00167	 :   (516.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00166	 :   (332.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00165	 :   (148.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01089	 :   (1620.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00286	 :   (2540.000000 9934.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01082	 :   (332.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00878	 :   (2540.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00877	 :   (2356.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01083	 :   (516.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01084	 :   (700.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01085	 :   (884.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01086	 :   (1068.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01087	 :   (1252.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01088	 :   (1436.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00490	 :   (332.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01090	 :   (1804.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01091	 :   (1988.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01092	 :   (2172.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01093	 :   (2356.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01094	 :   (2540.000000 7174.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00178	 :   (2540.000000 10302.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00876	 :   (2172.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00875	 :   (1988.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00874	 :   (1804.000000 7910.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01252	 :   (2356.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00389	 :   (1620.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00390	 :   (1804.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00391	 :   (1988.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00392	 :   (2172.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00393	 :   (2356.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01199	 :   (2172.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01200	 :   (2356.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01201	 :   (2540.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00222	 :   (700.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01253	 :   (2540.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00388	 :   (1436.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01251	 :   (2172.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01250	 :   (1988.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01249	 :   (1804.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01248	 :   (1620.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01247	 :   (1436.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01246	 :   (1252.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01245	 :   (1068.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00221	 :   (516.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00220	 :   (332.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00437	 :   (516.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00070	 :   (2540.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01195	 :   (1436.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01196	 :   (1620.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01197	 :   (1804.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01198	 :   (1988.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00649	 :   (148.000000 8646.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00441	 :   (1252.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00440	 :   (1068.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00439	 :   (884.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00438	 :   (700.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00111	 :   (148.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00436	 :   (332.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00435	 :   (148.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00381	 :   (148.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00382	 :   (332.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00383	 :   (516.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00384	 :   (700.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00385	 :   (884.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00386	 :   (1068.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00387	 :   (1252.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00496	 :   (1436.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01243	 :   (700.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01242	 :   (516.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01241	 :   (332.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01240	 :   (148.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00502	 :   (2540.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00501	 :   (2356.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00500	 :   (2172.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00499	 :   (1988.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00498	 :   (1804.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00497	 :   (1620.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01244	 :   (884.000000 6622.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00495	 :   (1252.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00494	 :   (1068.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00552	 :   (1804.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00551	 :   (1620.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00550	 :   (1436.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00549	 :   (1252.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00548	 :   (1068.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00547	 :   (884.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00546	 :   (700.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00121	 :   (1988.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00112	 :   (332.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00113	 :   (516.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00114	 :   (700.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00115	 :   (884.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00116	 :   (1068.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00117	 :   (1252.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00118	 :   (1436.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00119	 :   (1620.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00120	 :   (1804.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00764	 :   (1436.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00122	 :   (2172.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00123	 :   (2356.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00124	 :   (2540.000000 10486.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00394	 :   (2540.000000 9566.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00219	 :   (148.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00556	 :   (2540.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00555	 :   (2356.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00554	 :   (2172.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00553	 :   (1988.000000 9014.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00980	 :   (1436.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00012	 :   (1804.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00013	 :   (1988.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00014	 :   (2172.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00015	 :   (2356.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00016	 :   (2540.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00978	 :   (1068.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00979	 :   (1252.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00492	 :   (700.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00493	 :   (884.000000 9198.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00443	 :   (1620.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00442	 :   (1436.000000 9382.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00011	 :   (1620.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00981	 :   (1620.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00982	 :   (1804.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00983	 :   (1988.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00984	 :   (2172.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00985	 :   (2356.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00986	 :   (2540.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00232	 :   (2540.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00231	 :   (2356.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00230	 :   (2172.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00229	 :   (1988.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00000	 :   (148.000000 11047.519531)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00765	 :   (1620.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00763	 :   (1252.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00762	 :   (1068.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00761	 :   (884.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00760	 :   (700.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00759	 :   (516.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00758	 :   (332.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00757	 :   (148.000000 8278.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00975	 :   (516.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00976	 :   (700.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00977	 :   (884.000000 7542.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00068	 :   (2172.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00001	 :   (332.000000 11047.519531)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00002	 :   (516.000000 11047.519531)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00003	 :   (148.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00004	 :   (332.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00005	 :   (516.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00006	 :   (700.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00007	 :   (884.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00008	 :   (1068.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00009	 :   (1252.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00010	 :   (1436.000000 10854.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01193	 :   (884.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01189	 :   (148.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00069	 :   (2356.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00067	 :   (1988.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00065	 :   (1620.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00064	 :   (1436.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01190	 :   (332.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01191	 :   (516.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01192	 :   (700.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00066	 :   (1804.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_01194	 :   (1068.000000 6806.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00057	 :   (148.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00058	 :   (332.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00059	 :   (516.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00060	 :   (700.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00061	 :   (884.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00062	 :   (1068.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00063	 :   (1252.000000 10670.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00225	 :   (1252.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00605	 :   (1988.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00604	 :   (1804.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00603	 :   (1620.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00602	 :   (1436.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00601	 :   (1252.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00600	 :   (1068.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00599	 :   (884.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00598	 :   (700.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00224	 :   (1068.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00606	 :   (2172.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00607	 :   (2356.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00226	 :   (1436.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00608	 :   (2540.000000 8830.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00223	 :   (884.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00228	 :   (1804.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VDD075NNE_00227	 :   (1620.000000 10118.000000)	 :   PAR_0_1_VDD075NNE	  = PAR_0_1_VDD075NNE
* VSS_01760	 :   (3552.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00668	 :   (3552.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00667	 :   (3368.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00670	 :   (3920.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01761	 :   (3736.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00671	 :   (4104.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00666	 :   (3184.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00665	 :   (3000.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00664	 :   (2816.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00663	 :   (2632.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00941	 :   (3920.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01128	 :   (4656.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01763	 :   (4104.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01762	 :   (3920.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02302	 :   (3184.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00938	 :   (3368.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00939	 :   (3552.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00940	 :   (3736.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00669	 :   (3736.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00942	 :   (4104.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01768	 :   (5024.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00937	 :   (3184.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00936	 :   (3000.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02303	 :   (3368.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00934	 :   (2632.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02301	 :   (3000.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02300	 :   (2816.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02299	 :   (2632.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00935	 :   (2816.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01767	 :   (4840.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01766	 :   (4656.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01765	 :   (4472.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01764	 :   (4288.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02131	 :   (5024.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02035	 :   (4288.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02034	 :   (4104.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02033	 :   (3920.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02032	 :   (3736.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02031	 :   (3552.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02030	 :   (3368.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02029	 :   (3184.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02028	 :   (3000.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02027	 :   (2816.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02026	 :   (2632.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02128	 :   (4472.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02129	 :   (4656.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02130	 :   (4840.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02036	 :   (4472.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00768	 :   (5024.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00767	 :   (4840.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00766	 :   (4656.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00765	 :   (4472.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00764	 :   (4288.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00763	 :   (4104.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00762	 :   (3920.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00761	 :   (3736.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00760	 :   (3552.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02209	 :   (2632.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02210	 :   (2816.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02211	 :   (3000.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02212	 :   (3184.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00848	 :   (3368.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00845	 :   (2816.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00844	 :   (2632.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02126	 :   (4104.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02125	 :   (3920.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02124	 :   (3736.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02123	 :   (3552.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02122	 :   (3368.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02121	 :   (3184.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02120	 :   (3000.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02119	 :   (2816.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02118	 :   (2632.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00846	 :   (3000.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00847	 :   (3184.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02213	 :   (3368.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00849	 :   (3552.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00850	 :   (3736.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00851	 :   (3920.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00852	 :   (4104.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00853	 :   (4288.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00854	 :   (4472.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00855	 :   (4656.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00856	 :   (4840.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00857	 :   (5024.000000 10026.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02127	 :   (4288.000000 7450.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02039	 :   (5024.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02038	 :   (4840.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02037	 :   (4656.000000 7634.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01846	 :   (2632.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01859	 :   (5024.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01858	 :   (4840.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01857	 :   (4656.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01856	 :   (4472.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01855	 :   (4288.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01854	 :   (4104.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01853	 :   (3920.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01852	 :   (3736.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01851	 :   (3552.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01850	 :   (3368.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01849	 :   (3184.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01848	 :   (3000.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01847	 :   (2816.000000 8002.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01935	 :   (2632.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01209	 :   (2632.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01210	 :   (2816.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01211	 :   (3000.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01212	 :   (3184.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01213	 :   (3368.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01214	 :   (3552.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01215	 :   (3736.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01216	 :   (3920.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01217	 :   (4104.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00676	 :   (5024.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00675	 :   (4840.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00674	 :   (4656.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00673	 :   (4472.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02222	 :   (5024.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02214	 :   (3552.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02215	 :   (3736.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02216	 :   (3920.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02217	 :   (4104.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02218	 :   (4288.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02219	 :   (4472.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02220	 :   (4656.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00759	 :   (3368.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00758	 :   (3184.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00757	 :   (3000.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00756	 :   (2816.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00755	 :   (2632.000000 10210.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02221	 :   (4840.000000 7266.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00672	 :   (4288.000000 10394.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01948	 :   (5024.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01947	 :   (4840.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01946	 :   (4656.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01945	 :   (4472.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01944	 :   (4288.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01943	 :   (4104.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01942	 :   (3920.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01941	 :   (3736.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01940	 :   (3552.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01939	 :   (3368.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01938	 :   (3184.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01937	 :   (3000.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01936	 :   (2816.000000 7818.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01040	 :   (5024.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01484	 :   (3000.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01483	 :   (2816.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01482	 :   (2632.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01221	 :   (4840.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01030	 :   (3184.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01031	 :   (3368.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01032	 :   (3552.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01033	 :   (3736.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01034	 :   (3920.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01035	 :   (4104.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01036	 :   (4288.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01037	 :   (4472.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01038	 :   (4656.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01039	 :   (4840.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01485	 :   (3184.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01222	 :   (5024.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01405	 :   (5024.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01404	 :   (4840.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01403	 :   (4656.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01402	 :   (4472.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01401	 :   (4288.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02480	 :   (2632.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02481	 :   (2816.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02482	 :   (3000.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02483	 :   (3184.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02484	 :   (3368.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02485	 :   (3552.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02486	 :   (3736.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02402	 :   (5024.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00492	 :   (4656.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00491	 :   (4472.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00490	 :   (4288.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00489	 :   (4104.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00488	 :   (3920.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00487	 :   (3736.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00486	 :   (3552.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00485	 :   (3368.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00484	 :   (3184.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00483	 :   (3000.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00482	 :   (2816.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00481	 :   (2632.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02401	 :   (4840.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01400	 :   (4104.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01027	 :   (2632.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01495	 :   (5024.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01494	 :   (4840.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01028	 :   (2816.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01029	 :   (3000.000000 9658.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01493	 :   (4656.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01492	 :   (4472.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01491	 :   (4288.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01490	 :   (4104.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01489	 :   (3920.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01488	 :   (3736.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01487	 :   (3552.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01486	 :   (3368.000000 8738.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01307	 :   (3736.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00391	 :   (3000.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00390	 :   (2816.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00389	 :   (2632.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01312	 :   (4656.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01311	 :   (4472.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01310	 :   (4288.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01117	 :   (2632.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01118	 :   (2816.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01119	 :   (3000.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01120	 :   (3184.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01121	 :   (3368.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01122	 :   (3552.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01309	 :   (4104.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01308	 :   (3920.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00392	 :   (3184.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01306	 :   (3552.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01305	 :   (3368.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01304	 :   (3184.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01303	 :   (3000.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01302	 :   (2816.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01301	 :   (2632.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01123	 :   (3736.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01124	 :   (3920.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01125	 :   (4104.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01126	 :   (4288.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01127	 :   (4472.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01130	 :   (5024.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01129	 :   (4840.000000 9474.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00400	 :   (4656.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01399	 :   (3920.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01398	 :   (3736.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01397	 :   (3552.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01396	 :   (3368.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01395	 :   (3184.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01394	 :   (3000.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01393	 :   (2816.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01392	 :   (2632.000000 8922.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02487	 :   (3920.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02488	 :   (4104.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02489	 :   (4288.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00402	 :   (5024.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00401	 :   (4840.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01758	 :   (3184.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00399	 :   (4472.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02490	 :   (4472.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02491	 :   (4656.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02492	 :   (4840.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02493	 :   (5024.000000 6714.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01314	 :   (5024.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01313	 :   (4840.000000 9106.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00398	 :   (4288.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00397	 :   (4104.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00396	 :   (3920.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00395	 :   (3736.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00394	 :   (3552.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00393	 :   (3368.000000 10946.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02392	 :   (3184.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01667	 :   (3368.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01666	 :   (3184.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01665	 :   (3000.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00579	 :   (4472.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00580	 :   (4656.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00581	 :   (4840.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00582	 :   (5024.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02389	 :   (2632.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02390	 :   (2816.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02391	 :   (3000.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01668	 :   (3552.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02393	 :   (3368.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02394	 :   (3552.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02395	 :   (3736.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02396	 :   (3920.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02397	 :   (4104.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02398	 :   (4288.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02399	 :   (4472.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02400	 :   (4656.000000 6898.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01586	 :   (5024.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01585	 :   (4840.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00572	 :   (3184.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01674	 :   (4656.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01675	 :   (4840.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02310	 :   (4656.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01673	 :   (4472.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01672	 :   (4288.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01671	 :   (4104.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02309	 :   (4472.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00569	 :   (2632.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00570	 :   (2816.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00571	 :   (3000.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02308	 :   (4288.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00573	 :   (3368.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00574	 :   (3552.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00575	 :   (3736.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00576	 :   (3920.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00577	 :   (4104.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01676	 :   (5024.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00578	 :   (4288.000000 10578.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01670	 :   (3920.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01669	 :   (3736.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01218	 :   (4288.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00946	 :   (4840.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00945	 :   (4656.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00944	 :   (4472.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00943	 :   (4288.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01576	 :   (3184.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01575	 :   (3000.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01574	 :   (2816.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01573	 :   (2632.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02307	 :   (4104.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01219	 :   (4472.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01220	 :   (4656.000000 9290.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01755	 :   (2632.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00494	 :   (5024.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00493	 :   (4840.000000 10762.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01756	 :   (2816.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01757	 :   (3000.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01759	 :   (3368.000000 8186.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02304	 :   (3552.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01584	 :   (4656.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01583	 :   (4472.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01582	 :   (4288.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01581	 :   (4104.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01580	 :   (3920.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01579	 :   (3736.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02306	 :   (3920.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01577	 :   (3368.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02305	 :   (3736.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01664	 :   (2816.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01663	 :   (2632.000000 8370.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02311	 :   (4840.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_02312	 :   (5024.000000 7082.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_01578	 :   (3552.000000 8554.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VSS_00947	 :   (5024.000000 9842.000000)	 :   PAR_1_1_VSS	  = PAR_1_1_VSS
* VDD075NNE_00670	 :   (4012.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00664	 :   (2908.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00663	 :   (2724.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00242	 :   (4380.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00241	 :   (4196.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00240	 :   (4012.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00239	 :   (3828.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00238	 :   (3644.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00237	 :   (3460.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00235	 :   (3092.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01096	 :   (2908.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00407	 :   (4932.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00406	 :   (4748.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00405	 :   (4564.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00404	 :   (4380.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00403	 :   (4196.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00402	 :   (4012.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00401	 :   (3828.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00233	 :   (2724.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00234	 :   (2908.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01256	 :   (3092.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00236	 :   (3276.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00400	 :   (3644.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00399	 :   (3460.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00398	 :   (3276.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00397	 :   (3092.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00396	 :   (2908.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00395	 :   (2724.000000 9566.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01254	 :   (2724.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01255	 :   (2908.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00457	 :   (4196.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00296	 :   (4380.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00297	 :   (4564.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00298	 :   (4748.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00299	 :   (4932.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00287	 :   (2724.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00674	 :   (4748.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00675	 :   (4932.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00455	 :   (3828.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00456	 :   (4012.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00295	 :   (4196.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00458	 :   (4380.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00459	 :   (4564.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00460	 :   (4748.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00461	 :   (4932.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00245	 :   (4932.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00244	 :   (4748.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00454	 :   (3644.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00453	 :   (3460.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00189	 :   (4564.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00187	 :   (4196.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00186	 :   (4012.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00185	 :   (3828.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00184	 :   (3644.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00183	 :   (3460.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00182	 :   (3276.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00181	 :   (3092.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00180	 :   (2908.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00179	 :   (2724.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00452	 :   (3276.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00190	 :   (4748.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00288	 :   (2908.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00289	 :   (3092.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00290	 :   (3276.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00291	 :   (3460.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00292	 :   (3644.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00293	 :   (3828.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00294	 :   (4012.000000 9934.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01264	 :   (4564.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00351	 :   (4564.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00352	 :   (4748.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00353	 :   (4932.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00188	 :   (4380.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00669	 :   (3828.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00668	 :   (3644.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00667	 :   (3460.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01266	 :   (4932.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01265	 :   (4748.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00350	 :   (4380.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01263	 :   (4380.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01262	 :   (4196.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01261	 :   (4012.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01260	 :   (3828.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01259	 :   (3644.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01258	 :   (3460.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01257	 :   (3276.000000 6622.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00666	 :   (3276.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00344	 :   (3276.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00451	 :   (3092.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00450	 :   (2908.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00449	 :   (2724.000000 9382.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00243	 :   (4564.000000 10118.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00191	 :   (4932.000000 10302.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00341	 :   (2724.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00342	 :   (2908.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00343	 :   (3092.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00665	 :   (3092.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00345	 :   (3460.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00346	 :   (3644.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00347	 :   (3828.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00348	 :   (4012.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00349	 :   (4196.000000 9750.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00673	 :   (4564.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00672	 :   (4380.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00671	 :   (4196.000000 8646.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00564	 :   (4196.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00888	 :   (4380.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00889	 :   (4564.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00890	 :   (4748.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00891	 :   (4932.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00568	 :   (4932.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00567	 :   (4748.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00566	 :   (4564.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00565	 :   (4380.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00887	 :   (4196.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00563	 :   (4012.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00562	 :   (3828.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00561	 :   (3644.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00560	 :   (3460.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00559	 :   (3092.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00727	 :   (4564.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00726	 :   (4380.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00725	 :   (4196.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00728	 :   (4748.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00831	 :   (3828.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00832	 :   (4012.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00833	 :   (4196.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00834	 :   (4380.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00835	 :   (4564.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00836	 :   (4748.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00837	 :   (4932.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00729	 :   (4932.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00724	 :   (4012.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00879	 :   (2724.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00880	 :   (2908.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00881	 :   (3092.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00882	 :   (3276.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00883	 :   (3460.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00884	 :   (3644.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00885	 :   (3828.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00886	 :   (4012.000000 7910.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00993	 :   (3828.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00718	 :   (2908.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00717	 :   (2724.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00987	 :   (2724.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00988	 :   (2908.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00989	 :   (3092.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00990	 :   (3276.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00991	 :   (3460.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00992	 :   (3644.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00945	 :   (4932.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00994	 :   (4012.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00995	 :   (4196.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00996	 :   (4380.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00997	 :   (4564.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00998	 :   (4748.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00999	 :   (4932.000000 7542.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00558	 :   (2908.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00557	 :   (2724.000000 9014.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00936	 :   (3276.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00723	 :   (3828.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00722	 :   (3644.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00721	 :   (3460.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00720	 :   (3276.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00719	 :   (3092.000000 8462.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00933	 :   (2724.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00934	 :   (2908.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00935	 :   (3092.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00830	 :   (3644.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00937	 :   (3460.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00938	 :   (3644.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00939	 :   (3828.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00940	 :   (4012.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00941	 :   (4196.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00942	 :   (4380.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00943	 :   (4564.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00944	 :   (4748.000000 7726.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00081	 :   (4564.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00130	 :   (3644.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00129	 :   (3460.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00128	 :   (3276.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00127	 :   (3092.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00126	 :   (2908.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00125	 :   (2724.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00083	 :   (4932.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00082	 :   (4748.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00131	 :   (3828.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00080	 :   (4380.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00079	 :   (4196.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00078	 :   (4012.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00077	 :   (3828.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00076	 :   (3644.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00075	 :   (3460.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00074	 :   (3276.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00073	 :   (3092.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00613	 :   (3460.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00621	 :   (4932.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00620	 :   (4748.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00619	 :   (4564.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00618	 :   (4380.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00617	 :   (4196.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00616	 :   (4012.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00615	 :   (3828.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00614	 :   (3644.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00072	 :   (2908.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00612	 :   (3276.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00611	 :   (3092.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00137	 :   (4932.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00136	 :   (4748.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00135	 :   (4564.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00134	 :   (4380.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00133	 :   (4196.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00132	 :   (4012.000000 10486.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00780	 :   (4380.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00772	 :   (2908.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00773	 :   (3092.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00774	 :   (3276.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00775	 :   (3460.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00776	 :   (3644.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00777	 :   (3828.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00778	 :   (4012.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00779	 :   (4196.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00771	 :   (2724.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00781	 :   (4564.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00782	 :   (4748.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00783	 :   (4932.000000 8278.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00825	 :   (2724.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00826	 :   (2908.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00827	 :   (3092.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00828	 :   (3276.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00829	 :   (3460.000000 8094.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00024	 :   (4012.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00071	 :   (2724.000000 10670.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00610	 :   (2908.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00609	 :   (2724.000000 8830.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00029	 :   (4932.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00028	 :   (4748.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00027	 :   (4564.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00026	 :   (4380.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00025	 :   (4196.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00504	 :   (2908.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00023	 :   (3828.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00022	 :   (3644.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00021	 :   (3460.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00020	 :   (3276.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00019	 :   (3092.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00018	 :   (2908.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00017	 :   (2724.000000 10854.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01154	 :   (3644.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01160	 :   (4748.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01159	 :   (4564.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01158	 :   (4380.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01149	 :   (2724.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01150	 :   (2908.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01151	 :   (3092.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01152	 :   (3276.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01153	 :   (3460.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01161	 :   (4932.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01205	 :   (3276.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01206	 :   (3460.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01053	 :   (4932.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01207	 :   (3644.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01208	 :   (3828.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01209	 :   (4012.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01210	 :   (4196.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01211	 :   (4380.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01103	 :   (4196.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00510	 :   (4012.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01102	 :   (4012.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01101	 :   (3828.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01100	 :   (3644.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00509	 :   (3828.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00508	 :   (3644.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00507	 :   (3460.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01202	 :   (2724.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01203	 :   (2908.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01204	 :   (3092.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01095	 :   (2724.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01099	 :   (3460.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01097	 :   (3092.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01098	 :   (3276.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01052	 :   (4748.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01107	 :   (4932.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00511	 :   (4196.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00512	 :   (4380.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00513	 :   (4564.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00514	 :   (4748.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01041	 :   (2724.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01042	 :   (2908.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01043	 :   (3092.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01044	 :   (3276.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01045	 :   (3460.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01046	 :   (3644.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01047	 :   (3828.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01048	 :   (4012.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01049	 :   (4196.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01050	 :   (4380.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01106	 :   (4748.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00515	 :   (4932.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01105	 :   (4564.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01104	 :   (4380.000000 7174.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01157	 :   (4196.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01156	 :   (4012.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00503	 :   (2724.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00505	 :   (3092.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_00506	 :   (3276.000000 9198.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01155	 :   (3828.000000 6990.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01214	 :   (4932.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01213	 :   (4748.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01212	 :   (4564.000000 6806.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VDD075NNE_01051	 :   (4564.000000 7358.000000)	 :   PAR_1_1_VDD075NNE	  = PAR_1_1_VDD075NNE
* VSS_02134	 :   (5576.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02495	 :   (5392.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02133	 :   (5392.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02132	 :   (5208.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01957	 :   (6680.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01958	 :   (6864.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01959	 :   (7048.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01960	 :   (7232.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01961	 :   (7416.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01327	 :   (7416.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02494	 :   (5208.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02041	 :   (5392.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01954	 :   (6128.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01415	 :   (6864.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01414	 :   (6680.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01413	 :   (6496.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01412	 :   (6312.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01411	 :   (6128.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01410	 :   (5944.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01409	 :   (5760.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01408	 :   (5576.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01407	 :   (5392.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01406	 :   (5208.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01953	 :   (5944.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02135	 :   (5760.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01955	 :   (6312.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01956	 :   (6496.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02144	 :   (7416.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02143	 :   (7232.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02142	 :   (7048.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02141	 :   (6864.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02140	 :   (6680.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02139	 :   (6496.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02138	 :   (6312.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02137	 :   (6128.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02136	 :   (5944.000000 7450.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02052	 :   (7416.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01315	 :   (5208.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02042	 :   (5576.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02043	 :   (5760.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02044	 :   (5944.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02045	 :   (6128.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02046	 :   (6312.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02047	 :   (6496.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02048	 :   (6680.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01140	 :   (6864.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01139	 :   (6680.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02049	 :   (6864.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02050	 :   (7048.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02051	 :   (7232.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01316	 :   (5392.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01235	 :   (7416.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01138	 :   (6496.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01137	 :   (6312.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01136	 :   (6128.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01135	 :   (5944.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01134	 :   (5760.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01133	 :   (5576.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01132	 :   (5392.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01131	 :   (5208.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01234	 :   (7232.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01233	 :   (7048.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01769	 :   (5208.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01141	 :   (7048.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02497	 :   (5760.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02498	 :   (5944.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02499	 :   (6128.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02500	 :   (6312.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02501	 :   (6496.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02502	 :   (6680.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02503	 :   (6864.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02504	 :   (7048.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02505	 :   (7232.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02506	 :   (7416.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01143	 :   (7416.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01142	 :   (7232.000000 9474.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02496	 :   (5576.000000 6714.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02040	 :   (5208.000000 7634.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01232	 :   (6864.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01326	 :   (7232.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01325	 :   (7048.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01324	 :   (6864.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01323	 :   (6680.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01322	 :   (6496.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01321	 :   (6312.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01320	 :   (6128.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01319	 :   (5944.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01318	 :   (5760.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01317	 :   (5576.000000 9106.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02228	 :   (6128.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01777	 :   (6680.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01778	 :   (6864.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02318	 :   (6128.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02319	 :   (6312.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02320	 :   (6496.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02321	 :   (6680.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02322	 :   (6864.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02323	 :   (7048.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02324	 :   (7232.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02325	 :   (7416.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01779	 :   (7048.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01780	 :   (7232.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02230	 :   (6496.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02229	 :   (6312.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01776	 :   (6496.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02227	 :   (5944.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01781	 :   (7416.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01231	 :   (6680.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01860	 :   (5208.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01599	 :   (7416.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01598	 :   (7232.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01597	 :   (7048.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01596	 :   (6864.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01595	 :   (6680.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01594	 :   (6496.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01593	 :   (6312.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01592	 :   (6128.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01591	 :   (5944.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01590	 :   (5760.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01679	 :   (5576.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01770	 :   (5392.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01689	 :   (7416.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01688	 :   (7232.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01687	 :   (7048.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01686	 :   (6864.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01685	 :   (6680.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02235	 :   (7416.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02234	 :   (7232.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02233	 :   (7048.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01684	 :   (6496.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01683	 :   (6312.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01682	 :   (6128.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01681	 :   (5944.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01680	 :   (5760.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01589	 :   (5576.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01678	 :   (5392.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01677	 :   (5208.000000 8370.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02232	 :   (6864.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02231	 :   (6680.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02313	 :   (5208.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02314	 :   (5392.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02315	 :   (5576.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02316	 :   (5760.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02317	 :   (5944.000000 7082.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01771	 :   (5576.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01772	 :   (5760.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01773	 :   (5944.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01774	 :   (6128.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01775	 :   (6312.000000 8186.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02224	 :   (5392.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02403	 :   (5208.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02404	 :   (5392.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02405	 :   (5576.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02406	 :   (5760.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02407	 :   (5944.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02408	 :   (6128.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02409	 :   (6312.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02410	 :   (6496.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02411	 :   (6680.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02412	 :   (6864.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02413	 :   (7048.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02414	 :   (7232.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01496	 :   (5208.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02225	 :   (5576.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01497	 :   (5392.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02223	 :   (5208.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01951	 :   (5576.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01952	 :   (5760.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02415	 :   (7416.000000 6898.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01223	 :   (5208.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01224	 :   (5392.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01225	 :   (5576.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01226	 :   (5760.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01227	 :   (5944.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01228	 :   (6128.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01229	 :   (6312.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01230	 :   (6496.000000 9290.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01418	 :   (7416.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01417	 :   (7232.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01949	 :   (5208.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01588	 :   (5392.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01587	 :   (5208.000000 8554.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01861	 :   (5392.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01862	 :   (5576.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01863	 :   (5760.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01864	 :   (5944.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01865	 :   (6128.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01866	 :   (6312.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01867	 :   (6496.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01868	 :   (6680.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01869	 :   (6864.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01870	 :   (7048.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01871	 :   (7232.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01872	 :   (7416.000000 8002.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01416	 :   (7048.000000 8922.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01508	 :   (7416.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01950	 :   (5392.000000 7818.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_02226	 :   (5760.000000 7266.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01507	 :   (7232.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01506	 :   (7048.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01505	 :   (6864.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01504	 :   (6680.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01503	 :   (6496.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01502	 :   (6312.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01501	 :   (6128.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01500	 :   (5944.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01499	 :   (5760.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01498	 :   (5576.000000 8738.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00865	 :   (6496.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00867	 :   (6864.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01042	 :   (5392.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01043	 :   (5576.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01044	 :   (5760.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01045	 :   (5944.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01046	 :   (6128.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01047	 :   (6312.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01048	 :   (6496.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01049	 :   (6680.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01050	 :   (6864.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01051	 :   (7048.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01052	 :   (7232.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00866	 :   (6680.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00868	 :   (7048.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00864	 :   (6312.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00415	 :   (7416.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00863	 :   (6128.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00862	 :   (5944.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01053	 :   (7416.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00505	 :   (7048.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00506	 :   (7232.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00507	 :   (7416.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00414	 :   (7232.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00413	 :   (7048.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00412	 :   (6864.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00861	 :   (5760.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00495	 :   (5208.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00499	 :   (5944.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00500	 :   (6128.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00501	 :   (6312.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00502	 :   (6496.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00503	 :   (6680.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00504	 :   (6864.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00677	 :   (5208.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00678	 :   (5392.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00679	 :   (5576.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00680	 :   (5760.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00498	 :   (5760.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00497	 :   (5576.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00496	 :   (5392.000000 10762.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00586	 :   (5760.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00681	 :   (5944.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00682	 :   (6128.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00683	 :   (6312.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00684	 :   (6496.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00685	 :   (6680.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00686	 :   (6864.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00687	 :   (7048.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_01041	 :   (5208.000000 9658.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00688	 :   (7232.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00689	 :   (7416.000000 10394.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00870	 :   (7416.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00869	 :   (7232.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00950	 :   (5576.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00406	 :   (5760.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00405	 :   (5576.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00404	 :   (5392.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00403	 :   (5208.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00770	 :   (5392.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00771	 :   (5576.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00772	 :   (5760.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00589	 :   (6312.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00588	 :   (6128.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00860	 :   (5576.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00948	 :   (5208.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00949	 :   (5392.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00407	 :   (5944.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00951	 :   (5760.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00952	 :   (5944.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00953	 :   (6128.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00858	 :   (5208.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00587	 :   (5944.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00960	 :   (7416.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00959	 :   (7232.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00958	 :   (7048.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00957	 :   (6864.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00956	 :   (6680.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00955	 :   (6496.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00954	 :   (6312.000000 9842.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00408	 :   (6128.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00585	 :   (5576.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00859	 :   (5392.000000 10026.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00584	 :   (5392.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00583	 :   (5208.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00781	 :   (7416.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00780	 :   (7232.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00779	 :   (7048.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00778	 :   (6864.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00595	 :   (7416.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00594	 :   (7232.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00593	 :   (7048.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00777	 :   (6680.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00776	 :   (6496.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00775	 :   (6312.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00774	 :   (6128.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00773	 :   (5944.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00592	 :   (6864.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00591	 :   (6680.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00590	 :   (6496.000000 10578.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00769	 :   (5208.000000 10210.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00411	 :   (6680.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00410	 :   (6496.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VSS_00409	 :   (6312.000000 10946.000000)	 :   PAR_2_1_VSS	  = PAR_2_1_VSS
* VDD075NNE_01061	 :   (6404.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01013	 :   (7508.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01113	 :   (6036.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01009	 :   (6772.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01002	 :   (5484.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01003	 :   (5668.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01001	 :   (5300.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01000	 :   (5116.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01004	 :   (5852.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01005	 :   (6036.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01006	 :   (6220.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01007	 :   (6404.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01008	 :   (6588.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01060	 :   (6220.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01010	 :   (6956.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01011	 :   (7140.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01012	 :   (7324.000000 7542.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01054	 :   (5116.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01055	 :   (5300.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01056	 :   (5484.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01057	 :   (5668.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01058	 :   (5852.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01059	 :   (6036.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00516	 :   (5116.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00524	 :   (6588.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00523	 :   (6404.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00522	 :   (6220.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00521	 :   (6036.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00520	 :   (5852.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00689	 :   (7508.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01162	 :   (5116.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01163	 :   (5300.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01164	 :   (5484.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01165	 :   (5668.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01166	 :   (5852.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00519	 :   (5668.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00518	 :   (5484.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00517	 :   (5300.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00525	 :   (6772.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01167	 :   (6036.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01168	 :   (6220.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01169	 :   (6404.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01170	 :   (6588.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01171	 :   (6772.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01172	 :   (6956.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01173	 :   (7140.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01174	 :   (7324.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01175	 :   (7508.000000 6990.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00688	 :   (7324.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00687	 :   (7140.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00686	 :   (6956.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01215	 :   (5116.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01115	 :   (6404.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01063	 :   (6772.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01064	 :   (6956.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01065	 :   (7140.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01066	 :   (7324.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01067	 :   (7508.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00624	 :   (5484.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01108	 :   (5116.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01109	 :   (5300.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01110	 :   (5484.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01111	 :   (5668.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01112	 :   (5852.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00948	 :   (5484.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01114	 :   (6220.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01062	 :   (6588.000000 7358.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01116	 :   (6588.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01117	 :   (6772.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01118	 :   (6956.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01119	 :   (7140.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01120	 :   (7324.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01121	 :   (7508.000000 7174.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00625	 :   (5668.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00626	 :   (5852.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00627	 :   (6036.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00529	 :   (7508.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00528	 :   (7324.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00527	 :   (7140.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00526	 :   (6956.000000 9198.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00784	 :   (5116.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00084	 :   (5116.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00043	 :   (7508.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00042	 :   (7324.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00041	 :   (7140.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00040	 :   (6956.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00039	 :   (6772.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00038	 :   (6588.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00037	 :   (6404.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00036	 :   (6220.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00035	 :   (6036.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00034	 :   (5852.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00033	 :   (5668.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00032	 :   (5484.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00031	 :   (5300.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00030	 :   (5116.000000 10854.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00085	 :   (5300.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00785	 :   (5300.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00786	 :   (5484.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00787	 :   (5668.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00788	 :   (5852.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00789	 :   (6036.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00790	 :   (6220.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00791	 :   (6404.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00792	 :   (6588.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00793	 :   (6772.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00794	 :   (6956.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00795	 :   (7140.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00796	 :   (7324.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00797	 :   (7508.000000 8278.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00740	 :   (6956.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00739	 :   (6772.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00138	 :   (5116.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00623	 :   (5300.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00622	 :   (5116.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00151	 :   (7508.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00150	 :   (7324.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00149	 :   (7140.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00148	 :   (6956.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00147	 :   (6772.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00146	 :   (6588.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00145	 :   (6404.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00144	 :   (6220.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00143	 :   (6036.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00142	 :   (5852.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00141	 :   (5668.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00140	 :   (5484.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00139	 :   (5300.000000 10486.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00738	 :   (6588.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00743	 :   (7508.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00742	 :   (7324.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00741	 :   (7140.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00097	 :   (7508.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00096	 :   (7324.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00095	 :   (7140.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00094	 :   (6956.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00093	 :   (6772.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00092	 :   (6588.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00091	 :   (6404.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00090	 :   (6220.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00089	 :   (6036.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00088	 :   (5852.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00087	 :   (5668.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00086	 :   (5484.000000 10670.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00571	 :   (5484.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00572	 :   (5668.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00892	 :   (5116.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00893	 :   (5300.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00894	 :   (5484.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00895	 :   (5668.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00896	 :   (5852.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00897	 :   (6036.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00898	 :   (6220.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00899	 :   (6404.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00900	 :   (6588.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00901	 :   (6772.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00902	 :   (6956.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00903	 :   (7140.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00904	 :   (7324.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00905	 :   (7508.000000 7910.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00573	 :   (5852.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00570	 :   (5300.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00569	 :   (5116.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00946	 :   (5116.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00947	 :   (5300.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00420	 :   (7324.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00949	 :   (5668.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00950	 :   (5852.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00951	 :   (6036.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00952	 :   (6220.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00953	 :   (6404.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00954	 :   (6588.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00955	 :   (6772.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00956	 :   (6956.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00957	 :   (7140.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00958	 :   (7324.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00845	 :   (6404.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00737	 :   (6404.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00736	 :   (6220.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00735	 :   (6036.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00734	 :   (5852.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00733	 :   (5668.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00732	 :   (5484.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00731	 :   (5300.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00730	 :   (5116.000000 8462.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00838	 :   (5116.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00839	 :   (5300.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00840	 :   (5484.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00841	 :   (5668.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00842	 :   (5852.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00843	 :   (6036.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00844	 :   (6220.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00959	 :   (7508.000000 7726.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00846	 :   (6588.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00847	 :   (6772.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00848	 :   (6956.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00849	 :   (7140.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00850	 :   (7324.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00851	 :   (7508.000000 8094.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00581	 :   (7324.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00580	 :   (7140.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00579	 :   (6956.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00578	 :   (6772.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00577	 :   (6588.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00576	 :   (6404.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00575	 :   (6220.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00574	 :   (6036.000000 9014.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01277	 :   (6956.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00205	 :   (7508.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00204	 :   (7324.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00203	 :   (7140.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00202	 :   (6956.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00201	 :   (6772.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00468	 :   (6220.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00469	 :   (6404.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01276	 :   (6772.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00635	 :   (7508.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01278	 :   (7140.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01279	 :   (7324.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01280	 :   (7508.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00470	 :   (6588.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00471	 :   (6772.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00472	 :   (6956.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00473	 :   (7140.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00474	 :   (7324.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00246	 :   (5116.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00247	 :   (5300.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00248	 :   (5484.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00249	 :   (5668.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00250	 :   (5852.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00251	 :   (6036.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00252	 :   (6220.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00253	 :   (6404.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00357	 :   (5668.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01275	 :   (6588.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01274	 :   (6404.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01273	 :   (6220.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01272	 :   (6036.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01271	 :   (5852.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01270	 :   (5668.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00359	 :   (6036.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00310	 :   (6956.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00300	 :   (5116.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00301	 :   (5300.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00302	 :   (5484.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00303	 :   (5668.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00304	 :   (5852.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00309	 :   (6772.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00308	 :   (6588.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00311	 :   (7140.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00358	 :   (5852.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00628	 :   (6220.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00629	 :   (6404.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00630	 :   (6588.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00631	 :   (6772.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00632	 :   (6956.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00633	 :   (7140.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01269	 :   (5484.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00192	 :   (5116.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00193	 :   (5300.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00194	 :   (5484.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00360	 :   (6220.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00361	 :   (6404.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00362	 :   (6588.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00363	 :   (6772.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00364	 :   (6956.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00365	 :   (7140.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00366	 :   (7324.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00367	 :   (7508.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00312	 :   (7324.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00313	 :   (7508.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00634	 :   (7324.000000 8830.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00475	 :   (7508.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00416	 :   (6588.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01222	 :   (6588.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01221	 :   (6404.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01220	 :   (6220.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01219	 :   (6036.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01218	 :   (5668.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01217	 :   (5484.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01216	 :   (5300.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00408	 :   (5116.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00409	 :   (5300.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00410	 :   (5484.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00411	 :   (5668.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00412	 :   (5852.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00413	 :   (6036.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00414	 :   (6220.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00415	 :   (6404.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01268	 :   (5300.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00417	 :   (6772.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00418	 :   (6956.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00421	 :   (7508.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00419	 :   (7140.000000 9566.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00467	 :   (6036.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00356	 :   (5484.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00355	 :   (5300.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00354	 :   (5116.000000 9750.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00195	 :   (5668.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00196	 :   (5852.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00197	 :   (6036.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00198	 :   (6220.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00199	 :   (6404.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00200	 :   (6588.000000 10302.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01224	 :   (6956.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01267	 :   (5116.000000 6622.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00676	 :   (5116.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00307	 :   (6404.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00306	 :   (6220.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00305	 :   (6036.000000 9934.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00259	 :   (7508.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00258	 :   (7324.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00257	 :   (7140.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00256	 :   (6956.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00255	 :   (6772.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00254	 :   (6588.000000 10118.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00462	 :   (5116.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00463	 :   (5300.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00464	 :   (5484.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00466	 :   (5852.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01223	 :   (6772.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01225	 :   (7140.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01226	 :   (7324.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_01227	 :   (7508.000000 6806.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00685	 :   (6772.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00684	 :   (6588.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00683	 :   (6404.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00682	 :   (6220.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00681	 :   (6036.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00680	 :   (5852.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00679	 :   (5668.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00678	 :   (5484.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00677	 :   (5300.000000 8646.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VDD075NNE_00465	 :   (5668.000000 9382.000000)	 :   PAR_2_1_VDD075NNE	  = PAR_2_1_VDD075NNE
* VSS_01509	 :   (7600.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01510	 :   (7784.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01511	 :   (7968.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01512	 :   (8152.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02425	 :   (9256.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02416	 :   (7600.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02417	 :   (7784.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02418	 :   (7968.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02419	 :   (8152.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02420	 :   (8336.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02421	 :   (8520.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02422	 :   (8704.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02423	 :   (8888.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02424	 :   (9072.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01422	 :   (8152.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02335	 :   (9256.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00965	 :   (8336.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00964	 :   (8152.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00963	 :   (7968.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00962	 :   (7784.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02339	 :   (9992.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02338	 :   (9808.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02337	 :   (9624.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02336	 :   (9440.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00966	 :   (8520.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02334	 :   (9072.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00508	 :   (7600.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00509	 :   (7784.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00510	 :   (7968.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00511	 :   (8152.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01600	 :   (7600.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01601	 :   (7784.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01602	 :   (7968.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01522	 :   (9992.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01514	 :   (8520.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01515	 :   (8704.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01516	 :   (8888.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01517	 :   (9072.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01518	 :   (9256.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01519	 :   (9440.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01520	 :   (9624.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01521	 :   (9808.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01513	 :   (8336.000000 8738.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00974	 :   (9992.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00973	 :   (9808.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00972	 :   (9624.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00971	 :   (9440.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00970	 :   (9256.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00969	 :   (9072.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00968	 :   (8888.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00967	 :   (8704.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01341	 :   (9992.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01329	 :   (7784.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01330	 :   (7968.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01331	 :   (8152.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01332	 :   (8336.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01333	 :   (8520.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01334	 :   (8704.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01335	 :   (8888.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01336	 :   (9072.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01337	 :   (9256.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01338	 :   (9440.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01339	 :   (9624.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01340	 :   (9808.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01328	 :   (7600.000000 9106.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01153	 :   (9256.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02520	 :   (9992.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02519	 :   (9808.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02518	 :   (9624.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02517	 :   (9440.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02516	 :   (9256.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02515	 :   (9072.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02514	 :   (8888.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02513	 :   (8704.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02512	 :   (8520.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02511	 :   (8336.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01247	 :   (9624.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01236	 :   (7600.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01237	 :   (7784.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01238	 :   (7968.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01239	 :   (8152.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01240	 :   (8336.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01241	 :   (8520.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01242	 :   (8704.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01243	 :   (8888.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01244	 :   (9072.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01245	 :   (9256.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01246	 :   (9440.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02510	 :   (8152.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01248	 :   (9808.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01249	 :   (9992.000000 9290.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01144	 :   (7600.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01145	 :   (7784.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01146	 :   (7968.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01147	 :   (8152.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01148	 :   (8336.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01149	 :   (8520.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01150	 :   (8704.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01151	 :   (8888.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01152	 :   (9072.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00421	 :   (8520.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01426	 :   (8888.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01427	 :   (9072.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01428	 :   (9256.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01429	 :   (9440.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01430	 :   (9624.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01431	 :   (9808.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01432	 :   (9992.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00416	 :   (7600.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00417	 :   (7784.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00418	 :   (7968.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00419	 :   (8152.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00420	 :   (8336.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01425	 :   (8704.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00422	 :   (8704.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00423	 :   (8888.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00424	 :   (9072.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00425	 :   (9256.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00426	 :   (9440.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00427	 :   (9624.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00428	 :   (9808.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00429	 :   (9992.000000 10946.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02429	 :   (9992.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02428	 :   (9808.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02427	 :   (9624.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01059	 :   (8520.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02509	 :   (7968.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02508	 :   (7784.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02507	 :   (7600.000000 6714.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01067	 :   (9992.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01066	 :   (9808.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01065	 :   (9624.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01064	 :   (9440.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01063	 :   (9256.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01062	 :   (9072.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01061	 :   (8888.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01060	 :   (8704.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02426	 :   (9440.000000 6898.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01058	 :   (8336.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01057	 :   (8152.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01056	 :   (7968.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01055	 :   (7784.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01054	 :   (7600.000000 9658.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01419	 :   (7600.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01420	 :   (7784.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01421	 :   (7968.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02060	 :   (8888.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01423	 :   (8336.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01424	 :   (8520.000000 8922.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01882	 :   (9256.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00697	 :   (8888.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00698	 :   (9072.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01873	 :   (7600.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01874	 :   (7784.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01875	 :   (7968.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01876	 :   (8152.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01877	 :   (8336.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01878	 :   (8520.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01879	 :   (8704.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01880	 :   (8888.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01881	 :   (9072.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00696	 :   (8704.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01883	 :   (9440.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01884	 :   (9624.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01885	 :   (9808.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01886	 :   (9992.000000 8002.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02152	 :   (8888.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02151	 :   (8704.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02150	 :   (8520.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02149	 :   (8336.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02148	 :   (8152.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02147	 :   (7968.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02146	 :   (7784.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00690	 :   (7600.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00881	 :   (9440.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00880	 :   (9256.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00879	 :   (9072.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00878	 :   (8888.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00877	 :   (8704.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00876	 :   (8520.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00875	 :   (8336.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00874	 :   (8152.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00873	 :   (7968.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00872	 :   (7784.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00871	 :   (7600.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02145	 :   (7600.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00691	 :   (7784.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00692	 :   (7968.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00693	 :   (8152.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00694	 :   (8336.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00695	 :   (8520.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02158	 :   (9992.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02157	 :   (9808.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02156	 :   (9624.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02155	 :   (9440.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02154	 :   (9256.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02153	 :   (9072.000000 7450.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02065	 :   (9808.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00785	 :   (8152.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00786	 :   (8336.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00787	 :   (8520.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00788	 :   (8704.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00789	 :   (8888.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00790	 :   (9072.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00791	 :   (9256.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00792	 :   (9440.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00793	 :   (9624.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00794	 :   (9808.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00795	 :   (9992.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00784	 :   (7968.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02064	 :   (9624.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02063	 :   (9440.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02062	 :   (9256.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02053	 :   (7600.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02054	 :   (7784.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02055	 :   (7968.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02056	 :   (8152.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02057	 :   (8336.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02058	 :   (8520.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02059	 :   (8704.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02061	 :   (9072.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01968	 :   (8704.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00699	 :   (9256.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00700	 :   (9440.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00701	 :   (9624.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00702	 :   (9808.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00703	 :   (9992.000000 10394.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01962	 :   (7600.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01963	 :   (7784.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01964	 :   (7968.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01965	 :   (8152.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01966	 :   (8336.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01967	 :   (8520.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01604	 :   (8336.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01969	 :   (8888.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01970	 :   (9072.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01971	 :   (9256.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01972	 :   (9440.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01973	 :   (9624.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01974	 :   (9808.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01975	 :   (9992.000000 7818.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02066	 :   (9992.000000 7634.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00782	 :   (7600.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00783	 :   (7784.000000 10210.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01610	 :   (9440.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01693	 :   (8152.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01694	 :   (8336.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01695	 :   (8520.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01696	 :   (8704.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01697	 :   (8888.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01698	 :   (9072.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01699	 :   (9256.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01700	 :   (9440.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01701	 :   (9624.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01612	 :   (9808.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01611	 :   (9624.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01692	 :   (7968.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01609	 :   (9256.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01608	 :   (9072.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01607	 :   (8888.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01606	 :   (8704.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01605	 :   (8520.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01603	 :   (8152.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01702	 :   (9808.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00596	 :   (7600.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00597	 :   (7784.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00598	 :   (7968.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00599	 :   (8152.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00514	 :   (8704.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00515	 :   (8888.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00516	 :   (9072.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00517	 :   (9256.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00518	 :   (9440.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00519	 :   (9624.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00520	 :   (9808.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00521	 :   (9992.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02330	 :   (8336.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02329	 :   (8152.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02328	 :   (7968.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02327	 :   (7784.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01703	 :   (9992.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00513	 :   (8520.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00512	 :   (8336.000000 10762.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02331	 :   (8520.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02332	 :   (8704.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02333	 :   (8888.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01613	 :   (9992.000000 8554.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02326	 :   (7600.000000 7082.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00961	 :   (7600.000000 9842.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01690	 :   (7600.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01691	 :   (7784.000000 8370.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01786	 :   (8336.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00608	 :   (9808.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00600	 :   (8336.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00882	 :   (9624.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02240	 :   (8336.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02239	 :   (8152.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02238	 :   (7968.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02237	 :   (7784.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02236	 :   (7600.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01782	 :   (7600.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01783	 :   (7784.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01784	 :   (7968.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01785	 :   (8152.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00609	 :   (9992.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01787	 :   (8520.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01788	 :   (8704.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01789	 :   (8888.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01790	 :   (9072.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01791	 :   (9256.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01792	 :   (9440.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01793	 :   (9624.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01794	 :   (9808.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01795	 :   (9992.000000 8186.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00884	 :   (9992.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00883	 :   (9808.000000 10026.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00606	 :   (9440.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00601	 :   (8520.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00602	 :   (8704.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00603	 :   (8888.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01154	 :   (9440.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01155	 :   (9624.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01156	 :   (9808.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_01157	 :   (9992.000000 9474.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02249	 :   (9992.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02248	 :   (9808.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02243	 :   (8888.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00607	 :   (9624.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00605	 :   (9256.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_00604	 :   (9072.000000 10578.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02241	 :   (8520.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02242	 :   (8704.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02247	 :   (9624.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02244	 :   (9072.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02245	 :   (9256.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VSS_02246	 :   (9440.000000 7266.000000)	 :   PAR_3_1_VSS	  = PAR_3_1_VSS
* VDD075NNE_00745	 :   (7876.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00746	 :   (8060.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00747	 :   (8244.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00748	 :   (8428.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00750	 :   (8796.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00751	 :   (8980.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00752	 :   (9164.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00749	 :   (8612.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00753	 :   (9348.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00162	 :   (9532.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00690	 :   (7692.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00702	 :   (9900.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00636	 :   (7692.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00701	 :   (9716.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00700	 :   (9532.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00699	 :   (9348.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00698	 :   (9164.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00697	 :   (8980.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00696	 :   (8796.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00695	 :   (8612.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00694	 :   (8428.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00693	 :   (8244.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00692	 :   (8060.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00691	 :   (7876.000000 8646.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00744	 :   (7692.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00648	 :   (9900.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00647	 :   (9716.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00646	 :   (9532.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00645	 :   (9348.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00644	 :   (9164.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00643	 :   (8980.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00642	 :   (8796.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00641	 :   (8612.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00640	 :   (8428.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00639	 :   (8244.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00638	 :   (8060.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00637	 :   (7876.000000 8830.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01125	 :   (8244.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01074	 :   (8796.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01075	 :   (8980.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01076	 :   (9164.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01077	 :   (9348.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01078	 :   (9532.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01079	 :   (9716.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01080	 :   (9900.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01122	 :   (7692.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01123	 :   (7876.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01124	 :   (8060.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01073	 :   (8612.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01126	 :   (8428.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01127	 :   (8612.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01128	 :   (8796.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01129	 :   (8980.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01130	 :   (9164.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01131	 :   (9348.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01132	 :   (9532.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01133	 :   (9716.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01134	 :   (9900.000000 7174.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01176	 :   (7692.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01021	 :   (8980.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00970	 :   (9532.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00971	 :   (9716.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00972	 :   (9900.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01014	 :   (7692.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01015	 :   (7876.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01016	 :   (8060.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01017	 :   (8244.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01018	 :   (8428.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01019	 :   (8612.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01020	 :   (8796.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01177	 :   (7876.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01022	 :   (9164.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01023	 :   (9348.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01024	 :   (9532.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01025	 :   (9716.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01026	 :   (9900.000000 7542.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01068	 :   (7692.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01069	 :   (7876.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01070	 :   (8060.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01071	 :   (8244.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01072	 :   (8428.000000 7358.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01290	 :   (9348.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01239	 :   (9900.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01281	 :   (7692.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01282	 :   (7876.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01283	 :   (8060.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01284	 :   (8244.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01285	 :   (8428.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01286	 :   (8612.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01287	 :   (8796.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01288	 :   (8980.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01289	 :   (9164.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01238	 :   (9716.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01291	 :   (9532.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01292	 :   (9716.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01293	 :   (9900.000000 6622.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00163	 :   (9716.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00164	 :   (9900.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00206	 :   (7692.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00207	 :   (7876.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00208	 :   (8060.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00209	 :   (8244.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00210	 :   (8428.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01188	 :   (9900.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01178	 :   (8060.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01179	 :   (8244.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01180	 :   (8428.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01181	 :   (8612.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01182	 :   (8796.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01183	 :   (8980.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01184	 :   (9164.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01185	 :   (9348.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01186	 :   (9532.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01187	 :   (9716.000000 6990.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00969	 :   (9348.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01228	 :   (7692.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01229	 :   (7876.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01230	 :   (8060.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01231	 :   (8244.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01232	 :   (8428.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01233	 :   (8612.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01234	 :   (8796.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01235	 :   (8980.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01236	 :   (9348.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_01237	 :   (9532.000000 6806.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00047	 :   (8244.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00098	 :   (7692.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00056	 :   (9900.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00055	 :   (9716.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00054	 :   (9532.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00053	 :   (9348.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00052	 :   (9164.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00051	 :   (8980.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00050	 :   (8796.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00049	 :   (8612.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00048	 :   (8428.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00099	 :   (7876.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00046	 :   (8060.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00045	 :   (7876.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00044	 :   (7692.000000 10854.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00754	 :   (9532.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00755	 :   (9716.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00756	 :   (9900.000000 8462.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00798	 :   (7692.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00799	 :   (7876.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00800	 :   (8060.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00801	 :   (8244.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00110	 :   (9900.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00161	 :   (9348.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00160	 :   (9164.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00159	 :   (8980.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00158	 :   (8796.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00157	 :   (8612.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00156	 :   (8428.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00155	 :   (8244.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00154	 :   (8060.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00153	 :   (7876.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00152	 :   (7692.000000 10486.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00802	 :   (8428.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00109	 :   (9716.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00108	 :   (9532.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00107	 :   (9348.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00106	 :   (9164.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00105	 :   (8980.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00104	 :   (8796.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00103	 :   (8612.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00102	 :   (8428.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00101	 :   (8244.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00100	 :   (8060.000000 10670.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00917	 :   (9716.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00907	 :   (7876.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00908	 :   (8060.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00909	 :   (8244.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00910	 :   (8428.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00911	 :   (8612.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00912	 :   (8796.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00913	 :   (8980.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00914	 :   (9164.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00915	 :   (9348.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00916	 :   (9532.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00906	 :   (7692.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00918	 :   (9900.000000 7910.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00960	 :   (7692.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00961	 :   (7876.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00962	 :   (8060.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00963	 :   (8244.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00964	 :   (8428.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00965	 :   (8612.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00966	 :   (8796.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00967	 :   (8980.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00968	 :   (9164.000000 7726.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00854	 :   (8060.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00803	 :   (8612.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00804	 :   (8796.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00805	 :   (8980.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00806	 :   (9164.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00807	 :   (9348.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00808	 :   (9532.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00809	 :   (9716.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00810	 :   (9900.000000 8278.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00852	 :   (7692.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00853	 :   (7876.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00593	 :   (9716.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00855	 :   (8244.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00856	 :   (8428.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00857	 :   (8612.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00858	 :   (8796.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00859	 :   (8980.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00860	 :   (9164.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00861	 :   (9348.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00862	 :   (9532.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00863	 :   (9716.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00864	 :   (9900.000000 8094.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00424	 :   (8060.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00374	 :   (8796.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00375	 :   (8980.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00376	 :   (9164.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00377	 :   (9348.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00378	 :   (9532.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00379	 :   (9716.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00380	 :   (9900.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00422	 :   (7692.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00423	 :   (7876.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00373	 :   (8612.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00425	 :   (8244.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00426	 :   (8428.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00427	 :   (8612.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00428	 :   (8796.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00429	 :   (8980.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00430	 :   (9164.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00431	 :   (9348.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00432	 :   (9532.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00433	 :   (9716.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00322	 :   (9164.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00272	 :   (9900.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00314	 :   (7692.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00315	 :   (7876.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00316	 :   (8060.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00317	 :   (8244.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00318	 :   (8428.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00319	 :   (8612.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00320	 :   (8796.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00321	 :   (8980.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00434	 :   (9900.000000 9566.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00323	 :   (9348.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00324	 :   (9532.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00325	 :   (9716.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00326	 :   (9900.000000 9934.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00368	 :   (7692.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00369	 :   (7876.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00370	 :   (8060.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00371	 :   (8244.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00372	 :   (8428.000000 9750.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00584	 :   (8060.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00536	 :   (8796.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00537	 :   (8980.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00538	 :   (9164.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00539	 :   (9348.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00540	 :   (9532.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00541	 :   (9716.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00542	 :   (9900.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00582	 :   (7692.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00583	 :   (7876.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00535	 :   (8612.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00585	 :   (8244.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00586	 :   (8428.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00587	 :   (8612.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00588	 :   (8796.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00589	 :   (8980.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00590	 :   (9164.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00591	 :   (9348.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00592	 :   (9532.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00594	 :   (9900.000000 9014.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00485	 :   (9348.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00476	 :   (7692.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00477	 :   (7876.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00478	 :   (8060.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00479	 :   (8244.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00480	 :   (8428.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00481	 :   (8612.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00482	 :   (8796.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00483	 :   (8980.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00484	 :   (9164.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00212	 :   (8796.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00486	 :   (9532.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00487	 :   (9716.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00488	 :   (9900.000000 9382.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00530	 :   (7692.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00531	 :   (7876.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00532	 :   (8060.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00533	 :   (8244.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00534	 :   (8428.000000 9198.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00211	 :   (8612.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00265	 :   (8612.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00264	 :   (8428.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00263	 :   (8244.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00218	 :   (9900.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00217	 :   (9716.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00262	 :   (8060.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00261	 :   (7876.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00260	 :   (7692.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00266	 :   (8796.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00267	 :   (8980.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00268	 :   (9164.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00270	 :   (9532.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00213	 :   (8980.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00214	 :   (9164.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00215	 :   (9348.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00216	 :   (9532.000000 10302.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00269	 :   (9348.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VDD075NNE_00271	 :   (9716.000000 10118.000000)	 :   PAR_3_1_VDD075NNE	  = PAR_3_1_VDD075NNE
* VSS_02649	 :   (792.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02648	 :   (608.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02650	 :   (976.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02651	 :   (1160.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02647	 :   (424.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04150	 :   (240.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03297	 :   (424.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04151	 :   (424.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04152	 :   (608.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04153	 :   (792.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04154	 :   (976.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04155	 :   (1160.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04156	 :   (1344.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04157	 :   (1528.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04158	 :   (1712.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04159	 :   (1896.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04160	 :   (2080.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04161	 :   (2264.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04162	 :   (2448.000000 3402.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02646	 :   (240.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03964	 :   (976.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03298	 :   (608.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03299	 :   (792.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03300	 :   (976.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04059	 :   (976.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03304	 :   (1712.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03965	 :   (1160.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03966	 :   (1344.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03967	 :   (1528.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03968	 :   (1712.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03969	 :   (1896.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03970	 :   (2080.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03971	 :   (2264.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03972	 :   (2448.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03301	 :   (1160.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04055	 :   (240.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04056	 :   (424.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04057	 :   (608.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04058	 :   (792.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02652	 :   (1344.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04060	 :   (1160.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04061	 :   (1344.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04062	 :   (1528.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04063	 :   (1712.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04064	 :   (1896.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04065	 :   (2080.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04066	 :   (2264.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04067	 :   (2448.000000 3586.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02658	 :   (2448.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02657	 :   (2264.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02656	 :   (2080.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02655	 :   (1896.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02654	 :   (1712.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02653	 :   (1528.000000 6346.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03204	 :   (792.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03018	 :   (1896.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03017	 :   (1712.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03016	 :   (1528.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03015	 :   (1344.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03014	 :   (1160.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03201	 :   (240.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03202	 :   (424.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03203	 :   (608.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03019	 :   (2080.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03205	 :   (976.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03206	 :   (1160.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03207	 :   (1344.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03208	 :   (1528.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03209	 :   (1712.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03210	 :   (1896.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02557	 :   (240.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02558	 :   (424.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03020	 :   (2264.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03021	 :   (2448.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03116	 :   (2448.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03115	 :   (2264.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03114	 :   (2080.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03113	 :   (1896.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03112	 :   (1712.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03111	 :   (1528.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03110	 :   (1344.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03109	 :   (1160.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03108	 :   (976.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03107	 :   (792.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03106	 :   (608.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03105	 :   (424.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03104	 :   (240.000000 5426.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04245	 :   (240.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04253	 :   (1712.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04252	 :   (1528.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04251	 :   (1344.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04250	 :   (1160.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04249	 :   (976.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04248	 :   (792.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04247	 :   (608.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04246	 :   (424.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04254	 :   (1896.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03212	 :   (2264.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03213	 :   (2448.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03013	 :   (976.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03012	 :   (792.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03011	 :   (608.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03010	 :   (424.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03009	 :   (240.000000 5610.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03296	 :   (240.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04255	 :   (2080.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04256	 :   (2264.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_04257	 :   (2448.000000 3218.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03211	 :   (2080.000000 5242.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02569	 :   (2448.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02568	 :   (2264.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02567	 :   (2080.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02566	 :   (1896.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02565	 :   (1712.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02564	 :   (1528.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02563	 :   (1344.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02562	 :   (1160.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02561	 :   (976.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02560	 :   (792.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02559	 :   (608.000000 6530.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03584	 :   (976.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03395	 :   (1160.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03394	 :   (976.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03393	 :   (792.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03392	 :   (608.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03391	 :   (424.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02840	 :   (2448.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02839	 :   (2264.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02838	 :   (2080.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02837	 :   (1896.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02836	 :   (1712.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02835	 :   (1528.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03580	 :   (240.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03581	 :   (424.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03582	 :   (608.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03583	 :   (792.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02917	 :   (240.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03585	 :   (1160.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03586	 :   (1344.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03587	 :   (1528.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03588	 :   (1712.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03589	 :   (1896.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03590	 :   (2080.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03591	 :   (2264.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03592	 :   (2448.000000 4506.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02834	 :   (1344.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03675	 :   (240.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03676	 :   (424.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03677	 :   (608.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03678	 :   (792.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03679	 :   (976.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03680	 :   (1160.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02920	 :   (792.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03398	 :   (1712.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03399	 :   (1896.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03400	 :   (2080.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03401	 :   (2264.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03402	 :   (2448.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03396	 :   (1344.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02929	 :   (2448.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02928	 :   (2264.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02927	 :   (2080.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02926	 :   (1896.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02925	 :   (1712.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02924	 :   (1528.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02923	 :   (1344.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02922	 :   (1160.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02921	 :   (976.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03681	 :   (1344.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02919	 :   (608.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02918	 :   (424.000000 5794.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03485	 :   (240.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03486	 :   (424.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03487	 :   (608.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03488	 :   (792.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03489	 :   (976.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03490	 :   (1160.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03491	 :   (1344.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03492	 :   (1528.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03493	 :   (1712.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03494	 :   (1896.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03495	 :   (2080.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03496	 :   (2264.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03497	 :   (2448.000000 4690.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03873	 :   (1712.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02744	 :   (1528.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02743	 :   (1344.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02742	 :   (1160.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02741	 :   (976.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02740	 :   (792.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02739	 :   (608.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02738	 :   (424.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03865	 :   (240.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03866	 :   (424.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03867	 :   (608.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03868	 :   (792.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03869	 :   (976.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03870	 :   (1160.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03871	 :   (1344.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03872	 :   (1528.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02745	 :   (1712.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03874	 :   (1896.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03875	 :   (2080.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03876	 :   (2264.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03877	 :   (2448.000000 3954.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02737	 :   (240.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03308	 :   (2448.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03307	 :   (2264.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03306	 :   (2080.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03305	 :   (1896.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03397	 :   (1528.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03303	 :   (1528.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03302	 :   (1344.000000 5058.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03960	 :   (240.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03961	 :   (424.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03962	 :   (608.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03772	 :   (608.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03682	 :   (1528.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03683	 :   (1712.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03684	 :   (1896.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03685	 :   (2080.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03686	 :   (2264.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03687	 :   (2448.000000 4322.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02833	 :   (1160.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02832	 :   (976.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02831	 :   (792.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02830	 :   (608.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02829	 :   (424.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02828	 :   (240.000000 5978.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03390	 :   (240.000000 4874.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03770	 :   (240.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03771	 :   (424.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03963	 :   (792.000000 3770.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03773	 :   (792.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03774	 :   (976.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03775	 :   (1160.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03776	 :   (1344.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03777	 :   (1528.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03778	 :   (1712.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03779	 :   (1896.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03780	 :   (2080.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03781	 :   (2264.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_03782	 :   (2448.000000 4138.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02749	 :   (2448.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02748	 :   (2264.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02747	 :   (2080.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* VSS_02746	 :   (1896.000000 6162.000000)	 :   PAR_0_0_VSS	  = PAR_0_0_VSS
* End Chip Package Protocol <---

.subckt adsPowerModel
+ PAR_0_0_VDD075NNE PAR_1_0_VSS PAR_1_0_VDD075NNE PAR_2_0_VSS PAR_2_0_VDD075NNE
+ PAR_3_0_VSS PAR_3_0_VDD075NNE PAR_0_1_VSS PAR_0_1_VDD075NNE PAR_1_1_VSS
+ PAR_1_1_VDD075NNE PAR_2_1_VSS PAR_2_1_VDD075NNE PAR_3_1_VSS PAR_3_1_VDD075NNE
+ PAR_0_0_VSS

Xpdn
+ PAR_0_0_VDD075NNE PAR_1_0_VSS PAR_1_0_VDD075NNE PAR_2_0_VSS PAR_2_0_VDD075NNE
+ PAR_3_0_VSS PAR_3_0_VDD075NNE PAR_0_1_VSS PAR_0_1_VDD075NNE PAR_1_1_VSS
+ PAR_1_1_VDD075NNE PAR_2_1_VSS PAR_2_1_VDD075NNE PAR_3_1_VSS PAR_3_1_VDD075NNE
+ PAR_0_0_VSS
+ PowerModel

* CPM Port Name | Average current (A) | Max. magnitude of current | Net voltage *
* PAR_0_0_VSS -3.73536 5.10844 0
* PAR_0_0_VDD075NNE 4.17578 7.74687 0.7125
* PAR_1_0_VSS -3.80984 5.35321 0
* PAR_1_0_VDD075NNE 3.79172 6.90731 0.7125
* PAR_2_0_VSS -3.69164 5.30191 0
* PAR_2_0_VDD075NNE 4.07567 7.36738 0.7125
* PAR_3_0_VSS -5.05814 8.04883 0
* PAR_3_0_VDD075NNE 5.31282 11.5551 0.7125
* PAR_0_1_VSS -19.6666 27.8128 0
* PAR_0_1_VDD075NNE 21.8669 38.7293 0.7125
* PAR_1_1_VSS -19.8214 30.4777 0
* PAR_1_1_VDD075NNE 19.75 36.6949 0.7125
* PAR_2_1_VSS -18.9626 27.6987 0
* PAR_2_1_VDD075NNE 22.0788 40.0233 0.7125
* PAR_3_1_VSS -19.1364 26.4486 0
* PAR_3_1_VDD075NNE 19.8665 33.9918 0.7125
* Average power = 71.9042 W.

Icursig1 PAR_0_0_VDD075NNE 0 pwl(
+ 0.000000ps      0.56955719
+ 10.000000ps      0.63936858
+ 20.000000ps      0.90415121
+ 29.999999ps       1.2452308
+ 40.000000ps       1.5648984
+ 50.000001ps       1.8439716
+ 59.999998ps       2.0922152
+ 69.999999ps       2.2617654
+ 80.000000ps       2.3773915
+ 90.000001ps       2.4573044
+ 100.000001ps       2.4891991
+ 110.000002ps       2.4681143
+ 119.999996ps       2.4489592
+ 129.999997ps       2.5003369
+ 139.999998ps       2.5984483
+ 149.999999ps       2.7682726
+ 159.999999ps       2.9117756
+ 170.000000ps       3.0079369
+ 180.000001ps       3.0060014
+ 190.000002ps       2.9245496
+ 200.000003ps       2.7926398
+ 210.000003ps       2.6634861
+ 220.000004ps       2.5860371
+ 230.000005ps       2.5603744
+ 239.999992ps       2.5658673
+ 249.999993ps         2.56365
+ 259.999994ps        2.543451
+ 269.999995ps       2.5032945
+ 279.999995ps       2.4486437
+ 289.999996ps       2.3867242
+ 299.999997ps       2.3322318
+ 309.999998ps       2.3241968
+ 319.999999ps       2.4765203
+ 330.000000ps       2.7975716
+ 340.000000ps       3.2096151
+ 350.000001ps       3.6659843
+ 360.000002ps       4.0856127
+ 370.000003ps       4.3752991
+ 380.000004ps       4.4879418
+ 390.000005ps       4.5606617
+ 400.000005ps       4.6979996
+ 410.000006ps       5.0482838
+ 420.000007ps       5.5710183
+ 430.000008ps       6.2876407
+ 440.000009ps       6.9816604
+ 450.000009ps       7.4642038
+ 460.000010ps       7.6542006
+ 469.999983ps        7.609061
+ 479.999984ps       7.3773234
+ 489.999985ps       7.0663479
+ 499.999986ps       6.7405273
+ 509.999987ps       6.3864131
+ 519.999988ps       6.0617563
+ 529.999988ps       5.7579432
+ 539.999989ps       5.4807829
+ 549.999990ps       5.1817352
+ 559.999991ps       4.8783171
+ 569.999992ps       4.5332118
+ 579.999992ps       4.2103177
+ 589.999993ps       3.9322822
+ 599.999994ps        3.678944
+ 609.999995ps       3.4598279
+ 619.999996ps       3.3024859
+ 629.999997ps       3.2406496
+ 639.999997ps       3.2604128
+ 649.999998ps       3.3257858
+ 659.999999ps       3.3345727
+ 670.000000ps       3.2677479
+ 680.000001ps       3.1354165
+ 690.000002ps       2.9672512
+ 700.000002ps       2.7824952
+ 710.000003ps       2.6230763
+ 720.000004ps       2.5229026
+ 730.000005ps       2.4822662
+ 740.000006ps       2.4777738
+ 750.000007ps       2.4615869
+ 760.000007ps       2.4239423
+ 770.000008ps       2.3742405
+ 780.000009ps       2.3193947
+ 790.000010ps       2.2661767
+ 800.000011ps       2.2163312
+ 810.000012ps       2.2165369
+ 820.000012ps       2.3689697
+ 830.000013ps       2.6945463
+ 840.000014ps       3.1111534
+ 850.000015ps       3.5625138
+ 860.000016ps       3.9801249
+ 870.000016ps       4.2768198
+ 880.000017ps       4.4004267
+ 890.000018ps       4.4838622
+ 900.000019ps       4.6383303
+ 910.000020ps       4.9984566
+ 920.000021ps       5.5230625
+ 930.000021ps       6.2087274
+ 939.999967ps        6.834534
+ 949.999968ps       7.2310023
+ 959.999968ps        7.328015
+ 969.999969ps       7.2006103
+ 979.999970ps       6.9422126
+ 989.999971ps       6.6650316
+ 999.999972ps       6.4084353
+ 1009.999973ps       6.0853779
+ 1019.999973ps       5.8349707
+ 1029.999974ps       5.5909442
+ 1039.999975ps       5.3287169
+ 1049.999976ps       5.0200348
+ 1059.999977ps       4.7014441
+ 1069.999978ps       4.3638578
+ 1079.999978ps       4.0166279
+ 1089.999979ps       3.7104747
+ 1099.999980ps       3.4315089
+ 1109.999981ps       3.1574232
+ 1119.999982ps       2.9420601
+ 1129.999982ps       2.8343462
+ 1139.999983ps       2.8183185
+ 1149.999984ps       2.9109965
+ 1159.999985ps        3.011452
+ 1169.999986ps       3.0753977
+ 1179.999987ps        3.044692
+ 1189.999987ps       2.9269365
+ 1199.999988ps       2.7694375
+ 1209.999989ps       2.6275838
+ 1219.999990ps        2.537833
+ 1229.999991ps       2.5093954
+ 1239.999992ps       2.5144464
+ 1249.999992ps       2.4983402
+ 1259.999993ps       2.4607108
+ 1269.999994ps       2.4053297
+ 1279.999995ps       2.3439669
+ 1289.999996ps       2.2867075
+ 1299.999997ps       2.2321224
+ 1309.999997ps       2.2240469
+ 1319.999998ps       2.3694611
+ 1329.999999ps       2.6867349
+ 1340.000000ps       3.0856987
+ 1350.000001ps       3.5369428
+ 1360.000002ps       3.9556549
+ 1370.000002ps       4.2593187
+ 1380.000003ps       4.3860837
+ 1390.000004ps       4.4748652
+ 1400.000005ps       4.6411741
+ 1410.000006ps       5.0198308
+ 1420.000006ps       5.5582141
+ 1430.000007ps       6.2780769
+ 1440.000008ps       6.9563678
+ 1450.000009ps       7.3980897
+ 1460.000010ps       7.5399539
+ 1470.000011ps       7.4374688
+ 1480.000011ps       7.1716672
+ 1490.000012ps       6.8697218
+ 1500.000013ps       6.5914562
+ 1510.000014ps       6.2835492
+ 1520.000015ps       6.0128011
+ 1530.000016ps       5.7398852
+ 1540.000016ps       5.4728684
+ 1550.000017ps       5.1678791
+ 1560.000018ps       4.8637532
+ 1570.000019ps       4.5366339
+ 1580.000020ps       4.2245819
+ 1590.000021ps       3.9473322
+ 1600.000021ps       3.6961149
+ 1610.000022ps       3.4623526
+ 1620.000023ps       3.2655815
+ 1630.000024ps       3.1498072
+ 1640.000025ps       3.1148312
+ 1650.000025ps       3.1677022
+ 1660.000026ps        3.211558
+ 1670.000027ps       3.2094958
+ 1680.000028ps       3.1166186
+ 1690.000029ps       2.9587245
+ 1700.000030ps       2.7689566
+ 1710.000030ps        2.605723
+ 1720.000031ps       2.5052826
+ 1730.000032ps       2.4655306
+ 1740.000033ps       2.4608223
+ 1750.000034ps        2.444958
+ 1760.000035ps       2.4161656
+ 1770.000035ps         2.38136
+ 1780.000036ps       2.3410446
+ 1790.000037ps       2.2900196
+ 1800.000038ps       2.2453862
+ 1810.000039ps       2.2389101
+ 1820.000040ps       2.3805929
+ 1830.000040ps       2.7012967
+ 1840.000041ps       3.1122854
+ 1850.000042ps       3.5705899
+ 1860.000043ps       3.9950651
+ 1869.999933ps       4.2947459
+ 1879.999934ps       4.4051192
+ 1889.999934ps       4.4822605
+ 1899.999935ps       4.6300825
+ 1909.999936ps       4.9807441
+ 1919.999937ps       5.5137453
+ 1929.999938ps       6.2204453
+ 1939.999938ps       6.8646375
+ 1949.999939ps       7.2717484
+ 1959.999940ps          7.3891
+ 1969.999941ps       7.2862805
+ 1979.999942ps       7.0313427
+ 1989.999943ps       6.7366291
+ 1999.999943ps       6.4646484
+ 2009.999944ps       6.1348593
+ 2019.999945ps       5.8584906
+ 2029.999946ps        5.598857
+ 2039.999947ps       5.3333171
+ 2049.999948ps       5.0346852
+ 2059.999948ps       4.7224211
+ 2069.999949ps       4.4062374
+ 2079.999950ps       4.0923522
+ 2089.999951ps       3.8088885
+ 2099.999952ps       3.5448148
+ 2109.999953ps       3.2733993
+ 2119.999953ps       3.0588954
+ 2129.999954ps       2.9446241
+ 2139.999955ps       2.9338305
+ 2149.999956ps       3.0329025
+ 2159.999957ps       3.1005039
+ 2169.999958ps       3.1114829
+ 2179.999958ps       3.0300423
+ 2189.999959ps       2.8983196
+ 2199.999960ps       2.7346016
+ 2209.999961ps       2.5861543
+ 2219.999962ps       2.4898513
+ 2229.999962ps       2.4520261
+ 2239.999963ps       2.4463366
+ 2249.999964ps       2.4276839
+ 2259.999965ps       2.3883398
+ 2269.999966ps       2.3392806
+ 2279.999967ps       2.2856507
+ 2289.999967ps       2.2275431
+ 2299.999968ps       2.1825628
+ 2309.999969ps       2.1880535
+ 2319.999970ps       2.3377711
+ 2329.999971ps        2.667324
+ 2339.999972ps       3.0934638
+ 2349.999972ps       3.5696707
+ 2359.999973ps       4.0119985
+ 2369.999974ps       4.3285363
+ 2379.999975ps        4.472246
+ 2389.999976ps       4.5718618
+ 2399.999977ps       4.7587028
+ 2409.999977ps       5.1182398
+ 2419.999978ps       5.6354064
+ 2429.999979ps       6.3252453
+ 2439.999980ps       6.9645925
+ 2449.999981ps       7.3738005
+ 2459.999981ps       7.5043537
+ 2469.999982ps       7.4153271
+ 2479.999983ps       7.1595118
+ 2489.999984ps       6.8582253
+ 2499.999985ps       6.5812142
+ 2509.999986ps       6.2795412
+ 2519.999986ps       6.0118897
+ 2529.999987ps       5.7486624
+ 2539.999988ps       5.4979945
+ 2549.999989ps       5.2168744
+ 2559.999990ps       4.9276143
+ 2569.999991ps       4.6061997
+ 2579.999991ps       4.2717184
+ 2589.999992ps       3.9560944
+ 2599.999993ps       3.6599371
+ 2609.999994ps       3.3934544
+ 2619.999995ps       3.1825474
+ 2629.999996ps       3.0671896
+ 2639.999996ps       3.0523027
+ 2649.999997ps       3.1036318
+ 2659.999998ps       3.1293964
+ 2669.999999ps       3.1017155
+ 2680.000000ps       3.0145329
+ 2690.000001ps       2.8827185
+ 2700.000001ps       2.7183343
+ 2710.000002ps       2.5733734
+ 2720.000003ps       2.4821425
+ 2730.000004ps       2.4503072
+ 2740.000005ps       2.4483627
+ 2750.000005ps       2.4322993
+ 2760.000006ps       2.3942669
+ 2770.000007ps        2.344189
+ 2780.000008ps       2.2880874
+ 2790.000009ps       2.2280864
+ 2800.000010ps       2.1862877
+ 2810.000010ps       2.1860838
+ 2820.000011ps       2.3362589
+ 2830.000012ps       2.6671627
+ 2840.000013ps       3.0805945
+ 2850.000014ps        3.536494
+ 2860.000015ps       3.9760392
+ 2870.000015ps       4.2901026
+ 2880.000016ps       4.4278769
+ 2890.000017ps       4.5248954
+ 2900.000018ps       4.6985232
+ 2910.000019ps       5.0693975
+ 2920.000020ps       5.6019618
+ 2930.000020ps       6.2950626
+ 2940.000021ps        6.923274
+ 2950.000022ps       7.3255975
+ 2960.000023ps       7.4424513
+ 2970.000024ps       7.3250623
+ 2980.000025ps       7.0782769
+ 2990.000025ps       6.8051114
+ 3000.000026ps        6.530858
+ 3010.000027ps       6.1928022
+ 3020.000028ps        5.937354
+ 3030.000029ps       5.6810686
+ 3040.000029ps       5.4243436
+ 3050.000030ps       5.1437691
+ 3060.000031ps       4.8537458
+ 3070.000032ps        4.546243
+ 3080.000033ps       4.2293264
+ 3090.000034ps       3.9394718
+ 3100.000034ps       3.6557863
+ 3110.000035ps        3.363843
+ 3120.000036ps       3.1402743
+ 3130.000037ps       3.0308791
+ 3140.000038ps       3.0114811
+ 3150.000039ps       3.0926262
+ 3160.000039ps       3.1513333
+ 3170.000040ps       3.1628529
+ 3180.000041ps         3.07211
+ 3190.000042ps       2.9194236
+ 3200.000043ps       2.7442146
+ 3210.000044ps        2.589628
+ 3220.000044ps       2.4920791
+ 3230.000045ps       2.4553906
+ 3240.000046ps       2.4491763
+ 3250.000047ps       2.4294843
+ 3260.000048ps         2.39203
+ 3270.000049ps        2.341845
+ 3280.000049ps       2.2876978
+ 3290.000050ps       2.2342101
+ 3300.000051ps       2.1821172
+ 3310.000052ps       2.1802914
+ 3320.000053ps       2.3323741
+ 3330.000053ps       2.6558786
+ 3340.000054ps       3.0650144
+ 3350.000055ps        3.524907
+ 3360.000056ps        3.976733
+ 3370.000057ps       4.3082109
+ 3380.000058ps       4.4685699
+ 3390.000058ps       4.5935172
+ 3400.000059ps       4.8017799
+ 3410.000060ps       5.2087719
+ 3420.000061ps       5.7515402
+ 3430.000062ps       6.4256654
+ 3440.000063ps       7.0320327
+ 3450.000063ps       7.4030475
+ 3460.000064ps       7.4732037
+ 3470.000065ps       7.3097954
+ 3480.000066ps       7.0268731
+ 3490.000067ps       6.7406338
+ 3500.000068ps       6.4783347
+ 3510.000068ps       6.1979892
+ 3520.000069ps       5.9671439
+ 3530.000070ps       5.7491451
+ 3540.000071ps       5.5322065
+ 3550.000072ps       5.2636449
+ 3560.000073ps       4.9796003
+ 3570.000073ps       4.6641254
+ 3580.000074ps       4.3577743
+ 3590.000075ps       4.0718998
+ 3600.000076ps       3.7615723
+ 3610.000077ps       3.4269532
+ 3620.000077ps       3.1516531
+ 3630.000078ps       2.9951206
+ 3640.000079ps       2.9345481
+ 3650.000080ps       2.9667456
+ 3660.000081ps       3.0044218
+ 3670.000082ps       3.0226822
+ 3680.000082ps       2.9757146
+ 3690.000083ps       2.8654574
+ 3700.000084ps       2.7107344
+ 3710.000085ps         2.57112
+ 3720.000086ps       2.4828649
+ 3729.999865ps       2.4507983
+ 3739.999865ps       2.4481269
+ 3749.999866ps       2.4318801
+ 3759.999867ps       2.3936281
+ 3769.999868ps       2.3442049
+ 3779.999869ps       2.2904792
+ 3789.999869ps       2.2291812
+ 3799.999870ps       2.1770842
+ 3809.999871ps        2.177782
+ 3819.999872ps       2.3471206
+ 3829.999873ps       2.6695022
+ 3839.999874ps       3.0801065
+ 3849.999874ps       3.5453746
+ 3859.999875ps       3.9862625
+ 3869.999876ps       4.3139801
+ 3879.999877ps       4.4597254
+ 3889.999878ps       4.5830634
+ 3899.999879ps       4.7832342
+ 3909.999879ps        5.180724
+ 3919.999880ps       5.7322148
+ 3929.999881ps       6.4443815
+ 3939.999882ps       7.1226741
+ 3949.999883ps       7.5566259
+ 3959.999884ps       7.6858567
+ 3969.999884ps       7.6023264
+ 3979.999885ps       7.3682794
+ 3989.999886ps       7.0856427
+ 3999.999887ps       6.8210165
+ 4009.999888ps       6.4898659
+ 4019.999889ps       6.2078487
+ 4029.999889ps        5.946861
+ 4039.999890ps       5.6776917
+ 4049.999891ps       5.3863936
+ 4059.999892ps       5.1100074
+ 4069.999893ps       4.8161322
+ 4079.999893ps       4.5214913
+ 4089.999894ps       4.2403963
+ 4099.999895ps       3.9567248
+ 4109.999896ps       3.6946193
+ 4119.999897ps       3.4785103
+ 4129.999898ps       3.3638574
+ 4139.999898ps       3.3324443
+ 4149.999899ps       3.3883419
+ 4159.999900ps       3.4296427
+ 4169.999901ps       3.4030702
+ 4179.999902ps       3.2754458
+ 4189.999903ps       3.0770575
+ 4199.999903ps        2.854327
+ 4209.999904ps       2.6751026
+ 4219.999905ps        2.561555
+ 4229.999906ps       2.5129345
+ 4239.999907ps       2.4978718
+ 4249.999908ps       2.4733022
+ 4259.999908ps         2.42918
+ 4269.999909ps       2.3759695
+ 4279.999910ps       2.3198629
+ 4289.999911ps       2.2606643
+ 4299.999912ps       2.2154281
+ 4309.999913ps       2.2123599
+ 4319.999913ps       2.3574792
+ 4329.999914ps       2.6800228
+ 4339.999915ps       3.0957032
+ 4349.999916ps       3.5669675
+ 4359.999917ps       4.0094963
+ 4369.999917ps       4.3350476
+ 4379.999918ps       4.4723389
+ 4389.999919ps       4.5653692
+ 4399.999920ps       4.7298061
+ 4409.999921ps        5.075343
+ 4419.999922ps       5.5555796
+ 4429.999922ps        6.222724
+ 4439.999923ps       6.8726437
+ 4449.999924ps       7.3009216
+ 4459.999925ps       7.4555374
+ 4469.999926ps        7.392026
+ 4479.999927ps       7.1960642
+ 4489.999927ps       6.9851742
+ 4499.999928ps       6.7411538
+ 4509.999929ps       6.4326354
+ 4519.999930ps       6.1477186
+ 4529.999931ps       5.8521379
+ 4539.999932ps       5.5336651
+ 4549.999932ps       5.2106461
+ 4559.999933ps       4.9131825
+ 4569.999934ps       4.5745348
+ 4579.999935ps       4.2437326
+ 4589.999936ps       3.9331619
+ 4599.999937ps       3.6349871
+ 4609.999937ps       3.3719785
+ 4619.999938ps       3.1875301
+ 4629.999939ps       3.1043261
+ 4639.999940ps       3.1086329
+ 4649.999941ps        3.217826
+ 4659.999941ps       3.3443487
+ 4669.999942ps       3.3578732
+ 4679.999943ps       3.2352513
+ 4689.999944ps       3.0109679
+ 4699.999945ps       2.8011034
+ 4709.999946ps       2.6307327
+ 4719.999946ps        2.524897
+ 4729.999947ps       2.4834174
+ 4739.999948ps       2.4741827
+ 4749.999949ps       2.4536052
+ 4759.999950ps        2.412945
+ 4769.999951ps       2.3606957
+ 4779.999951ps       2.3040094
+ 4789.999952ps       2.2440501
+ 4799.999953ps       2.1960316
+ 4809.999954ps       2.1977631
+ 4819.999955ps       2.3464638
+ 4829.999956ps       2.6659124
+ 4839.999956ps       3.0752009
+ 4849.999957ps       3.5384446
+ 4859.999958ps       3.9649416
+ 4869.999959ps       4.2939294
+ 4879.999960ps       4.4449454
+ 4889.999961ps        4.569118
+ 4899.999961ps       4.7764701
+ 4909.999962ps       5.1963085
+ 4919.999963ps       5.7833806
+ 4929.999964ps       6.5430049
+ 4939.999965ps       7.2087171
+ 4949.999965ps       7.6037947
+ 4959.999966ps       7.6713854
+ 4969.999967ps       7.4791362
+ 4979.999968ps       7.1395266
+ 4989.999969ps       6.7961159
+ 4999.999970ps       6.4946873
+ 5009.999970ps       6.1616494
+ 5019.999971ps       5.9291721
+ 5029.999972ps       5.7149344
+ 5039.999973ps       5.4939708
+ 5049.999974ps        5.246126
+ 5059.999975ps       4.9883198
+ 5069.999975ps       4.7013166
+ 5079.999976ps       4.4213637
+ 5089.999977ps       4.1677379
+ 5099.999978ps       3.9359974
+ 5109.999979ps        3.659518
+ 5119.999980ps       3.3786292
+ 5129.999980ps          3.1692
+ 5139.999981ps       3.0441727
+ 5149.999982ps       3.0484542
+ 5159.999983ps       3.0650813
+ 5169.999984ps       3.0717649
+ 5179.999985ps       3.0054389
+ 5189.999985ps       2.8805075
+ 5199.999986ps       2.7215875
+ 5209.999987ps       2.5776759
+ 5219.999988ps        2.486506
+ 5229.999989ps       2.4532293
+ 5239.999989ps       2.4505577
+ 5249.999990ps       2.4337101
+ 5259.999991ps       2.3967589
+ 5269.999992ps       2.3488418
+ 5279.999993ps       2.2957492
+ 5289.999994ps        2.238921
+ 5299.999994ps       2.1912415
+ 5309.999995ps       2.1977061
+ 5319.999996ps       2.3426022
+ 5329.999997ps        2.670388
+ 5339.999998ps       3.0773749
+ 5349.999999ps       3.5385059
+ 5359.999999ps       3.9625919
+ 5370.000000ps       4.2739971
+ 5380.000001ps       4.4229182
+ 5390.000002ps       4.5298944
+ 5400.000003ps       4.7130904
+ 5410.000004ps       5.1039028
+ 5420.000004ps       5.6551564
+ 5430.000005ps       6.3815372
+ 5440.000006ps       7.0214752
+ 5450.000007ps       7.4177076
+ 5460.000008ps       7.5102758
+ 5470.000009ps       7.3691468
+ 5480.000009ps       7.0578281
+ 5490.000010ps       6.7460614
+ 5500.000011ps       6.4767765
+ 5510.000012ps       6.1840774
+ 5520.000013ps       5.9429923
+ 5530.000013ps       5.7129182
+ 5540.000014ps       5.4779304
+ 5550.000015ps       5.1976179
+ 5560.000016ps       4.9090823
+ 5570.000017ps       4.6096868
+ 5580.000018ps       4.2992816
+ 5590.000018ps       4.0158294
+ 5600.000019ps       3.7514895
+ 5610.000020ps       3.4542242
+ 5620.000021ps       3.1914619
+ 5630.000022ps       3.0187492
+ 5640.000023ps       2.9646211
+ 5650.000023ps       3.0095658
+ 5660.000024ps       3.0452392
+ 5670.000025ps       3.0500312
+ 5680.000026ps        2.993946
+ 5690.000027ps       2.8784613
+ 5700.000028ps       2.7246131
+ 5710.000028ps        2.584779
+ 5720.000029ps       2.4939995
+ 5730.000030ps       2.4597608
+ 5740.000031ps       2.4546339
+ 5750.000032ps        2.438745
+ 5760.000032ps       2.4027072
+ 5770.000033ps       2.3523536
+ 5780.000034ps       2.2980998
+ 5790.000035ps       2.2400354
+ 5800.000036ps       2.1922486
+ 5810.000037ps       2.2034921
+ 5820.000037ps       2.3509804
+ 5830.000038ps       2.6826468
+ 5840.000039ps       3.0969764
+ 5850.000040ps       3.5485033
+ 5860.000041ps       3.9741671
+ 5870.000042ps       4.2730995
+ 5880.000042ps       4.3887704
+ 5890.000043ps       4.4753503
+ 5900.000044ps       4.6422165
+ 5910.000045ps       5.0174203
+ 5920.000046ps       5.5711488
+ 5930.000047ps       6.3126603
+ 5940.000047ps       7.0160205
+ 5950.000048ps       7.4997779
+ 5960.000049ps       7.6808132
+ 5970.000050ps       7.6207341
+ 5980.000051ps        7.392922
+ 5990.000052ps       7.0969448
+ 6000.000052ps       6.7670014
+ 6010.000053ps       6.3744951
+ 6020.000054ps        6.040213
+ 6030.000055ps       5.7467348
+ 6040.000056ps       5.4590451
+ 6050.000056ps       5.1705918
+ 6060.000057ps        4.887973
+ 6070.000058ps       4.5951491
+ 6080.000059ps        4.302975
+ 6090.000060ps       4.0445781
+ 6100.000061ps       3.8121886
+ 6110.000061ps       3.5895912
+ 6120.000062ps       3.4328599
+ 6130.000063ps       3.3671314
+ 6140.000064ps       3.3724965
+ 6150.000065ps       3.4240486
+ 6160.000066ps       3.4387267
+ 6170.000066ps       3.3650243
+ 6180.000067ps       3.2080738
+ 6190.000068ps       3.0000286
+ 6200.000069ps       2.7953818
+ 6210.000070ps       2.6258346
+ 6220.000071ps       2.5185123
+ 6230.000071ps       2.4753071
+ 6240.000072ps       2.4628148
+ 6250.000073ps       2.4409827
+ 6260.000074ps        2.400819
+ 6270.000075ps       2.3513879
+ 6280.000076ps       2.2992239
+ 6290.000076ps       2.2405756
+ 6300.000077ps       2.1956605
+ 6310.000078ps        2.201617
+ 6320.000079ps       2.3489104
+ 6330.000080ps       2.6728694
+ 6340.000080ps       3.0823667
+ 6350.000081ps       3.5351973
+ 6360.000082ps       3.9659635
+ 6370.000083ps       4.2688144
+ 6380.000084ps       4.4115791
+ 6390.000085ps       4.5233464
+ 6400.000085ps       4.7121576
+ 6410.000086ps       5.1204104
+ 6420.000087ps       5.6930974
+ 6430.000088ps        6.430388
+ 6440.000089ps        7.138537
+ 6450.000090ps       7.5917662
+ 6460.000090ps       7.7330757
+ 6470.000091ps       7.6229064
+ 6480.000092ps       7.3433231
+ 6490.000093ps       6.9845348
+ 6500.000094ps       6.6664842
+ 6510.000095ps       6.3212149
+ 6520.000095ps        6.031503
+ 6530.000096ps       5.7702615
+ 6540.000097ps       5.5361982
+ 6550.000098ps       5.2697404
+ 6560.000099ps        4.996503
+ 6570.000100ps       4.6974926
+ 6580.000100ps       4.4141962
+ 6590.000101ps       4.1530613
+ 6600.000102ps       3.9027183
+ 6610.000103ps       3.6732434
+ 6620.000104ps       3.4752753
+ 6630.000104ps       3.3677887
+ 6640.000105ps       3.2947636
+ 6650.000106ps       3.2925196
+ 6660.000107ps       3.2640565
+ 6670.000108ps       3.2007816
+ 6680.000109ps       3.0857736
+ 6690.000109ps       2.9352042
+ 6700.000110ps       2.7563903
+ 6710.000111ps       2.6028249
+ 6720.000112ps       2.5083282
+ 6730.000113ps       2.4708923
+ 6740.000114ps       2.4647492
+ 6750.000114ps       2.4442923
+ 6760.000115ps       2.4047136
+ 6770.000116ps       2.3543376
+ 6780.000117ps       2.2986061
+ 6790.000118ps       2.2383886
+ 6800.000119ps       2.1873725
+ 6810.000119ps       2.1903802
+ 6820.000120ps       2.3489952
+ 6830.000121ps        2.670091
+ 6840.000122ps        3.084417
+ 6850.000123ps       3.5395445
+ 6860.000124ps       3.9710536
+ 6870.000124ps       4.2743726
+ 6880.000125ps         4.42408
+ 6890.000126ps       4.5447076
+ 6900.000127ps       4.7546994
+ 6910.000128ps       5.1778004
+ 6920.000128ps       5.7553599
+ 6930.000129ps       6.5113735
+ 6940.000130ps       7.2113658
+ 6950.000131ps       7.6413603
+ 6960.000132ps        7.746869
+ 6970.000133ps       7.5942499
+ 6980.000133ps        7.279436
+ 6990.000134ps       6.9400004
+ 7000.000135ps       6.6464968
+ 7010.000136ps       6.2974477
+ 7020.000137ps       6.0412602
+ 7030.000138ps       5.8080299
+ 7040.000138ps       5.5565232
+ 7050.000139ps       5.2820903
+ 7060.000140ps       4.9980952
+ 7070.000141ps       4.7093119
+ 7080.000142ps       4.4367611
+ 7090.000143ps       4.1957936
+ 7100.000143ps        3.972469
+ 7110.000144ps       3.7523572
+ 7120.000145ps       3.5211839
+ 7130.000146ps       3.3558805
+ 7140.000147ps       3.2245667
+ 7150.000148ps       3.2153024
+ 7160.000148ps        3.231587
+ 7170.000149ps        3.239326
+ 7180.000150ps        3.154059
+ 7190.000151ps        2.984673
+ 7200.000152ps       2.7857949
+ 7210.000152ps       2.6197977
+ 7220.000153ps       2.5151903
+ 7230.000154ps       2.4733697
+ 7240.000155ps       2.4656761
+ 7250.000156ps       2.4466721
+ 7260.000157ps       2.4082042
+ 7270.000157ps       2.3567888
+ 7280.000158ps       2.3023255
+ 7290.000159ps       2.2416658
+ 7300.000160ps       2.1928254
+ 7310.000161ps        2.190871
+ 7320.000162ps       2.3387522
+ 7330.000162ps       2.6750771
+ 7340.000163ps       3.0791067
+ 7350.000164ps       3.5306743
+ 7360.000165ps       3.9537632
+ 7370.000166ps       4.2497365
+ 7380.000167ps       4.3678437
+ 7390.000167ps       4.4312916
+ 7400.000168ps        4.569286
+ 7410.000169ps       4.9026932
+ 7420.000170ps       5.3975787
+ 7430.000171ps       6.0703564
+ 7440.000171ps       6.7117397
+ 7450.000172ps       7.1400615
+ 7459.999729ps         7.28933
+ 7469.999730ps       7.2048355
+ 7479.999731ps       6.9719683
+ 7489.999732ps       6.7075136
+ 7499.999732ps       6.4567039
+ 7509.999733ps       6.1567093
+ 7519.999734ps       5.9018994
+ 7529.999735ps          5.6303
+ 7539.999736ps       5.3418669
+ 7549.999737ps       5.0182432
+ 7559.999737ps       4.6953055
+ 7569.999738ps       4.3325496
+ 7579.999739ps       3.9817361
+ 7589.999740ps       3.6766106
+ 7599.999741ps        3.396886
+ 7609.999741ps       3.1472792
+ 7619.999742ps       2.9647234
+ 7629.999743ps       2.8938717
+ 7639.999744ps       2.8882234
+ 7649.999745ps       2.9813226
+ 7659.999746ps       3.0684456
+ 7669.999746ps       3.1211698
+ 7679.999747ps       3.0708091
+ 7689.999748ps       2.9385809
+ 7699.999749ps       2.7666562
+ 7709.999750ps       2.6136131
+ 7719.999751ps       2.5173192
+ 7729.999751ps       2.4801806
+ 7739.999752ps       2.4739002
+ 7749.999753ps       2.4541808
+ 7759.999754ps       2.4142799
+ 7769.999755ps       2.3657687
+ 7779.999756ps       2.3118195
+ 7789.999756ps       2.2527451
+ 7799.999757ps       2.2099587
+ 7809.999758ps       2.2092621
+ 7819.999759ps       2.3623335
+ 7829.999760ps       2.6874106
+ 7839.999761ps       3.1009909
+ 7849.999761ps       3.5739221
+ 7859.999762ps       3.9910048
+ 7869.999763ps       4.2926717
+ 7879.999764ps       4.4146218
+ 7889.999765ps       4.5069243
+ 7899.999765ps       4.6726627
+ 7909.999766ps       5.0373943
+ 7919.999767ps       5.5749296
+ 7929.999768ps       6.2962522
+ 7939.999769ps        6.967612
+ 7949.999770ps       7.4021231
+ 7959.999770ps       7.5425736
+ 7969.999771ps       7.4485926
+ 7979.999772ps       7.2043632
+ 7989.999773ps       6.9197536
+ 7999.999774ps        6.604177
+ 8009.999775ps       6.3158003
+ 8019.999775ps       6.0717496
+ 8029.999776ps        5.906335
+ 8039.999777ps       5.8024159
+ 8049.999778ps       5.7353847
+ 8059.999779ps       5.6911565
+ 8069.999780ps       5.6615089
+ 8079.999780ps       5.6413209
+ 8089.999781ps       5.6273574
+ 8099.999782ps       5.6175488
+ 8109.999783ps       5.6105538
+ 8119.999784ps       5.6054918
+ 8129.999785ps        5.601777
+ 8139.999785ps       5.5990144
+ 8149.999786ps       5.5969338
+ 8159.999787ps       5.5953483
+ 8169.999788ps       5.5941265
+ 8179.999789ps       5.5931752
+ 8189.999789ps       5.5924273
+ 8199.999790ps       5.5918341
+ 8209.999791ps       5.5913596
+ 8219.999792ps       5.5909771
+ 8229.999793ps       5.5906665
+ 8239.999794ps       5.5904126
+ 8249.999794ps       5.5902038
+ 8259.999795ps       5.5900311
+ 8269.999796ps       5.5898874
+ 8279.999797ps       5.5897673
+ 8289.999798ps       5.5896664
+ 8299.999799ps       5.5895813
+ 8309.999799ps       5.5895093
+)

Icursig2 PAR_1_0_VSS 0 pwl(
+ 0.000000ps     -0.58861989
+ 10.000000ps     -0.67857659
+ 20.000000ps      -1.0199595
+ 29.999999ps      -1.5746656
+ 40.000000ps      -2.2534888
+ 50.000001ps      -2.9041791
+ 59.999998ps      -3.4029773
+ 69.999999ps      -3.7150834
+ 80.000000ps      -3.7894133
+ 90.000001ps      -3.7697714
+ 100.000001ps      -3.7357521
+ 110.000002ps      -3.7638217
+ 119.999996ps      -3.8340313
+ 129.999997ps      -3.9380919
+ 139.999998ps      -4.1150702
+ 149.999999ps      -4.2961324
+ 159.999999ps       -4.427428
+ 170.000000ps      -4.5094722
+ 180.000001ps      -4.4765695
+ 190.000002ps       -4.354416
+ 200.000003ps      -4.1681062
+ 210.000003ps      -3.9055998
+ 220.000004ps      -3.5931503
+ 230.000005ps      -3.2605374
+ 239.999992ps      -2.9282402
+ 249.999993ps      -2.6152389
+ 259.999994ps      -2.3281395
+ 269.999995ps      -2.1671836
+ 279.999995ps      -2.1159105
+ 289.999996ps      -2.1721586
+ 299.999997ps      -2.3077219
+ 309.999998ps      -2.5164583
+ 319.999999ps      -2.7504478
+ 330.000000ps      -2.9970685
+ 340.000000ps      -3.2518207
+ 350.000001ps      -3.4742663
+ 360.000002ps      -3.6302303
+ 370.000003ps       -3.720128
+ 380.000004ps      -3.7350156
+ 390.000005ps      -3.7748079
+ 400.000005ps       -3.797087
+ 410.000006ps      -3.8289939
+ 420.000007ps      -3.8317168
+ 430.000008ps      -3.8330708
+ 440.000009ps      -3.8444456
+ 450.000009ps      -3.8451728
+ 460.000010ps      -3.8441398
+ 469.999983ps      -3.8540435
+ 479.999984ps      -3.8566289
+ 489.999985ps       -3.825536
+ 499.999986ps      -3.8481449
+ 509.999987ps      -3.7589277
+ 519.999988ps      -3.7309016
+ 529.999988ps      -3.8507007
+ 539.999989ps      -4.1110459
+ 549.999990ps      -4.4297607
+ 559.999991ps        -4.65683
+ 569.999992ps      -4.7723998
+ 579.999992ps      -4.6458494
+ 589.999993ps      -4.4296878
+ 599.999994ps      -4.2036946
+ 609.999995ps      -4.1022492
+ 619.999996ps      -4.0888061
+ 629.999997ps      -4.1389026
+ 639.999997ps      -4.2655213
+ 649.999998ps      -4.4051664
+ 659.999999ps      -4.4966037
+ 670.000000ps      -4.5508453
+ 680.000001ps       -4.500661
+ 690.000002ps      -4.3639375
+ 700.000002ps      -4.1670697
+ 710.000003ps      -3.8984099
+ 720.000004ps      -3.5790649
+ 730.000005ps       -3.244907
+ 740.000006ps      -2.9099598
+ 750.000007ps      -2.5951787
+ 760.000007ps      -2.3070332
+ 770.000008ps       -2.157626
+ 780.000009ps      -2.1031459
+ 790.000010ps      -2.1596188
+ 800.000011ps       -2.306947
+ 810.000012ps      -2.5256829
+ 820.000012ps       -2.773034
+ 830.000013ps       -3.039847
+ 840.000014ps      -3.3221179
+ 850.000015ps      -3.5807736
+ 860.000016ps      -3.7825511
+ 870.000016ps      -3.9269611
+ 880.000017ps      -4.0032898
+ 890.000018ps      -4.0929898
+ 900.000019ps      -4.1347438
+ 910.000020ps      -4.1816385
+ 920.000021ps      -4.1854012
+ 930.000021ps      -4.1486052
+ 939.999967ps      -4.0989817
+ 949.999968ps      -4.0467896
+ 959.999968ps      -4.0004103
+ 969.999969ps      -3.9725629
+ 979.999970ps      -3.9687072
+ 989.999971ps      -3.9618562
+ 999.999972ps      -4.0126599
+ 1009.999973ps      -3.9545637
+ 1019.999973ps      -3.9715241
+ 1029.999974ps      -4.1360502
+ 1039.999975ps      -4.4450171
+ 1049.999976ps       -4.794676
+ 1059.999977ps      -5.0586379
+ 1069.999978ps      -5.1860099
+ 1079.999978ps      -5.0376297
+ 1089.999979ps      -4.7861651
+ 1099.999980ps      -4.5005035
+ 1109.999981ps      -4.3149734
+ 1119.999982ps      -4.2019583
+ 1129.999982ps       -4.175167
+ 1139.999983ps      -4.2637721
+ 1149.999984ps      -4.3888215
+ 1159.999985ps      -4.4855159
+ 1169.999986ps      -4.5432908
+ 1179.999987ps      -4.4945242
+ 1189.999987ps      -4.3602058
+ 1199.999988ps       -4.166339
+ 1209.999989ps      -3.8975591
+ 1219.999990ps      -3.5806776
+ 1229.999991ps      -3.2474868
+ 1239.999992ps      -2.9124752
+ 1249.999992ps      -2.5979772
+ 1259.999993ps       -2.321767
+ 1269.999994ps      -2.1538312
+ 1279.999995ps      -2.1023159
+ 1289.999996ps      -2.1580496
+ 1299.999997ps      -2.3124821
+ 1309.999997ps       -2.537224
+ 1319.999998ps      -2.8062871
+ 1329.999999ps      -3.1092509
+ 1340.000000ps      -3.4182273
+ 1350.000001ps      -3.6831026
+ 1360.000002ps       -3.878233
+ 1370.000002ps      -3.9788752
+ 1380.000003ps      -3.9880021
+ 1390.000004ps      -3.9960369
+ 1400.000005ps       -3.941538
+ 1410.000006ps      -3.9256795
+ 1420.000006ps      -3.9090385
+ 1430.000007ps      -3.8952399
+ 1440.000008ps      -3.9231712
+ 1450.000009ps      -3.9792546
+ 1460.000010ps      -3.9937692
+ 1470.000011ps      -4.0074038
+ 1480.000011ps      -4.0252724
+ 1490.000012ps      -4.0199338
+ 1500.000013ps      -4.0808044
+ 1510.000014ps      -4.0360156
+ 1520.000015ps      -4.0512266
+ 1530.000016ps      -4.1865603
+ 1540.000016ps      -4.4277149
+ 1550.000017ps      -4.7063337
+ 1560.000018ps      -4.8618928
+ 1570.000019ps      -4.8789219
+ 1580.000020ps      -4.7022783
+ 1590.000021ps      -4.4707352
+ 1600.000021ps       -4.282122
+ 1610.000022ps      -4.1772678
+ 1620.000023ps      -4.1499298
+ 1630.000024ps      -4.1625905
+ 1640.000025ps       -4.268245
+ 1650.000025ps      -4.3934864
+ 1660.000026ps       -4.489177
+ 1670.000027ps      -4.5450925
+ 1680.000028ps      -4.4946403
+ 1690.000029ps      -4.3587151
+ 1700.000030ps      -4.1626029
+ 1710.000030ps      -3.8961539
+ 1720.000031ps      -3.5802989
+ 1730.000032ps      -3.2438015
+ 1740.000033ps      -2.9091427
+ 1750.000034ps      -2.5940298
+ 1760.000035ps      -2.3094594
+ 1770.000035ps      -2.1410958
+ 1780.000036ps      -2.0983138
+ 1790.000037ps      -2.1620377
+ 1800.000038ps      -2.3156408
+ 1810.000039ps      -2.5203653
+ 1820.000040ps       -2.774117
+ 1830.000040ps      -3.0556915
+ 1840.000041ps      -3.3471275
+ 1850.000042ps      -3.6002592
+ 1860.000043ps      -3.7998743
+ 1869.999933ps       -3.933011
+ 1879.999934ps      -3.9931216
+ 1889.999934ps      -4.0574326
+ 1899.999935ps      -4.0550501
+ 1909.999936ps      -4.0868828
+ 1919.999937ps      -4.1003726
+ 1929.999938ps      -4.0817154
+ 1939.999938ps      -4.0771553
+ 1949.999939ps      -4.1034353
+ 1959.999940ps      -4.0801352
+ 1969.999941ps      -4.0518746
+ 1979.999942ps      -4.0395815
+ 1989.999943ps      -4.0091205
+ 1999.999943ps      -4.0338515
+ 2009.999944ps       -3.967468
+ 2019.999945ps      -3.9703822
+ 2029.999946ps      -4.1376239
+ 2039.999947ps      -4.4440193
+ 2049.999948ps      -4.7951307
+ 2059.999948ps      -5.0185796
+ 2069.999949ps       -5.082799
+ 2079.999950ps      -4.9282778
+ 2089.999951ps      -4.7169356
+ 2099.999952ps      -4.5118054
+ 2109.999953ps      -4.3708057
+ 2119.999953ps      -4.2923036
+ 2129.999954ps      -4.2685666
+ 2139.999955ps      -4.3406863
+ 2149.999956ps      -4.4331813
+ 2159.999957ps      -4.5132437
+ 2169.999958ps      -4.5613885
+ 2179.999958ps      -4.5086254
+ 2189.999959ps      -4.3721408
+ 2199.999960ps      -4.1761803
+ 2209.999961ps      -3.9063238
+ 2219.999962ps      -3.5875502
+ 2229.999962ps      -3.2517384
+ 2239.999963ps      -2.9138997
+ 2249.999964ps      -2.6019808
+ 2259.999965ps      -2.3253939
+ 2269.999966ps      -2.1565921
+ 2279.999967ps       -2.101303
+ 2289.999967ps      -2.1547838
+ 2299.999968ps      -2.2996325
+ 2309.999969ps      -2.5298221
+ 2319.999970ps      -2.8115208
+ 2329.999971ps      -3.1059763
+ 2339.999972ps      -3.4102309
+ 2349.999972ps      -3.6870823
+ 2359.999973ps      -3.9279278
+ 2369.999974ps      -4.0989096
+ 2379.999975ps      -4.1633698
+ 2389.999976ps       -4.230333
+ 2399.999977ps      -4.2663034
+ 2409.999977ps        -4.31068
+ 2419.999978ps       -4.323706
+ 2429.999979ps      -4.3119751
+ 2439.999980ps       -4.311845
+ 2449.999981ps      -4.2755375
+ 2459.999981ps      -4.2155704
+ 2469.999982ps      -4.1666537
+ 2479.999983ps      -4.1608624
+ 2489.999984ps      -4.1502532
+ 2499.999985ps      -4.2300647
+ 2509.999986ps      -4.2150403
+ 2519.999986ps      -4.2581693
+ 2529.999987ps      -4.4510029
+ 2539.999988ps       -4.777917
+ 2549.999989ps      -5.0934495
+ 2559.999990ps      -5.2840413
+ 2569.999991ps      -5.3532064
+ 2579.999991ps      -5.2155949
+ 2589.999992ps      -5.0142075
+ 2599.999993ps      -4.7378198
+ 2609.999994ps      -4.5487101
+ 2619.999995ps      -4.4040933
+ 2629.999996ps      -4.3501246
+ 2639.999996ps      -4.3915197
+ 2649.999997ps      -4.4762555
+ 2659.999998ps      -4.5393246
+ 2669.999999ps      -4.5777628
+ 2680.000000ps      -4.5164547
+ 2690.000001ps      -4.3752002
+ 2700.000001ps       -4.176191
+ 2710.000002ps      -3.9070693
+ 2720.000003ps      -3.5888087
+ 2730.000004ps      -3.2528568
+ 2740.000005ps      -2.9163594
+ 2750.000005ps      -2.6018589
+ 2760.000006ps      -2.3209181
+ 2770.000007ps      -2.1550078
+ 2780.000008ps      -2.1009159
+ 2790.000009ps      -2.1599448
+ 2800.000010ps      -2.3212427
+ 2810.000010ps      -2.5462023
+ 2820.000011ps      -2.8151666
+ 2830.000012ps      -3.1089336
+ 2840.000013ps      -3.4134914
+ 2850.000014ps      -3.6815218
+ 2860.000015ps      -3.8925562
+ 2870.000015ps      -4.0102585
+ 2880.000016ps      -4.0346416
+ 2890.000017ps      -4.0584753
+ 2900.000018ps      -4.0352699
+ 2910.000019ps      -4.0319089
+ 2920.000020ps      -4.0430614
+ 2930.000020ps      -4.0284419
+ 2940.000021ps      -4.0281488
+ 2950.000022ps      -4.0443017
+ 2960.000023ps       -4.027101
+ 2970.000024ps      -4.0152476
+ 2980.000025ps      -4.0279077
+ 2990.000025ps      -4.0175814
+ 3000.000026ps      -4.0617969
+ 3010.000027ps      -4.0074254
+ 3020.000028ps      -4.0236727
+ 3030.000029ps      -4.1911307
+ 3040.000029ps      -4.4585754
+ 3050.000030ps      -4.7502206
+ 3060.000031ps      -4.9292658
+ 3070.000032ps      -4.9926385
+ 3080.000033ps      -4.8378232
+ 3090.000034ps      -4.6314114
+ 3100.000034ps      -4.4052892
+ 3110.000035ps      -4.2580841
+ 3120.000036ps      -4.1817941
+ 3130.000037ps      -4.1812685
+ 3140.000038ps      -4.2801555
+ 3150.000039ps      -4.4019024
+ 3160.000039ps      -4.4966475
+ 3170.000040ps      -4.5529518
+ 3180.000041ps      -4.5046599
+ 3190.000042ps      -4.3678665
+ 3200.000043ps      -4.1708144
+ 3210.000044ps       -3.902215
+ 3220.000044ps      -3.5843147
+ 3230.000045ps      -3.2483877
+ 3240.000046ps      -2.9101505
+ 3250.000047ps      -2.5940323
+ 3260.000048ps      -2.3056834
+ 3270.000049ps      -2.1414201
+ 3280.000049ps      -2.0886117
+ 3290.000050ps       -2.148911
+ 3300.000051ps      -2.3082644
+ 3310.000052ps      -2.5332154
+ 3320.000053ps      -2.7949037
+ 3330.000053ps      -3.0771781
+ 3340.000054ps      -3.3648914
+ 3350.000055ps      -3.6106055
+ 3360.000056ps       -3.796903
+ 3370.000057ps      -3.8991731
+ 3380.000058ps      -3.9158052
+ 3390.000058ps      -3.9491975
+ 3400.000059ps      -3.9345708
+ 3410.000060ps       -3.950966
+ 3420.000061ps      -4.0019828
+ 3430.000062ps      -4.0430286
+ 3440.000063ps       -4.077003
+ 3450.000063ps      -4.1152186
+ 3460.000064ps      -4.0983545
+ 3470.000065ps      -4.0607297
+ 3480.000066ps      -4.0275174
+ 3490.000067ps      -3.9990252
+ 3500.000068ps      -4.0324787
+ 3510.000068ps      -3.9900043
+ 3520.000069ps      -4.0108304
+ 3530.000070ps      -4.1722891
+ 3540.000071ps      -4.4290493
+ 3550.000072ps       -4.706062
+ 3560.000073ps      -4.8804987
+ 3570.000073ps      -4.9409782
+ 3580.000074ps      -4.8143664
+ 3590.000075ps      -4.6524237
+ 3600.000076ps      -4.4948865
+ 3610.000077ps      -4.3859333
+ 3620.000077ps      -4.3088906
+ 3630.000078ps      -4.2741513
+ 3640.000079ps      -4.3430199
+ 3650.000080ps      -4.4378251
+ 3660.000081ps      -4.5175672
+ 3670.000082ps      -4.5662017
+ 3680.000082ps      -4.5116462
+ 3690.000083ps      -4.3741776
+ 3700.000084ps      -4.1779528
+ 3710.000085ps      -3.9080168
+ 3720.000086ps      -3.5901785
+ 3729.999865ps      -3.2554283
+ 3739.999865ps      -2.9174959
+ 3749.999866ps      -2.5970353
+ 3759.999867ps      -2.3119159
+ 3769.999868ps      -2.1567985
+ 3779.999869ps       -2.106076
+ 3789.999869ps      -2.1649142
+ 3799.999870ps      -2.3144813
+ 3809.999871ps      -2.5370572
+ 3819.999872ps      -2.7820799
+ 3829.999873ps      -3.0624897
+ 3839.999874ps       -3.368953
+ 3849.999874ps      -3.6468866
+ 3859.999875ps      -3.8616239
+ 3869.999876ps      -3.9919184
+ 3879.999877ps      -4.0502991
+ 3889.999878ps      -4.1249119
+ 3899.999879ps      -4.1146784
+ 3909.999879ps      -4.0942639
+ 3919.999880ps      -4.0663134
+ 3929.999881ps      -4.0446737
+ 3939.999882ps       -4.027976
+ 3949.999883ps      -4.0264367
+ 3959.999884ps       -4.014359
+ 3969.999884ps      -4.0191475
+ 3979.999885ps      -4.0242093
+ 3989.999886ps      -4.0093606
+ 3999.999887ps      -4.0682271
+ 4009.999888ps      -4.0118019
+ 4019.999889ps      -4.0321276
+ 4029.999889ps       -4.218964
+ 4039.999890ps      -4.5321948
+ 4049.999891ps      -4.8771371
+ 4059.999892ps      -5.1280309
+ 4069.999893ps       -5.199487
+ 4079.999893ps      -5.0039554
+ 4089.999894ps      -4.7213061
+ 4099.999895ps      -4.4893535
+ 4109.999896ps      -4.3767157
+ 4119.999897ps      -4.3188386
+ 4129.999898ps      -4.3047316
+ 4139.999898ps      -4.3831467
+ 4149.999899ps      -4.5023835
+ 4159.999900ps      -4.5950898
+ 4169.999901ps      -4.6501916
+ 4179.999902ps      -4.6026701
+ 4189.999903ps      -4.4692263
+ 4199.999903ps      -4.2765355
+ 4209.999904ps      -4.0108671
+ 4219.999905ps       -3.694142
+ 4229.999906ps      -3.3602238
+ 4239.999907ps      -3.0227132
+ 4249.999908ps      -2.7046762
+ 4259.999908ps      -2.4147776
+ 4269.999909ps      -2.2506968
+ 4279.999910ps      -2.2054129
+ 4289.999911ps      -2.2638443
+ 4299.999912ps      -2.4110226
+ 4309.999913ps      -2.6364953
+ 4319.999913ps      -2.9022747
+ 4329.999914ps      -3.1883033
+ 4339.999915ps      -3.4753258
+ 4349.999916ps      -3.7124892
+ 4359.999917ps      -3.8860341
+ 4369.999917ps      -3.9803092
+ 4379.999918ps       -3.991371
+ 4389.999919ps      -4.0093957
+ 4399.999920ps      -3.9799967
+ 4409.999921ps      -3.9880096
+ 4419.999922ps      -4.0151303
+ 4429.999922ps      -4.0450639
+ 4439.999923ps       -4.087893
+ 4449.999924ps      -4.1222074
+ 4459.999925ps      -4.1157814
+ 4469.999926ps      -4.0946052
+ 4479.999927ps      -4.0697316
+ 4489.999927ps      -4.0337461
+ 4499.999928ps      -4.0750021
+ 4509.999929ps      -4.0153113
+ 4519.999930ps       -4.009478
+ 4529.999931ps      -4.1418336
+ 4539.999932ps      -4.3903671
+ 4549.999932ps      -4.6517534
+ 4559.999933ps      -4.8101063
+ 4569.999934ps      -4.8500368
+ 4579.999935ps      -4.7110119
+ 4589.999936ps      -4.5440551
+ 4599.999937ps      -4.3936991
+ 4609.999937ps      -4.2957442
+ 4619.999938ps      -4.2231464
+ 4629.999939ps       -4.198942
+ 4639.999940ps       -4.285253
+ 4649.999941ps      -4.4131704
+ 4659.999941ps      -4.5088646
+ 4669.999942ps      -4.5656382
+ 4679.999943ps      -4.5165724
+ 4689.999944ps      -4.3801589
+ 4699.999945ps      -4.1863436
+ 4709.999946ps      -3.9172862
+ 4719.999946ps      -3.5998482
+ 4729.999947ps      -3.2677585
+ 4739.999948ps      -2.9329538
+ 4749.999949ps      -2.6211244
+ 4759.999950ps      -2.3333442
+ 4769.999951ps      -2.1732178
+ 4779.999951ps      -2.1268371
+ 4789.999952ps      -2.1832778
+ 4799.999953ps      -2.3372852
+ 4809.999954ps      -2.5610295
+ 4819.999955ps      -2.8171616
+ 4829.999956ps      -3.0943971
+ 4839.999956ps      -3.3762775
+ 4849.999957ps      -3.6125263
+ 4859.999958ps      -3.7755091
+ 4869.999959ps      -3.8694429
+ 4879.999960ps       -3.893403
+ 4889.999961ps      -3.9415578
+ 4899.999961ps      -3.9459224
+ 4909.999962ps      -3.9877672
+ 4919.999963ps      -4.0346676
+ 4929.999964ps      -4.0850175
+ 4939.999965ps      -4.1206966
+ 4949.999965ps      -4.1348183
+ 4959.999966ps      -4.1118589
+ 4969.999967ps      -4.0708021
+ 4979.999968ps      -4.0211042
+ 4989.999969ps      -3.9706454
+ 4999.999970ps      -3.9965494
+ 5009.999970ps      -3.9148382
+ 5019.999971ps      -3.9070679
+ 5029.999972ps      -4.0551147
+ 5039.999973ps      -4.3311212
+ 5049.999974ps      -4.6383308
+ 5059.999975ps      -4.8640457
+ 5069.999975ps      -4.9650762
+ 5079.999976ps      -4.8521058
+ 5089.999977ps      -4.6860223
+ 5099.999978ps      -4.5234844
+ 5109.999979ps      -4.4227597
+ 5119.999980ps      -4.3341138
+ 5129.999980ps      -4.2903726
+ 5139.999981ps      -4.3461578
+ 5149.999982ps      -4.4504969
+ 5159.999983ps      -4.5341589
+ 5169.999984ps        -4.58365
+ 5179.999985ps       -4.532683
+ 5189.999985ps      -4.3945816
+ 5199.999986ps      -4.1990988
+ 5209.999987ps      -3.9296918
+ 5219.999988ps      -3.6112246
+ 5229.999989ps      -3.2763167
+ 5239.999989ps      -2.9414622
+ 5249.999990ps      -2.6296897
+ 5259.999991ps      -2.3418246
+ 5269.999992ps       -2.176651
+ 5279.999993ps      -2.1281208
+ 5289.999994ps      -2.1806095
+ 5299.999994ps      -2.3217295
+ 5309.999995ps      -2.5261979
+ 5319.999996ps       -2.768824
+ 5329.999997ps      -3.0360695
+ 5339.999998ps      -3.2981092
+ 5349.999999ps      -3.5186667
+ 5359.999999ps      -3.6736693
+ 5370.000000ps      -3.7564848
+ 5380.000001ps      -3.7590719
+ 5390.000002ps      -3.7664503
+ 5400.000003ps      -3.7458613
+ 5410.000004ps      -3.7664685
+ 5420.000004ps      -3.7731506
+ 5430.000005ps      -3.7732343
+ 5440.000006ps      -3.8155846
+ 5450.000007ps      -3.8662356
+ 5460.000008ps      -3.8709169
+ 5470.000009ps      -3.8783566
+ 5480.000009ps       -3.890893
+ 5490.000010ps      -3.8685806
+ 5500.000011ps      -3.8907039
+ 5510.000012ps      -3.8094678
+ 5520.000013ps      -3.7791168
+ 5530.000013ps      -3.8871696
+ 5540.000014ps      -4.1322798
+ 5550.000015ps      -4.4336465
+ 5560.000016ps        -4.62509
+ 5570.000017ps      -4.6887104
+ 5580.000018ps      -4.5617669
+ 5590.000018ps       -4.384934
+ 5600.000019ps      -4.2187432
+ 5610.000020ps      -4.1380943
+ 5620.000021ps      -4.1344791
+ 5630.000022ps      -4.1765058
+ 5640.000023ps      -4.2966513
+ 5650.000023ps      -4.4277274
+ 5660.000024ps      -4.5278966
+ 5670.000025ps      -4.5851417
+ 5680.000026ps      -4.5360566
+ 5690.000027ps      -4.3996105
+ 5700.000028ps      -4.2049831
+ 5710.000028ps      -3.9392148
+ 5720.000029ps       -3.619635
+ 5730.000030ps      -3.2876564
+ 5740.000031ps      -2.9508983
+ 5750.000032ps      -2.6368172
+ 5760.000032ps      -2.3542749
+ 5770.000033ps      -2.1948849
+ 5780.000034ps      -2.1440391
+ 5790.000035ps      -2.2109883
+ 5800.000036ps      -2.3598852
+ 5810.000037ps      -2.5768839
+ 5820.000037ps      -2.8296539
+ 5830.000038ps      -3.1169402
+ 5840.000039ps      -3.4088892
+ 5850.000040ps      -3.6580054
+ 5860.000041ps      -3.8447966
+ 5870.000042ps      -3.9721477
+ 5880.000042ps      -4.0164025
+ 5890.000043ps      -4.0469649
+ 5900.000044ps      -4.0031865
+ 5910.000045ps      -3.9833753
+ 5920.000046ps      -3.9522711
+ 5930.000047ps      -3.9245664
+ 5940.000047ps      -3.9185838
+ 5950.000048ps      -3.9489016
+ 5960.000049ps      -3.9644958
+ 5970.000050ps      -3.9793032
+ 5980.000051ps      -3.9915956
+ 5990.000052ps      -3.9845288
+ 6000.000052ps       -4.040638
+ 6010.000053ps      -3.9709841
+ 6020.000054ps      -3.9700857
+ 6030.000055ps       -4.119307
+ 6040.000056ps      -4.4190883
+ 6050.000056ps      -4.7472997
+ 6060.000057ps      -4.9498009
+ 6070.000058ps      -4.9639285
+ 6080.000059ps      -4.7637365
+ 6090.000060ps      -4.5308301
+ 6100.000061ps      -4.3421027
+ 6110.000061ps      -4.2418652
+ 6120.000062ps        -4.18998
+ 6130.000063ps      -4.1993781
+ 6140.000064ps      -4.3093877
+ 6150.000065ps      -4.4498539
+ 6160.000066ps      -4.5550082
+ 6170.000066ps      -4.6132896
+ 6180.000067ps      -4.5651112
+ 6190.000068ps      -4.4290663
+ 6200.000069ps      -4.2330379
+ 6210.000070ps      -3.9628016
+ 6220.000071ps      -3.6439999
+ 6230.000071ps      -3.3092087
+ 6240.000072ps      -2.9745715
+ 6250.000073ps      -2.6600632
+ 6260.000074ps      -2.3704818
+ 6270.000075ps      -2.2084207
+ 6280.000076ps      -2.1546648
+ 6290.000076ps      -2.2032162
+ 6300.000077ps      -2.3477885
+ 6310.000078ps      -2.5589853
+ 6320.000079ps      -2.8045455
+ 6330.000080ps      -3.0621638
+ 6340.000080ps      -3.3262078
+ 6350.000081ps      -3.5595714
+ 6360.000082ps      -3.7431387
+ 6370.000083ps      -3.8705083
+ 6380.000084ps      -3.9408702
+ 6390.000085ps      -4.0361903
+ 6400.000085ps      -4.0831731
+ 6410.000086ps      -4.1474814
+ 6420.000087ps      -4.1660932
+ 6430.000088ps      -4.1453174
+ 6440.000089ps      -4.1202772
+ 6450.000090ps      -4.0844892
+ 6460.000090ps      -4.0136035
+ 6470.000091ps       -3.966842
+ 6480.000092ps      -3.9450109
+ 6490.000093ps      -3.9272081
+ 6500.000094ps      -3.9940759
+ 6510.000095ps      -3.9605733
+ 6520.000095ps      -3.9780166
+ 6530.000096ps      -4.1403038
+ 6540.000097ps      -4.4486158
+ 6550.000098ps      -4.8042763
+ 6560.000099ps      -5.0680082
+ 6570.000100ps      -5.1814977
+ 6580.000100ps       -5.072395
+ 6590.000101ps       -4.849968
+ 6600.000102ps      -4.5992943
+ 6610.000103ps      -4.4108636
+ 6620.000104ps      -4.2959225
+ 6630.000104ps      -4.2636245
+ 6640.000105ps      -4.3425382
+ 6650.000106ps      -4.4617445
+ 6660.000107ps      -4.5508623
+ 6670.000108ps       -4.600659
+ 6680.000109ps      -4.5457265
+ 6690.000109ps      -4.4060329
+ 6700.000110ps      -4.2097193
+ 6710.000111ps       -3.945475
+ 6720.000112ps      -3.6349798
+ 6730.000113ps      -3.3089704
+ 6740.000114ps      -2.9767691
+ 6750.000114ps      -2.6620115
+ 6760.000115ps      -2.3822755
+ 6770.000116ps      -2.2231452
+ 6780.000117ps      -2.1855766
+ 6790.000118ps      -2.2443197
+ 6800.000119ps      -2.3995577
+ 6810.000119ps      -2.6341772
+ 6820.000120ps      -2.9169128
+ 6830.000121ps       -3.216959
+ 6840.000122ps      -3.5305215
+ 6850.000123ps       -3.809684
+ 6860.000124ps      -4.0197567
+ 6870.000124ps      -4.1370715
+ 6880.000125ps      -4.1494015
+ 6890.000126ps      -4.1585193
+ 6900.000127ps       -4.114077
+ 6910.000128ps      -4.0901254
+ 6920.000128ps      -4.0563701
+ 6930.000129ps      -4.0433683
+ 6940.000130ps      -4.0607206
+ 6950.000131ps      -4.0944639
+ 6960.000132ps      -4.1121537
+ 6970.000133ps      -4.1400257
+ 6980.000133ps      -4.1668937
+ 6990.000134ps      -4.1688609
+ 7000.000135ps      -4.2213349
+ 7010.000136ps      -4.1619156
+ 7020.000137ps       -4.173287
+ 7030.000138ps      -4.3299584
+ 7040.000138ps      -4.5979906
+ 7050.000139ps      -4.8714015
+ 7060.000140ps      -5.0303435
+ 7070.000141ps      -5.0609449
+ 7080.000142ps      -4.8893018
+ 7090.000143ps      -4.6484941
+ 7100.000143ps      -4.4199271
+ 7110.000144ps      -4.2929093
+ 7120.000145ps      -4.2391297
+ 7130.000146ps      -4.2436063
+ 7140.000147ps      -4.3328175
+ 7150.000148ps      -4.4475528
+ 7160.000148ps      -4.5390843
+ 7170.000149ps      -4.5943227
+ 7180.000150ps      -4.5439804
+ 7190.000151ps      -4.4096945
+ 7200.000152ps      -4.2168962
+ 7210.000152ps      -3.9575285
+ 7220.000153ps      -3.6466586
+ 7230.000154ps      -3.3171917
+ 7240.000155ps      -2.9810987
+ 7250.000156ps       -2.663779
+ 7260.000157ps       -2.376792
+ 7270.000157ps      -2.2084151
+ 7280.000158ps      -2.1583947
+ 7290.000159ps      -2.2155522
+ 7300.000160ps      -2.3660186
+ 7310.000161ps      -2.5819474
+ 7320.000162ps      -2.8310868
+ 7330.000162ps      -3.1051826
+ 7340.000163ps       -3.398272
+ 7350.000164ps      -3.6607286
+ 7360.000165ps      -3.8635795
+ 7370.000166ps      -4.0005224
+ 7380.000167ps      -4.0648538
+ 7390.000167ps       -4.147852
+ 7400.000168ps      -4.1659544
+ 7410.000169ps      -4.1696307
+ 7420.000170ps      -4.1334339
+ 7430.000171ps      -4.0965403
+ 7440.000171ps      -4.0842146
+ 7450.000172ps      -4.0757823
+ 7459.999729ps      -4.0576998
+ 7469.999730ps      -4.0587271
+ 7479.999731ps      -4.0601901
+ 7489.999732ps      -4.0342498
+ 7499.999732ps      -4.0977807
+ 7509.999733ps      -4.0788329
+ 7519.999734ps      -4.1060341
+ 7529.999735ps      -4.2613569
+ 7539.999736ps       -4.573081
+ 7549.999737ps      -4.9086202
+ 7559.999737ps      -5.1470163
+ 7569.999738ps      -5.2054291
+ 7579.999739ps      -5.0148932
+ 7589.999740ps       -4.732404
+ 7599.999741ps       -4.482322
+ 7609.999741ps      -4.3634054
+ 7619.999742ps      -4.3135008
+ 7629.999743ps       -4.299321
+ 7639.999744ps      -4.3621455
+ 7649.999745ps      -4.4630797
+ 7659.999746ps      -4.5434112
+ 7669.999746ps      -4.5913718
+ 7679.999747ps      -4.5378531
+ 7689.999748ps      -4.4014259
+ 7699.999749ps      -4.2055566
+ 7709.999750ps      -3.9376545
+ 7719.999751ps      -3.6230959
+ 7729.999751ps      -3.2927454
+ 7739.999752ps      -2.9665034
+ 7749.999753ps      -2.6591586
+ 7759.999754ps      -2.3764684
+ 7769.999755ps      -2.2215526
+ 7779.999756ps      -2.1714281
+ 7789.999756ps      -2.2283564
+ 7799.999757ps      -2.3644054
+ 7809.999758ps      -2.5715286
+ 7819.999759ps      -2.8199267
+ 7829.999760ps      -3.1017577
+ 7839.999761ps      -3.3839635
+ 7849.999761ps      -3.6130075
+ 7859.999762ps      -3.7859246
+ 7869.999763ps       -3.883981
+ 7879.999764ps      -3.9019406
+ 7889.999765ps       -3.918494
+ 7899.999765ps      -3.8787752
+ 7909.999766ps      -3.8812027
+ 7919.999767ps      -3.8895925
+ 7929.999768ps      -3.8843579
+ 7939.999769ps      -3.9027658
+ 7949.999770ps      -3.9333793
+ 7959.999770ps      -3.9392822
+ 7969.999771ps       -3.936243
+ 7979.999772ps      -3.9423844
+ 7989.999773ps      -3.9508467
+ 7999.999774ps      -3.9793145
+ 8009.999775ps      -3.8899995
+ 8019.999775ps      -3.8103609
+ 8029.999776ps       -3.755682
+ 8039.999777ps      -3.7235436
+ 8049.999778ps      -3.7043878
+ 8059.999779ps      -3.6927719
+ 8069.999780ps      -3.6856791
+ 8079.999780ps      -3.6813112
+ 8089.999781ps      -3.6785924
+ 8099.999782ps      -3.6768783
+ 8109.999783ps      -3.6757819
+ 8119.999784ps      -3.6750692
+ 8129.999785ps      -3.6745982
+ 8139.999785ps      -3.6742819
+ 8149.999786ps      -3.6740663
+ 8159.999787ps      -3.6739178
+ 8169.999788ps      -3.6738149
+ 8179.999789ps      -3.6737438
+ 8189.999789ps      -3.6736953
+ 8199.999790ps      -3.6736634
+ 8209.999791ps      -3.6736439
+ 8219.999792ps      -3.6736337
+ 8229.999793ps      -3.6736308
+ 8239.999794ps      -3.6736336
+ 8249.999794ps      -3.6736408
+ 8259.999795ps      -3.6736516
+ 8269.999796ps      -3.6736652
+ 8279.999797ps      -3.6736811
+ 8289.999798ps      -3.6736988
+ 8299.999799ps       -3.673718
+ 8309.999799ps      -3.6737383
+)

Icursig3 PAR_1_0_VDD075NNE 0 pwl(
+ 0.000000ps      0.55495393
+ 10.000000ps      0.62883242
+ 20.000000ps      0.80514872
+ 29.999999ps       1.0313866
+ 40.000000ps       1.2495352
+ 50.000001ps       1.4528003
+ 59.999998ps       1.6283339
+ 69.999999ps        1.793292
+ 80.000000ps         1.97868
+ 90.000001ps       2.1786984
+ 100.000001ps       2.3607287
+ 110.000002ps       2.4996105
+ 119.999996ps       2.5646068
+ 129.999997ps       2.5529531
+ 139.999998ps       2.5100934
+ 149.999999ps       2.4081346
+ 159.999999ps       2.3270164
+ 170.000000ps       2.2443649
+ 180.000001ps        2.200414
+ 190.000002ps       2.1989382
+ 200.000003ps       2.2289993
+ 210.000003ps       2.2525526
+ 220.000004ps        2.262032
+ 230.000005ps       2.2755579
+ 239.999992ps       2.2729058
+ 249.999993ps        2.362219
+ 259.999994ps       2.3072871
+ 269.999995ps       2.3773938
+ 279.999995ps       2.5913836
+ 289.999996ps       2.9900739
+ 299.999997ps       3.4162483
+ 309.999998ps       3.7793861
+ 319.999999ps       3.9804888
+ 330.000000ps       4.0232495
+ 340.000000ps       4.0739398
+ 350.000001ps       4.2347431
+ 360.000002ps       4.5568699
+ 370.000003ps        4.964335
+ 380.000004ps       5.4069679
+ 390.000005ps       5.9031105
+ 400.000005ps       6.3107783
+ 410.000006ps       6.5257275
+ 420.000007ps        6.539114
+ 430.000008ps       6.3651549
+ 440.000009ps       6.0891312
+ 450.000009ps       5.8249141
+ 460.000010ps       5.6128715
+ 469.999983ps       5.4284231
+ 479.999984ps       5.2221431
+ 489.999985ps       4.9999501
+ 499.999986ps       4.7118786
+ 509.999987ps       4.3918196
+ 519.999988ps       4.1086622
+ 529.999988ps       3.8374846
+ 539.999989ps       3.5772777
+ 549.999990ps       3.3460308
+ 559.999991ps       3.1665924
+ 569.999992ps       3.0452488
+ 579.999992ps       2.9547252
+ 589.999993ps       2.8937891
+ 599.999994ps       2.8360302
+ 609.999995ps       2.8078722
+ 619.999996ps       2.7689374
+ 629.999997ps       2.6928412
+ 639.999997ps       2.6026695
+ 649.999998ps       2.4571539
+ 659.999999ps       2.3359672
+ 670.000000ps       2.2285268
+ 680.000001ps       2.1655602
+ 690.000002ps       2.1505607
+ 700.000002ps        2.168452
+ 710.000003ps       2.1784755
+ 720.000004ps       2.1827125
+ 730.000005ps        2.191887
+ 740.000006ps       2.1893071
+ 750.000007ps       2.2787154
+ 760.000007ps        2.221437
+ 770.000008ps       2.2791079
+ 780.000009ps        2.491413
+ 790.000010ps       2.8933059
+ 800.000011ps       3.3261583
+ 810.000012ps       3.6937725
+ 820.000012ps        3.900616
+ 830.000013ps       3.9686005
+ 840.000014ps       4.0581307
+ 850.000015ps        4.264102
+ 860.000016ps       4.6342343
+ 870.000016ps       5.0979712
+ 880.000017ps       5.5983835
+ 890.000018ps       6.1454264
+ 900.000019ps       6.5781631
+ 910.000020ps       6.7971426
+ 920.000021ps       6.8043147
+ 930.000021ps        6.600544
+ 939.999967ps       6.2589909
+ 949.999968ps       5.9311409
+ 959.999968ps       5.6575218
+ 969.999969ps       5.4425885
+ 979.999970ps       5.2424953
+ 989.999971ps       5.0495123
+ 999.999972ps       4.8074392
+ 1009.999973ps        4.540891
+ 1019.999973ps       4.3116681
+ 1029.999974ps       4.0913261
+ 1039.999975ps       3.8683766
+ 1049.999976ps       3.6723113
+ 1059.999977ps       3.5163932
+ 1069.999978ps       3.3903013
+ 1079.999978ps       3.2829749
+ 1089.999979ps       3.1867256
+ 1099.999980ps       3.0730903
+ 1109.999981ps        2.958534
+ 1119.999982ps       2.8255982
+ 1129.999982ps       2.6839155
+ 1139.999983ps        2.564179
+ 1149.999984ps       2.4118777
+ 1159.999985ps       2.3008102
+ 1169.999986ps       2.1982367
+ 1179.999987ps       2.1392613
+ 1189.999987ps       2.1250373
+ 1199.999988ps       2.1456522
+ 1209.999989ps       2.1582383
+ 1219.999990ps       2.1636436
+ 1229.999991ps       2.1721219
+ 1239.999992ps       2.1689521
+ 1249.999992ps       2.2562502
+ 1259.999993ps       2.2038216
+ 1269.999994ps       2.2565169
+ 1279.999995ps       2.4793098
+ 1289.999996ps       2.8949386
+ 1299.999997ps       3.3461774
+ 1309.999997ps       3.7148087
+ 1319.999998ps        3.940994
+ 1329.999999ps       4.0272036
+ 1340.000000ps       4.1191515
+ 1350.000001ps       4.3192782
+ 1360.000002ps       4.6685849
+ 1370.000002ps       5.0795149
+ 1380.000003ps       5.5249041
+ 1390.000004ps       6.0004117
+ 1400.000005ps       6.3498427
+ 1410.000006ps       6.5293679
+ 1420.000006ps       6.5282335
+ 1430.000007ps       6.3416511
+ 1440.000008ps       6.0757921
+ 1450.000009ps       5.8501603
+ 1460.000010ps       5.6405808
+ 1470.000011ps       5.4696399
+ 1480.000011ps       5.2771947
+ 1490.000012ps       5.0727855
+ 1500.000013ps       4.8331707
+ 1510.000014ps       4.5701035
+ 1520.000015ps       4.3207095
+ 1530.000016ps        4.077326
+ 1540.000016ps        3.813272
+ 1550.000017ps       3.5577465
+ 1560.000018ps       3.3267101
+ 1570.000019ps       3.1241631
+ 1580.000020ps       2.9845319
+ 1590.000021ps       2.9107918
+ 1600.000021ps       2.8881704
+ 1610.000022ps       2.8591137
+ 1620.000023ps       2.8079137
+ 1630.000024ps       2.6972874
+ 1640.000025ps       2.5832907
+ 1650.000025ps       2.4222877
+ 1660.000026ps       2.3067389
+ 1670.000027ps       2.2040346
+ 1680.000028ps       2.1452465
+ 1690.000029ps        2.131424
+ 1700.000030ps       2.1510569
+ 1710.000030ps       2.1625896
+ 1720.000031ps       2.1652389
+ 1730.000032ps       2.1744847
+ 1740.000033ps       2.1704757
+ 1750.000034ps       2.2574903
+ 1760.000035ps        2.212558
+ 1770.000035ps       2.2639914
+ 1780.000036ps       2.4811376
+ 1790.000037ps       2.8790093
+ 1800.000038ps       3.3095495
+ 1810.000039ps       3.6679874
+ 1820.000040ps       3.8783702
+ 1830.000040ps        3.957598
+ 1840.000041ps       4.0512505
+ 1850.000042ps        4.243923
+ 1860.000043ps       4.6132108
+ 1869.999933ps       5.0667581
+ 1879.999934ps        5.544146
+ 1889.999934ps       6.0626011
+ 1899.999935ps       6.4560191
+ 1909.999936ps       6.6650552
+ 1919.999937ps       6.6900977
+ 1929.999938ps       6.5131513
+ 1939.999938ps       6.2285104
+ 1949.999939ps       5.9792905
+ 1959.999940ps       5.7319471
+ 1969.999941ps       5.4991556
+ 1979.999942ps       5.2783869
+ 1989.999943ps       5.0518954
+ 1999.999943ps       4.7938062
+ 2009.999944ps       4.5168071
+ 2019.999945ps       4.2745882
+ 2029.999946ps       4.0592933
+ 2039.999947ps       3.8391759
+ 2049.999948ps       3.6322126
+ 2059.999948ps       3.4508706
+ 2069.999949ps       3.2716635
+ 2079.999950ps       3.1634425
+ 2089.999951ps       3.1161934
+ 2099.999952ps       3.0851124
+ 2109.999953ps       3.0184091
+ 2119.999953ps       2.9205872
+ 2129.999954ps       2.7793307
+ 2139.999955ps       2.6385502
+ 2149.999956ps       2.4535258
+ 2159.999957ps       2.3255869
+ 2169.999958ps       2.2137947
+ 2179.999958ps       2.1492562
+ 2189.999959ps       2.1326515
+ 2199.999960ps        2.150585
+ 2209.999961ps       2.1634752
+ 2219.999962ps       2.1685669
+ 2229.999962ps       2.1783339
+ 2239.999963ps       2.1741635
+ 2249.999964ps       2.2603503
+ 2259.999965ps       2.2136202
+ 2269.999966ps       2.2695475
+ 2279.999967ps       2.4866637
+ 2289.999967ps       2.8945117
+ 2299.999968ps       3.3316869
+ 2309.999969ps       3.7010043
+ 2319.999970ps       3.9273774
+ 2329.999971ps       4.0076685
+ 2339.999972ps        4.100509
+ 2349.999972ps       4.3074905
+ 2359.999973ps       4.6961204
+ 2369.999974ps       5.1770968
+ 2379.999975ps       5.6700868
+ 2389.999976ps       6.1996122
+ 2399.999977ps       6.6353319
+ 2409.999977ps       6.8733579
+ 2419.999978ps       6.9073126
+ 2429.999979ps       6.7230717
+ 2439.999980ps       6.4299596
+ 2449.999981ps       6.1281615
+ 2459.999981ps       5.8460367
+ 2469.999982ps       5.6082916
+ 2479.999983ps       5.3977699
+ 2489.999984ps       5.1789136
+ 2499.999985ps       4.9381152
+ 2509.999986ps       4.6984066
+ 2519.999986ps       4.4896103
+ 2529.999987ps       4.3044727
+ 2539.999988ps       4.1095258
+ 2549.999989ps       3.9032505
+ 2559.999990ps       3.7017134
+ 2569.999991ps       3.5474512
+ 2579.999991ps       3.4521152
+ 2589.999992ps       3.4080581
+ 2599.999993ps       3.3099577
+ 2609.999994ps       3.2012087
+ 2619.999995ps        3.036392
+ 2629.999996ps       2.8652463
+ 2639.999996ps       2.6931326
+ 2649.999997ps       2.5016434
+ 2659.999998ps       2.3577517
+ 2669.999999ps       2.2363948
+ 2680.000000ps       2.1661028
+ 2690.000001ps       2.1451294
+ 2700.000001ps       2.1594218
+ 2710.000002ps       2.1676206
+ 2720.000003ps       2.1692109
+ 2730.000004ps       2.1780757
+ 2740.000005ps       2.1710146
+ 2750.000005ps       2.2601593
+ 2760.000006ps        2.216142
+ 2770.000007ps       2.2655482
+ 2780.000008ps       2.4753357
+ 2790.000009ps       2.8731358
+ 2800.000010ps       3.3083632
+ 2810.000010ps        3.684135
+ 2820.000011ps       3.9103251
+ 2830.000012ps       3.9989144
+ 2840.000013ps       4.0948016
+ 2850.000014ps       4.2970708
+ 2860.000015ps       4.6755684
+ 2870.000015ps        5.112299
+ 2880.000016ps       5.5666427
+ 2890.000017ps       6.0510685
+ 2900.000018ps       6.4190361
+ 2910.000019ps       6.5993153
+ 2920.000020ps       6.6135009
+ 2930.000020ps       6.4411859
+ 2940.000021ps       6.1579043
+ 2950.000022ps       5.9017667
+ 2960.000023ps       5.6650943
+ 2970.000024ps       5.4524942
+ 2980.000025ps       5.2611677
+ 2990.000025ps       5.0600521
+ 3000.000026ps       4.8082297
+ 3010.000027ps       4.5369251
+ 3020.000028ps        4.294922
+ 3030.000029ps       4.0740454
+ 3040.000029ps       3.8236994
+ 3050.000030ps       3.5797191
+ 3060.000031ps       3.3520888
+ 3070.000032ps       3.1690605
+ 3080.000033ps       3.0582106
+ 3090.000034ps       3.0156474
+ 3100.000034ps       2.9659102
+ 3110.000035ps       2.9078906
+ 3120.000036ps       2.8143802
+ 3130.000037ps       2.6970415
+ 3140.000038ps       2.5783533
+ 3150.000039ps       2.4199225
+ 3160.000039ps       2.3054049
+ 3170.000040ps       2.2019937
+ 3180.000041ps       2.1417701
+ 3190.000042ps       2.1262228
+ 3200.000043ps       2.1453297
+ 3210.000044ps       2.1575578
+ 3220.000044ps       2.1613995
+ 3230.000045ps       2.1715904
+ 3240.000046ps       2.1656661
+ 3250.000047ps       2.2475179
+ 3260.000048ps       2.1964353
+ 3270.000049ps       2.2648764
+ 3280.000049ps       2.4835498
+ 3290.000050ps       2.8880066
+ 3300.000051ps       3.3322958
+ 3310.000052ps       3.7137468
+ 3320.000053ps       3.9305444
+ 3330.000053ps       4.0114772
+ 3340.000054ps       4.0993451
+ 3350.000055ps       4.2866373
+ 3360.000056ps       4.6373632
+ 3370.000057ps        5.052268
+ 3380.000058ps       5.4964933
+ 3390.000058ps        5.985209
+ 3400.000059ps       6.3581342
+ 3410.000060ps       6.5532699
+ 3420.000061ps       6.6129803
+ 3430.000062ps       6.4826733
+ 3440.000063ps       6.2363641
+ 3450.000063ps       6.0099105
+ 3460.000064ps       5.7741083
+ 3470.000065ps       5.5462077
+ 3480.000066ps       5.3116276
+ 3490.000067ps       5.0894099
+ 3500.000068ps       4.8241465
+ 3510.000068ps       4.5561449
+ 3520.000069ps        4.325496
+ 3530.000070ps       4.1129436
+ 3540.000071ps       3.8462543
+ 3550.000072ps       3.5898552
+ 3560.000073ps       3.3613958
+ 3570.000073ps       3.1819048
+ 3580.000074ps       3.0816559
+ 3590.000075ps       3.0711999
+ 3600.000076ps       3.0843652
+ 3610.000077ps       3.0576863
+ 3620.000077ps       2.9659119
+ 3630.000078ps       2.8119294
+ 3640.000079ps       2.6628917
+ 3650.000080ps       2.4729295
+ 3660.000081ps       2.3402139
+ 3670.000082ps       2.2258582
+ 3680.000082ps       2.1593258
+ 3690.000083ps       2.1395206
+ 3700.000084ps       2.1551393
+ 3710.000085ps       2.1645901
+ 3720.000086ps       2.1678276
+ 3729.999865ps       2.1757212
+ 3739.999865ps       2.1683048
+ 3749.999866ps        2.254475
+ 3759.999867ps       2.1971451
+ 3769.999868ps       2.2520557
+ 3779.999869ps       2.4646226
+ 3789.999869ps       2.8704661
+ 3799.999870ps       3.3156916
+ 3809.999871ps       3.6818045
+ 3819.999872ps       3.8891996
+ 3829.999873ps       3.9609204
+ 3839.999874ps       4.0596872
+ 3849.999874ps       4.2660477
+ 3859.999875ps       4.6340297
+ 3869.999876ps       5.0721876
+ 3879.999877ps       5.5419155
+ 3889.999878ps       6.0695939
+ 3899.999879ps       6.4536641
+ 3909.999879ps        6.616092
+ 3919.999880ps       6.6026843
+ 3929.999881ps        6.426899
+ 3939.999882ps       6.1286085
+ 3949.999883ps       5.8605501
+ 3959.999884ps       5.6356115
+ 3969.999884ps       5.4496128
+ 3979.999885ps       5.2437971
+ 3989.999886ps       5.0422739
+ 3999.999887ps       4.7999956
+ 4009.999888ps       4.5461928
+ 4019.999889ps       4.3181429
+ 4029.999889ps       4.1087208
+ 4039.999890ps       3.8735703
+ 4049.999891ps       3.6461112
+ 4059.999892ps       3.4578462
+ 4069.999893ps       3.2777931
+ 4079.999893ps       3.1282527
+ 4089.999894ps       3.0126831
+ 4099.999895ps       2.9632469
+ 4109.999896ps       2.9407872
+ 4119.999897ps       2.8652939
+ 4129.999898ps       2.7385248
+ 4139.999898ps       2.6073524
+ 4149.999899ps        2.450066
+ 4159.999900ps        2.336483
+ 4169.999901ps       2.2320382
+ 4179.999902ps       2.1716463
+ 4189.999903ps       2.1556602
+ 4199.999903ps        2.174795
+ 4209.999904ps       2.1882324
+ 4219.999905ps       2.1927834
+ 4229.999906ps       2.2035273
+ 4239.999907ps       2.1985227
+ 4249.999908ps       2.2862135
+ 4259.999908ps       2.2308344
+ 4269.999909ps        2.293088
+ 4279.999910ps       2.5154131
+ 4289.999911ps       2.9143191
+ 4299.999912ps       3.3514506
+ 4309.999913ps       3.7274457
+ 4319.999913ps       3.9549797
+ 4329.999914ps        4.042514
+ 4339.999915ps       4.1254823
+ 4349.999916ps       4.3011486
+ 4359.999917ps       4.6345372
+ 4369.999917ps       5.0447796
+ 4379.999918ps       5.4797635
+ 4389.999919ps       5.9538962
+ 4399.999920ps       6.3188952
+ 4409.999921ps       6.5117864
+ 4419.999922ps       6.5498589
+ 4429.999922ps       6.4149746
+ 4439.999923ps       6.1696788
+ 4449.999924ps       5.9291302
+ 4459.999925ps       5.7029155
+ 4469.999926ps       5.4919113
+ 4479.999927ps       5.2628987
+ 4489.999927ps       5.0448059
+ 4499.999928ps       4.7961007
+ 4509.999929ps       4.5214357
+ 4519.999930ps       4.2760829
+ 4529.999931ps       4.0448771
+ 4539.999932ps       3.7897107
+ 4549.999932ps        3.533131
+ 4559.999933ps       3.2936184
+ 4569.999934ps       3.0969042
+ 4579.999935ps       2.9880104
+ 4589.999936ps       2.9774391
+ 4599.999937ps       2.9920367
+ 4609.999937ps       2.9723931
+ 4619.999938ps        2.878615
+ 4629.999939ps        2.734819
+ 4639.999940ps       2.6043766
+ 4649.999941ps       2.4490518
+ 4659.999941ps       2.3351931
+ 4669.999942ps       2.2309479
+ 4679.999943ps       2.1703688
+ 4689.999944ps       2.1542216
+ 4699.999945ps       2.1728477
+ 4709.999946ps       2.1822369
+ 4719.999946ps       2.1862858
+ 4729.999947ps       2.1963099
+ 4739.999948ps        2.191161
+ 4749.999949ps       2.2754568
+ 4759.999950ps       2.2201844
+ 4769.999951ps       2.2775881
+ 4779.999951ps       2.4961611
+ 4789.999952ps       2.9021207
+ 4799.999953ps       3.3356753
+ 4809.999954ps       3.7036296
+ 4819.999955ps       3.9157194
+ 4829.999956ps       3.9791995
+ 4839.999956ps       4.0574607
+ 4849.999957ps       4.2327147
+ 4859.999958ps       4.5642493
+ 4869.999959ps       4.9745535
+ 4879.999960ps       5.4275839
+ 4889.999961ps       5.9424896
+ 4899.999961ps       6.3490124
+ 4909.999962ps       6.5677116
+ 4919.999963ps       6.6268326
+ 4929.999964ps       6.5066441
+ 4939.999965ps       6.2527414
+ 4949.999965ps       5.9937431
+ 4959.999966ps        5.745225
+ 4969.999967ps        5.506356
+ 4979.999968ps       5.2681974
+ 4989.999969ps       5.0216168
+ 4999.999970ps       4.7526674
+ 5009.999970ps        4.458383
+ 5019.999971ps        4.202861
+ 5029.999972ps       3.9655523
+ 5039.999973ps        3.710451
+ 5049.999974ps       3.4905674
+ 5059.999975ps       3.3180368
+ 5069.999975ps       3.1800378
+ 5079.999976ps       3.1049073
+ 5089.999977ps       3.0918564
+ 5099.999978ps       3.0982883
+ 5109.999979ps       3.0795733
+ 5119.999980ps       2.9661993
+ 5129.999980ps       2.8002462
+ 5139.999981ps       2.6441059
+ 5149.999982ps       2.4747365
+ 5159.999983ps       2.3532671
+ 5169.999984ps       2.2461195
+ 5179.999985ps       2.1822727
+ 5189.999985ps       2.1647277
+ 5199.999986ps       2.1824614
+ 5209.999987ps       2.1961108
+ 5219.999988ps       2.2013696
+ 5229.999989ps       2.2128985
+ 5239.999989ps       2.2094658
+ 5249.999990ps       2.2985984
+ 5259.999991ps       2.2518761
+ 5269.999992ps       2.3122668
+ 5279.999993ps        2.524487
+ 5289.999994ps       2.9344697
+ 5299.999994ps       3.3637352
+ 5309.999995ps       3.7210866
+ 5319.999996ps       3.9191687
+ 5329.999997ps       3.9715218
+ 5339.999998ps       4.0159276
+ 5349.999999ps       4.1698152
+ 5359.999999ps       4.4842395
+ 5370.000000ps       4.8769997
+ 5380.000001ps       5.3031967
+ 5390.000002ps       5.7728414
+ 5400.000003ps       6.1527031
+ 5410.000004ps       6.3723287
+ 5420.000004ps       6.4001351
+ 5430.000005ps       6.2358434
+ 5440.000006ps       5.9943204
+ 5450.000007ps       5.7682376
+ 5460.000008ps       5.5529862
+ 5470.000009ps       5.3664079
+ 5480.000009ps       5.1584814
+ 5490.000010ps       4.9354606
+ 5500.000011ps       4.6579914
+ 5510.000012ps       4.3625868
+ 5520.000013ps       4.0780487
+ 5530.000013ps       3.8077438
+ 5540.000014ps       3.5388232
+ 5550.000015ps       3.2979004
+ 5560.000016ps       3.0873011
+ 5570.000017ps       2.9264995
+ 5580.000018ps       2.8484969
+ 5590.000018ps       2.8304221
+ 5600.000019ps       2.8371815
+ 5610.000020ps       2.8294473
+ 5620.000021ps       2.8027951
+ 5630.000022ps       2.7186244
+ 5640.000023ps       2.6163595
+ 5650.000023ps        2.463701
+ 5660.000024ps       2.3529417
+ 5670.000025ps       2.2527638
+ 5680.000026ps       2.1958385
+ 5690.000027ps       2.1818227
+ 5700.000028ps       2.1997859
+ 5710.000028ps       2.2122655
+ 5720.000029ps       2.2201135
+ 5730.000030ps       2.2303846
+ 5740.000031ps       2.2272738
+ 5750.000032ps       2.3148592
+ 5760.000032ps       2.2597061
+ 5770.000033ps       2.3155589
+ 5780.000034ps       2.5353393
+ 5790.000035ps        2.933437
+ 5800.000036ps       3.3632401
+ 5810.000037ps       3.7188795
+ 5820.000037ps       3.9307588
+ 5830.000038ps       4.0134256
+ 5840.000039ps       4.1066795
+ 5850.000040ps       4.2938192
+ 5860.000041ps       4.6385913
+ 5870.000042ps       5.0691717
+ 5880.000042ps       5.5210253
+ 5890.000043ps       6.0029664
+ 5900.000044ps       6.3540074
+ 5910.000045ps       6.5128897
+ 5920.000046ps       6.4994511
+ 5930.000047ps       6.3122679
+ 5940.000047ps       6.0277495
+ 5950.000048ps       5.7917394
+ 5960.000049ps       5.5933564
+ 5970.000050ps       5.4102764
+ 5980.000051ps       5.2321689
+ 5990.000052ps       5.0281131
+ 6000.000052ps       4.7742385
+ 6010.000053ps       4.4854972
+ 6020.000054ps       4.2189533
+ 6030.000055ps       3.9763326
+ 6040.000056ps       3.7384894
+ 6050.000056ps       3.5148894
+ 6060.000057ps       3.3080225
+ 6070.000058ps       3.0910558
+ 6080.000059ps       2.9415085
+ 6090.000060ps       2.8740211
+ 6100.000061ps       2.8643863
+ 6110.000061ps        2.847005
+ 6120.000062ps       2.7896291
+ 6130.000063ps       2.6908704
+ 6140.000064ps       2.5942556
+ 6150.000065ps        2.456345
+ 6160.000066ps       2.3527968
+ 6170.000066ps       2.2557489
+ 6180.000067ps       2.2023698
+ 6190.000068ps       2.1912177
+ 6200.000069ps       2.2123433
+ 6210.000070ps        2.224732
+ 6220.000071ps       2.2283854
+ 6230.000071ps       2.2368614
+ 6240.000072ps       2.2311656
+ 6250.000073ps       2.3163457
+ 6260.000074ps       2.2699387
+ 6270.000075ps       2.3285091
+ 6280.000076ps       2.5520926
+ 6290.000076ps       2.9509992
+ 6300.000077ps       3.3763523
+ 6310.000078ps       3.7326227
+ 6320.000079ps       3.9362781
+ 6330.000080ps       3.9888126
+ 6340.000080ps       4.0516794
+ 6350.000081ps       4.2250305
+ 6360.000082ps       4.5712559
+ 6370.000083ps       5.0093531
+ 6380.000084ps        5.503751
+ 6390.000085ps        6.054583
+ 6400.000085ps       6.4932481
+ 6410.000086ps       6.7455508
+ 6420.000087ps       6.7809409
+ 6430.000088ps       6.5921539
+ 6440.000089ps       6.2781866
+ 6450.000090ps       5.9739932
+ 6460.000090ps       5.6916824
+ 6470.000091ps       5.4580047
+ 6480.000092ps       5.2372302
+ 6490.000093ps       5.0222732
+ 6500.000094ps       4.7791047
+ 6510.000095ps       4.5206111
+ 6520.000095ps       4.2837903
+ 6530.000096ps       4.0633893
+ 6540.000097ps       3.8439182
+ 6550.000098ps       3.6478328
+ 6560.000099ps       3.5014289
+ 6570.000100ps       3.3769463
+ 6580.000100ps        3.318798
+ 6590.000101ps       3.2683068
+ 6600.000102ps       3.1935531
+ 6610.000103ps       3.0872705
+ 6620.000104ps       2.9516217
+ 6630.000104ps       2.7934786
+ 6640.000105ps       2.6505918
+ 6650.000106ps       2.4859563
+ 6660.000107ps       2.3714943
+ 6670.000108ps       2.2686332
+ 6680.000109ps       2.2085786
+ 6690.000109ps       2.1925473
+ 6700.000110ps       2.2090205
+ 6710.000111ps       2.2185201
+ 6720.000112ps       2.2225309
+ 6730.000113ps       2.2346846
+ 6740.000114ps       2.2324191
+ 6750.000114ps       2.3233311
+ 6760.000115ps       2.2728344
+ 6770.000116ps       2.3378351
+ 6780.000117ps       2.5490926
+ 6790.000118ps       2.9416905
+ 6800.000119ps       3.3828879
+ 6810.000119ps       3.7699266
+ 6820.000120ps       4.0152906
+ 6830.000121ps       4.1146203
+ 6840.000122ps       4.2264898
+ 6850.000123ps       4.4450146
+ 6860.000124ps        4.819487
+ 6870.000124ps       5.2514929
+ 6880.000125ps       5.6833589
+ 6890.000126ps       6.1501307
+ 6900.000127ps       6.5013939
+ 6910.000128ps       6.6552311
+ 6920.000128ps       6.6325538
+ 6930.000129ps       6.4586511
+ 6940.000130ps        6.193097
+ 6950.000131ps       5.9568568
+ 6960.000132ps       5.7440482
+ 6970.000133ps        5.568592
+ 6980.000133ps       5.3902973
+ 6990.000134ps       5.1999336
+ 7000.000135ps       4.9534086
+ 7010.000136ps       4.6914466
+ 7020.000137ps       4.4520721
+ 7030.000138ps       4.2190237
+ 7040.000138ps       3.9670872
+ 7050.000139ps       3.6915665
+ 7060.000140ps       3.4322362
+ 7070.000141ps       3.2246346
+ 7080.000142ps       3.1004571
+ 7090.000143ps       3.0286128
+ 7100.000143ps       2.9737947
+ 7110.000144ps       2.9256321
+ 7120.000145ps       2.8602225
+ 7130.000146ps       2.7511607
+ 7140.000147ps        2.633421
+ 7150.000148ps       2.4703526
+ 7160.000148ps       2.3522385
+ 7170.000149ps        2.248198
+ 7180.000150ps       2.1899896
+ 7190.000151ps       2.1787704
+ 7200.000152ps       2.1984442
+ 7210.000152ps       2.2128008
+ 7220.000153ps       2.2229929
+ 7230.000154ps       2.2348201
+ 7240.000155ps       2.2320272
+ 7250.000156ps       2.3218847
+ 7260.000157ps       2.2684005
+ 7270.000157ps       2.3348077
+ 7280.000158ps       2.5489043
+ 7290.000159ps       2.9554739
+ 7300.000160ps       3.3818372
+ 7310.000161ps       3.7413691
+ 7320.000162ps       3.9462812
+ 7330.000162ps       4.0284059
+ 7340.000163ps       4.1220223
+ 7350.000164ps       4.3230923
+ 7360.000165ps       4.6883538
+ 7370.000166ps       5.1370719
+ 7380.000167ps       5.6185549
+ 7390.000167ps       6.1547869
+ 7400.000168ps       6.5571605
+ 7410.000169ps       6.7508858
+ 7420.000170ps       6.7330768
+ 7430.000171ps       6.5305664
+ 7440.000171ps       6.2328637
+ 7450.000172ps       5.9596557
+ 7459.999729ps       5.7239102
+ 7469.999730ps       5.5459272
+ 7479.999731ps       5.3450456
+ 7489.999732ps       5.1269727
+ 7499.999732ps       4.8865787
+ 7509.999733ps       4.6210883
+ 7519.999734ps       4.3808814
+ 7529.999735ps       4.1628531
+ 7539.999736ps       3.9512443
+ 7549.999737ps       3.7564521
+ 7559.999737ps       3.5835639
+ 7569.999738ps       3.4107832
+ 7579.999739ps       3.2558918
+ 7589.999740ps       3.1378075
+ 7599.999741ps        3.067994
+ 7609.999741ps       3.0313805
+ 7619.999742ps       2.9598311
+ 7629.999743ps       2.8261701
+ 7639.999744ps       2.6770067
+ 7649.999745ps       2.4997599
+ 7659.999746ps         2.37781
+ 7669.999746ps       2.2685456
+ 7679.999747ps       2.2033465
+ 7689.999748ps       2.1852669
+ 7699.999749ps       2.2012806
+ 7709.999750ps       2.2139186
+ 7719.999751ps       2.2206455
+ 7729.999751ps       2.2302855
+ 7739.999752ps       2.2267639
+ 7749.999753ps       2.3120471
+ 7759.999754ps        2.262617
+ 7769.999755ps       2.3229962
+ 7779.999756ps       2.5406537
+ 7789.999756ps       2.9412568
+ 7799.999757ps        3.377198
+ 7809.999758ps       3.7364805
+ 7819.999759ps       3.9511191
+ 7829.999760ps       4.0258328
+ 7839.999761ps       4.1049108
+ 7849.999761ps       4.2796048
+ 7859.999762ps        4.620147
+ 7869.999763ps       5.0330841
+ 7879.999764ps       5.4738591
+ 7889.999765ps       5.9410754
+ 7899.999765ps       6.2954396
+ 7909.999766ps       6.4729506
+ 7919.999767ps       6.4931292
+ 7929.999768ps       6.3299534
+ 7939.999769ps       6.0648398
+ 7949.999770ps        5.825628
+ 7959.999770ps       5.6100821
+ 7969.999771ps       5.4068949
+ 7979.999772ps       5.2109245
+ 7989.999773ps       5.0148174
+ 7999.999774ps       4.7659053
+ 8009.999775ps       4.4565596
+ 8019.999775ps        4.207488
+ 8029.999776ps       4.0421865
+ 8039.999777ps       3.9409604
+ 8049.999778ps       3.8775132
+ 8059.999779ps       3.8367242
+ 8069.999780ps       3.8100197
+ 8079.999780ps       3.7921928
+ 8089.999781ps       3.7800413
+ 8099.999782ps       3.7715763
+ 8109.999783ps       3.7655469
+ 8119.999784ps       3.7611563
+ 8129.999785ps       3.7578895
+ 8139.999785ps        3.755409
+ 8149.999786ps       3.7534893
+ 8159.999787ps       3.7519777
+ 8169.999788ps       3.7507687
+ 8179.999789ps       3.7497882
+ 8189.999789ps       3.7489833
+ 8199.999790ps       3.7483153
+ 8209.999791ps       3.7477557
+ 8219.999792ps       3.7472831
+ 8229.999793ps        3.746881
+ 8239.999794ps       3.7465367
+ 8249.999794ps       3.7462403
+ 8259.999795ps       3.7459839
+ 8269.999796ps        3.745761
+ 8279.999797ps       3.7455666
+ 8289.999798ps       3.7453964
+ 8299.999799ps        3.745247
+ 8309.999799ps       3.7451154
+)

Icursig4 PAR_2_0_VSS 0 pwl(
+ 0.000000ps     -0.54126004
+ 10.000000ps     -0.63151179
+ 20.000000ps     -0.99727048
+ 29.999999ps      -1.4465061
+ 40.000000ps      -1.8137645
+ 50.000001ps       -2.214937
+ 59.999998ps      -2.6276443
+ 69.999999ps       -3.026088
+ 80.000000ps      -3.3964031
+ 90.000001ps      -3.7032678
+ 100.000001ps      -3.9396935
+ 110.000002ps        -4.12908
+ 119.999996ps      -4.2267296
+ 129.999997ps      -4.2101451
+ 139.999998ps      -4.0697684
+ 149.999999ps      -3.8597097
+ 159.999999ps      -3.5664945
+ 170.000000ps      -3.2358183
+ 180.000001ps      -2.9045446
+ 190.000002ps      -2.6285892
+ 200.000003ps      -2.4232349
+ 210.000003ps      -2.3051906
+ 220.000004ps      -2.2460762
+ 230.000005ps      -2.2764398
+ 239.999992ps      -2.3503085
+ 249.999993ps       -2.428458
+ 259.999994ps      -2.5337881
+ 269.999995ps      -2.6977843
+ 279.999995ps       -2.868592
+ 289.999996ps      -3.0653156
+ 299.999997ps      -3.2866124
+ 309.999998ps      -3.4362351
+ 319.999999ps      -3.5015335
+ 330.000000ps      -3.5177349
+ 340.000000ps       -3.542766
+ 350.000001ps      -3.6032037
+ 360.000002ps      -3.6730054
+ 370.000003ps      -3.7132815
+ 380.000004ps      -3.7444536
+ 390.000005ps      -3.7553797
+ 400.000005ps      -3.7612656
+ 410.000006ps      -3.7381043
+ 420.000007ps      -3.6924561
+ 430.000008ps      -3.6405123
+ 440.000009ps      -3.6162585
+ 450.000009ps      -3.7201098
+ 460.000010ps      -3.9521747
+ 469.999983ps      -4.1701924
+ 479.999984ps      -4.3829815
+ 489.999985ps      -4.5894507
+ 499.999986ps      -4.6634828
+ 509.999987ps       -4.430505
+ 519.999988ps      -4.2084845
+ 529.999988ps      -4.0684193
+ 539.999989ps      -3.8944357
+ 549.999990ps        -3.81151
+ 559.999991ps      -3.7927736
+ 569.999992ps      -3.8368068
+ 579.999992ps      -3.9422734
+ 589.999993ps      -4.0742206
+ 599.999994ps      -4.2002848
+ 609.999995ps      -4.3183456
+ 619.999996ps      -4.3640749
+ 629.999997ps      -4.3096526
+ 639.999997ps       -4.140471
+ 649.999998ps       -3.908307
+ 659.999999ps       -3.594708
+ 670.000000ps      -3.2553963
+ 680.000001ps      -2.9173225
+ 690.000002ps      -2.6347569
+ 700.000002ps      -2.4259151
+ 710.000003ps      -2.3012278
+ 720.000004ps      -2.2437849
+ 730.000005ps      -2.2644992
+ 740.000006ps      -2.3321048
+ 750.000007ps      -2.4105715
+ 760.000007ps      -2.5066026
+ 770.000008ps       -2.659864
+ 780.000009ps      -2.8351377
+ 790.000010ps      -3.0376351
+ 800.000011ps      -3.2702437
+ 810.000012ps      -3.4312087
+ 820.000012ps       -3.493951
+ 830.000013ps      -3.5113689
+ 840.000014ps      -3.5374346
+ 850.000015ps      -3.5888877
+ 860.000016ps      -3.6565116
+ 870.000016ps      -3.6889519
+ 880.000017ps      -3.7084005
+ 890.000018ps      -3.7329169
+ 900.000019ps      -3.7597906
+ 910.000020ps      -3.7452172
+ 920.000021ps      -3.7065619
+ 930.000021ps      -3.6636183
+ 939.999967ps      -3.6204577
+ 949.999968ps      -3.7040291
+ 959.999968ps      -3.9270805
+ 969.999969ps      -4.1546456
+ 979.999970ps      -4.3686978
+ 989.999971ps      -4.5683377
+ 999.999972ps      -4.6429096
+ 1009.999973ps      -4.4065622
+ 1019.999973ps      -4.1762556
+ 1029.999974ps      -4.0287308
+ 1039.999975ps      -3.8390692
+ 1049.999976ps      -3.7597256
+ 1059.999977ps      -3.7614113
+ 1069.999978ps      -3.8398062
+ 1079.999978ps      -3.9668072
+ 1089.999979ps      -4.0991718
+ 1099.999980ps      -4.2139011
+ 1109.999981ps      -4.3253665
+ 1119.999982ps      -4.3679903
+ 1129.999982ps      -4.3130178
+ 1139.999983ps      -4.1459449
+ 1149.999984ps      -3.9166698
+ 1159.999985ps      -3.6011118
+ 1169.999986ps      -3.2602471
+ 1179.999987ps      -2.9223974
+ 1189.999987ps      -2.6318864
+ 1199.999988ps      -2.4249534
+ 1209.999989ps      -2.2927603
+ 1219.999990ps      -2.2410512
+ 1229.999991ps      -2.2726268
+ 1239.999992ps       -2.366862
+ 1249.999992ps      -2.4544716
+ 1259.999993ps       -2.555337
+ 1269.999994ps      -2.7156663
+ 1279.999995ps      -2.9183341
+ 1289.999996ps      -3.1696787
+ 1299.999997ps      -3.4602528
+ 1309.999997ps      -3.6754684
+ 1319.999998ps       -3.788163
+ 1329.999999ps      -3.8513489
+ 1340.000000ps      -3.9268936
+ 1350.000001ps      -3.9799055
+ 1360.000002ps      -4.0022032
+ 1370.000002ps      -3.9901243
+ 1380.000003ps      -3.9519922
+ 1390.000004ps      -3.8924612
+ 1400.000005ps      -3.8582313
+ 1410.000006ps      -3.8380851
+ 1420.000006ps      -3.8204677
+ 1430.000007ps      -3.8230444
+ 1440.000008ps      -3.8369445
+ 1450.000009ps      -3.9883579
+ 1460.000010ps      -4.2671075
+ 1470.000011ps      -4.5421564
+ 1480.000011ps      -4.7892861
+ 1490.000012ps      -5.0159038
+ 1500.000013ps      -5.1032151
+ 1510.000014ps      -4.9001962
+ 1520.000015ps      -4.6471933
+ 1530.000016ps      -4.4041891
+ 1540.000016ps      -4.1061373
+ 1550.000017ps      -3.9248368
+ 1560.000018ps      -3.8636183
+ 1570.000019ps      -3.8806333
+ 1580.000020ps      -3.9785265
+ 1590.000021ps      -4.1056387
+ 1600.000021ps      -4.2269784
+ 1610.000022ps      -4.3377346
+ 1620.000023ps      -4.3795612
+ 1630.000024ps      -4.3227604
+ 1640.000025ps      -4.1541704
+ 1650.000025ps      -3.9242802
+ 1660.000026ps      -3.6105103
+ 1670.000027ps      -3.2714295
+ 1680.000028ps      -2.9361971
+ 1690.000029ps      -2.6488745
+ 1700.000030ps      -2.4426852
+ 1710.000030ps      -2.3096609
+ 1720.000031ps      -2.2611712
+ 1730.000032ps      -2.2873688
+ 1740.000033ps      -2.3655367
+ 1750.000034ps      -2.4504507
+ 1760.000035ps      -2.5646812
+ 1770.000035ps      -2.7472339
+ 1780.000036ps      -2.9578604
+ 1790.000037ps      -3.1959129
+ 1800.000038ps      -3.4668473
+ 1810.000039ps      -3.6582011
+ 1820.000040ps      -3.7324947
+ 1830.000040ps       -3.736812
+ 1840.000041ps      -3.7425033
+ 1850.000042ps      -3.7695161
+ 1860.000043ps      -3.8250868
+ 1869.999933ps      -3.8558393
+ 1879.999934ps      -3.8904266
+ 1889.999934ps      -3.9445339
+ 1899.999935ps      -3.9817424
+ 1909.999936ps      -3.9642833
+ 1919.999937ps        -3.92699
+ 1929.999938ps      -3.8919987
+ 1939.999938ps       -3.856683
+ 1949.999939ps      -3.9659643
+ 1959.999940ps      -4.2183279
+ 1969.999941ps      -4.4733507
+ 1979.999942ps      -4.7021217
+ 1989.999943ps      -4.9041383
+ 1999.999943ps      -4.9423573
+ 2009.999944ps      -4.6602316
+ 2019.999945ps      -4.3845723
+ 2029.999946ps      -4.2190715
+ 2039.999947ps      -4.0288017
+ 2049.999948ps      -3.9467653
+ 2059.999948ps      -3.9523149
+ 2069.999949ps      -4.0054334
+ 2079.999950ps      -4.1002125
+ 2089.999951ps       -4.186722
+ 2099.999952ps      -4.2761527
+ 2109.999953ps      -4.3698014
+ 2119.999953ps      -4.4022099
+ 2129.999954ps      -4.3411522
+ 2139.999955ps      -4.1705724
+ 2149.999956ps      -3.9437981
+ 2159.999957ps       -3.642583
+ 2169.999958ps      -3.3102072
+ 2179.999958ps      -2.9796812
+ 2189.999959ps      -2.6951014
+ 2199.999960ps      -2.4892891
+ 2209.999961ps      -2.3505827
+ 2219.999962ps      -2.2840423
+ 2229.999962ps      -2.3052566
+ 2239.999963ps      -2.3792831
+ 2249.999964ps      -2.4838189
+ 2259.999965ps      -2.5965104
+ 2269.999966ps      -2.7605311
+ 2279.999967ps      -2.9337116
+ 2289.999967ps       -3.137999
+ 2299.999968ps      -3.3748361
+ 2309.999969ps      -3.5279286
+ 2319.999970ps      -3.5655634
+ 2329.999971ps      -3.5575126
+ 2339.999972ps      -3.5576287
+ 2349.999972ps      -3.5971314
+ 2359.999973ps      -3.6486992
+ 2369.999974ps      -3.6986508
+ 2379.999975ps       -3.751697
+ 2389.999976ps      -3.7863406
+ 2399.999977ps      -3.8153386
+ 2409.999977ps      -3.8089541
+ 2419.999978ps      -3.7819346
+ 2429.999979ps       -3.733357
+ 2439.999980ps      -3.6948596
+ 2449.999981ps      -3.7803074
+ 2459.999981ps      -4.0034673
+ 2469.999982ps      -4.2349703
+ 2479.999983ps      -4.4458597
+ 2489.999984ps      -4.6376059
+ 2499.999985ps      -4.7055594
+ 2509.999986ps      -4.4661985
+ 2519.999986ps      -4.2375343
+ 2529.999987ps      -4.0868871
+ 2539.999988ps      -3.9117084
+ 2549.999989ps      -3.8505786
+ 2559.999990ps      -3.8648965
+ 2569.999991ps      -3.9402662
+ 2579.999991ps      -4.0512041
+ 2589.999992ps      -4.1704878
+ 2599.999993ps      -4.2768999
+ 2609.999994ps      -4.3756181
+ 2619.999995ps      -4.4111101
+ 2629.999996ps         -4.3501
+ 2639.999996ps       -4.178993
+ 2649.999997ps      -3.9487536
+ 2659.999998ps       -3.633615
+ 2669.999999ps      -3.2930042
+ 2680.000000ps      -2.9577008
+ 2690.000001ps      -2.6717325
+ 2700.000001ps      -2.4686866
+ 2710.000002ps      -2.3428654
+ 2720.000003ps      -2.2930202
+ 2730.000004ps      -2.3360226
+ 2740.000005ps      -2.4227638
+ 2750.000005ps      -2.5173157
+ 2760.000006ps      -2.6384324
+ 2770.000007ps      -2.8229637
+ 2780.000008ps      -3.0287296
+ 2790.000009ps      -3.2711981
+ 2800.000010ps      -3.5585815
+ 2810.000010ps      -3.7776023
+ 2820.000011ps      -3.9038254
+ 2830.000012ps      -3.9428734
+ 2840.000013ps      -3.9539139
+ 2850.000014ps      -3.9763193
+ 2860.000015ps      -4.0159027
+ 2870.000015ps      -4.0090997
+ 2880.000016ps      -3.9984416
+ 2890.000017ps      -3.9998381
+ 2900.000018ps      -4.0028588
+ 2910.000019ps      -3.9770788
+ 2920.000020ps      -3.9446159
+ 2930.000020ps      -3.9238529
+ 2940.000021ps      -3.9264378
+ 2950.000022ps      -4.0736637
+ 2960.000023ps      -4.3552519
+ 2970.000024ps      -4.6520307
+ 2980.000025ps      -4.9095911
+ 2990.000025ps      -5.1513953
+ 3000.000026ps      -5.2020464
+ 3010.000027ps       -4.906403
+ 3020.000028ps      -4.5803126
+ 3030.000029ps      -4.3778359
+ 3040.000029ps      -4.1557788
+ 3050.000030ps      -4.0199903
+ 3060.000031ps      -3.9552104
+ 3070.000032ps      -3.9597858
+ 3080.000033ps      -4.0462342
+ 3090.000034ps        -4.15378
+ 3100.000034ps      -4.2671271
+ 3110.000035ps      -4.3800615
+ 3120.000036ps      -4.4257146
+ 3130.000037ps      -4.3739849
+ 3140.000038ps        -4.20438
+ 3150.000039ps      -3.9727361
+ 3160.000039ps       -3.655967
+ 3170.000040ps      -3.3140378
+ 3180.000041ps      -2.9794844
+ 3190.000042ps      -2.6872932
+ 3200.000043ps      -2.4724383
+ 3210.000044ps      -2.3416082
+ 3220.000044ps      -2.2876498
+ 3230.000045ps      -2.3110486
+ 3240.000046ps      -2.3812439
+ 3250.000047ps      -2.4671435
+ 3260.000048ps      -2.5805246
+ 3270.000049ps      -2.7362989
+ 3280.000049ps      -2.9177463
+ 3290.000050ps      -3.1244603
+ 3300.000051ps      -3.3682111
+ 3310.000052ps      -3.5362279
+ 3320.000053ps      -3.5913463
+ 3330.000053ps      -3.6045054
+ 3340.000054ps      -3.6371212
+ 3350.000055ps      -3.6970151
+ 3360.000056ps      -3.7651817
+ 3370.000057ps      -3.8028246
+ 3380.000058ps      -3.8183511
+ 3390.000058ps      -3.8281696
+ 3400.000059ps      -3.8347433
+ 3410.000060ps      -3.8143802
+ 3420.000061ps      -3.7874649
+ 3430.000062ps      -3.7570917
+ 3440.000063ps      -3.7428145
+ 3450.000063ps      -3.8531649
+ 3460.000064ps      -4.0866598
+ 3470.000065ps      -4.3206623
+ 3480.000066ps      -4.5270656
+ 3490.000067ps      -4.7180128
+ 3500.000068ps      -4.7814099
+ 3510.000068ps      -4.5463722
+ 3520.000069ps      -4.3222995
+ 3530.000070ps      -4.1732601
+ 3540.000071ps      -3.9690204
+ 3550.000072ps      -3.8581185
+ 3560.000073ps      -3.8417326
+ 3570.000073ps      -3.8997314
+ 3580.000074ps      -4.0270687
+ 3590.000075ps      -4.1554817
+ 3600.000076ps      -4.2748437
+ 3610.000077ps      -4.3813788
+ 3620.000077ps      -4.4185847
+ 3630.000078ps      -4.3631679
+ 3640.000079ps      -4.1945439
+ 3650.000080ps      -3.9654403
+ 3660.000081ps       -3.650036
+ 3670.000082ps      -3.3118911
+ 3680.000082ps      -2.9783738
+ 3690.000083ps      -2.6992746
+ 3700.000084ps      -2.4961866
+ 3710.000085ps      -2.3655064
+ 3720.000086ps      -2.3079432
+ 3729.999865ps      -2.3334215
+ 3739.999865ps      -2.3966373
+ 3749.999866ps      -2.4744769
+ 3759.999867ps      -2.5727515
+ 3769.999868ps      -2.7286391
+ 3779.999869ps      -2.9093897
+ 3789.999869ps      -3.1258315
+ 3799.999870ps      -3.3743432
+ 3809.999871ps      -3.5583329
+ 3819.999872ps      -3.6380281
+ 3829.999873ps      -3.6746038
+ 3839.999874ps      -3.7318486
+ 3849.999874ps      -3.7972992
+ 3859.999875ps      -3.8644116
+ 3869.999876ps      -3.8961286
+ 3879.999877ps      -3.9029415
+ 3889.999878ps      -3.8921107
+ 3899.999879ps      -3.8848899
+ 3909.999879ps      -3.8393558
+ 3919.999880ps       -3.798653
+ 3929.999881ps      -3.7675102
+ 3939.999882ps      -3.7369201
+ 3949.999883ps      -3.8511529
+ 3959.999884ps      -4.1022819
+ 3969.999884ps      -4.3544988
+ 3979.999885ps      -4.6065825
+ 3989.999886ps      -4.8303588
+ 3999.999887ps      -4.9228777
+ 4009.999888ps      -4.7159079
+ 4019.999889ps      -4.4915044
+ 4029.999889ps      -4.3328623
+ 4039.999890ps      -4.1086412
+ 4049.999891ps      -4.0026671
+ 4059.999892ps      -3.9780608
+ 4069.999893ps      -4.0277985
+ 4079.999893ps      -4.1367058
+ 4089.999894ps      -4.2541507
+ 4099.999895ps      -4.3763934
+ 4109.999896ps      -4.4930817
+ 4119.999897ps       -4.537807
+ 4129.999898ps      -4.4831761
+ 4139.999898ps      -4.3099754
+ 4149.999899ps      -4.0743839
+ 4159.999900ps       -3.755969
+ 4169.999901ps      -3.4195791
+ 4179.999902ps      -3.0782108
+ 4189.999903ps      -2.7888445
+ 4199.999903ps      -2.5909174
+ 4209.999904ps      -2.4554526
+ 4219.999905ps      -2.3895667
+ 4229.999906ps      -2.4206948
+ 4239.999907ps       -2.499278
+ 4249.999908ps      -2.5859322
+ 4259.999908ps      -2.6950673
+ 4269.999909ps      -2.8752513
+ 4279.999910ps      -3.0802298
+ 4289.999911ps      -3.3189703
+ 4299.999912ps      -3.5931736
+ 4309.999913ps      -3.8075179
+ 4319.999913ps      -3.9250816
+ 4329.999914ps      -3.9706827
+ 4339.999915ps      -4.0053887
+ 4349.999916ps      -4.0449918
+ 4359.999917ps      -4.1048122
+ 4369.999917ps      -4.1533631
+ 4379.999918ps      -4.1549375
+ 4389.999919ps      -4.1342476
+ 4399.999920ps      -4.1189277
+ 4409.999921ps      -4.0666962
+ 4419.999922ps      -3.9927474
+ 4429.999922ps      -3.9669654
+ 4439.999923ps       -3.966716
+ 4449.999924ps      -4.1077058
+ 4459.999925ps      -4.3771314
+ 4469.999926ps      -4.6502363
+ 4479.999927ps      -4.8909593
+ 4489.999927ps      -5.1100896
+ 4499.999928ps      -5.1741014
+ 4509.999929ps      -4.9065927
+ 4519.999930ps      -4.6352865
+ 4529.999931ps       -4.458163
+ 4539.999932ps      -4.2745421
+ 4549.999932ps      -4.1336364
+ 4559.999933ps      -4.0351953
+ 4569.999934ps      -3.9838356
+ 4579.999935ps      -4.0513719
+ 4589.999936ps      -4.1613044
+ 4599.999937ps      -4.2729577
+ 4609.999937ps      -4.3768037
+ 4619.999938ps      -4.4125193
+ 4629.999939ps       -4.351741
+ 4639.999940ps      -4.1765268
+ 4649.999941ps      -3.9429499
+ 4659.999941ps      -3.6265297
+ 4669.999942ps      -3.2888521
+ 4679.999943ps      -2.9523385
+ 4689.999944ps      -2.6686456
+ 4699.999945ps      -2.4796095
+ 4709.999946ps      -2.3465613
+ 4719.999946ps      -2.2924049
+ 4729.999947ps      -2.3205876
+ 4739.999948ps      -2.3958724
+ 4749.999949ps      -2.4848101
+ 4759.999950ps      -2.6055263
+ 4769.999951ps      -2.7985714
+ 4779.999951ps      -3.0274069
+ 4789.999952ps      -3.3078039
+ 4799.999953ps      -3.6250604
+ 4809.999954ps      -3.8725856
+ 4819.999955ps      -4.0093809
+ 4829.999956ps      -4.0778592
+ 4839.999956ps      -4.1301473
+ 4849.999957ps      -4.1634536
+ 4859.999958ps      -4.1668279
+ 4869.999959ps      -4.1183995
+ 4879.999960ps      -4.0625787
+ 4889.999961ps      -4.0238321
+ 4899.999961ps      -4.0046709
+ 4909.999962ps      -3.9993567
+ 4919.999963ps      -4.0020976
+ 4929.999964ps      -4.0095805
+ 4939.999965ps      -4.0156091
+ 4949.999965ps      -4.1649438
+ 4959.999966ps      -4.4482986
+ 4969.999967ps      -4.7303681
+ 4979.999968ps      -4.9907636
+ 4989.999969ps      -5.2313309
+ 4999.999970ps      -5.3019139
+ 5009.999970ps      -5.0279071
+ 5019.999971ps      -4.7059661
+ 5029.999972ps         -4.4423
+ 5039.999973ps      -4.1331401
+ 5049.999974ps      -3.9549359
+ 5059.999975ps       -3.907679
+ 5069.999975ps      -3.9359827
+ 5079.999976ps      -4.0302365
+ 5089.999977ps      -4.1279936
+ 5099.999978ps      -4.2320278
+ 5109.999979ps      -4.3362809
+ 5119.999980ps       -4.374955
+ 5129.999980ps      -4.3227496
+ 5139.999981ps      -4.1602951
+ 5149.999982ps      -3.9334322
+ 5159.999983ps      -3.6167911
+ 5169.999984ps      -3.2742402
+ 5179.999985ps      -2.9324558
+ 5189.999985ps      -2.6407014
+ 5199.999986ps       -2.434895
+ 5209.999987ps      -2.2975174
+ 5219.999988ps      -2.2336916
+ 5229.999989ps       -2.264084
+ 5239.999989ps      -2.3452327
+ 5249.999990ps      -2.4348223
+ 5259.999991ps      -2.5383577
+ 5269.999992ps      -2.7227124
+ 5279.999993ps      -2.9309083
+ 5289.999994ps      -3.1737506
+ 5299.999994ps      -3.4434885
+ 5309.999995ps      -3.6420867
+ 5319.999996ps      -3.7386146
+ 5329.999997ps      -3.7703773
+ 5339.999998ps      -3.7785005
+ 5349.999999ps      -3.7890868
+ 5359.999999ps      -3.8145257
+ 5370.000000ps       -3.830966
+ 5380.000001ps      -3.8444836
+ 5390.000002ps      -3.8626235
+ 5400.000003ps      -3.8827506
+ 5410.000004ps      -3.8763898
+ 5420.000004ps      -3.8470415
+ 5430.000005ps      -3.8126127
+ 5440.000006ps      -3.8017794
+ 5450.000007ps      -3.9365744
+ 5460.000008ps      -4.1913223
+ 5470.000009ps       -4.453053
+ 5480.000009ps      -4.6937081
+ 5490.000010ps      -4.9137589
+ 5500.000011ps       -4.963942
+ 5510.000012ps      -4.6802182
+ 5520.000013ps      -4.3727865
+ 5530.000013ps      -4.1715244
+ 5540.000014ps      -3.9804729
+ 5550.000015ps      -3.8934945
+ 5560.000016ps      -3.8741535
+ 5570.000017ps      -3.8905822
+ 5580.000018ps      -3.9780995
+ 5590.000018ps      -4.0871529
+ 5600.000019ps       -4.199811
+ 5610.000020ps      -4.3078779
+ 5620.000021ps      -4.3472539
+ 5630.000022ps      -4.2899828
+ 5640.000023ps      -4.1214931
+ 5650.000023ps      -3.8905944
+ 5660.000024ps       -3.576729
+ 5670.000025ps      -3.2358905
+ 5680.000026ps      -2.8970061
+ 5690.000027ps      -2.6102753
+ 5700.000028ps      -2.4088743
+ 5710.000028ps      -2.2758063
+ 5720.000029ps        -2.21395
+ 5730.000030ps      -2.2392297
+ 5740.000031ps      -2.3256626
+ 5750.000032ps      -2.4190589
+ 5760.000032ps      -2.5276135
+ 5770.000033ps      -2.7024241
+ 5780.000034ps      -2.8923274
+ 5790.000035ps      -3.1015727
+ 5800.000036ps      -3.3374661
+ 5810.000037ps       -3.471865
+ 5820.000037ps      -3.4861837
+ 5830.000038ps      -3.4384777
+ 5840.000039ps      -3.3970608
+ 5850.000040ps      -3.3927918
+ 5860.000041ps      -3.4231984
+ 5870.000042ps      -3.4663042
+ 5880.000042ps      -3.5288858
+ 5890.000043ps      -3.6154834
+ 5900.000044ps      -3.7013304
+ 5910.000045ps      -3.7406143
+ 5920.000046ps       -3.733978
+ 5930.000047ps      -3.7034748
+ 5940.000047ps      -3.6617909
+ 5950.000048ps      -3.7362013
+ 5960.000049ps      -3.9397668
+ 5970.000050ps      -4.1512383
+ 5980.000051ps      -4.3210045
+ 5990.000052ps      -4.4716307
+ 6000.000052ps      -4.4761355
+ 6010.000053ps      -4.1940576
+ 6020.000054ps       -3.927472
+ 6030.000055ps      -3.7635613
+ 6040.000056ps      -3.6123947
+ 6050.000056ps      -3.5901392
+ 6060.000057ps      -3.6690269
+ 6070.000058ps      -3.8045624
+ 6080.000059ps      -3.9608075
+ 6090.000060ps      -4.0955025
+ 6100.000061ps      -4.1994928
+ 6110.000061ps      -4.3033146
+ 6120.000062ps      -4.3434558
+ 6130.000063ps      -4.2868508
+ 6140.000064ps      -4.1169797
+ 6150.000065ps      -3.8860965
+ 6160.000066ps      -3.5727191
+ 6170.000066ps      -3.2356509
+ 6180.000067ps      -2.9052008
+ 6190.000068ps      -2.6163097
+ 6200.000069ps      -2.4087857
+ 6210.000070ps      -2.2738444
+ 6220.000071ps      -2.2282835
+ 6230.000071ps      -2.2534941
+ 6240.000072ps      -2.3365875
+ 6250.000073ps      -2.4118234
+ 6260.000074ps      -2.5134569
+ 6270.000075ps      -2.6850259
+ 6280.000076ps      -2.8899162
+ 6290.000076ps      -3.1231011
+ 6300.000077ps      -3.3864465
+ 6310.000078ps      -3.5706305
+ 6320.000079ps      -3.6556738
+ 6330.000080ps      -3.6868529
+ 6340.000080ps      -3.7132927
+ 6350.000081ps      -3.7494608
+ 6360.000082ps      -3.7845155
+ 6370.000083ps      -3.7862797
+ 6380.000084ps      -3.7848616
+ 6390.000085ps      -3.7947458
+ 6400.000085ps      -3.8203443
+ 6410.000086ps      -3.8112229
+ 6420.000087ps      -3.7904756
+ 6430.000088ps      -3.7697278
+ 6440.000089ps      -3.7498778
+ 6450.000090ps      -3.8706804
+ 6460.000090ps       -4.117186
+ 6470.000091ps      -4.3756392
+ 6480.000092ps      -4.6135109
+ 6490.000093ps      -4.8349431
+ 6500.000094ps      -4.9129784
+ 6510.000095ps      -4.6653876
+ 6520.000095ps      -4.3852318
+ 6530.000096ps      -4.1804465
+ 6540.000097ps      -3.9516981
+ 6550.000098ps      -3.8398061
+ 6560.000099ps      -3.8352582
+ 6570.000100ps      -3.8954339
+ 6580.000100ps      -4.0056954
+ 6590.000101ps       -4.114282
+ 6600.000102ps      -4.2148664
+ 6610.000103ps      -4.3157898
+ 6620.000104ps      -4.3529642
+ 6630.000104ps      -4.2947028
+ 6640.000105ps      -4.1257926
+ 6650.000106ps      -3.8937649
+ 6660.000107ps      -3.5791468
+ 6670.000108ps      -3.2404147
+ 6680.000109ps      -2.9068101
+ 6690.000109ps      -2.6183755
+ 6700.000110ps      -2.4087771
+ 6710.000111ps      -2.2733539
+ 6720.000112ps      -2.2233018
+ 6730.000113ps      -2.2479468
+ 6740.000114ps      -2.3234138
+ 6750.000114ps      -2.4013125
+ 6760.000115ps      -2.4991978
+ 6770.000116ps      -2.6629662
+ 6780.000117ps      -2.8529638
+ 6790.000118ps      -3.0837914
+ 6800.000119ps        -3.34819
+ 6810.000119ps      -3.5422775
+ 6820.000120ps      -3.6398934
+ 6830.000121ps      -3.6927769
+ 6840.000122ps      -3.7483194
+ 6850.000123ps      -3.8166899
+ 6860.000124ps      -3.8790458
+ 6870.000124ps      -3.8910405
+ 6880.000125ps       -3.878341
+ 6890.000126ps      -3.8584235
+ 6900.000127ps      -3.8496704
+ 6910.000128ps      -3.8190595
+ 6920.000128ps      -3.7793171
+ 6930.000129ps      -3.7523087
+ 6940.000130ps      -3.7323484
+ 6950.000131ps      -3.8552634
+ 6960.000132ps      -4.1097246
+ 6970.000133ps      -4.3754592
+ 6980.000133ps      -4.6081852
+ 6990.000134ps      -4.8290395
+ 7000.000135ps      -4.9207631
+ 7010.000136ps      -4.6972166
+ 7020.000137ps      -4.4586227
+ 7030.000138ps      -4.2674322
+ 7040.000138ps       -4.023277
+ 7050.000139ps      -3.8818573
+ 7060.000140ps      -3.8347136
+ 7070.000141ps      -3.8758149
+ 7080.000142ps        -3.98143
+ 7090.000143ps      -4.1008517
+ 7100.000143ps      -4.2090674
+ 7110.000144ps      -4.3140643
+ 7120.000145ps      -4.3528886
+ 7130.000146ps      -4.2959337
+ 7140.000147ps      -4.1263642
+ 7150.000148ps        -3.89647
+ 7160.000148ps      -3.5856481
+ 7170.000149ps      -3.2455754
+ 7180.000150ps      -2.9082985
+ 7190.000151ps      -2.6201988
+ 7200.000152ps      -2.4145554
+ 7210.000152ps      -2.2872272
+ 7220.000153ps      -2.2297802
+ 7230.000154ps      -2.2471271
+ 7240.000155ps      -2.3157523
+ 7250.000156ps      -2.3986116
+ 7260.000157ps       -2.496966
+ 7270.000157ps      -2.6560198
+ 7280.000158ps      -2.8269411
+ 7290.000159ps      -3.0243407
+ 7300.000160ps      -3.2508818
+ 7310.000161ps      -3.4081761
+ 7320.000162ps      -3.4674288
+ 7330.000162ps      -3.4859173
+ 7340.000163ps      -3.5168673
+ 7350.000164ps      -3.5753035
+ 7360.000165ps      -3.6335837
+ 7370.000166ps      -3.6609309
+ 7380.000167ps      -3.6840358
+ 7390.000167ps      -3.7128508
+ 7400.000168ps      -3.7506112
+ 7410.000169ps       -3.756925
+ 7420.000170ps       -3.738385
+ 7430.000171ps      -3.6902064
+ 7440.000171ps       -3.628533
+ 7450.000172ps      -3.6969577
+ 7459.999729ps      -3.9146675
+ 7469.999730ps      -4.1385777
+ 7479.999731ps      -4.3572309
+ 7489.999732ps       -4.573333
+ 7499.999732ps      -4.6707987
+ 7509.999733ps      -4.4624241
+ 7519.999734ps      -4.2458904
+ 7529.999735ps      -4.0722533
+ 7539.999736ps      -3.8704742
+ 7549.999737ps      -3.7784085
+ 7559.999737ps      -3.8073305
+ 7569.999738ps      -3.9126466
+ 7579.999739ps      -4.0440652
+ 7589.999740ps      -4.1529351
+ 7599.999741ps      -4.2415212
+ 7609.999741ps      -4.3366085
+ 7619.999742ps      -4.3711469
+ 7629.999743ps      -4.3100966
+ 7639.999744ps      -4.1377484
+ 7649.999745ps      -3.9057372
+ 7659.999746ps      -3.5891427
+ 7669.999746ps      -3.2466779
+ 7679.999747ps      -2.9148582
+ 7689.999748ps      -2.6256416
+ 7699.999749ps      -2.4185418
+ 7709.999750ps      -2.2855221
+ 7719.999751ps      -2.2281135
+ 7729.999751ps      -2.2534586
+ 7739.999752ps      -2.3258899
+ 7749.999753ps      -2.4071242
+ 7759.999754ps        -2.51093
+ 7769.999755ps      -2.6770347
+ 7779.999756ps      -2.8535982
+ 7789.999756ps       -3.053519
+ 7799.999757ps      -3.2838446
+ 7809.999758ps      -3.4542256
+ 7819.999759ps      -3.5318612
+ 7829.999760ps      -3.5513012
+ 7839.999761ps      -3.5807682
+ 7849.999761ps      -3.6475864
+ 7859.999762ps      -3.7213269
+ 7869.999763ps      -3.7652701
+ 7879.999764ps      -3.7738215
+ 7889.999765ps      -3.7689533
+ 7899.999765ps      -3.7566938
+ 7909.999766ps      -3.7240098
+ 7919.999767ps      -3.6846483
+ 7929.999768ps      -3.6551105
+ 7939.999769ps      -3.6291845
+ 7949.999770ps      -3.7395506
+ 7959.999770ps      -3.9706341
+ 7969.999771ps      -4.2119572
+ 7979.999772ps      -4.4318244
+ 7989.999773ps      -4.6635913
+ 7999.999774ps      -4.7346277
+ 8009.999775ps      -4.8052953
+ 8019.999775ps      -4.8664283
+ 8029.999776ps      -4.9044426
+ 8039.999777ps      -4.9311435
+ 8049.999778ps       -4.950407
+ 8059.999779ps      -4.9644808
+ 8069.999780ps      -4.9749071
+ 8079.999780ps      -4.9827354
+ 8089.999781ps      -4.9886895
+ 8099.999782ps       -4.993275
+ 8109.999783ps      -4.9968496
+ 8119.999784ps       -4.999669
+ 8129.999785ps      -5.0019183
+ 8139.999785ps      -5.0037325
+ 8149.999786ps      -5.0052114
+ 8159.999787ps      -5.0064292
+ 8169.999788ps      -5.0074419
+ 8179.999789ps      -5.0082919
+ 8189.999789ps      -5.0090115
+ 8199.999790ps       -5.009626
+ 8209.999791ps      -5.0101548
+ 8219.999792ps      -5.0106132
+ 8229.999793ps      -5.0110135
+ 8239.999794ps      -5.0113651
+ 8249.999794ps      -5.0116758
+ 8259.999795ps       -5.011952
+ 8269.999796ps      -5.0121988
+ 8279.999797ps      -5.0124203
+ 8289.999798ps      -5.0126199
+ 8299.999799ps      -5.0128007
+ 8309.999799ps      -5.0129649
+)

Icursig5 PAR_2_0_VDD075NNE 0 pwl(
+ 0.000000ps      0.60656049
+ 10.000000ps      0.69950882
+ 20.000000ps      0.90911353
+ 29.999999ps       1.1715149
+ 40.000000ps       1.5046092
+ 50.000001ps       1.8558984
+ 59.999998ps       2.1472778
+ 69.999999ps       2.3265932
+ 80.000000ps         2.41572
+ 90.000001ps        2.443323
+ 100.000001ps       2.4296657
+ 110.000002ps       2.3905668
+ 119.999996ps       2.3581951
+ 129.999997ps        2.350464
+ 139.999998ps       2.3570324
+ 149.999999ps       2.3791129
+ 159.999999ps       2.3976495
+ 170.000000ps       2.4103551
+ 180.000001ps       2.4100614
+ 190.000002ps       2.4494663
+ 200.000003ps       2.6571704
+ 210.000003ps       3.0023195
+ 220.000004ps       3.3271719
+ 230.000005ps       3.6555515
+ 239.999992ps        3.978066
+ 249.999993ps       4.2084227
+ 259.999994ps       4.0975348
+ 269.999995ps       4.0756993
+ 279.999995ps       4.1529296
+ 289.999996ps       4.2594196
+ 299.999997ps       4.5474491
+ 309.999998ps       4.9906719
+ 319.999999ps       5.4840842
+ 330.000000ps       5.9393432
+ 340.000000ps       6.3510117
+ 350.000001ps       6.7231337
+ 360.000002ps       6.9753781
+ 370.000003ps       7.0006973
+ 380.000004ps       6.8448015
+ 390.000005ps       6.5757138
+ 400.000005ps       6.2867539
+ 410.000006ps       5.9910562
+ 420.000007ps       5.7209117
+ 430.000008ps        5.465145
+ 440.000009ps       5.2398832
+ 450.000009ps       5.0129546
+ 460.000010ps       4.7704082
+ 469.999983ps       4.5004432
+ 479.999984ps       4.2069833
+ 489.999985ps       3.9361647
+ 499.999986ps        3.646176
+ 509.999987ps        3.385799
+ 519.999988ps       3.2447375
+ 529.999988ps        3.149449
+ 539.999989ps       3.1080396
+ 549.999990ps       3.0987479
+ 559.999991ps       3.0418037
+ 569.999992ps       2.9264014
+ 579.999992ps       2.7899078
+ 589.999993ps         2.67016
+ 599.999994ps       2.5620855
+ 609.999995ps       2.4587162
+ 619.999996ps       2.3858924
+ 629.999997ps       2.3490782
+ 639.999997ps       2.3355975
+ 649.999998ps       2.3449499
+ 659.999999ps       2.3551701
+ 670.000000ps       2.3581669
+ 680.000001ps       2.3516341
+ 690.000002ps       2.3846214
+ 700.000002ps       2.5842089
+ 710.000003ps       2.9218436
+ 720.000004ps       3.2318738
+ 730.000005ps       3.5625177
+ 740.000006ps       3.8842254
+ 750.000007ps       4.1126887
+ 760.000007ps       4.0079715
+ 770.000008ps       4.0017355
+ 780.000009ps       4.0827555
+ 790.000010ps       4.1924455
+ 800.000011ps       4.4865816
+ 810.000012ps       4.9370906
+ 820.000012ps       5.4213344
+ 830.000013ps       5.8774375
+ 840.000014ps       6.2830565
+ 850.000015ps       6.6278135
+ 860.000016ps       6.8581166
+ 870.000016ps       6.8650792
+ 880.000017ps       6.6911918
+ 890.000018ps       6.4368533
+ 900.000019ps        6.180653
+ 910.000020ps       5.9105735
+ 920.000021ps       5.6598715
+ 930.000021ps       5.4132247
+ 939.999967ps       5.1812154
+ 949.999968ps       4.9392258
+ 959.999968ps       4.6910329
+ 969.999969ps       4.4131319
+ 979.999970ps       4.1260251
+ 989.999971ps       3.8588601
+ 999.999972ps        3.578156
+ 1009.999973ps       3.3187604
+ 1019.999973ps       3.1603734
+ 1029.999974ps       3.0539419
+ 1039.999975ps       3.0017196
+ 1049.999976ps       3.0017854
+ 1059.999977ps        2.967522
+ 1069.999978ps        2.892794
+ 1079.999978ps       2.7799439
+ 1089.999979ps       2.6650085
+ 1099.999980ps       2.5508743
+ 1109.999981ps       2.4457764
+ 1119.999982ps        2.374434
+ 1129.999982ps       2.3390526
+ 1139.999983ps       2.3268333
+ 1149.999984ps       2.3377769
+ 1159.999985ps       2.3420345
+ 1169.999986ps       2.3448237
+ 1179.999987ps       2.3413244
+ 1189.999987ps       2.3645973
+ 1199.999988ps       2.5708009
+ 1209.999989ps        2.900325
+ 1219.999990ps        3.228015
+ 1229.999991ps       3.5593925
+ 1239.999992ps       3.8875628
+ 1249.999992ps       4.1174815
+ 1259.999993ps       4.0106875
+ 1269.999994ps       4.0011844
+ 1279.999995ps       4.1036281
+ 1289.999996ps       4.2647815
+ 1299.999997ps       4.6201782
+ 1309.999997ps       5.1283784
+ 1319.999998ps       5.6787412
+ 1329.999999ps       6.1877492
+ 1340.000000ps       6.6556212
+ 1350.000001ps       7.0258675
+ 1360.000002ps       7.2313376
+ 1370.000002ps       7.1988633
+ 1380.000003ps       6.9755567
+ 1390.000004ps       6.6247075
+ 1400.000005ps       6.2945228
+ 1410.000006ps       6.0115134
+ 1420.000006ps       5.7620116
+ 1430.000007ps        5.549705
+ 1440.000008ps       5.3712703
+ 1450.000009ps        5.198377
+ 1460.000010ps       5.0075613
+ 1470.000011ps       4.7840774
+ 1480.000011ps       4.5262011
+ 1490.000012ps       4.2871737
+ 1500.000013ps       4.0274512
+ 1510.000014ps       3.8122591
+ 1520.000015ps       3.6520579
+ 1530.000016ps        3.461741
+ 1540.000016ps       3.2977732
+ 1550.000017ps       3.1918822
+ 1560.000018ps       3.0938828
+ 1570.000019ps       2.9501975
+ 1580.000020ps       2.8023914
+ 1590.000021ps       2.6794888
+ 1600.000021ps       2.5699788
+ 1610.000022ps       2.4660455
+ 1620.000023ps       2.3920759
+ 1630.000024ps       2.3531361
+ 1640.000025ps       2.3398752
+ 1650.000025ps       2.3473865
+ 1660.000026ps       2.3495053
+ 1670.000027ps       2.3541158
+ 1680.000028ps       2.3511722
+ 1690.000029ps         2.37429
+ 1700.000030ps       2.5784643
+ 1710.000030ps       2.9107737
+ 1720.000031ps        3.235411
+ 1730.000032ps       3.5750014
+ 1740.000033ps       3.9204825
+ 1750.000034ps       4.1588574
+ 1760.000035ps       4.0583742
+ 1770.000035ps       4.0577478
+ 1780.000036ps       4.1649954
+ 1790.000037ps       4.3003025
+ 1800.000038ps       4.6218609
+ 1810.000039ps       5.0958817
+ 1820.000040ps       5.5872474
+ 1830.000040ps       6.0322778
+ 1840.000041ps       6.4280863
+ 1850.000042ps        6.763182
+ 1860.000043ps       7.0042189
+ 1869.999933ps       7.0279781
+ 1879.999934ps       6.8802973
+ 1889.999934ps       6.6608458
+ 1899.999935ps        6.404265
+ 1909.999936ps       6.1139153
+ 1919.999937ps       5.8540447
+ 1929.999938ps       5.5957087
+ 1939.999938ps       5.3493007
+ 1949.999939ps       5.1277512
+ 1959.999940ps        4.908045
+ 1969.999941ps       4.6640554
+ 1979.999942ps        4.389684
+ 1989.999943ps       4.1293742
+ 1999.999943ps       3.8217445
+ 2009.999944ps       3.5375078
+ 2019.999945ps       3.3573017
+ 2029.999946ps       3.2519731
+ 2039.999947ps       3.2094502
+ 2049.999948ps        3.215163
+ 2059.999948ps       3.1888467
+ 2069.999949ps       3.0842854
+ 2079.999950ps       2.9307441
+ 2089.999951ps       2.7599525
+ 2099.999952ps       2.6125773
+ 2109.999953ps        2.488647
+ 2119.999953ps       2.4057945
+ 2129.999954ps         2.36383
+ 2139.999955ps       2.3493184
+ 2149.999956ps       2.3595728
+ 2159.999957ps       2.3639988
+ 2169.999958ps       2.3700653
+ 2179.999958ps       2.3689509
+ 2189.999959ps       2.3970741
+ 2199.999960ps       2.6070171
+ 2209.999961ps       2.9427159
+ 2219.999962ps       3.2549412
+ 2229.999962ps       3.5865374
+ 2239.999963ps       3.9069182
+ 2249.999964ps       4.1438232
+ 2259.999965ps       4.0420113
+ 2269.999966ps       4.0276995
+ 2279.999967ps       4.1097984
+ 2289.999967ps        4.217591
+ 2299.999968ps       4.5168087
+ 2309.999969ps       4.9567673
+ 2319.999970ps       5.4258609
+ 2329.999971ps       5.8663579
+ 2339.999972ps       6.2574359
+ 2349.999972ps       6.6079928
+ 2359.999973ps       6.8477936
+ 2369.999974ps       6.8818017
+ 2379.999975ps       6.7462047
+ 2389.999976ps       6.5099339
+ 2399.999977ps       6.2534628
+ 2409.999977ps       5.9900661
+ 2419.999978ps       5.7323014
+ 2429.999979ps        5.465624
+ 2439.999980ps       5.2237698
+ 2449.999981ps       4.9840653
+ 2459.999981ps       4.7315178
+ 2469.999982ps       4.4604224
+ 2479.999983ps       4.1665542
+ 2489.999984ps       3.8852966
+ 2499.999985ps        3.599722
+ 2509.999986ps       3.3409162
+ 2519.999986ps        3.201567
+ 2529.999987ps       3.1040593
+ 2539.999988ps       3.0776354
+ 2549.999989ps       3.1028704
+ 2559.999990ps        3.089084
+ 2569.999991ps       3.0111198
+ 2579.999991ps       2.8757723
+ 2589.999992ps       2.7409867
+ 2599.999993ps       2.6088763
+ 2609.999994ps       2.4892986
+ 2619.999995ps       2.4062254
+ 2629.999996ps       2.3638446
+ 2639.999996ps       2.3483911
+ 2649.999997ps       2.3579018
+ 2659.999998ps       2.3672509
+ 2669.999999ps       2.3695334
+ 2680.000000ps       2.3646561
+ 2690.000001ps       2.3939839
+ 2700.000001ps       2.6014302
+ 2710.000002ps       2.9279744
+ 2720.000003ps       3.2416671
+ 2730.000004ps       3.5746775
+ 2740.000005ps       3.9064105
+ 2750.000005ps       4.1696883
+ 2760.000006ps        4.087888
+ 2770.000007ps       4.1152564
+ 2780.000008ps       4.2366608
+ 2790.000009ps       4.3922678
+ 2800.000010ps       4.7403033
+ 2810.000010ps         5.25114
+ 2820.000011ps       5.8044586
+ 2830.000012ps       6.2801555
+ 2840.000013ps        6.668772
+ 2850.000014ps       6.9865868
+ 2860.000015ps       7.1910704
+ 2870.000015ps       7.1533783
+ 2880.000016ps       6.9454683
+ 2890.000017ps       6.6670917
+ 2900.000018ps       6.3781406
+ 2910.000019ps       6.0872957
+ 2920.000020ps       5.8434252
+ 2930.000020ps       5.6332479
+ 2940.000021ps       5.4487234
+ 2950.000022ps       5.2705038
+ 2960.000023ps       5.0793417
+ 2970.000024ps       4.8616102
+ 2980.000025ps       4.6209229
+ 2990.000025ps       4.4050258
+ 3000.000026ps       4.1102299
+ 3010.000027ps       3.7930929
+ 3020.000028ps       3.5437526
+ 3030.000029ps       3.3859552
+ 3040.000029ps        3.303136
+ 3050.000030ps       3.2510969
+ 3060.000031ps       3.1542474
+ 3070.000032ps        3.005072
+ 3080.000033ps       2.8500777
+ 3090.000034ps       2.7111773
+ 3100.000034ps       2.5933088
+ 3110.000035ps       2.4842972
+ 3120.000036ps        2.408795
+ 3130.000037ps       2.3717035
+ 3140.000038ps       2.3609296
+ 3150.000039ps       2.3723726
+ 3160.000039ps        2.377879
+ 3170.000040ps       2.3835499
+ 3180.000041ps       2.3799441
+ 3190.000042ps       2.4073945
+ 3200.000043ps       2.6072691
+ 3210.000044ps       2.9341434
+ 3220.000044ps       3.2459757
+ 3230.000045ps       3.5755029
+ 3240.000046ps       3.8971741
+ 3250.000047ps       4.1344406
+ 3260.000048ps       4.0339223
+ 3270.000049ps       4.0240557
+ 3280.000049ps       4.1126113
+ 3290.000050ps       4.2312577
+ 3300.000051ps       4.5372372
+ 3310.000052ps       4.9944319
+ 3320.000053ps       5.4776167
+ 3330.000053ps       5.9237508
+ 3340.000054ps       6.3303953
+ 3350.000055ps       6.6869433
+ 3360.000056ps       6.9370735
+ 3370.000057ps       6.9662324
+ 3380.000058ps       6.7949822
+ 3390.000058ps       6.5161169
+ 3400.000059ps       6.2313035
+ 3410.000060ps       5.9407163
+ 3420.000061ps       5.6878802
+ 3430.000062ps       5.4700248
+ 3440.000063ps       5.2510002
+ 3450.000063ps       5.0335031
+ 3460.000064ps       4.7982931
+ 3470.000065ps        4.524674
+ 3480.000066ps       4.2308394
+ 3490.000067ps       3.9495988
+ 3500.000068ps       3.6522647
+ 3510.000068ps       3.3979108
+ 3520.000069ps       3.2565581
+ 3530.000070ps       3.1574518
+ 3540.000071ps       3.0955604
+ 3550.000072ps       3.0641892
+ 3560.000073ps       3.0186769
+ 3570.000073ps       2.9261727
+ 3580.000074ps       2.8178188
+ 3590.000075ps       2.7016644
+ 3600.000076ps        2.594262
+ 3610.000077ps       2.4887761
+ 3620.000077ps       2.4128833
+ 3630.000078ps        2.372571
+ 3640.000079ps       2.3563907
+ 3650.000080ps       2.3626479
+ 3660.000081ps       2.3654154
+ 3670.000082ps       2.3720576
+ 3680.000082ps       2.3758586
+ 3690.000083ps       2.4029297
+ 3700.000084ps       2.6069582
+ 3710.000085ps        2.945715
+ 3720.000086ps       3.2721693
+ 3729.999865ps       3.6049831
+ 3739.999865ps       3.9263301
+ 3749.999866ps       4.1604511
+ 3759.999867ps       4.0634611
+ 3769.999868ps        4.039651
+ 3779.999869ps       4.1338631
+ 3789.999869ps       4.2552994
+ 3799.999870ps       4.5692993
+ 3809.999871ps       5.0465686
+ 3819.999872ps       5.5509927
+ 3829.999873ps       6.0270581
+ 3839.999874ps       6.4662081
+ 3849.999874ps       6.8327912
+ 3859.999875ps       7.0657453
+ 3869.999876ps       7.0812926
+ 3879.999877ps       6.8974317
+ 3889.999878ps       6.6150159
+ 3899.999879ps       6.3183388
+ 3909.999879ps       6.0136662
+ 3919.999880ps       5.7468089
+ 3929.999881ps        5.487841
+ 3939.999882ps       5.2732582
+ 3949.999883ps         5.06624
+ 3959.999884ps       4.8482185
+ 3969.999884ps       4.6056003
+ 3979.999885ps       4.3439363
+ 3989.999886ps       4.1149831
+ 3999.999887ps       3.8693745
+ 4009.999888ps       3.6568337
+ 4019.999889ps       3.5242326
+ 4029.999889ps       3.4055647
+ 4039.999890ps        3.311466
+ 4049.999891ps       3.2620067
+ 4059.999892ps       3.1851069
+ 4069.999893ps       3.0532062
+ 4079.999893ps       2.9006221
+ 4089.999894ps       2.7551365
+ 4099.999895ps       2.6310878
+ 4109.999896ps       2.5186917
+ 4119.999897ps       2.4433599
+ 4129.999898ps       2.4082636
+ 4139.999898ps       2.4000149
+ 4149.999899ps       2.4104505
+ 4159.999900ps        2.411281
+ 4169.999901ps       2.4121227
+ 4179.999902ps       2.4026781
+ 4189.999903ps       2.4318971
+ 4199.999903ps       2.6529306
+ 4209.999904ps       2.9776926
+ 4219.999905ps       3.2925141
+ 4229.999906ps       3.6207014
+ 4239.999907ps       3.9427217
+ 4249.999908ps       4.1763112
+ 4259.999908ps       4.0823856
+ 4269.999909ps       4.0904316
+ 4279.999910ps       4.2080742
+ 4289.999911ps       4.3598514
+ 4299.999912ps       4.6908797
+ 4309.999913ps       5.1905276
+ 4319.999913ps       5.7351113
+ 4329.999914ps         6.22436
+ 4339.999915ps        6.640303
+ 4349.999916ps       6.9852715
+ 4359.999917ps       7.2232007
+ 4369.999917ps       7.2568531
+ 4379.999918ps       7.0634842
+ 4389.999919ps       6.7528116
+ 4399.999920ps       6.4434376
+ 4409.999921ps       6.1443004
+ 4419.999922ps       5.8504359
+ 4429.999922ps       5.6204011
+ 4439.999923ps       5.4283661
+ 4449.999924ps       5.2363224
+ 4459.999925ps       5.0395019
+ 4469.999926ps        4.814405
+ 4479.999927ps       4.5580011
+ 4489.999927ps       4.3104392
+ 4499.999928ps       4.0232202
+ 4509.999929ps        3.740602
+ 4519.999930ps       3.5482932
+ 4529.999931ps       3.4252826
+ 4539.999932ps       3.3939189
+ 4549.999932ps       3.3499542
+ 4559.999933ps       3.2314312
+ 4569.999934ps       3.0314291
+ 4579.999935ps       2.8590947
+ 4589.999936ps       2.7197994
+ 4599.999937ps       2.5994265
+ 4609.999937ps       2.4898315
+ 4619.999938ps       2.4103475
+ 4629.999939ps       2.3683019
+ 4639.999940ps       2.3501299
+ 4649.999941ps       2.3564421
+ 4659.999941ps       2.3590425
+ 4669.999942ps       2.3682755
+ 4679.999943ps       2.3633686
+ 4689.999944ps       2.3919324
+ 4699.999945ps       2.6089837
+ 4709.999946ps       2.9359358
+ 4719.999946ps       3.2459524
+ 4729.999947ps       3.5849089
+ 4739.999948ps       3.9221657
+ 4749.999949ps       4.1614731
+ 4759.999950ps       4.0674325
+ 4769.999951ps       4.0749012
+ 4779.999951ps       4.1995082
+ 4789.999952ps       4.3832263
+ 4799.999953ps       4.7687882
+ 4809.999954ps       5.3174918
+ 4819.999955ps       5.8921459
+ 4829.999956ps       6.4097526
+ 4839.999956ps       6.8543613
+ 4849.999957ps       7.1940114
+ 4859.999958ps       7.3673826
+ 4869.999959ps       7.2868657
+ 4879.999960ps        7.024561
+ 4889.999961ps       6.7007227
+ 4899.999961ps       6.3831889
+ 4909.999962ps       6.0929376
+ 4919.999963ps       5.8734255
+ 4929.999964ps       5.6784301
+ 4939.999965ps       5.5002991
+ 4949.999965ps       5.3348491
+ 4959.999966ps       5.1483625
+ 4969.999967ps       4.9408184
+ 4979.999968ps       4.7144306
+ 4989.999969ps       4.5079118
+ 4999.999970ps       4.2568072
+ 5009.999970ps       3.9791687
+ 5019.999971ps       3.7448118
+ 5029.999972ps       3.5160892
+ 5039.999973ps       3.3294194
+ 5049.999974ps       3.2061035
+ 5059.999975ps       3.1162362
+ 5069.999975ps       2.9849754
+ 5079.999976ps       2.8415676
+ 5089.999977ps       2.6947833
+ 5099.999978ps       2.5735806
+ 5109.999979ps        2.464601
+ 5119.999980ps       2.3880639
+ 5129.999980ps       2.3475416
+ 5139.999981ps       2.3341641
+ 5149.999982ps       2.3432016
+ 5159.999983ps       2.3503386
+ 5169.999984ps       2.3543602
+ 5179.999985ps       2.3465436
+ 5189.999985ps        2.374481
+ 5199.999986ps       2.5834193
+ 5209.999987ps       2.9110725
+ 5219.999988ps       3.2200334
+ 5229.999989ps       3.5480031
+ 5239.999989ps       3.8822637
+ 5249.999990ps       4.1195836
+ 5259.999991ps       4.0268164
+ 5269.999992ps       4.0460603
+ 5279.999993ps       4.1733889
+ 5289.999994ps       4.3255112
+ 5299.999994ps       4.6656867
+ 5309.999995ps       5.1585808
+ 5319.999996ps       5.6812121
+ 5329.999997ps       6.1430799
+ 5339.999998ps       6.5272495
+ 5349.999999ps       6.8416222
+ 5359.999999ps       7.0424179
+ 5370.000000ps       7.0530181
+ 5380.000001ps       6.8890447
+ 5390.000002ps       6.6300611
+ 5400.000003ps       6.3577035
+ 5410.000004ps       6.0803222
+ 5420.000004ps        5.813638
+ 5430.000005ps       5.5815668
+ 5440.000006ps        5.388808
+ 5450.000007ps       5.1970898
+ 5460.000008ps       4.9901026
+ 5470.000009ps       4.7580077
+ 5480.000009ps       4.4955482
+ 5490.000010ps       4.2381299
+ 5500.000011ps       3.9250638
+ 5510.000012ps       3.6111536
+ 5520.000013ps       3.3861136
+ 5530.000013ps       3.2287104
+ 5540.000014ps       3.1791743
+ 5550.000015ps       3.1759832
+ 5560.000016ps       3.1247155
+ 5570.000017ps       2.9816683
+ 5580.000018ps       2.8223355
+ 5590.000018ps       2.6795293
+ 5600.000019ps       2.5597044
+ 5610.000020ps        2.448928
+ 5620.000021ps       2.3722776
+ 5630.000022ps       2.3332558
+ 5640.000023ps       2.3197908
+ 5650.000023ps       2.3283513
+ 5660.000024ps       2.3323087
+ 5670.000025ps        2.334885
+ 5680.000026ps       2.3296114
+ 5690.000027ps       2.3580249
+ 5700.000028ps       2.5699418
+ 5710.000028ps       2.8972529
+ 5720.000029ps        3.207942
+ 5730.000030ps       3.5472246
+ 5740.000031ps       3.8810537
+ 5750.000032ps       4.1412472
+ 5760.000032ps       4.0365369
+ 5770.000033ps       4.0389909
+ 5780.000034ps       4.1317368
+ 5790.000035ps       4.2561259
+ 5800.000036ps       4.5567854
+ 5810.000037ps       4.9814693
+ 5820.000037ps        5.421086
+ 5830.000038ps       5.8127959
+ 5840.000039ps       6.1521058
+ 5850.000040ps       6.4398638
+ 5860.000041ps       6.6400264
+ 5870.000042ps       6.6518486
+ 5880.000042ps       6.5139192
+ 5890.000043ps       6.3231517
+ 5900.000044ps       6.1271559
+ 5910.000045ps       5.9146057
+ 5920.000046ps       5.7004411
+ 5930.000047ps       5.4516907
+ 5940.000047ps       5.2089805
+ 5950.000048ps        4.954375
+ 5960.000049ps       4.6890129
+ 5970.000050ps       4.4060462
+ 5980.000051ps       4.0806071
+ 5990.000052ps       3.7711205
+ 6000.000052ps       3.4328656
+ 6010.000053ps        3.129787
+ 6020.000054ps       2.9442646
+ 6030.000055ps       2.8233083
+ 6040.000056ps       2.8051368
+ 6050.000056ps       2.8584784
+ 6060.000057ps       2.9055532
+ 6070.000058ps       2.8857656
+ 6080.000059ps       2.7990397
+ 6090.000060ps       2.6840263
+ 6100.000061ps       2.5562295
+ 6110.000061ps       2.4444595
+ 6120.000062ps       2.3684335
+ 6130.000063ps       2.3305419
+ 6140.000064ps       2.3154479
+ 6150.000065ps       2.3227971
+ 6160.000066ps       2.3279183
+ 6170.000066ps       2.3351324
+ 6180.000067ps       2.3326896
+ 6190.000068ps       2.3611598
+ 6200.000069ps        2.564261
+ 6210.000070ps       2.8931965
+ 6220.000071ps        3.219301
+ 6230.000071ps       3.5484769
+ 6240.000072ps       3.8773843
+ 6250.000073ps       4.1082895
+ 6260.000074ps       4.0033506
+ 6270.000075ps       4.0045809
+ 6280.000076ps       4.1173626
+ 6290.000076ps       4.2660245
+ 6300.000077ps        4.594878
+ 6310.000078ps       5.0729974
+ 6320.000079ps       5.5889348
+ 6330.000080ps       6.0595733
+ 6340.000080ps       6.4687864
+ 6350.000081ps       6.8038668
+ 6360.000082ps       7.0190995
+ 6370.000083ps       7.0075533
+ 6380.000084ps       6.8187265
+ 6390.000085ps       6.5506035
+ 6400.000085ps        6.287516
+ 6410.000086ps       6.0171382
+ 6420.000087ps        5.762841
+ 6430.000088ps       5.5338443
+ 6440.000089ps       5.3132988
+ 6450.000090ps       5.1040706
+ 6460.000090ps       4.8848803
+ 6470.000091ps       4.6510215
+ 6480.000092ps       4.3799084
+ 6490.000093ps       4.1265921
+ 6500.000094ps       3.8469693
+ 6510.000095ps       3.5749391
+ 6520.000095ps       3.3780846
+ 6530.000096ps       3.2178672
+ 6540.000097ps       3.1335793
+ 6550.000098ps       3.1120699
+ 6560.000099ps       3.0751859
+ 6570.000100ps        2.976445
+ 6580.000100ps       2.8435644
+ 6590.000101ps       2.7030705
+ 6600.000102ps        2.573686
+ 6610.000103ps       2.4593587
+ 6620.000104ps       2.3808592
+ 6630.000104ps       2.3388759
+ 6640.000105ps       2.3232951
+ 6650.000106ps       2.3306069
+ 6660.000107ps       2.3331872
+ 6670.000108ps       2.3369254
+ 6680.000109ps       2.3375291
+ 6690.000109ps        2.360644
+ 6700.000110ps        2.566964
+ 6710.000111ps       2.8940234
+ 6720.000112ps       3.2228601
+ 6730.000113ps       3.5531138
+ 6740.000114ps       3.8920559
+ 6750.000114ps        4.120636
+ 6760.000115ps       4.0112021
+ 6770.000116ps       4.0010087
+ 6780.000117ps       4.0994637
+ 6790.000118ps       4.2342027
+ 6800.000119ps       4.5597861
+ 6810.000119ps       5.0379034
+ 6820.000120ps       5.5556253
+ 6830.000121ps       6.0441913
+ 6840.000122ps       6.4785499
+ 6850.000123ps       6.8444148
+ 6860.000124ps       7.0766245
+ 6870.000124ps       7.0650866
+ 6880.000125ps       6.8630548
+ 6890.000126ps       6.5682676
+ 6900.000127ps       6.2717007
+ 6910.000128ps       5.9790719
+ 6920.000128ps       5.7277567
+ 6930.000129ps        5.491201
+ 6940.000130ps        5.284932
+ 6950.000131ps       5.0742976
+ 6960.000132ps       4.8588729
+ 6970.000133ps       4.6190176
+ 6980.000133ps       4.3581475
+ 6990.000134ps       4.1173451
+ 7000.000135ps       3.8536527
+ 7010.000136ps       3.6157497
+ 7020.000137ps       3.4552747
+ 7030.000138ps       3.3111366
+ 7040.000138ps       3.2098686
+ 7050.000139ps       3.1463843
+ 7060.000140ps       3.0686593
+ 7070.000141ps       2.9570923
+ 7080.000142ps        2.823179
+ 7090.000143ps       2.6967103
+ 7100.000143ps       2.5746676
+ 7110.000144ps       2.4623532
+ 7120.000145ps       2.3851238
+ 7130.000146ps       2.3441465
+ 7140.000147ps       2.3305004
+ 7150.000148ps       2.3400455
+ 7160.000148ps       2.3428248
+ 7170.000149ps       2.3463866
+ 7180.000150ps        2.346881
+ 7190.000151ps       2.3719074
+ 7200.000152ps       2.5763286
+ 7210.000152ps       2.9049475
+ 7220.000153ps       3.2211128
+ 7230.000154ps       3.5555291
+ 7240.000155ps       3.8783978
+ 7250.000156ps        4.105517
+ 7260.000157ps       3.9880162
+ 7270.000157ps       3.9683555
+ 7280.000158ps       4.0466686
+ 7290.000159ps       4.1559167
+ 7300.000160ps       4.4448693
+ 7310.000161ps        4.891087
+ 7320.000162ps          5.3763
+ 7330.000162ps       5.8337058
+ 7340.000163ps         6.25185
+ 7350.000164ps       6.6216097
+ 7360.000165ps       6.8576474
+ 7370.000166ps       6.8718837
+ 7380.000167ps       6.7155407
+ 7390.000167ps       6.4733271
+ 7400.000168ps       6.2244176
+ 7410.000169ps       5.9624562
+ 7420.000170ps       5.7105563
+ 7430.000171ps       5.4517129
+ 7440.000171ps       5.1876888
+ 7450.000172ps       4.9253195
+ 7459.999729ps       4.6629097
+ 7469.999730ps       4.3912039
+ 7479.999731ps       4.1127897
+ 7489.999732ps       3.8572194
+ 7499.999732ps       3.6015478
+ 7509.999733ps       3.3736668
+ 7519.999734ps       3.2397946
+ 7529.999735ps         3.11344
+ 7539.999736ps       3.0466707
+ 7549.999737ps       3.0456169
+ 7559.999737ps       3.0542546
+ 7569.999738ps       3.0034893
+ 7579.999739ps       2.8887508
+ 7589.999740ps        2.741677
+ 7599.999741ps       2.5948501
+ 7609.999741ps       2.4716976
+ 7619.999742ps       2.3892028
+ 7629.999743ps       2.3503975
+ 7639.999744ps       2.3373561
+ 7649.999745ps       2.3455414
+ 7659.999746ps       2.3523937
+ 7669.999746ps       2.3547363
+ 7679.999747ps       2.3452492
+ 7689.999748ps       2.3685103
+ 7699.999749ps       2.5749252
+ 7709.999750ps        2.909684
+ 7719.999751ps       3.2270926
+ 7729.999751ps       3.5494017
+ 7739.999752ps       3.8763246
+ 7749.999753ps       4.1214581
+ 7759.999754ps       4.0235334
+ 7769.999755ps       4.0207663
+ 7779.999756ps        4.102318
+ 7789.999756ps        4.208664
+ 7799.999757ps       4.5024647
+ 7809.999758ps       4.9599799
+ 7819.999759ps       5.4577821
+ 7829.999760ps       5.9120834
+ 7839.999761ps       6.3143066
+ 7849.999761ps       6.6714108
+ 7859.999762ps       6.9141078
+ 7869.999763ps        6.933375
+ 7879.999764ps       6.7485011
+ 7889.999765ps       6.4708059
+ 7899.999765ps       6.1734778
+ 7909.999766ps        5.882991
+ 7919.999767ps       5.6260372
+ 7929.999768ps       5.3916851
+ 7939.999769ps       5.1731928
+ 7949.999770ps       4.9553372
+ 7959.999770ps       4.7212038
+ 7969.999771ps       4.4650417
+ 7979.999772ps       4.1727508
+ 7989.999773ps        3.913585
+ 7999.999774ps       3.6371236
+ 8009.999775ps       3.4389224
+ 8019.999775ps       3.3126573
+ 8029.999776ps       3.2308046
+ 8039.999777ps       3.1797577
+ 8049.999778ps       3.1474186
+ 8059.999779ps       3.1264724
+ 8069.999780ps       3.1126149
+ 8079.999780ps       3.1032286
+ 8089.999781ps       3.0967065
+ 8099.999782ps       3.0920522
+ 8109.999783ps       3.0886405
+ 8119.999784ps       3.0860738
+ 8129.999785ps       3.0840952
+ 8139.999785ps       3.0825358
+ 8149.999786ps       3.0812826
+ 8159.999787ps       3.0802582
+ 8169.999788ps       3.0794089
+ 8179.999789ps        3.078696
+ 8189.999789ps       3.0780915
+ 8199.999790ps       3.0775746
+ 8209.999791ps       3.0771295
+ 8219.999792ps       3.0767438
+ 8229.999793ps        3.076408
+ 8239.999794ps       3.0761143
+ 8249.999794ps       3.0758565
+ 8259.999795ps       3.0756295
+ 8269.999796ps        3.075429
+ 8279.999797ps       3.0752515
+ 8289.999798ps        3.075094
+ 8299.999799ps        3.074954
+ 8309.999799ps       3.0748294
+)

Icursig6 PAR_3_0_VSS 0 pwl(
+ 0.000000ps     -0.91155469
+ 10.000000ps       -1.030313
+ 20.000000ps      -1.5051738
+ 29.999999ps      -2.1107996
+ 40.000000ps      -2.7271792
+ 50.000001ps       -3.252844
+ 59.999998ps      -3.7159892
+ 69.999999ps       -4.049297
+ 80.000000ps      -4.2649745
+ 90.000001ps      -4.3016324
+ 100.000001ps      -4.2341953
+ 110.000002ps      -4.0382799
+ 119.999996ps      -3.7755022
+ 129.999997ps      -3.4849485
+ 139.999998ps      -3.2098533
+ 149.999999ps      -3.0082887
+ 159.999999ps       -2.868238
+ 170.000000ps      -2.8310542
+ 180.000001ps      -2.8931255
+ 190.000002ps      -3.0270498
+ 200.000003ps      -3.2403177
+ 210.000003ps      -3.5094808
+ 220.000004ps      -3.7768202
+ 230.000005ps      -3.9848164
+ 239.999992ps      -4.1576923
+ 249.999993ps      -4.2710076
+ 259.999994ps      -4.3844171
+ 269.999995ps      -4.6498385
+ 279.999995ps      -5.0584608
+ 289.999996ps      -5.6303888
+ 299.999997ps      -6.3016534
+ 309.999998ps      -7.0113386
+ 319.999999ps      -7.5769565
+ 330.000000ps      -7.8816827
+ 340.000000ps      -7.9248329
+ 350.000001ps      -7.7692792
+ 360.000002ps      -7.4848881
+ 370.000003ps      -7.1940732
+ 380.000004ps      -6.9324208
+ 390.000005ps      -6.6605552
+ 400.000005ps      -6.4038424
+ 410.000006ps      -6.2601219
+ 420.000007ps      -6.2957679
+ 430.000008ps      -6.3761812
+ 440.000009ps      -6.3567271
+ 450.000009ps       -6.199772
+ 460.000010ps      -5.9825831
+ 469.999983ps      -5.7440195
+ 479.999984ps      -5.5066776
+ 489.999985ps      -5.3166192
+ 499.999986ps       -5.092848
+ 509.999987ps      -4.7232317
+ 519.999988ps       -4.545016
+ 529.999988ps      -4.4932935
+ 539.999989ps      -4.5260498
+ 549.999990ps      -4.5613188
+ 559.999991ps      -4.6571639
+ 569.999992ps      -4.7303905
+ 579.999992ps      -4.7597845
+ 589.999993ps      -4.6625843
+ 599.999994ps      -4.4863187
+ 609.999995ps      -4.2253244
+ 619.999996ps      -3.9076633
+ 629.999997ps      -3.5708733
+ 639.999997ps      -3.2666164
+ 649.999998ps      -3.0372163
+ 659.999999ps      -2.8825843
+ 670.000000ps      -2.8340881
+ 680.000001ps      -2.8787558
+ 690.000002ps      -3.0016349
+ 700.000002ps      -3.2006124
+ 710.000003ps       -3.450035
+ 720.000004ps      -3.7058938
+ 730.000005ps      -3.8869765
+ 740.000006ps      -4.0241757
+ 750.000007ps      -4.0726196
+ 760.000007ps      -4.0950416
+ 770.000008ps      -4.2506324
+ 780.000009ps      -4.4928236
+ 790.000010ps      -4.8353283
+ 800.000011ps      -5.3224742
+ 810.000012ps      -5.8737287
+ 820.000012ps      -6.3819368
+ 830.000013ps      -6.8691707
+ 840.000014ps      -7.1987743
+ 850.000015ps      -7.3759965
+ 860.000016ps      -7.4310955
+ 870.000016ps       -7.420755
+ 880.000017ps      -7.3368071
+ 890.000018ps      -7.1445312
+ 900.000019ps       -6.904955
+ 910.000020ps      -6.7374154
+ 920.000021ps      -6.7155384
+ 930.000021ps      -6.7492367
+ 939.999967ps      -6.7019418
+ 949.999968ps       -6.499556
+ 959.999968ps      -6.2364701
+ 969.999969ps      -5.9414966
+ 979.999970ps      -5.6674498
+ 989.999971ps      -5.4482074
+ 999.999972ps      -5.2166399
+ 1009.999973ps      -4.8425652
+ 1019.999973ps       -4.648837
+ 1029.999974ps      -4.5750073
+ 1039.999975ps      -4.5911525
+ 1049.999976ps      -4.6281405
+ 1059.999977ps      -4.7223303
+ 1069.999978ps      -4.7917365
+ 1079.999978ps      -4.8253661
+ 1089.999979ps      -4.7438962
+ 1099.999980ps      -4.5800408
+ 1109.999981ps      -4.3246629
+ 1119.999982ps      -4.0192211
+ 1129.999982ps      -3.6888438
+ 1139.999983ps      -3.3717445
+ 1149.999984ps      -3.1334584
+ 1159.999985ps      -2.9896212
+ 1169.999986ps      -2.9620349
+ 1179.999987ps      -3.0252738
+ 1189.999987ps       -3.144466
+ 1199.999988ps      -3.3377875
+ 1209.999989ps      -3.5988613
+ 1219.999990ps      -3.8500515
+ 1229.999991ps      -4.0386743
+ 1239.999992ps      -4.1854374
+ 1249.999992ps      -4.2724472
+ 1259.999993ps      -4.3508801
+ 1269.999994ps       -4.579407
+ 1279.999995ps      -4.9656613
+ 1289.999996ps      -5.5174063
+ 1299.999997ps      -6.1788083
+ 1309.999997ps      -6.8956155
+ 1319.999998ps      -7.4700891
+ 1329.999999ps      -7.8099006
+ 1340.000000ps      -7.8878049
+ 1350.000001ps      -7.7312391
+ 1360.000002ps      -7.4359035
+ 1370.000002ps      -7.1230924
+ 1380.000003ps      -6.8295933
+ 1390.000004ps      -6.5259462
+ 1400.000005ps      -6.2574202
+ 1410.000006ps      -6.0858169
+ 1420.000006ps      -6.0790256
+ 1430.000007ps       -6.124763
+ 1440.000008ps      -6.0833005
+ 1450.000009ps      -5.9099159
+ 1460.000010ps      -5.6974915
+ 1470.000011ps      -5.4937985
+ 1480.000011ps      -5.2966297
+ 1490.000012ps      -5.1453112
+ 1500.000013ps      -4.9843968
+ 1510.000014ps      -4.6656367
+ 1520.000015ps      -4.5076679
+ 1530.000016ps       -4.457255
+ 1540.000016ps      -4.4984526
+ 1550.000017ps      -4.5605461
+ 1560.000018ps      -4.6720455
+ 1570.000019ps      -4.7527075
+ 1580.000020ps       -4.786524
+ 1590.000021ps      -4.6928299
+ 1600.000021ps      -4.5211953
+ 1610.000022ps       -4.254257
+ 1620.000023ps      -3.9424872
+ 1630.000024ps      -3.6162432
+ 1640.000025ps      -3.3227728
+ 1650.000025ps      -3.1048305
+ 1660.000026ps      -2.9622963
+ 1670.000027ps      -2.9260485
+ 1680.000028ps      -2.9847405
+ 1690.000029ps      -3.1136288
+ 1700.000030ps      -3.3218641
+ 1710.000030ps      -3.5885621
+ 1720.000031ps      -3.8517174
+ 1730.000032ps      -4.0534421
+ 1740.000033ps      -4.2173269
+ 1750.000034ps      -4.2836959
+ 1760.000035ps      -4.2839013
+ 1770.000035ps      -4.3670691
+ 1780.000036ps      -4.5674347
+ 1790.000037ps      -4.8056587
+ 1800.000038ps      -5.2109799
+ 1810.000039ps      -5.7063387
+ 1820.000040ps      -6.2282637
+ 1830.000040ps      -6.7325587
+ 1840.000041ps       -7.088189
+ 1850.000042ps      -7.3013775
+ 1860.000043ps      -7.3882038
+ 1869.999933ps      -7.3902172
+ 1879.999934ps      -7.3028811
+ 1889.999934ps      -7.0981123
+ 1899.999935ps      -6.8347972
+ 1909.999936ps      -6.6400992
+ 1919.999937ps        -6.59011
+ 1929.999938ps      -6.5756114
+ 1939.999938ps      -6.4569924
+ 1949.999939ps      -6.1954846
+ 1959.999940ps      -5.8976007
+ 1969.999941ps      -5.6090747
+ 1979.999942ps      -5.3668205
+ 1989.999943ps      -5.1964626
+ 1999.999943ps      -5.0305032
+ 2009.999944ps      -4.7056311
+ 2019.999945ps      -4.5516768
+ 2029.999946ps      -4.5040531
+ 2039.999947ps      -4.5509274
+ 2049.999948ps       -4.609669
+ 2059.999948ps      -4.7151292
+ 2069.999949ps      -4.7902094
+ 2079.999950ps      -4.8240641
+ 2089.999951ps      -4.7324302
+ 2099.999952ps      -4.5710871
+ 2109.999953ps      -4.3044676
+ 2119.999953ps      -3.9891962
+ 2129.999954ps        -3.65746
+ 2139.999955ps      -3.3459613
+ 2149.999956ps      -3.1169233
+ 2159.999957ps      -2.9765749
+ 2169.999958ps      -2.9327166
+ 2179.999958ps      -2.9843407
+ 2189.999959ps      -3.0994892
+ 2199.999960ps      -3.2875279
+ 2209.999961ps      -3.5442425
+ 2219.999962ps      -3.8097483
+ 2229.999962ps      -4.0128501
+ 2239.999963ps      -4.1902711
+ 2249.999964ps      -4.3062542
+ 2259.999965ps       -4.435907
+ 2269.999966ps      -4.7052846
+ 2279.999967ps      -5.1155884
+ 2289.999967ps      -5.6842971
+ 2299.999968ps      -6.3504582
+ 2309.999969ps      -7.0232595
+ 2319.999970ps      -7.5233614
+ 2329.999971ps      -7.7623688
+ 2339.999972ps      -7.7635226
+ 2349.999972ps      -7.5754073
+ 2359.999973ps      -7.2898805
+ 2369.999974ps      -7.0200793
+ 2379.999975ps      -6.7973284
+ 2389.999976ps      -6.5454367
+ 2399.999977ps      -6.3029817
+ 2409.999977ps      -6.1576388
+ 2419.999978ps      -6.1798184
+ 2429.999979ps      -6.2564335
+ 2439.999980ps      -6.2435558
+ 2449.999981ps      -6.0862752
+ 2459.999981ps      -5.8688405
+ 2469.999982ps       -5.627254
+ 2479.999983ps      -5.3581359
+ 2489.999984ps      -5.1096367
+ 2499.999985ps      -4.8380888
+ 2509.999986ps      -4.4575604
+ 2519.999986ps      -4.2989809
+ 2529.999987ps      -4.3001614
+ 2539.999988ps      -4.3866717
+ 2549.999989ps      -4.4737269
+ 2559.999990ps      -4.5943817
+ 2569.999991ps      -4.6802372
+ 2579.999991ps      -4.7217126
+ 2589.999992ps      -4.6341013
+ 2599.999993ps      -4.4658449
+ 2609.999994ps      -4.2088152
+ 2619.999995ps      -3.9012658
+ 2629.999996ps      -3.5768834
+ 2639.999996ps      -3.2823461
+ 2649.999997ps      -3.0608252
+ 2659.999998ps      -2.9340839
+ 2669.999999ps      -2.9081519
+ 2680.000000ps      -2.9612729
+ 2690.000001ps      -3.0895556
+ 2700.000001ps      -3.2931577
+ 2710.000002ps      -3.5575781
+ 2720.000003ps      -3.8263086
+ 2730.000004ps      -4.0328102
+ 2740.000005ps      -4.1776963
+ 2750.000005ps      -4.2289947
+ 2760.000006ps      -4.2240172
+ 2770.000007ps      -4.3085596
+ 2780.000008ps      -4.5178771
+ 2790.000009ps      -4.8177208
+ 2800.000010ps      -5.2383346
+ 2810.000010ps       -5.724805
+ 2820.000011ps      -6.1798026
+ 2830.000012ps      -6.6350151
+ 2840.000013ps      -6.9533262
+ 2850.000014ps      -7.1703802
+ 2860.000015ps       -7.284862
+ 2870.000015ps       -7.317771
+ 2880.000016ps      -7.2611995
+ 2890.000017ps      -7.0883164
+ 2900.000018ps       -6.852989
+ 2910.000019ps      -6.6603442
+ 2920.000020ps      -6.6139852
+ 2930.000020ps      -6.6190888
+ 2940.000021ps      -6.5157222
+ 2950.000022ps      -6.2721967
+ 2960.000023ps      -5.9807657
+ 2970.000024ps      -5.6505523
+ 2980.000025ps      -5.3263079
+ 2990.000025ps      -5.0862413
+ 3000.000026ps      -4.8928889
+ 3010.000027ps      -4.5774096
+ 3020.000028ps      -4.4386838
+ 3030.000029ps      -4.4294059
+ 3040.000029ps      -4.5069452
+ 3050.000030ps      -4.5884142
+ 3060.000031ps        -4.70575
+ 3070.000032ps      -4.7877042
+ 3080.000033ps      -4.8269165
+ 3090.000034ps      -4.7389503
+ 3100.000034ps      -4.5705974
+ 3110.000035ps      -4.3115543
+ 3120.000036ps      -4.0074097
+ 3130.000037ps      -3.6787462
+ 3140.000038ps      -3.3649682
+ 3150.000039ps      -3.1396112
+ 3160.000039ps      -2.9900001
+ 3170.000040ps      -2.9453218
+ 3180.000041ps      -2.9971697
+ 3190.000042ps      -3.1158636
+ 3200.000043ps      -3.3087679
+ 3210.000044ps      -3.5465172
+ 3220.000044ps      -3.7833011
+ 3230.000045ps      -3.9610217
+ 3240.000046ps      -4.0944283
+ 3250.000047ps      -4.1563636
+ 3260.000048ps      -4.2205938
+ 3270.000049ps      -4.4528201
+ 3280.000049ps      -4.8379215
+ 3290.000050ps       -5.404508
+ 3300.000051ps      -6.0789892
+ 3310.000052ps      -6.8036799
+ 3320.000053ps      -7.3750597
+ 3330.000053ps      -7.6822718
+ 3340.000054ps      -7.7396604
+ 3350.000055ps       -7.602936
+ 3360.000056ps      -7.3254439
+ 3370.000057ps      -7.0200988
+ 3380.000058ps      -6.7497579
+ 3390.000058ps      -6.4452275
+ 3400.000059ps      -6.1488517
+ 3410.000060ps      -5.9621076
+ 3420.000061ps      -5.9488541
+ 3430.000062ps      -5.9844036
+ 3440.000063ps      -5.9601151
+ 3450.000063ps      -5.8188807
+ 3460.000064ps      -5.6402256
+ 3470.000065ps      -5.4300236
+ 3480.000066ps      -5.2159771
+ 3490.000067ps      -5.0503045
+ 3500.000068ps      -4.8684195
+ 3510.000068ps      -4.5526671
+ 3520.000069ps      -4.4241625
+ 3530.000070ps      -4.4201231
+ 3540.000071ps      -4.4814073
+ 3550.000072ps       -4.531854
+ 3560.000073ps      -4.6334153
+ 3570.000073ps      -4.7094699
+ 3580.000074ps      -4.7447365
+ 3590.000075ps      -4.6539405
+ 3600.000076ps      -4.4851086
+ 3610.000077ps      -4.2278085
+ 3620.000077ps      -3.9271988
+ 3630.000078ps      -3.6047779
+ 3640.000079ps      -3.3083038
+ 3650.000080ps      -3.0838169
+ 3660.000081ps      -2.9481598
+ 3670.000082ps      -2.9186721
+ 3680.000082ps       -2.973082
+ 3690.000083ps      -3.0977608
+ 3700.000084ps      -3.2885648
+ 3710.000085ps      -3.5360408
+ 3720.000086ps       -3.787682
+ 3729.999865ps      -3.9982237
+ 3739.999865ps      -4.1703526
+ 3749.999866ps      -4.2537471
+ 3759.999867ps      -4.3162442
+ 3769.999868ps      -4.5078986
+ 3779.999869ps      -4.7893699
+ 3789.999869ps      -5.1354412
+ 3799.999870ps      -5.5657514
+ 3809.999871ps      -6.0870689
+ 3819.999872ps      -6.5745536
+ 3829.999873ps      -6.9815494
+ 3839.999874ps      -7.2435397
+ 3849.999874ps      -7.3904657
+ 3859.999875ps      -7.4540759
+ 3869.999876ps      -7.4513156
+ 3879.999877ps      -7.3868079
+ 3889.999878ps        -7.21523
+ 3899.999879ps      -6.9919972
+ 3909.999879ps      -6.8307075
+ 3919.999880ps      -6.8286922
+ 3929.999881ps      -6.8680364
+ 3939.999882ps      -6.8207019
+ 3949.999883ps      -6.6414432
+ 3959.999884ps      -6.4005613
+ 3969.999884ps      -6.1000426
+ 3979.999885ps      -5.7976708
+ 3989.999886ps      -5.5267017
+ 3999.999887ps      -5.2528462
+ 4009.999888ps      -4.8403553
+ 4019.999889ps      -4.6252959
+ 4029.999889ps      -4.5754704
+ 4039.999890ps      -4.6339218
+ 4049.999891ps      -4.7010519
+ 4059.999892ps      -4.8173925
+ 4069.999893ps      -4.9014464
+ 4079.999893ps      -4.9424594
+ 4089.999894ps      -4.8543398
+ 4099.999895ps      -4.6938298
+ 4109.999896ps      -4.4275834
+ 4119.999897ps      -4.1182319
+ 4129.999898ps       -3.788131
+ 4139.999898ps      -3.4800146
+ 4149.999899ps      -3.2459396
+ 4159.999900ps      -3.1036731
+ 4169.999901ps      -3.0633363
+ 4179.999902ps       -3.118851
+ 4189.999903ps      -3.2367988
+ 4199.999903ps       -3.456723
+ 4209.999904ps      -3.7333202
+ 4219.999905ps      -4.0111857
+ 4229.999906ps      -4.2267413
+ 4239.999907ps      -4.4053485
+ 4249.999908ps      -4.5147499
+ 4259.999908ps      -4.5949201
+ 4269.999909ps      -4.8047052
+ 4279.999910ps       -5.148259
+ 4289.999911ps      -5.6594608
+ 4299.999912ps       -6.266943
+ 4309.999913ps      -6.9369617
+ 4319.999913ps      -7.4900832
+ 4329.999914ps      -7.8172754
+ 4339.999915ps       -7.912769
+ 4349.999916ps      -7.8032575
+ 4359.999917ps      -7.5585993
+ 4369.999917ps      -7.2900953
+ 4379.999918ps      -7.0315693
+ 4389.999919ps      -6.7556851
+ 4399.999920ps      -6.4982414
+ 4409.999921ps      -6.3404854
+ 4419.999922ps      -6.3506185
+ 4429.999922ps      -6.3965824
+ 4439.999923ps      -6.3210902
+ 4449.999924ps      -6.0825393
+ 4459.999925ps      -5.8073501
+ 4469.999926ps      -5.5429759
+ 4479.999927ps      -5.2954461
+ 4489.999927ps      -5.1059938
+ 4499.999928ps      -4.9256608
+ 4509.999929ps      -4.6178761
+ 4519.999930ps      -4.4857063
+ 4529.999931ps      -4.4634006
+ 4539.999932ps      -4.5117263
+ 4549.999932ps      -4.5624692
+ 4559.999933ps      -4.6648237
+ 4569.999934ps      -4.7372989
+ 4579.999935ps      -4.7716607
+ 4589.999936ps      -4.6813378
+ 4599.999937ps      -4.5147475
+ 4609.999937ps       -4.258776
+ 4619.999938ps      -3.9556003
+ 4629.999939ps      -3.6257632
+ 4639.999940ps      -3.3203063
+ 4649.999941ps      -3.0958192
+ 4659.999941ps      -2.9510216
+ 4669.999942ps       -2.916798
+ 4679.999943ps      -2.9691232
+ 4689.999944ps      -3.0961881
+ 4699.999945ps      -3.2942008
+ 4709.999946ps      -3.5558318
+ 4719.999946ps      -3.8213843
+ 4729.999947ps      -4.0168485
+ 4739.999948ps      -4.1413714
+ 4749.999949ps      -4.1874791
+ 4759.999950ps      -4.1844034
+ 4769.999951ps      -4.3200762
+ 4779.999951ps      -4.5432016
+ 4789.999952ps      -4.8818972
+ 4799.999953ps      -5.3667358
+ 4809.999954ps      -5.9359253
+ 4819.999955ps      -6.4679867
+ 4829.999956ps      -6.9568132
+ 4839.999956ps      -7.2782106
+ 4849.999957ps      -7.4353029
+ 4859.999958ps      -7.4694435
+ 4869.999959ps      -7.4494496
+ 4879.999960ps      -7.3482193
+ 4889.999961ps      -7.1517491
+ 4899.999961ps      -6.9064211
+ 4909.999962ps      -6.7262162
+ 4919.999963ps      -6.7062318
+ 4929.999964ps      -6.7392308
+ 4939.999965ps      -6.6699065
+ 4949.999965ps      -6.4688278
+ 4959.999966ps      -6.2090813
+ 4969.999967ps      -5.9406845
+ 4979.999968ps      -5.7016482
+ 4989.999969ps      -5.5050458
+ 4999.999970ps      -5.2814005
+ 5009.999970ps      -4.8743797
+ 5019.999971ps      -4.6506678
+ 5029.999972ps      -4.5702054
+ 5039.999973ps       -4.597154
+ 5049.999974ps      -4.6457185
+ 5059.999975ps      -4.7429807
+ 5069.999975ps      -4.8131049
+ 5079.999976ps      -4.8460876
+ 5089.999977ps        -4.75708
+ 5099.999978ps      -4.5889637
+ 5109.999979ps       -4.332797
+ 5119.999980ps      -4.0253621
+ 5129.999980ps      -3.6921874
+ 5139.999981ps       -3.375912
+ 5149.999982ps      -3.1393661
+ 5159.999983ps      -2.9944586
+ 5169.999984ps      -2.9509463
+ 5179.999985ps      -2.9941959
+ 5189.999985ps      -3.1143261
+ 5199.999986ps      -3.3040522
+ 5209.999987ps      -3.5623867
+ 5219.999988ps      -3.8027789
+ 5229.999989ps      -3.9927276
+ 5239.999989ps      -4.1456713
+ 5249.999990ps      -4.2569638
+ 5259.999991ps      -4.3874196
+ 5269.999992ps       -4.697594
+ 5279.999993ps      -5.1705146
+ 5289.999994ps      -5.8086616
+ 5299.999994ps       -6.538114
+ 5309.999995ps      -7.2891735
+ 5319.999996ps      -7.8167517
+ 5329.999997ps      -8.0488284
+ 5339.999998ps      -8.0177229
+ 5349.999999ps      -7.7794467
+ 5359.999999ps      -7.4248564
+ 5370.000000ps      -7.1086466
+ 5380.000001ps      -6.8656033
+ 5390.000002ps      -6.6100295
+ 5400.000003ps      -6.3704426
+ 5410.000004ps       -6.235211
+ 5420.000004ps      -6.2718684
+ 5430.000005ps      -6.3704687
+ 5440.000006ps      -6.3977169
+ 5450.000007ps      -6.3109154
+ 5460.000008ps      -6.1708195
+ 5470.000009ps        -5.98538
+ 5480.000009ps      -5.7476461
+ 5490.000010ps      -5.4794385
+ 5500.000011ps      -5.1571726
+ 5510.000012ps      -4.7088995
+ 5520.000013ps      -4.4987373
+ 5530.000013ps       -4.450335
+ 5540.000014ps      -4.4953235
+ 5550.000015ps      -4.5468684
+ 5560.000016ps      -4.6472638
+ 5570.000017ps      -4.7232188
+ 5580.000018ps      -4.7574651
+ 5590.000018ps      -4.6645076
+ 5600.000019ps      -4.5003159
+ 5610.000020ps      -4.2466633
+ 5620.000021ps      -3.9420705
+ 5630.000022ps      -3.6141949
+ 5640.000023ps      -3.3076874
+ 5650.000023ps      -3.0774826
+ 5660.000024ps      -2.9408785
+ 5670.000025ps      -2.9100136
+ 5680.000026ps      -2.9680795
+ 5690.000027ps      -3.0910019
+ 5700.000028ps       -3.297003
+ 5710.000028ps       -3.563219
+ 5720.000029ps      -3.8347326
+ 5730.000030ps      -4.0441443
+ 5740.000031ps      -4.2115002
+ 5750.000032ps      -4.2646856
+ 5760.000032ps      -4.3092895
+ 5770.000033ps      -4.4582861
+ 5780.000034ps      -4.6823127
+ 5790.000035ps      -4.9841127
+ 5800.000036ps      -5.4252475
+ 5810.000037ps      -5.9124493
+ 5820.000037ps       -6.348998
+ 5830.000038ps      -6.7538148
+ 5840.000039ps      -7.0651026
+ 5850.000040ps      -7.2597149
+ 5860.000041ps      -7.3551814
+ 5870.000042ps      -7.3902671
+ 5880.000042ps      -7.3537533
+ 5890.000043ps      -7.1838899
+ 5900.000044ps      -6.9474719
+ 5910.000045ps      -6.7718026
+ 5920.000046ps       -6.747729
+ 5930.000047ps      -6.7683349
+ 5940.000047ps      -6.6834344
+ 5950.000048ps      -6.4741577
+ 5960.000049ps      -6.1782793
+ 5970.000050ps      -5.8541065
+ 5980.000051ps      -5.5199938
+ 5990.000052ps      -5.2540753
+ 6000.000052ps      -4.9939896
+ 6010.000053ps      -4.6385461
+ 6020.000054ps       -4.494478
+ 6030.000055ps      -4.4884489
+ 6040.000056ps       -4.557046
+ 6050.000056ps      -4.6267897
+ 6060.000057ps      -4.7375962
+ 6070.000058ps      -4.8193763
+ 6080.000059ps      -4.8563172
+ 6090.000060ps      -4.7677011
+ 6100.000061ps      -4.6076462
+ 6110.000061ps      -4.3396228
+ 6120.000062ps      -4.0271866
+ 6130.000063ps      -3.6961048
+ 6140.000064ps       -3.391795
+ 6150.000065ps      -3.1585512
+ 6160.000066ps      -3.0042269
+ 6170.000066ps       -2.962904
+ 6180.000067ps      -3.0060974
+ 6190.000068ps      -3.1215274
+ 6200.000069ps      -3.3078882
+ 6210.000070ps      -3.5588245
+ 6220.000071ps       -3.810924
+ 6230.000071ps      -3.9943114
+ 6240.000072ps      -4.1332744
+ 6250.000073ps       -4.198033
+ 6260.000074ps      -4.2621227
+ 6270.000075ps      -4.4835768
+ 6280.000076ps       -4.864619
+ 6290.000076ps      -5.4160943
+ 6300.000077ps      -6.0688922
+ 6310.000078ps      -6.7628192
+ 6320.000079ps      -7.3076664
+ 6330.000080ps      -7.6132692
+ 6340.000080ps      -7.6795556
+ 6350.000081ps      -7.5400499
+ 6360.000082ps      -7.2777607
+ 6370.000083ps      -7.0050018
+ 6380.000084ps      -6.7474984
+ 6390.000085ps      -6.4493815
+ 6400.000085ps      -6.1715694
+ 6410.000086ps      -5.9793328
+ 6420.000087ps      -5.9564285
+ 6430.000088ps      -5.9865868
+ 6440.000089ps       -5.946435
+ 6450.000090ps      -5.7898693
+ 6460.000090ps      -5.5867935
+ 6470.000091ps      -5.3599154
+ 6480.000092ps      -5.1259369
+ 6490.000093ps       -4.946196
+ 6500.000094ps      -4.7669671
+ 6510.000095ps      -4.4732027
+ 6520.000095ps      -4.3515389
+ 6530.000096ps      -4.3580928
+ 6540.000097ps      -4.4327539
+ 6550.000098ps      -4.5149149
+ 6560.000099ps      -4.6342533
+ 6570.000100ps      -4.7176085
+ 6580.000100ps      -4.7572822
+ 6590.000101ps      -4.6703914
+ 6600.000102ps      -4.5047903
+ 6610.000103ps      -4.2503456
+ 6620.000104ps      -3.9531171
+ 6630.000104ps      -3.6341405
+ 6640.000105ps      -3.3385379
+ 6650.000106ps      -3.1169348
+ 6660.000107ps      -2.9711709
+ 6670.000108ps      -2.9392635
+ 6680.000109ps      -2.9897952
+ 6690.000109ps      -3.1139997
+ 6700.000110ps      -3.3162898
+ 6710.000111ps      -3.5731935
+ 6720.000112ps      -3.8368642
+ 6730.000113ps      -4.0410867
+ 6740.000114ps      -4.2110001
+ 6750.000114ps      -4.2976893
+ 6760.000115ps      -4.3497112
+ 6770.000116ps      -4.4818355
+ 6780.000117ps      -4.7156127
+ 6790.000118ps      -5.0241396
+ 6800.000119ps      -5.4767608
+ 6810.000119ps      -5.9557171
+ 6820.000120ps      -6.4176397
+ 6830.000121ps      -6.8598176
+ 6840.000122ps      -7.1889062
+ 6850.000123ps      -7.3902188
+ 6860.000124ps       -7.475441
+ 6870.000124ps      -7.4882854
+ 6880.000125ps      -7.4239838
+ 6890.000126ps      -7.2284966
+ 6900.000127ps      -6.9761789
+ 6910.000128ps      -6.7939358
+ 6920.000128ps      -6.7725478
+ 6930.000129ps      -6.7952438
+ 6940.000130ps      -6.7113997
+ 6950.000131ps      -6.5076053
+ 6960.000132ps      -6.2319503
+ 6970.000133ps      -5.9518781
+ 6980.000133ps      -5.6447086
+ 6990.000134ps      -5.3854981
+ 7000.000135ps       -5.125014
+ 7010.000136ps      -4.7786697
+ 7020.000137ps      -4.6392872
+ 7030.000138ps      -4.6121916
+ 7040.000138ps      -4.6441804
+ 7050.000139ps      -4.6787382
+ 7060.000140ps      -4.7734482
+ 7070.000141ps      -4.8430432
+ 7080.000142ps      -4.8762003
+ 7090.000143ps      -4.7826151
+ 7100.000143ps      -4.6114104
+ 7110.000144ps      -4.3478029
+ 7120.000145ps      -4.0370448
+ 7130.000146ps      -3.7071855
+ 7140.000147ps      -3.3948926
+ 7150.000148ps      -3.1681409
+ 7160.000148ps      -3.0229072
+ 7170.000149ps       -2.975655
+ 7180.000150ps      -3.0209712
+ 7190.000151ps       -3.139566
+ 7200.000152ps      -3.3268061
+ 7210.000152ps      -3.5720256
+ 7220.000153ps      -3.8221961
+ 7230.000154ps      -3.9940335
+ 7240.000155ps      -4.1358514
+ 7250.000156ps      -4.2048179
+ 7260.000157ps      -4.2721765
+ 7270.000157ps      -4.5104693
+ 7280.000158ps      -4.9081795
+ 7290.000159ps       -5.481304
+ 7300.000160ps      -6.1572372
+ 7310.000161ps      -6.8458015
+ 7320.000162ps      -7.3788702
+ 7330.000162ps      -7.6610294
+ 7340.000163ps      -7.6880873
+ 7350.000164ps       -7.513057
+ 7360.000165ps      -7.2343595
+ 7370.000166ps      -6.9535465
+ 7380.000167ps      -6.7137556
+ 7390.000167ps      -6.4391288
+ 7400.000168ps      -6.1755759
+ 7410.000169ps      -5.9942355
+ 7420.000170ps      -5.9724282
+ 7430.000171ps      -6.0162174
+ 7440.000171ps      -5.9912448
+ 7450.000172ps      -5.8448236
+ 7459.999729ps      -5.6620755
+ 7469.999730ps      -5.4521886
+ 7479.999731ps      -5.2005632
+ 7489.999732ps      -4.9982091
+ 7499.999732ps      -4.7735452
+ 7509.999733ps      -4.4463974
+ 7519.999734ps      -4.3067134
+ 7529.999735ps      -4.3175622
+ 7539.999736ps      -4.4088844
+ 7549.999737ps      -4.4981358
+ 7559.999737ps      -4.6218963
+ 7569.999738ps      -4.7117064
+ 7579.999739ps      -4.7548235
+ 7589.999740ps      -4.6678175
+ 7599.999741ps      -4.5051574
+ 7609.999741ps      -4.2473014
+ 7619.999742ps      -3.9382023
+ 7629.999743ps      -3.6199105
+ 7639.999744ps      -3.3234166
+ 7649.999745ps      -3.0998962
+ 7659.999746ps      -2.9626115
+ 7669.999746ps      -2.9285268
+ 7679.999747ps       -2.980123
+ 7689.999748ps      -3.1033577
+ 7699.999749ps      -3.3043477
+ 7709.999750ps       -3.564091
+ 7719.999751ps      -3.8239552
+ 7729.999751ps      -4.0151298
+ 7739.999752ps      -4.1427248
+ 7749.999753ps      -4.1789446
+ 7759.999754ps      -4.1646397
+ 7769.999755ps      -4.2630766
+ 7779.999756ps      -4.4939826
+ 7789.999756ps      -4.8314846
+ 7799.999757ps      -5.3227049
+ 7809.999758ps      -5.8740741
+ 7819.999759ps      -6.3956412
+ 7829.999760ps       -6.856104
+ 7839.999761ps      -7.1714035
+ 7849.999761ps      -7.3412586
+ 7859.999762ps      -7.4078267
+ 7869.999763ps      -7.3985679
+ 7879.999764ps       -7.324338
+ 7889.999765ps       -7.124444
+ 7899.999765ps      -6.8620045
+ 7909.999766ps       -6.667275
+ 7919.999767ps      -6.6330548
+ 7929.999768ps      -6.6543958
+ 7939.999769ps      -6.5935434
+ 7949.999770ps      -6.3978808
+ 7959.999770ps      -6.1495175
+ 7969.999771ps      -5.8788756
+ 7979.999772ps      -5.6028492
+ 7989.999773ps      -5.4131519
+ 7999.999774ps      -5.1825858
+ 8009.999775ps       -5.062366
+ 8019.999775ps      -4.9973457
+ 8029.999776ps      -4.9450421
+ 8039.999777ps        -4.90451
+ 8049.999778ps      -4.8723886
+ 8059.999779ps       -4.846439
+ 8069.999780ps      -4.8251155
+ 8079.999780ps      -4.8073232
+ 8089.999781ps      -4.7922696
+ 8099.999782ps       -4.779371
+ 8109.999783ps      -4.7681912
+ 8119.999784ps      -4.7584001
+ 8129.999785ps       -4.749745
+ 8139.999785ps        -4.74203
+ 8149.999786ps      -4.7351016
+ 8159.999787ps      -4.7288381
+ 8169.999788ps      -4.7231422
+ 8179.999789ps      -4.7179349
+ 8189.999789ps      -4.7131516
+ 8199.999790ps      -4.7087392
+ 8209.999791ps      -4.7046531
+ 8219.999792ps      -4.7008561
+ 8229.999793ps      -4.6973165
+ 8239.999794ps      -4.6940072
+ 8249.999794ps       -4.690905
+ 8259.999795ps      -4.6879898
+ 8269.999796ps       -4.685244
+ 8279.999797ps      -4.6826523
+ 8289.999798ps      -4.6802011
+ 8299.999799ps      -4.6778787
+ 8309.999799ps      -4.6756743
+)

Icursig7 PAR_3_0_VDD075NNE 0 pwl(
+ 0.000000ps      0.96325353
+ 10.000000ps       1.0623295
+ 20.000000ps       1.2794272
+ 29.999999ps       1.5266168
+ 40.000000ps        1.736046
+ 50.000001ps       1.9609372
+ 59.999998ps       2.1639375
+ 69.999999ps       2.3394605
+ 80.000000ps       2.4680785
+ 90.000001ps       2.5706783
+ 100.000001ps       2.6407546
+ 110.000002ps       2.7161929
+ 119.999996ps       2.7926856
+ 129.999997ps       2.9288403
+ 139.999998ps       3.0451251
+ 149.999999ps        3.156695
+ 159.999999ps        3.381184
+ 170.000000ps         3.74928
+ 180.000001ps       4.1074827
+ 190.000002ps       4.3667611
+ 200.000003ps       4.4563261
+ 210.000003ps       4.4948835
+ 220.000004ps       4.5667235
+ 230.000005ps         4.74375
+ 239.999992ps       5.1055216
+ 249.999993ps       5.5436882
+ 259.999994ps       5.8788577
+ 269.999995ps       6.3822116
+ 279.999995ps       6.9440405
+ 289.999996ps       7.4713773
+ 299.999997ps       7.9015041
+ 309.999998ps       8.3147688
+ 319.999999ps       8.5951193
+ 330.000000ps       8.8535612
+ 340.000000ps       8.9343675
+ 350.000001ps       8.8329975
+ 360.000002ps       8.5991561
+ 370.000003ps       8.2446579
+ 380.000004ps       7.7938133
+ 390.000005ps       7.2869457
+ 400.000005ps       6.7937993
+ 410.000006ps         6.31825
+ 420.000007ps        5.855658
+ 430.000008ps         5.42611
+ 440.000009ps       5.0231483
+ 450.000009ps        4.716593
+ 460.000010ps       4.5361688
+ 469.999983ps       4.4190781
+ 479.999984ps       4.2948071
+ 489.999985ps       4.1450923
+ 499.999986ps        3.868497
+ 509.999987ps       3.5237549
+ 519.999988ps       3.2672263
+ 529.999988ps       3.0470617
+ 539.999989ps       2.8436839
+ 549.999990ps       2.7179947
+ 559.999991ps       2.6537004
+ 569.999992ps       2.6387654
+ 579.999992ps       2.6349355
+ 589.999993ps       2.6462296
+ 599.999994ps       2.6631401
+ 609.999995ps       2.6841194
+ 619.999996ps       2.7241021
+ 629.999997ps       2.8276715
+ 639.999997ps       2.9185069
+ 649.999998ps       3.0181909
+ 659.999999ps       3.2351649
+ 670.000000ps       3.6061895
+ 680.000001ps       3.9903956
+ 690.000002ps       4.2587744
+ 700.000002ps        4.337874
+ 710.000003ps       4.3749285
+ 720.000004ps       4.4537302
+ 730.000005ps       4.6563242
+ 740.000006ps       5.0611501
+ 750.000007ps       5.6005369
+ 760.000007ps       6.1063794
+ 770.000008ps       6.8883937
+ 780.000009ps       7.8256181
+ 790.000010ps       8.8710992
+ 800.000011ps       9.8597723
+ 810.000012ps       10.759858
+ 820.000012ps       11.240734
+ 830.000013ps       11.463455
+ 840.000014ps       11.555123
+ 850.000015ps       11.521306
+ 860.000016ps       11.345104
+ 870.000016ps       11.051242
+ 880.000017ps       10.552965
+ 890.000018ps       9.9141819
+ 900.000019ps       9.2226045
+ 910.000020ps       8.5148531
+ 920.000021ps       7.7798258
+ 930.000021ps       7.0259163
+ 939.999967ps       6.3152861
+ 949.999968ps       5.6971144
+ 959.999968ps       5.2415983
+ 969.999969ps       4.9212955
+ 979.999970ps       4.7019276
+ 989.999971ps       4.4788602
+ 999.999972ps       4.1479453
+ 1009.999973ps        3.776086
+ 1019.999973ps       3.4853721
+ 1029.999974ps        3.229368
+ 1039.999975ps       2.9973965
+ 1049.999976ps        2.864331
+ 1059.999977ps       2.7889106
+ 1069.999978ps       2.7665231
+ 1079.999978ps       2.7541739
+ 1089.999979ps       2.7654768
+ 1099.999980ps       2.8026327
+ 1109.999981ps       2.8082621
+ 1119.999982ps       2.8451731
+ 1129.999982ps       2.9503521
+ 1139.999983ps       3.0502918
+ 1149.999984ps       3.1518349
+ 1159.999985ps       3.3737194
+ 1169.999986ps       3.7350516
+ 1179.999987ps       4.0852777
+ 1189.999987ps        4.327348
+ 1199.999988ps        4.405885
+ 1209.999989ps       4.4428304
+ 1219.999990ps       4.5091026
+ 1229.999991ps       4.6728214
+ 1239.999992ps       5.0195254
+ 1249.999992ps       5.4420422
+ 1259.999993ps       5.7413852
+ 1269.999994ps       6.2039427
+ 1279.999995ps       6.7339668
+ 1289.999996ps        7.237886
+ 1299.999997ps       7.6507016
+ 1309.999997ps       8.0644604
+ 1319.999998ps       8.3630362
+ 1329.999999ps        8.659856
+ 1340.000000ps       8.7730763
+ 1350.000001ps       8.6786364
+ 1360.000002ps       8.4421833
+ 1370.000002ps       8.0841675
+ 1380.000003ps       7.6139556
+ 1390.000004ps        7.076055
+ 1400.000005ps       6.5574559
+ 1410.000006ps       6.0573305
+ 1420.000006ps       5.5742628
+ 1430.000007ps       5.1256206
+ 1440.000008ps       4.6955783
+ 1450.000009ps       4.3547223
+ 1460.000010ps       4.1352076
+ 1470.000011ps       4.0320465
+ 1480.000011ps        3.968408
+ 1490.000012ps       3.8739827
+ 1500.000013ps       3.6710588
+ 1510.000014ps       3.3833084
+ 1520.000015ps       3.1526737
+ 1530.000016ps       2.9311026
+ 1540.000016ps       2.7329844
+ 1550.000017ps       2.6377239
+ 1560.000018ps       2.5916831
+ 1570.000019ps       2.5939551
+ 1580.000020ps       2.6015259
+ 1590.000021ps       2.6182058
+ 1600.000021ps       2.6344904
+ 1610.000022ps       2.6551439
+ 1620.000023ps       2.7009156
+ 1630.000024ps       2.8179201
+ 1640.000025ps       2.9196855
+ 1650.000025ps       3.0242323
+ 1660.000026ps       3.2591768
+ 1670.000027ps       3.6528495
+ 1680.000028ps       4.0522138
+ 1690.000029ps       4.3307662
+ 1700.000030ps       4.4186431
+ 1710.000030ps       4.4795545
+ 1720.000031ps       4.5767654
+ 1730.000032ps       4.8091368
+ 1740.000033ps       5.2386451
+ 1750.000034ps       5.8035204
+ 1760.000035ps        6.303205
+ 1770.000035ps       7.0219662
+ 1780.000036ps        7.926038
+ 1790.000037ps       8.8505287
+ 1800.000038ps       9.7581814
+ 1810.000039ps       10.595772
+ 1820.000040ps       11.073755
+ 1830.000040ps       11.306022
+ 1840.000041ps       11.425439
+ 1850.000042ps       11.423818
+ 1860.000043ps       11.277271
+ 1869.999933ps       11.001406
+ 1879.999934ps       10.500021
+ 1889.999934ps       9.8586237
+ 1899.999935ps       9.1545053
+ 1909.999936ps       8.4353277
+ 1919.999937ps       7.6723927
+ 1929.999938ps       6.8691281
+ 1939.999938ps       6.0833647
+ 1949.999939ps       5.4147579
+ 1959.999940ps       4.9283287
+ 1969.999941ps       4.6066184
+ 1979.999942ps       4.3811832
+ 1989.999943ps       4.1929965
+ 1999.999943ps       3.9362717
+ 2009.999944ps       3.6186778
+ 2019.999945ps       3.3691757
+ 2029.999946ps       3.1290136
+ 2039.999947ps       2.9173604
+ 2049.999948ps       2.7955548
+ 2059.999948ps       2.7291458
+ 2069.999949ps       2.7100767
+ 2079.999950ps       2.7069037
+ 2089.999951ps        2.719187
+ 2099.999952ps       2.7264499
+ 2109.999953ps       2.7445742
+ 2119.999953ps       2.7888776
+ 2129.999954ps       2.9009449
+ 2139.999955ps        3.000947
+ 2149.999956ps       3.0936343
+ 2159.999957ps       3.3182112
+ 2169.999958ps       3.6881664
+ 2179.999958ps       4.0387978
+ 2189.999959ps       4.2814996
+ 2199.999960ps       4.3514284
+ 2209.999961ps       4.3812664
+ 2219.999962ps       4.4477026
+ 2229.999962ps       4.6206952
+ 2239.999963ps       4.9827649
+ 2249.999964ps       5.4357991
+ 2259.999965ps       5.7829962
+ 2269.999966ps       6.2908998
+ 2279.999967ps        6.858917
+ 2289.999967ps       7.3802977
+ 2299.999968ps       7.7988845
+ 2309.999969ps       8.1788311
+ 2319.999970ps       8.4104543
+ 2329.999971ps       8.6104127
+ 2339.999972ps       8.6555423
+ 2349.999972ps         8.53772
+ 2359.999973ps       8.3023747
+ 2369.999974ps       7.9784006
+ 2379.999975ps       7.5606327
+ 2389.999976ps       7.0738665
+ 2399.999977ps       6.5949937
+ 2409.999977ps       6.1078349
+ 2419.999978ps       5.6418805
+ 2429.999979ps       5.2196334
+ 2439.999980ps       4.8289215
+ 2449.999981ps       4.5138975
+ 2459.999981ps       4.3108355
+ 2469.999982ps       4.1801397
+ 2479.999983ps       4.0462869
+ 2489.999984ps       3.8623488
+ 2499.999985ps       3.5476851
+ 2509.999986ps       3.2029292
+ 2519.999986ps        2.974556
+ 2529.999987ps       2.8048201
+ 2539.999988ps       2.6502066
+ 2549.999989ps       2.5809092
+ 2559.999990ps       2.5492826
+ 2569.999991ps       2.5534085
+ 2579.999991ps       2.5619949
+ 2589.999992ps       2.5795993
+ 2599.999993ps       2.5987759
+ 2609.999994ps       2.6230179
+ 2619.999995ps       2.6704478
+ 2629.999996ps       2.7877427
+ 2639.999996ps       2.8904043
+ 2649.999997ps        3.002892
+ 2659.999998ps       3.2464122
+ 2669.999999ps       3.6323511
+ 2680.000000ps       4.0218025
+ 2690.000001ps       4.2923821
+ 2700.000001ps       4.3777345
+ 2710.000002ps       4.4359146
+ 2720.000003ps       4.5374478
+ 2730.000004ps       4.7745065
+ 2740.000005ps       5.1974444
+ 2750.000005ps       5.7422461
+ 2760.000006ps       6.2331377
+ 2770.000007ps       6.9407587
+ 2780.000008ps       7.8397149
+ 2790.000009ps       8.8351859
+ 2800.000010ps       9.7529134
+ 2810.000010ps       10.580924
+ 2820.000011ps       10.990257
+ 2830.000012ps       11.174036
+ 2840.000013ps       11.256631
+ 2850.000014ps       11.271227
+ 2860.000015ps        11.15854
+ 2870.000015ps       10.911035
+ 2880.000016ps       10.448587
+ 2890.000017ps       9.8287036
+ 2900.000018ps       9.1329437
+ 2910.000019ps       8.4190328
+ 2920.000020ps       7.6634285
+ 2930.000020ps       6.8823219
+ 2940.000021ps       6.1139498
+ 2950.000022ps       5.4574633
+ 2960.000023ps       4.9673033
+ 2970.000024ps       4.5991827
+ 2980.000025ps       4.3133674
+ 2990.000025ps       4.0633742
+ 3000.000026ps       3.7767574
+ 3010.000027ps       3.4682599
+ 3020.000028ps       3.2407815
+ 3030.000029ps       3.0515913
+ 3040.000029ps       2.8833911
+ 3050.000030ps       2.7884625
+ 3060.000031ps       2.7404849
+ 3070.000032ps       2.7322953
+ 3080.000033ps       2.7249423
+ 3090.000034ps       2.7370157
+ 3100.000034ps       2.7660297
+ 3110.000035ps       2.7742968
+ 3120.000036ps       2.8178369
+ 3130.000037ps       2.9240651
+ 3140.000038ps       3.0225655
+ 3150.000039ps       3.1162634
+ 3160.000039ps       3.3481505
+ 3170.000040ps       3.7156259
+ 3180.000041ps       4.0604256
+ 3190.000042ps       4.2960498
+ 3200.000043ps       4.3518365
+ 3210.000044ps       4.3649051
+ 3220.000044ps       4.4085726
+ 3230.000045ps       4.5591189
+ 3240.000046ps       4.8862406
+ 3250.000047ps       5.2829313
+ 3260.000048ps       5.5712496
+ 3270.000049ps       6.0437064
+ 3280.000049ps       6.5842111
+ 3290.000050ps       7.1026817
+ 3300.000051ps       7.5359116
+ 3310.000052ps       7.9605725
+ 3320.000053ps       8.2514841
+ 3330.000053ps         8.52043
+ 3340.000054ps       8.6191874
+ 3350.000055ps       8.5406065
+ 3360.000056ps       8.3236101
+ 3370.000057ps       7.9624399
+ 3380.000058ps        7.495511
+ 3390.000058ps        6.952154
+ 3400.000059ps       6.4105705
+ 3410.000060ps       5.8844219
+ 3420.000061ps        5.388837
+ 3430.000062ps          4.9294
+ 3440.000063ps       4.5294764
+ 3450.000063ps       4.2347361
+ 3460.000064ps       4.0706554
+ 3470.000065ps       3.9738878
+ 3480.000066ps       3.8922861
+ 3490.000067ps       3.7905286
+ 3500.000068ps       3.5586603
+ 3510.000068ps       3.2811563
+ 3520.000069ps       3.0830009
+ 3530.000070ps       2.9084706
+ 3540.000071ps       2.7282618
+ 3550.000072ps       2.6181951
+ 3560.000073ps       2.5650482
+ 3570.000073ps       2.5599574
+ 3580.000074ps       2.5627905
+ 3590.000075ps        2.577478
+ 3600.000076ps       2.5959191
+ 3610.000077ps        2.621621
+ 3620.000077ps       2.6704137
+ 3630.000078ps       2.7893391
+ 3640.000079ps       2.8945568
+ 3650.000080ps       3.0114656
+ 3660.000081ps       3.2418196
+ 3670.000082ps        3.622259
+ 3680.000082ps        4.012804
+ 3690.000083ps       4.2811897
+ 3700.000084ps       4.3650832
+ 3710.000085ps       4.3989744
+ 3720.000086ps       4.4803742
+ 3729.999865ps       4.7093575
+ 3739.999865ps       5.1471943
+ 3749.999866ps       5.7210964
+ 3759.999867ps       6.2722017
+ 3769.999868ps       7.0853605
+ 3779.999869ps       8.0516701
+ 3789.999869ps       9.0986748
+ 3799.999870ps       10.020271
+ 3809.999871ps       10.887383
+ 3819.999872ps        11.34586
+ 3829.999873ps       11.489236
+ 3839.999874ps       11.515815
+ 3849.999874ps       11.453425
+ 3859.999875ps       11.281495
+ 3869.999876ps        11.00666
+ 3879.999877ps       10.528943
+ 3889.999878ps       9.9215023
+ 3899.999879ps        9.246794
+ 3909.999879ps       8.5666688
+ 3919.999880ps       7.8352515
+ 3929.999881ps        7.090425
+ 3939.999882ps       6.3605806
+ 3949.999883ps        5.749516
+ 3959.999884ps       5.3066038
+ 3969.999884ps       4.9758178
+ 3979.999885ps       4.7076484
+ 3989.999886ps       4.4455354
+ 3999.999887ps       4.1070849
+ 4009.999888ps        3.720856
+ 4019.999889ps       3.4156574
+ 4029.999889ps       3.1678796
+ 4039.999890ps       2.9570407
+ 4049.999891ps       2.8428486
+ 4059.999892ps       2.7789684
+ 4069.999893ps       2.7614344
+ 4079.999893ps       2.7562964
+ 4089.999894ps       2.7664581
+ 4099.999895ps       2.7726228
+ 4109.999896ps        2.791922
+ 4119.999897ps       2.8384867
+ 4129.999898ps       2.9464647
+ 4139.999898ps        3.039636
+ 4149.999899ps       3.1361862
+ 4159.999900ps       3.3493299
+ 4169.999901ps       3.7164608
+ 4179.999902ps       4.0718226
+ 4189.999903ps       4.3253627
+ 4199.999903ps       4.4121181
+ 4209.999904ps       4.4615835
+ 4219.999905ps       4.5456411
+ 4229.999906ps       4.7281052
+ 4239.999907ps       5.0972938
+ 4249.999908ps       5.5383641
+ 4259.999908ps       5.8436583
+ 4269.999909ps       6.2810755
+ 4279.999910ps       6.7780021
+ 4289.999911ps       7.2412962
+ 4299.999912ps       7.6111128
+ 4309.999913ps       7.9853393
+ 4319.999913ps       8.2650221
+ 4329.999914ps       8.5614585
+ 4339.999915ps       8.7023922
+ 4349.999916ps       8.6462289
+ 4359.999917ps       8.4538309
+ 4369.999917ps       8.1393258
+ 4379.999918ps       7.6895145
+ 4389.999919ps       7.1736832
+ 4399.999920ps       6.6506163
+ 4409.999921ps       6.1555102
+ 4419.999922ps       5.6773583
+ 4429.999922ps       5.2190898
+ 4439.999923ps       4.7568105
+ 4449.999924ps       4.3675836
+ 4459.999925ps       4.1162822
+ 4469.999926ps       3.9785099
+ 4479.999927ps       3.8756573
+ 4489.999927ps       3.7600188
+ 4499.999928ps       3.5412395
+ 4509.999929ps       3.2834838
+ 4519.999930ps       3.0902691
+ 4529.999931ps       2.9109324
+ 4539.999932ps       2.7251032
+ 4549.999932ps       2.6245643
+ 4559.999933ps       2.5789417
+ 4569.999934ps       2.5743423
+ 4579.999935ps       2.5793425
+ 4589.999936ps       2.5961622
+ 4599.999937ps       2.6171289
+ 4609.999937ps       2.6440348
+ 4619.999938ps       2.6923193
+ 4629.999939ps       2.8086113
+ 4639.999940ps         2.90566
+ 4649.999941ps         3.00683
+ 4659.999941ps       3.2354067
+ 4669.999942ps       3.6210119
+ 4679.999943ps       4.0097201
+ 4689.999944ps        4.270633
+ 4699.999945ps       4.3647397
+ 4709.999946ps        4.421723
+ 4719.999946ps       4.5172063
+ 4729.999947ps       4.7431595
+ 4739.999948ps       5.1371637
+ 4749.999949ps       5.6863036
+ 4759.999950ps       6.1784779
+ 4769.999951ps       6.9556595
+ 4779.999951ps       7.8641053
+ 4789.999952ps       8.8989551
+ 4799.999953ps       9.8751968
+ 4809.999954ps        10.78028
+ 4819.999955ps       11.266658
+ 4829.999956ps       11.474798
+ 4839.999956ps       11.548508
+ 4849.999957ps       11.506513
+ 4859.999958ps        11.31274
+ 4869.999959ps       11.006978
+ 4879.999960ps       10.497103
+ 4889.999961ps       9.8802508
+ 4899.999961ps       9.2062842
+ 4909.999962ps       8.5116353
+ 4919.999963ps        7.769592
+ 4929.999964ps       7.0192927
+ 4939.999965ps       6.2930829
+ 4949.999965ps       5.6692781
+ 4959.999966ps       5.2078374
+ 4969.999967ps       4.8858417
+ 4979.999968ps       4.6801315
+ 4989.999969ps       4.4724642
+ 4999.999970ps       4.1546264
+ 5009.999970ps       3.7473202
+ 5019.999971ps        3.436576
+ 5029.999972ps       3.1794136
+ 5039.999973ps       2.9711105
+ 5049.999974ps       2.8543274
+ 5059.999975ps       2.7849677
+ 5069.999975ps       2.7621165
+ 5079.999976ps       2.7481766
+ 5089.999977ps        2.758793
+ 5099.999978ps       2.7926269
+ 5109.999979ps       2.8060682
+ 5119.999980ps       2.8476831
+ 5129.999980ps        2.949016
+ 5139.999981ps       3.0400884
+ 5149.999982ps       3.1319512
+ 5159.999983ps       3.3614751
+ 5169.999984ps       3.7260001
+ 5179.999985ps       4.0762096
+ 5189.999985ps       4.3082894
+ 5199.999986ps       4.3693836
+ 5209.999987ps       4.3877221
+ 5219.999988ps       4.4366612
+ 5229.999989ps       4.5913875
+ 5239.999989ps       4.9408554
+ 5249.999990ps       5.3875692
+ 5259.999991ps       5.7425114
+ 5269.999992ps       6.2875761
+ 5279.999993ps       6.9132366
+ 5289.999994ps       7.5064542
+ 5299.999994ps       7.9891062
+ 5309.999995ps       8.4368464
+ 5319.999996ps       8.6796023
+ 5329.999997ps       8.8726478
+ 5339.999998ps       8.8800993
+ 5349.999999ps       8.7141002
+ 5359.999999ps       8.4231956
+ 5370.000000ps       8.0611974
+ 5380.000001ps       7.6150051
+ 5390.000002ps       7.1210207
+ 5400.000003ps       6.6331073
+ 5410.000004ps          6.1604
+ 5420.000004ps       5.7123352
+ 5430.000005ps       5.3001184
+ 5440.000006ps       4.9475198
+ 5450.000007ps       4.7056339
+ 5460.000008ps       4.5814174
+ 5470.000009ps       4.5103168
+ 5480.000009ps       4.4026749
+ 5490.000010ps       4.1933329
+ 5500.000011ps       3.8381066
+ 5510.000012ps       3.4319775
+ 5520.000013ps       3.1557362
+ 5530.000013ps       2.9373323
+ 5540.000014ps       2.7442194
+ 5550.000015ps       2.6361156
+ 5560.000016ps       2.5831799
+ 5570.000017ps       2.5771762
+ 5580.000018ps       2.5817546
+ 5590.000018ps       2.5995982
+ 5600.000019ps       2.6195663
+ 5610.000020ps       2.6465901
+ 5620.000021ps       2.6947736
+ 5630.000022ps       2.8083498
+ 5640.000023ps       2.9065908
+ 5650.000023ps       3.0078373
+ 5660.000024ps       3.2427262
+ 5670.000025ps       3.6266008
+ 5680.000026ps       4.0070016
+ 5690.000027ps       4.2810495
+ 5700.000028ps       4.3704598
+ 5710.000028ps       4.4395382
+ 5720.000029ps       4.5418119
+ 5730.000030ps       4.7836297
+ 5740.000031ps       5.2220511
+ 5750.000032ps       5.7715126
+ 5760.000032ps        6.308438
+ 5770.000033ps        7.086203
+ 5780.000034ps       7.9954613
+ 5790.000035ps       8.9930251
+ 5800.000036ps       9.9300529
+ 5810.000037ps       10.760397
+ 5820.000037ps       11.161842
+ 5830.000038ps       11.285873
+ 5840.000039ps       11.357609
+ 5850.000040ps       11.339765
+ 5860.000041ps       11.199119
+ 5870.000042ps       10.964204
+ 5880.000042ps       10.526032
+ 5890.000043ps       9.9277714
+ 5900.000044ps       9.2433704
+ 5910.000045ps       8.5454017
+ 5920.000046ps        7.800142
+ 5930.000047ps       7.0450529
+ 5940.000047ps        6.292126
+ 5950.000048ps       5.6587818
+ 5960.000049ps       5.1559704
+ 5970.000050ps       4.7926757
+ 5980.000051ps       4.4812885
+ 5990.000052ps       4.2056086
+ 6000.000052ps       3.8582682
+ 6010.000053ps       3.5078232
+ 6020.000054ps       3.2680468
+ 6030.000055ps       3.0756297
+ 6040.000056ps       2.8885079
+ 6050.000056ps       2.7876588
+ 6060.000057ps       2.7331009
+ 6070.000058ps       2.7184854
+ 6080.000059ps       2.7167396
+ 6090.000060ps       2.7317385
+ 6100.000061ps        2.741458
+ 6110.000061ps       2.7615857
+ 6120.000062ps       2.8175684
+ 6130.000063ps       2.9353144
+ 6140.000064ps       3.0295222
+ 6150.000065ps       3.1226449
+ 6160.000066ps       3.3292575
+ 6170.000066ps       3.6943569
+ 6180.000067ps       4.0451426
+ 6190.000068ps       4.2868314
+ 6200.000069ps       4.3566673
+ 6210.000070ps       4.3781542
+ 6220.000071ps       4.4354795
+ 6230.000071ps       4.5942095
+ 6240.000072ps       4.9316451
+ 6250.000073ps       5.3411554
+ 6260.000074ps       5.6349609
+ 6270.000075ps       6.0942851
+ 6280.000076ps       6.6189282
+ 6290.000076ps       7.1167997
+ 6300.000077ps       7.5224731
+ 6310.000078ps       7.9130112
+ 6320.000079ps       8.1752972
+ 6330.000080ps       8.4393483
+ 6340.000080ps        8.554633
+ 6350.000081ps       8.4904037
+ 6360.000082ps       8.2905391
+ 6370.000083ps       7.9572451
+ 6380.000084ps       7.5066239
+ 6390.000085ps        6.972524
+ 6400.000085ps       6.4517697
+ 6410.000086ps       5.9267968
+ 6420.000087ps       5.4231625
+ 6430.000088ps       4.9507239
+ 6440.000089ps       4.5286344
+ 6450.000090ps       4.2074996
+ 6460.000090ps       4.0132435
+ 6470.000091ps       3.8969985
+ 6480.000092ps       3.7872602
+ 6490.000093ps       3.6600283
+ 6500.000094ps       3.4357009
+ 6510.000095ps       3.1824152
+ 6520.000095ps       2.9941957
+ 6530.000096ps       2.8353558
+ 6540.000097ps       2.6762498
+ 6550.000098ps       2.6065819
+ 6560.000099ps       2.5758703
+ 6570.000100ps       2.5797423
+ 6580.000100ps       2.5868693
+ 6590.000101ps       2.6040433
+ 6600.000102ps       2.6242998
+ 6610.000103ps       2.6533396
+ 6620.000104ps       2.7060759
+ 6630.000104ps       2.8265104
+ 6640.000105ps       2.9305909
+ 6650.000106ps       3.0349815
+ 6660.000107ps       3.2628942
+ 6670.000108ps       3.6531791
+ 6680.000109ps       4.0327927
+ 6690.000109ps       4.3049317
+ 6700.000110ps       4.3884772
+ 6710.000111ps       4.4483063
+ 6720.000112ps       4.5563942
+ 6730.000113ps       4.7854915
+ 6740.000114ps       5.2282281
+ 6750.000114ps       5.8071996
+ 6760.000115ps       6.3559259
+ 6770.000116ps       7.1198021
+ 6780.000117ps       8.0513543
+ 6790.000118ps       9.0579992
+ 6800.000119ps       9.9995288
+ 6810.000119ps       10.820934
+ 6820.000120ps       11.239931
+ 6830.000121ps       11.409885
+ 6840.000122ps       11.501272
+ 6850.000123ps        11.48858
+ 6860.000124ps       11.340006
+ 6870.000124ps       11.081168
+ 6880.000125ps        10.60913
+ 6890.000126ps       9.9762713
+ 6900.000127ps       9.2809018
+ 6910.000128ps       8.5792177
+ 6920.000128ps       7.8368654
+ 6930.000129ps       7.0829539
+ 6940.000130ps       6.3388701
+ 6950.000131ps        5.719283
+ 6960.000132ps       5.2439478
+ 6970.000133ps       4.9279461
+ 6980.000133ps       4.6571562
+ 6990.000134ps       4.3890587
+ 7000.000135ps       4.0322998
+ 7010.000136ps       3.6863392
+ 7020.000137ps       3.4474515
+ 7030.000138ps       3.2356155
+ 7040.000138ps       3.0132138
+ 7050.000139ps       2.8722233
+ 7060.000140ps       2.7963724
+ 7070.000141ps       2.7706743
+ 7080.000142ps       2.7587934
+ 7090.000143ps       2.7699517
+ 7100.000143ps       2.8017375
+ 7110.000144ps       2.8072657
+ 7120.000145ps       2.8441433
+ 7130.000146ps       2.9554114
+ 7140.000147ps       3.0535084
+ 7150.000148ps       3.1494275
+ 7160.000148ps       3.3766942
+ 7170.000149ps       3.7437121
+ 7180.000150ps       4.0847913
+ 7190.000151ps       4.3140858
+ 7200.000152ps       4.3747807
+ 7210.000152ps       4.3897448
+ 7220.000153ps       4.4324882
+ 7230.000154ps       4.5851586
+ 7240.000155ps       4.9222144
+ 7250.000156ps       5.3267247
+ 7260.000157ps       5.6261989
+ 7270.000157ps       6.1069126
+ 7280.000158ps       6.6587241
+ 7290.000159ps       7.1807728
+ 7300.000160ps        7.611426
+ 7310.000161ps       8.0071494
+ 7320.000162ps         8.26637
+ 7330.000162ps       8.4973128
+ 7340.000163ps       8.5683184
+ 7350.000164ps       8.4603159
+ 7360.000165ps       8.2445025
+ 7370.000166ps        7.905521
+ 7380.000167ps        7.456261
+ 7390.000167ps       6.9473813
+ 7400.000168ps       6.4349452
+ 7410.000169ps       5.9122543
+ 7420.000170ps       5.4227909
+ 7430.000171ps       4.9742847
+ 7440.000171ps       4.5738923
+ 7450.000172ps       4.2741491
+ 7459.999729ps       4.1022675
+ 7469.999730ps       3.9980165
+ 7479.999731ps       3.8768767
+ 7489.999732ps         3.73464
+ 7499.999732ps       3.4641058
+ 7509.999733ps       3.1736375
+ 7519.999734ps       2.9665663
+ 7529.999735ps       2.8074146
+ 7539.999736ps       2.6612012
+ 7549.999737ps       2.5922711
+ 7559.999737ps       2.5619225
+ 7569.999738ps       2.5685478
+ 7579.999739ps       2.5789465
+ 7589.999740ps       2.5972434
+ 7599.999741ps       2.6170969
+ 7609.999741ps       2.6416247
+ 7619.999742ps       2.6895758
+ 7629.999743ps       2.8064969
+ 7639.999744ps          2.9081
+ 7649.999745ps       3.0219099
+ 7659.999746ps       3.2502284
+ 7669.999746ps        3.633344
+ 7679.999747ps       4.0107611
+ 7689.999748ps       4.2861127
+ 7699.999749ps       4.3687863
+ 7709.999750ps       4.4209065
+ 7719.999751ps       4.5225846
+ 7729.999751ps       4.7330644
+ 7739.999752ps       5.1292441
+ 7749.999753ps       5.6653884
+ 7759.999754ps       6.1364492
+ 7769.999755ps       6.8644457
+ 7779.999756ps       7.7947723
+ 7789.999756ps       8.8429022
+ 7799.999757ps        9.837014
+ 7809.999758ps        10.73367
+ 7819.999759ps       11.223876
+ 7829.999760ps       11.418379
+ 7839.999761ps       11.489174
+ 7849.999761ps        11.44212
+ 7859.999762ps       11.263962
+ 7869.999763ps        10.96996
+ 7879.999764ps       10.494665
+ 7889.999765ps       9.8517491
+ 7899.999765ps        9.146667
+ 7909.999766ps       8.4284204
+ 7919.999767ps       7.6737824
+ 7929.999768ps       6.9132191
+ 7939.999769ps       6.1738592
+ 7949.999770ps       5.5608137
+ 7959.999770ps       5.1208656
+ 7969.999771ps       4.8307705
+ 7979.999772ps       4.5933038
+ 7989.999773ps       4.3849864
+ 7999.999774ps        4.085752
+ 8009.999775ps       3.8979171
+ 8019.999775ps       3.7871782
+ 8029.999776ps       3.7097428
+ 8039.999777ps       3.6546998
+ 8049.999778ps       3.6143119
+ 8059.999779ps       3.5838371
+ 8069.999780ps       3.5602243
+ 8079.999780ps       3.5414849
+ 8089.999781ps       3.5262911
+ 8099.999782ps        3.513736
+ 8109.999783ps        3.503187
+ 8119.999784ps        3.494193
+ 8129.999785ps       3.4864264
+ 8139.999785ps       3.4796438
+ 8149.999786ps       3.4736619
+ 8159.999787ps       3.4683397
+ 8169.999788ps       3.4635673
+ 8179.999789ps       3.4592578
+ 8189.999789ps       3.4553414
+ 8199.999790ps       3.4517619
+ 8209.999791ps       3.4484728
+ 8219.999792ps        3.445436
+ 8229.999793ps       3.4426198
+ 8239.999794ps       3.4399972
+ 8249.999794ps       3.4375457
+ 8259.999795ps       3.4352462
+ 8269.999796ps       3.4330821
+ 8279.999797ps       3.4310394
+ 8289.999798ps       3.4291059
+ 8299.999799ps        3.427271
+ 8309.999799ps       3.4255255
+)

Icursig8 PAR_0_1_VSS 0 pwl(
+ 0.000000ps      -9.1415842
+ 10.000000ps      -9.6414053
+ 20.000000ps      -10.846887
+ 29.999999ps      -12.385311
+ 40.000000ps      -14.101521
+ 50.000001ps      -16.112616
+ 59.999998ps      -18.292425
+ 69.999999ps      -20.436531
+ 80.000000ps      -22.423051
+ 90.000001ps        -24.1396
+ 100.000001ps      -25.537263
+ 110.000002ps      -26.530713
+ 119.999996ps      -27.017814
+ 129.999997ps       -27.00054
+ 139.999998ps      -26.534695
+ 149.999999ps      -25.763425
+ 159.999999ps      -24.680251
+ 170.000000ps      -23.316459
+ 180.000001ps      -21.826432
+ 190.000002ps      -20.266151
+ 200.000003ps      -18.763536
+ 210.000003ps      -17.411193
+ 220.000004ps      -16.248282
+ 230.000005ps      -15.323083
+ 239.999992ps      -14.637385
+ 249.999993ps      -14.279232
+ 259.999994ps      -14.378648
+ 269.999995ps      -15.532471
+ 279.999995ps      -17.739774
+ 289.999996ps      -20.121612
+ 299.999997ps      -22.356984
+ 309.999998ps      -24.240997
+ 319.999999ps      -25.719834
+ 330.000000ps      -26.791444
+ 340.000000ps      -27.463425
+ 350.000001ps          -27.68
+ 360.000002ps      -27.418642
+ 370.000003ps        -26.6448
+ 380.000004ps      -25.437217
+ 390.000005ps      -23.806378
+ 400.000005ps      -21.955059
+ 410.000006ps      -20.130073
+ 420.000007ps       -18.30758
+ 430.000008ps      -16.661789
+ 440.000009ps      -15.193879
+ 450.000009ps      -13.929566
+ 460.000010ps       -12.90406
+ 469.999983ps      -12.111226
+ 479.999984ps      -11.544316
+ 489.999985ps      -11.238429
+ 499.999986ps      -11.245014
+ 509.999987ps       -11.67498
+ 519.999988ps      -12.662973
+ 529.999988ps      -13.974961
+ 539.999989ps      -15.459873
+ 549.999990ps      -17.269854
+ 559.999991ps      -19.263161
+ 569.999992ps      -21.251491
+ 579.999992ps      -23.106576
+ 589.999993ps      -24.704372
+ 599.999994ps      -26.018456
+ 609.999995ps      -26.963121
+ 619.999996ps      -27.376228
+ 629.999997ps      -27.294225
+ 639.999997ps      -26.768047
+ 649.999998ps      -25.946621
+ 659.999999ps      -24.846544
+ 670.000000ps      -23.468343
+ 680.000001ps      -21.990506
+ 690.000002ps      -20.412103
+ 700.000002ps      -18.902664
+ 710.000003ps      -17.567738
+ 720.000004ps      -16.402271
+ 730.000005ps      -15.460063
+ 740.000006ps      -14.768932
+ 750.000007ps      -14.405427
+ 760.000007ps      -14.516502
+ 770.000008ps      -15.685033
+ 780.000009ps        -17.8445
+ 790.000010ps       -20.17587
+ 800.000011ps      -22.394364
+ 810.000012ps      -24.273125
+ 820.000012ps      -25.736065
+ 830.000013ps      -26.806362
+ 840.000014ps      -27.485646
+ 850.000015ps       -27.70395
+ 860.000016ps      -27.444321
+ 870.000016ps      -26.682144
+ 880.000017ps      -25.474248
+ 890.000018ps      -23.833184
+ 900.000019ps      -21.974076
+ 910.000020ps      -20.153894
+ 920.000021ps       -18.32728
+ 930.000021ps      -16.667092
+ 939.999967ps       -15.19293
+ 949.999968ps      -13.924728
+ 959.999968ps      -12.901016
+ 969.999969ps      -12.097511
+ 979.999970ps      -11.527553
+ 989.999971ps      -11.207575
+ 999.999972ps      -11.191681
+ 1009.999973ps      -11.641668
+ 1019.999973ps       -12.66592
+ 1029.999974ps      -13.991705
+ 1039.999975ps      -15.494693
+ 1049.999976ps      -17.298801
+ 1059.999977ps      -19.304029
+ 1069.999978ps      -21.285733
+ 1079.999978ps      -23.128117
+ 1089.999979ps      -24.733218
+ 1099.999980ps      -26.039284
+ 1109.999981ps      -26.955396
+ 1119.999982ps      -27.363884
+ 1129.999982ps        -27.3282
+ 1139.999983ps      -26.847905
+ 1149.999984ps      -26.052182
+ 1159.999985ps      -24.978128
+ 1169.999986ps      -23.665129
+ 1179.999987ps      -22.206244
+ 1189.999987ps      -20.667727
+ 1199.999988ps       -19.14725
+ 1209.999989ps      -17.756644
+ 1219.999990ps      -16.590135
+ 1229.999991ps      -15.622865
+ 1239.999992ps      -14.905845
+ 1249.999992ps       -14.50107
+ 1259.999993ps      -14.575517
+ 1269.999994ps      -15.719553
+ 1279.999995ps      -17.845534
+ 1289.999996ps      -20.173271
+ 1299.999997ps      -22.397202
+ 1309.999997ps      -24.280412
+ 1319.999998ps      -25.755155
+ 1329.999999ps      -26.816543
+ 1340.000000ps      -27.488095
+ 1350.000001ps      -27.711956
+ 1360.000002ps      -27.460142
+ 1370.000002ps      -26.703397
+ 1380.000003ps      -25.504767
+ 1390.000004ps      -23.890031
+ 1400.000005ps      -22.044529
+ 1410.000006ps      -20.235838
+ 1420.000006ps      -18.434885
+ 1430.000007ps      -16.799381
+ 1440.000008ps      -15.346887
+ 1450.000009ps      -14.104029
+ 1460.000010ps      -13.097255
+ 1470.000011ps       -12.29506
+ 1480.000011ps      -11.716265
+ 1490.000012ps      -11.378102
+ 1500.000013ps      -11.334865
+ 1510.000014ps      -11.751531
+ 1520.000015ps      -12.762778
+ 1530.000016ps      -14.084778
+ 1540.000016ps       -15.60274
+ 1550.000017ps       -17.44837
+ 1560.000018ps      -19.460115
+ 1570.000019ps      -21.462546
+ 1580.000020ps      -23.320856
+ 1590.000021ps      -24.945648
+ 1600.000021ps      -26.258431
+ 1610.000022ps      -27.162997
+ 1620.000023ps      -27.583908
+ 1630.000024ps      -27.535048
+ 1640.000025ps      -27.024978
+ 1650.000025ps      -26.200444
+ 1660.000026ps      -25.119626
+ 1670.000027ps      -23.767996
+ 1680.000028ps      -22.315644
+ 1690.000029ps       -20.78028
+ 1700.000030ps      -19.310752
+ 1710.000030ps      -17.975652
+ 1720.000031ps      -16.817913
+ 1730.000032ps      -15.880237
+ 1740.000033ps      -15.151928
+ 1750.000034ps      -14.768001
+ 1760.000035ps      -14.857604
+ 1770.000035ps      -15.972065
+ 1780.000036ps      -18.103494
+ 1790.000037ps      -20.414241
+ 1800.000038ps      -22.579755
+ 1810.000039ps       -24.40904
+ 1820.000040ps      -25.866045
+ 1830.000040ps      -26.921837
+ 1840.000041ps      -27.582215
+ 1850.000042ps      -27.803309
+ 1860.000043ps       -27.53866
+ 1869.999933ps      -26.785326
+ 1879.999934ps      -25.598869
+ 1889.999934ps      -23.984487
+ 1899.999935ps      -22.131085
+ 1909.999936ps      -20.315599
+ 1919.999937ps       -18.49529
+ 1929.999938ps      -16.839004
+ 1939.999938ps      -15.351027
+ 1949.999939ps      -14.073011
+ 1959.999940ps      -13.028494
+ 1969.999941ps      -12.228998
+ 1979.999942ps      -11.662779
+ 1989.999943ps      -11.345045
+ 1999.999943ps      -11.348307
+ 2009.999944ps      -11.794971
+ 2019.999945ps      -12.817145
+ 2029.999946ps      -14.182673
+ 2039.999947ps      -15.706124
+ 2049.999948ps      -17.551217
+ 2059.999948ps       -19.59245
+ 2069.999949ps      -21.628868
+ 2079.999950ps      -23.521604
+ 2089.999951ps      -25.184642
+ 2099.999952ps      -26.499787
+ 2109.999953ps      -27.368319
+ 2119.999953ps      -27.737706
+ 2129.999954ps      -27.610165
+ 2139.999955ps      -27.067902
+ 2149.999956ps        -26.2345
+ 2159.999957ps      -25.169696
+ 2169.999958ps      -23.869508
+ 2179.999958ps      -22.462182
+ 2189.999959ps      -20.990608
+ 2199.999960ps      -19.504516
+ 2209.999961ps      -18.145006
+ 2219.999962ps      -16.976199
+ 2229.999962ps       -16.03324
+ 2239.999963ps      -15.325209
+ 2249.999964ps        -14.9288
+ 2259.999965ps      -14.945742
+ 2269.999966ps      -16.001342
+ 2279.999967ps      -18.077371
+ 2289.999967ps      -20.369904
+ 2299.999968ps      -22.573651
+ 2309.999969ps      -24.432572
+ 2319.999970ps       -25.88917
+ 2329.999971ps       -26.94669
+ 2339.999972ps      -27.604219
+ 2349.999972ps      -27.812782
+ 2359.999973ps      -27.544543
+ 2369.999974ps       -26.76365
+ 2379.999975ps      -25.553613
+ 2389.999976ps      -23.919828
+ 2399.999977ps      -22.057795
+ 2409.999977ps      -20.239422
+ 2419.999978ps      -18.430314
+ 2429.999979ps      -16.777621
+ 2439.999980ps      -15.313179
+ 2449.999981ps      -14.051324
+ 2459.999981ps      -13.020191
+ 2469.999982ps      -12.227604
+ 2479.999983ps      -11.667608
+ 2489.999984ps      -11.330063
+ 2499.999985ps      -11.300861
+ 2509.999986ps       -11.72865
+ 2519.999986ps      -12.747639
+ 2529.999987ps      -14.050594
+ 2539.999988ps      -15.539955
+ 2549.999989ps      -17.358686
+ 2559.999990ps      -19.362748
+ 2569.999991ps      -21.363562
+ 2579.999991ps      -23.217145
+ 2589.999992ps      -24.837817
+ 2599.999993ps      -26.159653
+ 2609.999994ps      -27.064445
+ 2619.999995ps      -27.448079
+ 2629.999996ps      -27.369106
+ 2639.999996ps       -26.86831
+ 2649.999997ps      -26.049882
+ 2659.999998ps      -24.952011
+ 2669.999999ps      -23.621002
+ 2680.000000ps      -22.172788
+ 2690.000001ps      -20.625381
+ 2700.000001ps      -19.102934
+ 2710.000002ps      -17.738434
+ 2720.000003ps      -16.581161
+ 2730.000004ps      -15.656134
+ 2740.000005ps       -14.94554
+ 2750.000005ps       -14.55285
+ 2760.000006ps      -14.656236
+ 2770.000007ps      -15.778837
+ 2780.000008ps      -17.885085
+ 2790.000009ps      -20.194482
+ 2800.000010ps      -22.392433
+ 2810.000010ps       -24.27121
+ 2820.000011ps      -25.740988
+ 2830.000012ps      -26.798337
+ 2840.000013ps      -27.457386
+ 2850.000014ps       -27.66192
+ 2860.000015ps      -27.393759
+ 2870.000015ps      -26.617545
+ 2880.000016ps       -25.40136
+ 2890.000017ps      -23.758707
+ 2900.000018ps      -21.894449
+ 2910.000019ps      -20.062296
+ 2920.000020ps      -18.238372
+ 2930.000020ps      -16.580732
+ 2940.000021ps      -15.103311
+ 2950.000022ps      -13.834802
+ 2960.000023ps      -12.811732
+ 2970.000024ps      -12.014072
+ 2980.000025ps      -11.449836
+ 2990.000025ps      -11.133284
+ 3000.000026ps      -11.111056
+ 3010.000027ps      -11.546282
+ 3020.000028ps      -12.551721
+ 3030.000029ps      -13.872546
+ 3040.000029ps      -15.364379
+ 3050.000030ps      -17.159966
+ 3060.000031ps      -19.147678
+ 3070.000032ps       -21.12878
+ 3080.000033ps      -22.971398
+ 3090.000034ps      -24.581692
+ 3100.000034ps      -25.883778
+ 3110.000035ps      -26.786797
+ 3120.000036ps      -27.209591
+ 3130.000037ps      -27.169406
+ 3140.000038ps      -26.677648
+ 3150.000039ps      -25.871267
+ 3160.000039ps      -24.787059
+ 3170.000040ps      -23.434189
+ 3180.000041ps      -21.964939
+ 3190.000042ps      -20.435834
+ 3200.000043ps      -18.931765
+ 3210.000044ps        -17.5554
+ 3220.000044ps      -16.394237
+ 3230.000045ps      -15.447913
+ 3240.000046ps      -14.730424
+ 3250.000047ps      -14.337223
+ 3260.000048ps      -14.416845
+ 3270.000049ps      -15.559328
+ 3280.000049ps      -17.729658
+ 3290.000050ps      -20.075679
+ 3300.000051ps      -22.314776
+ 3310.000052ps       -24.20112
+ 3320.000053ps       -25.68022
+ 3330.000053ps      -26.750354
+ 3340.000054ps      -27.420098
+ 3350.000055ps       -27.63858
+ 3360.000056ps      -27.377455
+ 3370.000057ps      -26.609738
+ 3380.000058ps      -25.409275
+ 3390.000058ps      -23.783752
+ 3400.000059ps      -21.935553
+ 3410.000060ps      -20.127046
+ 3420.000061ps      -18.325036
+ 3430.000062ps      -16.687738
+ 3440.000063ps        -15.2254
+ 3450.000063ps      -13.953395
+ 3460.000064ps      -12.912808
+ 3470.000065ps      -12.094856
+ 3480.000066ps      -11.517164
+ 3490.000067ps      -11.196131
+ 3500.000068ps      -11.186799
+ 3510.000068ps      -11.622081
+ 3520.000069ps       -12.63199
+ 3530.000070ps      -13.958935
+ 3540.000071ps      -15.466538
+ 3550.000072ps      -17.297499
+ 3560.000073ps      -19.314384
+ 3570.000073ps      -21.324736
+ 3580.000074ps      -23.199341
+ 3590.000075ps      -24.801981
+ 3600.000076ps       -26.09187
+ 3610.000077ps      -26.999899
+ 3620.000077ps      -27.399304
+ 3630.000078ps      -27.327994
+ 3640.000079ps      -26.825846
+ 3650.000080ps      -26.021241
+ 3660.000081ps      -24.917418
+ 3670.000082ps      -23.569068
+ 3680.000082ps       -22.09928
+ 3690.000083ps       -20.59518
+ 3700.000084ps      -19.119712
+ 3710.000085ps      -17.800253
+ 3720.000086ps      -16.654466
+ 3729.999865ps        -15.7057
+ 3739.999865ps      -14.980751
+ 3749.999866ps      -14.567211
+ 3759.999867ps      -14.625096
+ 3769.999868ps      -15.765385
+ 3779.999869ps      -17.901137
+ 3789.999869ps      -20.211914
+ 3799.999870ps      -22.397661
+ 3809.999871ps      -24.257233
+ 3819.999872ps      -25.710798
+ 3829.999873ps      -26.771855
+ 3839.999874ps      -27.447595
+ 3849.999874ps        -27.6667
+ 3859.999875ps      -27.413339
+ 3869.999876ps       -26.65356
+ 3879.999877ps      -25.447763
+ 3889.999878ps      -23.815426
+ 3899.999879ps      -21.962758
+ 3909.999879ps      -20.147941
+ 3919.999880ps      -18.331885
+ 3929.999881ps       -16.67694
+ 3939.999882ps       -15.19968
+ 3949.999883ps       -13.93881
+ 3959.999884ps       -12.91195
+ 3969.999884ps      -12.120181
+ 3979.999885ps      -11.555907
+ 3989.999886ps      -11.250847
+ 3999.999887ps      -11.256045
+ 4009.999888ps      -11.711232
+ 4019.999889ps      -12.770115
+ 4029.999889ps      -14.147243
+ 4039.999890ps      -15.710387
+ 4049.999891ps       -17.56642
+ 4059.999892ps      -19.587028
+ 4069.999893ps      -21.587945
+ 4079.999893ps      -23.416762
+ 4089.999894ps      -25.020175
+ 4099.999895ps      -26.289528
+ 4109.999896ps      -27.177617
+ 4119.999897ps       -27.57435
+ 4129.999898ps      -27.533968
+ 4139.999898ps      -27.044165
+ 4149.999899ps      -26.244545
+ 4159.999900ps      -25.197321
+ 4169.999901ps      -23.884878
+ 4179.999902ps      -22.441068
+ 4189.999903ps      -20.939968
+ 4199.999903ps      -19.451087
+ 4209.999904ps      -18.101851
+ 4219.999905ps      -16.929131
+ 4229.999906ps      -15.960283
+ 4239.999907ps      -15.205124
+ 4249.999908ps      -14.775988
+ 4259.999908ps      -14.795792
+ 4269.999909ps      -15.887915
+ 4279.999910ps      -18.046269
+ 4289.999911ps      -20.395288
+ 4299.999912ps       -22.59543
+ 4309.999913ps      -24.432369
+ 4319.999913ps      -25.864717
+ 4329.999914ps      -26.909445
+ 4339.999915ps      -27.561392
+ 4349.999916ps      -27.770641
+ 4359.999917ps      -27.504697
+ 4369.999917ps      -26.731074
+ 4379.999918ps      -25.513058
+ 4389.999919ps       -23.88477
+ 4399.999920ps      -22.030548
+ 4409.999921ps      -20.211691
+ 4419.999922ps      -18.400285
+ 4429.999922ps      -16.753049
+ 4439.999923ps      -15.285288
+ 4449.999924ps      -14.028464
+ 4459.999925ps      -13.002776
+ 4469.999926ps      -12.203445
+ 4479.999927ps       -11.61461
+ 4489.999927ps      -11.254703
+ 4499.999928ps      -11.204509
+ 4509.999929ps       -11.62265
+ 4519.999930ps       -12.63488
+ 4529.999931ps      -13.949746
+ 4539.999932ps      -15.457981
+ 4549.999932ps      -17.300883
+ 4559.999933ps      -19.335271
+ 4569.999934ps      -21.339935
+ 4579.999935ps      -23.181092
+ 4589.999936ps      -24.773953
+ 4599.999937ps      -26.049381
+ 4609.999937ps      -26.925917
+ 4619.999938ps      -27.325459
+ 4629.999939ps      -27.263802
+ 4639.999940ps      -26.776015
+ 4649.999941ps      -25.973678
+ 4659.999941ps      -24.880651
+ 4669.999942ps      -23.552791
+ 4679.999943ps      -22.087322
+ 4689.999944ps      -20.548807
+ 4699.999945ps      -19.075075
+ 4709.999946ps      -17.736799
+ 4719.999946ps      -16.600348
+ 4729.999947ps      -15.657918
+ 4739.999948ps      -14.914709
+ 4749.999949ps      -14.492876
+ 4759.999950ps      -14.554602
+ 4769.999951ps      -15.680065
+ 4779.999951ps      -17.829064
+ 4789.999952ps      -20.166314
+ 4799.999953ps      -22.374922
+ 4809.999954ps      -24.244189
+ 4819.999955ps      -25.701226
+ 4829.999956ps      -26.759022
+ 4839.999956ps      -27.424045
+ 4849.999957ps      -27.640059
+ 4859.999958ps      -27.381123
+ 4869.999959ps       -26.62124
+ 4879.999960ps      -25.426485
+ 4889.999961ps       -23.80318
+ 4899.999961ps      -21.959314
+ 4909.999962ps      -20.150632
+ 4919.999963ps      -18.345548
+ 4929.999964ps      -16.705173
+ 4939.999965ps      -15.228025
+ 4949.999965ps      -13.951768
+ 4959.999966ps      -12.911814
+ 4969.999967ps      -12.095682
+ 4979.999968ps      -11.514395
+ 4989.999969ps      -11.166926
+ 4999.999970ps      -11.139039
+ 5009.999970ps      -11.554582
+ 5019.999971ps      -12.550103
+ 5029.999972ps      -13.869054
+ 5039.999973ps      -15.371286
+ 5049.999974ps      -17.201327
+ 5059.999975ps      -19.208539
+ 5069.999975ps      -21.215541
+ 5079.999976ps       -23.06616
+ 5089.999977ps      -24.704927
+ 5099.999978ps      -26.079108
+ 5109.999979ps      -27.015375
+ 5119.999980ps      -27.436425
+ 5129.999980ps      -27.384694
+ 5139.999981ps      -26.866216
+ 5149.999982ps      -26.012625
+ 5159.999983ps      -24.915062
+ 5169.999984ps      -23.561093
+ 5179.999985ps      -22.087039
+ 5189.999985ps      -20.556765
+ 5199.999986ps      -19.054995
+ 5209.999987ps      -17.695991
+ 5219.999988ps      -16.524661
+ 5229.999989ps      -15.582736
+ 5239.999989ps      -14.891463
+ 5249.999990ps      -14.532644
+ 5259.999991ps      -14.672596
+ 5269.999992ps       -15.81473
+ 5279.999993ps      -17.925833
+ 5289.999994ps       -20.23233
+ 5299.999994ps      -22.419168
+ 5309.999995ps      -24.272147
+ 5319.999996ps       -25.71139
+ 5329.999997ps      -26.753808
+ 5339.999998ps      -27.415805
+ 5349.999999ps      -27.630457
+ 5359.999999ps      -27.368129
+ 5370.000000ps      -26.602024
+ 5380.000001ps      -25.408328
+ 5390.000002ps      -23.789847
+ 5400.000003ps      -21.948696
+ 5410.000004ps      -20.136483
+ 5420.000004ps      -18.332011
+ 5430.000005ps       -16.68055
+ 5440.000006ps      -15.215825
+ 5450.000007ps      -13.947459
+ 5460.000008ps      -12.915959
+ 5470.000009ps       -12.09404
+ 5480.000009ps      -11.519478
+ 5490.000010ps      -11.184871
+ 5500.000011ps      -11.173722
+ 5510.000012ps       -11.61199
+ 5520.000013ps       -12.62444
+ 5530.000013ps        -13.9572
+ 5540.000014ps      -15.455089
+ 5550.000015ps      -17.284789
+ 5560.000016ps       -19.27263
+ 5570.000017ps      -21.248951
+ 5580.000018ps      -23.096791
+ 5590.000018ps      -24.717268
+ 5600.000019ps      -26.057167
+ 5610.000020ps      -26.994009
+ 5620.000021ps      -27.429023
+ 5630.000022ps      -27.379612
+ 5640.000023ps      -26.889355
+ 5650.000023ps      -26.069134
+ 5660.000024ps      -24.978578
+ 5670.000025ps      -23.613114
+ 5680.000026ps      -22.141107
+ 5690.000027ps      -20.620542
+ 5700.000028ps      -19.117573
+ 5710.000028ps      -17.743272
+ 5720.000029ps      -16.546239
+ 5730.000030ps      -15.591371
+ 5740.000031ps      -14.884361
+ 5750.000032ps      -14.529645
+ 5760.000032ps      -14.647152
+ 5770.000033ps      -15.780223
+ 5780.000034ps      -17.929669
+ 5790.000035ps      -20.239961
+ 5800.000036ps       -22.42197
+ 5810.000037ps       -24.25491
+ 5820.000037ps       -25.68989
+ 5830.000038ps      -26.747099
+ 5840.000039ps      -27.418645
+ 5850.000040ps      -27.649559
+ 5860.000041ps      -27.401677
+ 5870.000042ps      -26.652669
+ 5880.000042ps      -25.461927
+ 5890.000043ps      -23.849984
+ 5900.000044ps      -22.009904
+ 5910.000045ps      -20.202246
+ 5920.000046ps      -18.393272
+ 5930.000047ps      -16.741857
+ 5940.000047ps      -15.269113
+ 5950.000048ps      -13.974342
+ 5960.000049ps      -12.926993
+ 5970.000050ps      -12.079664
+ 5980.000051ps      -11.471784
+ 5990.000052ps      -11.131664
+ 6000.000052ps      -11.125725
+ 6010.000053ps      -11.593591
+ 6020.000054ps      -12.654963
+ 6030.000055ps      -14.030571
+ 6040.000056ps      -15.582572
+ 6050.000056ps      -17.434828
+ 6060.000057ps      -19.437816
+ 6070.000058ps      -21.411412
+ 6080.000059ps      -23.185471
+ 6090.000060ps      -24.715189
+ 6100.000061ps      -25.946785
+ 6110.000061ps      -26.831819
+ 6120.000062ps      -27.246474
+ 6130.000063ps      -27.232327
+ 6140.000064ps      -26.789149
+ 6150.000065ps      -26.029059
+ 6160.000066ps      -24.960074
+ 6170.000066ps      -23.637708
+ 6180.000067ps      -22.205285
+ 6190.000068ps      -20.693226
+ 6200.000069ps      -19.227941
+ 6210.000070ps      -17.857176
+ 6220.000071ps      -16.641143
+ 6230.000071ps      -15.624032
+ 6240.000072ps      -14.819575
+ 6250.000073ps      -14.361929
+ 6260.000074ps      -14.406626
+ 6270.000075ps      -15.568206
+ 6280.000076ps      -17.751588
+ 6290.000076ps      -20.124702
+ 6300.000077ps      -22.350791
+ 6310.000078ps       -24.23425
+ 6320.000079ps      -25.702733
+ 6330.000080ps      -26.768038
+ 6340.000080ps      -27.444198
+ 6350.000081ps      -27.665177
+ 6360.000082ps      -27.411962
+ 6370.000083ps      -26.656768
+ 6380.000084ps      -25.471243
+ 6390.000085ps      -23.857663
+ 6400.000085ps      -22.022885
+ 6410.000086ps      -20.227442
+ 6420.000087ps      -18.413638
+ 6430.000088ps      -16.758713
+ 6440.000089ps      -15.287966
+ 6450.000090ps      -14.023642
+ 6460.000090ps      -12.974883
+ 6470.000091ps      -12.168745
+ 6480.000092ps       -11.59849
+ 6490.000093ps       -11.25779
+ 6500.000094ps      -11.228825
+ 6510.000095ps      -11.644172
+ 6520.000095ps      -12.629832
+ 6530.000096ps      -13.922849
+ 6540.000097ps      -15.410361
+ 6550.000098ps      -17.207311
+ 6560.000099ps      -19.196743
+ 6570.000100ps      -21.179424
+ 6580.000100ps       -23.04454
+ 6590.000101ps      -24.643375
+ 6600.000102ps      -25.942154
+ 6610.000103ps      -26.852981
+ 6620.000104ps      -27.261074
+ 6630.000104ps      -27.214904
+ 6640.000105ps      -26.734691
+ 6650.000106ps      -25.952666
+ 6660.000107ps      -24.868187
+ 6670.000108ps      -23.503897
+ 6680.000109ps      -22.023821
+ 6690.000109ps      -20.465071
+ 6700.000110ps       -18.93322
+ 6710.000111ps      -17.548712
+ 6720.000112ps      -16.379028
+ 6730.000113ps      -15.451116
+ 6740.000114ps      -14.750665
+ 6750.000114ps      -14.367987
+ 6760.000115ps      -14.450993
+ 6770.000116ps      -15.591026
+ 6780.000117ps      -17.770782
+ 6790.000118ps      -20.144408
+ 6800.000119ps      -22.366686
+ 6810.000119ps      -24.230557
+ 6820.000120ps      -25.685781
+ 6830.000121ps      -26.744999
+ 6840.000122ps      -27.414133
+ 6850.000123ps      -27.628385
+ 6860.000124ps      -27.367384
+ 6870.000124ps      -26.601906
+ 6880.000125ps      -25.398288
+ 6890.000126ps      -23.769597
+ 6900.000127ps      -21.919429
+ 6910.000128ps      -20.101389
+ 6920.000128ps      -18.290945
+ 6930.000129ps      -16.648769
+ 6940.000130ps      -15.190177
+ 6950.000131ps      -13.928201
+ 6960.000132ps      -12.896566
+ 6970.000133ps       -12.09386
+ 6980.000133ps       -11.52224
+ 6990.000134ps      -11.186855
+ 7000.000135ps      -11.169318
+ 7010.000136ps       -11.60145
+ 7020.000137ps      -12.634904
+ 7030.000138ps      -13.994703
+ 7040.000138ps      -15.553476
+ 7050.000139ps      -17.462461
+ 7060.000140ps      -19.541485
+ 7070.000141ps      -21.604192
+ 7080.000142ps      -23.453001
+ 7090.000143ps      -25.011585
+ 7100.000143ps      -26.256932
+ 7110.000144ps      -27.083324
+ 7120.000145ps      -27.404795
+ 7130.000146ps      -27.314617
+ 7140.000147ps      -26.813793
+ 7150.000148ps      -26.018201
+ 7160.000148ps      -24.985623
+ 7170.000149ps      -23.710991
+ 7180.000150ps      -22.285371
+ 7190.000151ps      -20.802731
+ 7200.000152ps      -19.358789
+ 7210.000152ps      -18.069367
+ 7220.000153ps      -16.948555
+ 7230.000154ps       -16.00791
+ 7240.000155ps      -15.228129
+ 7250.000156ps      -14.723073
+ 7260.000157ps      -14.692982
+ 7270.000157ps      -15.740029
+ 7280.000158ps      -17.827259
+ 7290.000159ps      -20.122787
+ 7300.000160ps      -22.339244
+ 7310.000161ps      -24.212837
+ 7320.000162ps      -25.674833
+ 7330.000162ps      -26.733346
+ 7340.000163ps      -27.397636
+ 7350.000164ps      -27.619899
+ 7360.000165ps      -27.359458
+ 7370.000166ps       -26.59839
+ 7380.000167ps       -25.40705
+ 7390.000167ps      -23.788733
+ 7400.000168ps      -21.946922
+ 7410.000169ps       -20.14372
+ 7420.000170ps      -18.336687
+ 7430.000171ps      -16.697929
+ 7440.000171ps      -15.236132
+ 7450.000172ps      -13.966869
+ 7459.999729ps      -12.932602
+ 7469.999730ps      -12.107048
+ 7479.999731ps      -11.511689
+ 7489.999732ps      -11.159782
+ 7499.999732ps      -11.143005
+ 7509.999733ps      -11.595009
+ 7519.999734ps      -12.631639
+ 7529.999735ps      -13.992218
+ 7539.999736ps      -15.545282
+ 7549.999737ps       -17.41067
+ 7559.999737ps      -19.438814
+ 7569.999738ps      -21.447059
+ 7579.999739ps       -23.30423
+ 7589.999740ps      -24.873556
+ 7599.999741ps      -26.123969
+ 7609.999741ps       -26.98347
+ 7619.999742ps      -27.332885
+ 7629.999743ps       -27.24355
+ 7639.999744ps      -26.752831
+ 7649.999745ps      -25.976806
+ 7659.999746ps      -24.935289
+ 7669.999746ps      -23.631289
+ 7679.999747ps      -22.198553
+ 7689.999748ps      -20.700121
+ 7699.999749ps      -19.218692
+ 7709.999750ps      -17.866778
+ 7719.999751ps      -16.688021
+ 7729.999751ps      -15.715369
+ 7739.999752ps      -14.961119
+ 7749.999753ps      -14.516099
+ 7759.999754ps      -14.515862
+ 7769.999755ps      -15.571342
+ 7779.999756ps      -17.672435
+ 7789.999756ps      -20.006408
+ 7799.999757ps      -22.232922
+ 7809.999758ps      -24.111454
+ 7819.999759ps       -25.58079
+ 7829.999760ps      -26.651693
+ 7839.999761ps      -27.334036
+ 7849.999761ps      -27.572088
+ 7859.999762ps      -27.334609
+ 7869.999763ps      -26.596872
+ 7879.999764ps      -25.420822
+ 7889.999765ps      -23.814126
+ 7899.999765ps      -21.987763
+ 7909.999766ps      -20.183453
+ 7919.999767ps      -18.385087
+ 7929.999768ps      -16.746952
+ 7939.999769ps      -15.271102
+ 7949.999770ps      -13.999255
+ 7959.999770ps      -12.941949
+ 7969.999771ps      -12.118709
+ 7979.999772ps      -11.528113
+ 7989.999773ps       -11.16412
+ 7999.999774ps      -10.959635
+ 8009.999775ps      -10.813174
+ 8019.999775ps      -10.695148
+ 8029.999776ps      -10.600353
+ 8039.999777ps      -10.524872
+ 8049.999778ps      -10.464596
+ 8059.999779ps      -10.416206
+ 8069.999780ps      -10.377131
+ 8079.999780ps      -10.345392
+ 8089.999781ps      -10.319457
+ 8099.999782ps      -10.298141
+ 8109.999783ps      -10.280518
+ 8119.999784ps      -10.265865
+ 8129.999785ps      -10.253613
+ 8139.999785ps      -10.243311
+ 8149.999786ps      -10.234603
+ 8159.999787ps      -10.227204
+ 8169.999788ps      -10.220886
+ 8179.999789ps      -10.215465
+ 8189.999789ps      -10.210792
+ 8199.999790ps      -10.206746
+ 8209.999791ps      -10.203228
+ 8219.999792ps      -10.200156
+ 8229.999793ps      -10.197464
+ 8239.999794ps      -10.195096
+ 8249.999794ps      -10.193006
+ 8259.999795ps      -10.191156
+ 8269.999796ps      -10.189512
+ 8279.999797ps      -10.188047
+ 8289.999798ps      -10.186738
+ 8299.999799ps      -10.185566
+ 8309.999799ps      -10.184514
+)

Icursig9 PAR_0_1_VDD075NNE 0 pwl(
+ 0.000000ps       9.1469553
+ 10.000000ps       9.5553207
+ 20.000000ps       11.480881
+ 29.999999ps       14.797095
+ 40.000000ps       18.513439
+ 50.000001ps       22.122026
+ 59.999998ps       25.512657
+ 69.999999ps       28.561082
+ 80.000000ps       31.299122
+ 90.000001ps       33.759857
+ 100.000001ps       35.803355
+ 110.000002ps       37.320742
+ 119.999996ps       38.071253
+ 129.999997ps       38.020233
+ 139.999998ps       37.288585
+ 149.999999ps       35.894018
+ 159.999999ps        34.21305
+ 170.000000ps       32.078789
+ 180.000001ps       29.787006
+ 190.000002ps       27.374823
+ 200.000003ps       24.929939
+ 210.000003ps       22.605006
+ 220.000004ps       20.462339
+ 230.000005ps       18.591323
+ 239.999992ps       17.097183
+ 249.999993ps       16.031094
+ 259.999994ps       15.520558
+ 269.999995ps       15.649231
+ 279.999995ps       16.064408
+ 289.999996ps         16.6137
+ 299.999997ps       17.479795
+ 309.999998ps       18.501219
+ 319.999999ps       19.547101
+ 330.000000ps       20.517879
+ 340.000000ps       21.264209
+ 350.000001ps       21.744789
+ 360.000002ps       21.904946
+ 370.000003ps         21.7496
+ 380.000004ps       21.265698
+ 390.000005ps       20.504863
+ 400.000005ps       19.597712
+ 410.000006ps       18.542953
+ 420.000007ps       17.401562
+ 430.000008ps       16.222483
+ 440.000009ps       15.077333
+ 450.000009ps       14.000423
+ 460.000010ps       13.115685
+ 469.999983ps       12.469902
+ 479.999984ps       12.036319
+ 489.999985ps       11.850933
+ 499.999986ps       12.010861
+ 509.999987ps       12.676067
+ 519.999988ps       14.630639
+ 529.999988ps       17.762409
+ 539.999989ps         21.1711
+ 549.999990ps       24.368587
+ 559.999991ps       27.342866
+ 569.999992ps       30.018889
+ 579.999992ps       32.450139
+ 589.999993ps       34.636058
+ 599.999994ps       36.491099
+ 609.999995ps       37.821453
+ 619.999996ps       38.432715
+ 629.999997ps       38.264977
+ 639.999997ps       37.439517
+ 649.999998ps        35.98471
+ 659.999999ps       34.268097
+ 670.000000ps       32.117845
+ 680.000001ps       29.833404
+ 690.000002ps       27.401673
+ 700.000002ps       24.971411
+ 710.000003ps       22.637464
+ 720.000004ps       20.465866
+ 730.000005ps       18.598711
+ 740.000006ps       17.099038
+ 750.000007ps        16.03669
+ 760.000007ps       15.555764
+ 770.000008ps       15.670911
+ 780.000009ps       16.062159
+ 790.000010ps       16.566476
+ 800.000011ps       17.418442
+ 810.000012ps       18.438366
+ 820.000012ps       19.480863
+ 830.000013ps       20.448826
+ 840.000014ps       21.190507
+ 850.000015ps       21.673288
+ 860.000016ps       21.831124
+ 870.000016ps       21.669946
+ 880.000017ps        21.18029
+ 890.000018ps       20.407616
+ 900.000019ps       19.494293
+ 910.000020ps       18.447589
+ 920.000021ps       17.308283
+ 930.000021ps       16.123729
+ 939.999967ps       14.980222
+ 949.999968ps       13.914674
+ 959.999968ps       13.028876
+ 969.999969ps       12.361789
+ 979.999970ps       11.927337
+ 989.999971ps       11.738191
+ 999.999972ps       11.910144
+ 1009.999973ps       12.611383
+ 1019.999973ps       14.609201
+ 1029.999974ps       17.751659
+ 1039.999975ps       21.179839
+ 1049.999976ps        24.37586
+ 1059.999977ps       27.355328
+ 1069.999978ps       30.011462
+ 1079.999978ps       32.424841
+ 1089.999979ps       34.630242
+ 1099.999980ps        36.47654
+ 1109.999981ps       37.784268
+ 1119.999982ps        38.37974
+ 1129.999982ps       38.262738
+ 1139.999983ps       37.482972
+ 1149.999984ps       36.049302
+ 1159.999985ps       34.363482
+ 1169.999986ps       32.257398
+ 1179.999987ps       30.014029
+ 1189.999987ps       27.621768
+ 1199.999988ps       25.186244
+ 1209.999989ps        22.82723
+ 1219.999990ps       20.649002
+ 1229.999991ps       18.764471
+ 1239.999992ps       17.226382
+ 1249.999992ps       16.119672
+ 1259.999993ps       15.596062
+ 1269.999994ps        15.68547
+ 1279.999995ps       16.035639
+ 1289.999996ps       16.537444
+ 1299.999997ps        17.39098
+ 1309.999997ps       18.413678
+ 1319.999998ps       19.449367
+ 1329.999999ps       20.411434
+ 1340.000000ps       21.149993
+ 1350.000001ps       21.642778
+ 1360.000002ps       21.806295
+ 1370.000002ps       21.663255
+ 1380.000003ps        21.19384
+ 1390.000004ps       20.440178
+ 1400.000005ps        19.53371
+ 1410.000006ps       18.499174
+ 1420.000006ps       17.375359
+ 1430.000007ps       16.206331
+ 1440.000008ps       15.082942
+ 1450.000009ps       14.038271
+ 1460.000010ps       13.174729
+ 1470.000011ps       12.522707
+ 1480.000011ps       12.081477
+ 1490.000012ps       11.871864
+ 1500.000013ps       12.011018
+ 1510.000014ps       12.685948
+ 1520.000015ps       14.679033
+ 1530.000016ps       17.828543
+ 1540.000016ps       21.285787
+ 1550.000017ps       24.519126
+ 1560.000018ps        27.50769
+ 1570.000019ps       30.179528
+ 1580.000020ps        32.60346
+ 1590.000021ps        34.79904
+ 1600.000021ps       36.628349
+ 1610.000022ps        37.94927
+ 1620.000023ps       38.581738
+ 1630.000024ps       38.466411
+ 1640.000025ps       37.666279
+ 1650.000025ps        36.21902
+ 1660.000026ps       34.520224
+ 1670.000027ps       32.404045
+ 1680.000028ps       30.144675
+ 1690.000029ps       27.745904
+ 1700.000030ps        25.32594
+ 1710.000030ps       23.010194
+ 1720.000031ps       20.877734
+ 1730.000032ps        18.98984
+ 1740.000033ps        17.44366
+ 1750.000034ps       16.328905
+ 1760.000035ps       15.789979
+ 1770.000035ps       15.872454
+ 1780.000036ps       16.237269
+ 1790.000037ps       16.715267
+ 1800.000038ps       17.526177
+ 1810.000039ps       18.501562
+ 1820.000040ps       19.528957
+ 1830.000040ps       20.487261
+ 1840.000041ps        21.22447
+ 1850.000042ps       21.708254
+ 1860.000043ps        21.85832
+ 1869.999933ps       21.704672
+ 1879.999934ps       21.230385
+ 1889.999934ps       20.479869
+ 1899.999935ps       19.582559
+ 1909.999936ps       18.547572
+ 1919.999937ps       17.411589
+ 1929.999938ps       16.223624
+ 1939.999938ps       15.054318
+ 1949.999939ps       13.967017
+ 1959.999940ps       13.079785
+ 1969.999941ps       12.422384
+ 1979.999942ps       12.007914
+ 1989.999943ps       11.836145
+ 1999.999943ps       12.009684
+ 2009.999944ps       12.703734
+ 2019.999945ps        14.70223
+ 2029.999946ps       17.878047
+ 2039.999947ps       21.324425
+ 2049.999948ps       24.566577
+ 2059.999948ps       27.573224
+ 2069.999949ps       30.292558
+ 2079.999950ps       32.772871
+ 2089.999951ps       35.026456
+ 2099.999952ps       36.885263
+ 2109.999953ps        38.17765
+ 2119.999953ps        38.72927
+ 2129.999954ps       38.530443
+ 2139.999955ps       37.701186
+ 2149.999956ps       36.243369
+ 2159.999957ps       34.531212
+ 2169.999958ps       32.415959
+ 2179.999958ps       30.199865
+ 2189.999959ps       27.846534
+ 2199.999960ps       25.419121
+ 2209.999961ps       23.078966
+ 2219.999962ps       20.916328
+ 2229.999962ps       19.047642
+ 2239.999963ps        17.55252
+ 2249.999964ps       16.477664
+ 2259.999965ps       15.934383
+ 2269.999966ps       15.953189
+ 2279.999967ps       16.232863
+ 2289.999967ps       16.670928
+ 2299.999968ps       17.477635
+ 2309.999969ps        18.47059
+ 2319.999970ps       19.494254
+ 2329.999971ps       20.457584
+ 2339.999972ps       21.198443
+ 2349.999972ps       21.684257
+ 2359.999973ps       21.838955
+ 2369.999974ps       21.668068
+ 2379.999975ps       21.174502
+ 2389.999976ps       20.410108
+ 2399.999977ps       19.499431
+ 2409.999977ps       18.459276
+ 2419.999978ps       17.328646
+ 2429.999979ps       16.140098
+ 2439.999980ps       14.998194
+ 2449.999981ps       13.932245
+ 2459.999981ps       13.054443
+ 2469.999982ps       12.409894
+ 2479.999983ps       11.992453
+ 2489.999984ps       11.787546
+ 2499.999985ps       11.938867
+ 2509.999986ps       12.621407
+ 2519.999986ps       14.619181
+ 2529.999987ps       17.750871
+ 2539.999988ps        21.16489
+ 2549.999989ps       24.370091
+ 2559.999990ps        27.34175
+ 2569.999991ps       30.020453
+ 2579.999991ps       32.461979
+ 2589.999992ps       34.676673
+ 2599.999993ps       36.536918
+ 2609.999994ps       37.850529
+ 2619.999995ps       38.438012
+ 2629.999996ps       38.285165
+ 2639.999996ps        37.46827
+ 2649.999997ps       35.998476
+ 2659.999998ps         34.3133
+ 2669.999999ps       32.196202
+ 2680.000000ps       29.950424
+ 2690.000001ps        27.54114
+ 2700.000001ps       25.100077
+ 2710.000002ps       22.784402
+ 2720.000003ps       20.631124
+ 2730.000004ps       18.764753
+ 2740.000005ps       17.236268
+ 2750.000005ps       16.131666
+ 2760.000006ps       15.604231
+ 2770.000007ps       15.685806
+ 2780.000008ps       16.028582
+ 2790.000009ps       16.506092
+ 2800.000010ps       17.359553
+ 2810.000010ps       18.392472
+ 2820.000011ps       19.433636
+ 2830.000012ps       20.385089
+ 2840.000013ps       21.113909
+ 2850.000014ps       21.587829
+ 2860.000015ps       21.734131
+ 2870.000015ps       21.564529
+ 2880.000016ps       21.068118
+ 2890.000017ps       20.290448
+ 2900.000018ps        19.37135
+ 2910.000019ps        18.31345
+ 2920.000020ps       17.172825
+ 2930.000020ps       15.992073
+ 2940.000021ps       14.842437
+ 2950.000022ps       13.775644
+ 2960.000023ps       12.905734
+ 2970.000024ps       12.257716
+ 2980.000025ps       11.834567
+ 2990.000025ps       11.647806
+ 3000.000026ps       11.801234
+ 3010.000027ps       12.486899
+ 3020.000028ps       14.461505
+ 3030.000029ps       17.599519
+ 3040.000029ps       21.017811
+ 3050.000030ps       24.209052
+ 3060.000031ps       27.189315
+ 3070.000032ps       29.856857
+ 3080.000033ps       32.273883
+ 3090.000034ps       34.470218
+ 3100.000034ps       36.297971
+ 3110.000035ps       37.607435
+ 3120.000036ps       38.226408
+ 3130.000037ps       38.103569
+ 3140.000038ps       37.317261
+ 3150.000039ps       35.882039
+ 3160.000039ps       34.165493
+ 3170.000040ps       32.022578
+ 3180.000041ps       29.740705
+ 3190.000042ps         27.3572
+ 3200.000043ps       24.933635
+ 3210.000044ps       22.603118
+ 3220.000044ps       20.441066
+ 3230.000045ps       18.553604
+ 3240.000046ps       17.022447
+ 3250.000047ps       15.934506
+ 3260.000048ps       15.413398
+ 3270.000049ps       15.523363
+ 3280.000049ps       15.908289
+ 3290.000050ps       16.434527
+ 3300.000051ps       17.298007
+ 3310.000052ps       18.320863
+ 3320.000053ps       19.362546
+ 3330.000053ps       20.329929
+ 3340.000054ps        21.07676
+ 3350.000055ps       21.561008
+ 3360.000056ps        21.72454
+ 3370.000057ps       21.571321
+ 3380.000058ps       21.086061
+ 3390.000058ps       20.327772
+ 3400.000059ps       19.425678
+ 3410.000060ps       18.394606
+ 3420.000061ps       17.276889
+ 3430.000062ps       16.114811
+ 3440.000063ps       14.978527
+ 3450.000063ps       13.902845
+ 3460.000064ps       13.012795
+ 3470.000065ps       12.345895
+ 3480.000066ps       11.913504
+ 3490.000067ps       11.710279
+ 3500.000068ps       11.864015
+ 3510.000068ps        12.54378
+ 3520.000069ps        14.53167
+ 3530.000070ps       17.692516
+ 3540.000071ps       21.137422
+ 3550.000072ps       24.365525
+ 3560.000073ps       27.350525
+ 3570.000073ps       30.036933
+ 3580.000074ps       32.485614
+ 3590.000075ps       34.688655
+ 3600.000076ps       36.526898
+ 3610.000077ps       37.852858
+ 3620.000077ps       38.448309
+ 3630.000078ps       38.306458
+ 3640.000079ps        37.50313
+ 3650.000080ps       36.047491
+ 3660.000081ps       34.344455
+ 3670.000082ps       32.221412
+ 3680.000082ps       29.967311
+ 3690.000083ps       27.582784
+ 3700.000084ps       25.172531
+ 3710.000085ps       22.855721
+ 3720.000086ps       20.711721
+ 3729.999865ps       18.833922
+ 3739.999865ps       17.296561
+ 3749.999866ps       16.182389
+ 3759.999867ps       15.625369
+ 3769.999868ps       15.713463
+ 3779.999869ps       16.082455
+ 3789.999869ps       16.564229
+ 3799.999870ps       17.394704
+ 3809.999871ps       18.402534
+ 3819.999872ps       19.425463
+ 3829.999873ps       20.382084
+ 3839.999874ps       21.122736
+ 3849.999874ps       21.613815
+ 3859.999875ps       21.771249
+ 3869.999876ps       21.616699
+ 3879.999877ps       21.129052
+ 3889.999878ps       20.364884
+ 3899.999879ps       19.453674
+ 3909.999879ps       18.413193
+ 3919.999880ps       17.275882
+ 3929.999881ps        16.09032
+ 3939.999882ps       14.941609
+ 3949.999883ps       13.872965
+ 3959.999884ps       12.995344
+ 3969.999884ps       12.345197
+ 3979.999885ps       11.920106
+ 3989.999886ps       11.772109
+ 3999.999887ps       11.990218
+ 4009.999888ps       12.737981
+ 4019.999889ps       14.780114
+ 4029.999889ps       17.963209
+ 4039.999890ps       21.444329
+ 4049.999891ps       24.680355
+ 4059.999892ps       27.672755
+ 4069.999893ps       30.348397
+ 4079.999893ps       32.727447
+ 4089.999894ps       34.902561
+ 4099.999895ps       36.695709
+ 4109.999896ps       37.985677
+ 4119.999897ps       38.589562
+ 4129.999898ps       38.457702
+ 4139.999898ps       37.667577
+ 4149.999899ps        36.24082
+ 4159.999900ps       34.534052
+ 4169.999901ps       32.426269
+ 4179.999902ps       30.164629
+ 4189.999903ps       27.800016
+ 4199.999903ps       25.400671
+ 4209.999904ps       23.081796
+ 4219.999905ps       20.920681
+ 4229.999906ps       19.030132
+ 4239.999907ps        17.47413
+ 4249.999908ps       16.346362
+ 4259.999908ps       15.764683
+ 4269.999909ps       15.810208
+ 4279.999910ps       16.170704
+ 4289.999911ps        16.68513
+ 4299.999912ps       17.512142
+ 4309.999913ps       18.489231
+ 4319.999913ps       19.485101
+ 4329.999914ps       20.412067
+ 4339.999915ps       21.138374
+ 4349.999916ps       21.613183
+ 4359.999917ps       21.766346
+ 4369.999917ps       21.599991
+ 4379.999918ps       21.111344
+ 4389.999919ps       20.345938
+ 4399.999920ps       19.434254
+ 4409.999921ps        18.39117
+ 4419.999922ps       17.254533
+ 4429.999922ps       16.074196
+ 4439.999923ps       14.933386
+ 4449.999924ps       13.875107
+ 4459.999925ps       13.004592
+ 4469.999926ps       12.355194
+ 4479.999927ps       11.911546
+ 4489.999927ps       11.691885
+ 4499.999928ps       11.831673
+ 4509.999929ps       12.503275
+ 4519.999930ps       14.499458
+ 4529.999931ps       17.650045
+ 4539.999932ps        21.09318
+ 4549.999932ps       24.324291
+ 4559.999933ps       27.336144
+ 4569.999934ps       30.025131
+ 4579.999935ps       32.449001
+ 4589.999936ps       34.636328
+ 4599.999937ps       36.444383
+ 4609.999937ps        37.72939
+ 4619.999938ps       38.322054
+ 4629.999939ps       38.186047
+ 4639.999940ps       37.393101
+ 4649.999941ps       35.939718
+ 4659.999941ps       34.271393
+ 4669.999942ps       32.181215
+ 4679.999943ps       29.926995
+ 4689.999944ps        27.53205
+ 4699.999945ps       25.108881
+ 4709.999946ps       22.785863
+ 4719.999946ps       20.657809
+ 4729.999947ps       18.777658
+ 4739.999948ps       17.232963
+ 4749.999949ps       16.101723
+ 4759.999950ps       15.550059
+ 4769.999951ps       15.629426
+ 4779.999951ps       16.011541
+ 4789.999952ps       16.516595
+ 4799.999953ps       17.364431
+ 4809.999954ps       18.376832
+ 4819.999955ps       19.402177
+ 4829.999956ps       20.363142
+ 4839.999956ps       21.102453
+ 4849.999957ps       21.588844
+ 4859.999958ps       21.751826
+ 4869.999959ps       21.594817
+ 4879.999960ps       21.111255
+ 4889.999961ps       20.353998
+ 4899.999961ps       19.450332
+ 4909.999962ps       18.420878
+ 4919.999963ps       17.303438
+ 4929.999964ps       16.146782
+ 4939.999965ps       14.998339
+ 4949.999965ps       13.917445
+ 4959.999966ps        13.02273
+ 4969.999967ps       12.349828
+ 4979.999968ps       11.917984
+ 4989.999969ps       11.703949
+ 4999.999970ps       11.861805
+ 5009.999970ps       12.524674
+ 5019.999971ps       14.501157
+ 5029.999972ps       17.646254
+ 5039.999973ps       21.089752
+ 5049.999974ps       24.328448
+ 5059.999975ps       27.318878
+ 5069.999975ps       30.002092
+ 5079.999976ps       32.428245
+ 5089.999977ps       34.656675
+ 5099.999978ps       36.557404
+ 5109.999979ps       37.908978
+ 5119.999980ps       38.514449
+ 5129.999980ps       38.375222
+ 5139.999981ps       37.573844
+ 5149.999982ps        36.08379
+ 5159.999983ps       34.360518
+ 5169.999984ps       32.207485
+ 5179.999985ps       29.936683
+ 5189.999985ps       27.564014
+ 5199.999986ps       25.152099
+ 5209.999987ps       22.817475
+ 5219.999988ps       20.637513
+ 5229.999989ps       18.751664
+ 5239.999989ps        17.24775
+ 5249.999990ps       16.189741
+ 5259.999991ps       15.735041
+ 5269.999992ps       15.828385
+ 5279.999993ps       16.164085
+ 5289.999994ps       16.618353
+ 5299.999994ps       17.446024
+ 5309.999995ps        18.43051
+ 5319.999996ps        19.43201
+ 5329.999997ps       20.379268
+ 5339.999998ps        21.10946
+ 5349.999999ps        21.60037
+ 5359.999999ps       21.754495
+ 5370.000000ps       21.606102
+ 5380.000001ps       21.129844
+ 5390.000002ps       20.384113
+ 5400.000003ps        19.48869
+ 5410.000004ps       18.459075
+ 5420.000004ps       17.339119
+ 5430.000005ps       16.164135
+ 5440.000006ps       15.020803
+ 5450.000007ps       13.941467
+ 5460.000008ps       13.055649
+ 5470.000009ps       12.374766
+ 5480.000009ps       11.936379
+ 5490.000010ps       11.726147
+ 5500.000011ps        11.88379
+ 5510.000012ps       12.579361
+ 5520.000013ps       14.568095
+ 5530.000013ps       17.736818
+ 5540.000014ps       21.171322
+ 5550.000015ps       24.401736
+ 5560.000016ps        27.36666
+ 5570.000017ps       30.028086
+ 5580.000018ps        32.45093
+ 5590.000018ps       34.659493
+ 5600.000019ps       36.523399
+ 5610.000020ps       37.870773
+ 5620.000021ps       38.515755
+ 5630.000022ps       38.391302
+ 5640.000023ps       37.568188
+ 5650.000023ps       36.124193
+ 5660.000024ps       34.429671
+ 5670.000025ps       32.277054
+ 5680.000026ps       30.008551
+ 5690.000027ps       27.606612
+ 5700.000028ps       25.161919
+ 5710.000028ps       22.819032
+ 5720.000029ps       20.646851
+ 5730.000030ps       18.743675
+ 5740.000031ps       17.226616
+ 5750.000032ps       16.168335
+ 5760.000032ps        15.67324
+ 5770.000033ps       15.772992
+ 5780.000034ps       16.139173
+ 5790.000035ps       16.630234
+ 5800.000036ps       17.453628
+ 5810.000037ps       18.435638
+ 5820.000037ps       19.445869
+ 5830.000038ps       20.398702
+ 5840.000039ps       21.141967
+ 5850.000040ps       21.645328
+ 5860.000041ps        21.81742
+ 5870.000042ps       21.678767
+ 5880.000042ps       21.214854
+ 5890.000043ps       20.477292
+ 5900.000044ps       19.586538
+ 5910.000045ps       18.557087
+ 5920.000046ps       17.431361
+ 5930.000047ps        16.24499
+ 5940.000047ps       15.089927
+ 5950.000048ps        13.98617
+ 5960.000049ps       13.072754
+ 5970.000050ps       12.368055
+ 5980.000051ps        11.90848
+ 5990.000052ps       11.711278
+ 6000.000052ps       11.898154
+ 6010.000053ps       12.625989
+ 6020.000054ps       14.667981
+ 6030.000055ps       17.872556
+ 6040.000056ps       21.366485
+ 6050.000056ps       24.618854
+ 6060.000057ps        27.62323
+ 6070.000058ps       30.267525
+ 6080.000059ps       32.603596
+ 6090.000060ps       34.696263
+ 6100.000061ps       36.458989
+ 6110.000061ps       37.742591
+ 6120.000062ps       38.328171
+ 6130.000063ps        38.23541
+ 6140.000064ps        37.49745
+ 6150.000065ps       36.110993
+ 6160.000066ps       34.440112
+ 6170.000066ps        32.33316
+ 6180.000067ps       30.094503
+ 6190.000068ps       27.741454
+ 6200.000069ps       25.308181
+ 6210.000070ps       22.968083
+ 6220.000071ps       20.773355
+ 6230.000071ps         18.8178
+ 6240.000072ps       17.180529
+ 6250.000073ps       16.002248
+ 6260.000074ps       15.446394
+ 6270.000075ps       15.562838
+ 6280.000076ps       15.965919
+ 6290.000076ps         16.5057
+ 6300.000077ps       17.370271
+ 6310.000078ps       18.394194
+ 6320.000079ps       19.430401
+ 6330.000080ps       20.393067
+ 6340.000080ps        21.13621
+ 6350.000081ps       21.635466
+ 6360.000082ps       21.810434
+ 6370.000083ps       21.668527
+ 6380.000084ps       21.201264
+ 6390.000085ps        20.46065
+ 6400.000085ps       19.573646
+ 6410.000086ps       18.555781
+ 6420.000087ps        17.42081
+ 6430.000088ps       16.231522
+ 6440.000089ps       15.082756
+ 6450.000090ps       14.010668
+ 6460.000090ps       13.107334
+ 6470.000091ps       12.448915
+ 6480.000092ps        12.01355
+ 6490.000093ps       11.804272
+ 6500.000094ps       11.955482
+ 6510.000095ps       12.622983
+ 6520.000095ps       14.581447
+ 6530.000096ps       17.695794
+ 6540.000097ps       21.102681
+ 6550.000098ps       24.296462
+ 6560.000099ps       27.262592
+ 6570.000100ps        29.93551
+ 6580.000100ps        32.37678
+ 6590.000101ps       34.571644
+ 6600.000102ps       36.398227
+ 6610.000103ps       37.711155
+ 6620.000104ps       38.331465
+ 6630.000104ps       38.207373
+ 6640.000105ps       37.430666
+ 6650.000106ps       35.995119
+ 6660.000107ps       34.279781
+ 6670.000108ps       32.140953
+ 6680.000109ps       29.871446
+ 6690.000109ps       27.446928
+ 6700.000110ps       25.014009
+ 6710.000111ps       22.645568
+ 6720.000112ps        20.47762
+ 6730.000113ps       18.597037
+ 6740.000114ps       17.098727
+ 6750.000114ps       16.023579
+ 6760.000115ps       15.498491
+ 6770.000116ps       15.612355
+ 6780.000117ps       16.017059
+ 6790.000118ps       16.556973
+ 6800.000119ps       17.410548
+ 6810.000119ps       18.418919
+ 6820.000120ps       19.442959
+ 6830.000121ps       20.400061
+ 6840.000122ps        21.14246
+ 6850.000123ps       21.623903
+ 6860.000124ps       21.777353
+ 6870.000124ps       21.618243
+ 6880.000125ps       21.132268
+ 6890.000126ps       20.369181
+ 6900.000127ps       19.463317
+ 6910.000128ps       18.421872
+ 6920.000128ps       17.292756
+ 6930.000129ps       16.129643
+ 6940.000130ps       14.999537
+ 6950.000131ps       13.927503
+ 6960.000132ps       13.040561
+ 6970.000133ps       12.383759
+ 6980.000133ps       11.953607
+ 6990.000134ps       11.750565
+ 7000.000135ps       11.901564
+ 7010.000136ps       12.584941
+ 7020.000137ps       14.600531
+ 7030.000138ps       17.789007
+ 7040.000138ps        21.27795
+ 7050.000139ps       24.587236
+ 7060.000140ps       27.649672
+ 7070.000141ps       30.389804
+ 7080.000142ps       32.821041
+ 7090.000143ps       34.961154
+ 7100.000143ps       36.735211
+ 7110.000144ps       37.962351
+ 7120.000145ps       38.463303
+ 7130.000146ps       38.285164
+ 7140.000147ps        37.51029
+ 7150.000148ps       36.069423
+ 7160.000148ps       34.405421
+ 7170.000149ps       32.325998
+ 7180.000150ps       30.126308
+ 7190.000151ps       27.787603
+ 7200.000152ps       25.413445
+ 7210.000152ps       23.160049
+ 7220.000153ps       21.052494
+ 7230.000154ps       19.179117
+ 7240.000155ps       17.576197
+ 7250.000156ps       16.366999
+ 7260.000157ps       15.737103
+ 7270.000157ps        15.73619
+ 7280.000158ps       16.038695
+ 7290.000159ps       16.507128
+ 7300.000160ps       17.357292
+ 7310.000161ps       18.373985
+ 7320.000162ps       19.410928
+ 7330.000162ps        20.37092
+ 7340.000163ps        21.10767
+ 7350.000164ps       21.596223
+ 7360.000165ps        21.75156
+ 7370.000166ps       21.601846
+ 7380.000167ps       21.129462
+ 7390.000167ps       20.380849
+ 7400.000168ps       19.484991
+ 7410.000169ps       18.460143
+ 7420.000170ps        17.34069
+ 7430.000171ps       16.182098
+ 7440.000171ps        15.04546
+ 7450.000172ps       13.965548
+ 7459.999729ps       13.068776
+ 7469.999730ps       12.382613
+ 7479.999731ps       11.924994
+ 7489.999732ps       11.711554
+ 7499.999732ps       11.871106
+ 7509.999733ps        12.57106
+ 7519.999734ps       14.597128
+ 7529.999735ps       17.787466
+ 7539.999736ps       21.271171
+ 7549.999737ps       24.526749
+ 7559.999737ps       27.534326
+ 7569.999738ps       30.221215
+ 7579.999739ps       32.640347
+ 7589.999740ps       34.807403
+ 7599.999741ps       36.598609
+ 7609.999741ps        37.87385
+ 7619.999742ps       38.425883
+ 7629.999743ps       38.252349
+ 7639.999744ps       37.443589
+ 7649.999745ps       36.035037
+ 7659.999746ps       34.408238
+ 7669.999746ps       32.339113
+ 7679.999747ps       30.101402
+ 7689.999748ps       27.721819
+ 7699.999749ps       25.296341
+ 7709.999750ps       22.962378
+ 7719.999751ps       20.778793
+ 7729.999751ps       18.872438
+ 7739.999752ps       17.300942
+ 7749.999753ps        16.15773
+ 7759.999754ps       15.545143
+ 7769.999755ps       15.561355
+ 7779.999756ps       15.914032
+ 7789.999756ps       16.433128
+ 7799.999757ps       17.316245
+ 7809.999758ps       18.350413
+ 7819.999759ps       19.399928
+ 7829.999760ps       20.370284
+ 7839.999761ps       21.114033
+ 7849.999761ps       21.613583
+ 7859.999762ps        21.77868
+ 7869.999763ps       21.649719
+ 7879.999764ps       21.215266
+ 7889.999765ps        20.48628
+ 7899.999765ps       19.606369
+ 7909.999766ps        18.58395
+ 7919.999767ps       17.478401
+ 7929.999768ps        16.34204
+ 7939.999769ps       15.194044
+ 7949.999770ps       14.110624
+ 7959.999770ps       13.190356
+ 7969.999771ps       12.491142
+ 7979.999772ps        12.05428
+ 7989.999773ps       11.874955
+ 7999.999774ps       11.911593
+ 8009.999775ps       11.932753
+ 8019.999775ps       11.929574
+ 8029.999776ps         11.9136
+ 8039.999777ps       11.896739
+ 8049.999778ps       11.881335
+ 8059.999779ps       11.867923
+ 8069.999780ps       11.856488
+ 8079.999780ps        11.84682
+ 8089.999781ps       11.838663
+ 8099.999782ps       11.831771
+ 8109.999783ps       11.825931
+ 8119.999784ps       11.820963
+ 8129.999785ps       11.816718
+ 8139.999785ps       11.813075
+ 8149.999786ps       11.809936
+ 8159.999787ps        11.80722
+ 8169.999788ps        11.80486
+ 8179.999789ps       11.802803
+ 8189.999789ps       11.801003
+ 8199.999790ps       11.799424
+ 8209.999791ps       11.798034
+ 8219.999792ps       11.796807
+ 8229.999793ps       11.795722
+ 8239.999794ps        11.79476
+ 8249.999794ps       11.793906
+ 8259.999795ps       11.793145
+ 8269.999796ps       11.792467
+ 8279.999797ps       11.791861
+ 8289.999798ps       11.791319
+ 8299.999799ps       11.790834
+ 8309.999799ps       11.790398
+)

Icursig10 PAR_1_1_VSS 0 pwl(
+ 0.000000ps      -10.328265
+ 10.000000ps      -11.899248
+ 20.000000ps      -15.232758
+ 29.999999ps      -18.487835
+ 40.000000ps      -21.224316
+ 50.000001ps      -23.641472
+ 59.999998ps      -25.625891
+ 69.999999ps      -26.851128
+ 80.000000ps      -27.213267
+ 90.000001ps       -26.91662
+ 100.000001ps      -26.230858
+ 110.000002ps      -25.193426
+ 119.999996ps       -23.85646
+ 129.999997ps      -22.312293
+ 139.999998ps      -20.708866
+ 149.999999ps      -19.182113
+ 159.999999ps      -17.788384
+ 170.000000ps       -16.59594
+ 180.000001ps      -15.595743
+ 190.000002ps      -14.877926
+ 200.000003ps      -14.441966
+ 210.000003ps      -14.302816
+ 220.000004ps      -14.477294
+ 230.000005ps      -15.069154
+ 239.999992ps      -16.070539
+ 249.999993ps      -17.485249
+ 259.999994ps      -19.556707
+ 269.999995ps      -23.103403
+ 279.999995ps      -27.116567
+ 289.999996ps      -29.638516
+ 299.999997ps      -30.377402
+ 309.999998ps      -30.059411
+ 319.999999ps      -29.058193
+ 330.000000ps      -27.549758
+ 340.000000ps      -25.700147
+ 350.000001ps      -23.625085
+ 360.000002ps      -21.454422
+ 370.000003ps      -19.405748
+ 380.000004ps      -17.516903
+ 390.000005ps      -15.841925
+ 400.000005ps      -14.451213
+ 410.000006ps      -13.314944
+ 420.000007ps      -12.432829
+ 430.000008ps      -11.799049
+ 440.000009ps      -11.397228
+ 450.000009ps      -11.208604
+ 460.000010ps      -11.275224
+ 469.999983ps      -11.581385
+ 479.999984ps      -12.154641
+ 489.999985ps       -13.12607
+ 499.999986ps       -14.66142
+ 509.999987ps      -16.924018
+ 519.999988ps      -20.017233
+ 529.999988ps      -22.798273
+ 539.999989ps      -25.012312
+ 549.999990ps      -26.815122
+ 559.999991ps      -28.153853
+ 569.999992ps      -28.791818
+ 579.999992ps      -28.689172
+ 589.999993ps      -28.029201
+ 599.999994ps      -27.053244
+ 609.999995ps      -25.834803
+ 619.999996ps      -24.382422
+ 629.999997ps      -22.755332
+ 639.999997ps      -21.142876
+ 649.999998ps      -19.580689
+ 659.999999ps      -18.166522
+ 670.000000ps      -16.921323
+ 680.000001ps      -15.923207
+ 690.000002ps       -15.19652
+ 700.000002ps      -14.748028
+ 710.000003ps      -14.550688
+ 720.000004ps      -14.654105
+ 730.000005ps      -15.153372
+ 740.000006ps      -16.078853
+ 750.000007ps      -17.469609
+ 760.000007ps      -19.542838
+ 770.000008ps       -23.10269
+ 780.000009ps      -27.147282
+ 790.000010ps      -29.679165
+ 800.000011ps      -30.415124
+ 810.000012ps      -30.115998
+ 820.000012ps      -29.133555
+ 830.000013ps      -27.633669
+ 840.000014ps      -25.791843
+ 850.000015ps      -23.736571
+ 860.000016ps       -21.59937
+ 870.000016ps      -19.575432
+ 880.000017ps      -17.719521
+ 890.000018ps      -16.092693
+ 900.000019ps       -14.72982
+ 910.000020ps      -13.611482
+ 920.000021ps      -12.733083
+ 930.000021ps      -12.074079
+ 939.999967ps      -11.629553
+ 949.999968ps      -11.391816
+ 959.999968ps      -11.418609
+ 969.999969ps      -11.673769
+ 979.999970ps       -12.23142
+ 989.999971ps      -13.177028
+ 999.999972ps      -14.713376
+ 1009.999973ps      -16.990966
+ 1019.999973ps       -20.09443
+ 1029.999974ps      -22.895928
+ 1039.999975ps      -25.103347
+ 1049.999976ps      -26.927731
+ 1059.999977ps      -28.280967
+ 1069.999978ps      -28.939154
+ 1079.999978ps      -28.889118
+ 1089.999979ps       -28.24688
+ 1099.999980ps      -27.256241
+ 1109.999981ps       -26.00349
+ 1119.999982ps      -24.519789
+ 1129.999982ps       -22.87347
+ 1139.999983ps       -21.22753
+ 1149.999984ps      -19.689233
+ 1159.999985ps      -18.314315
+ 1169.999986ps       -17.15558
+ 1179.999987ps      -16.223816
+ 1189.999987ps      -15.490364
+ 1199.999988ps      -14.996137
+ 1209.999989ps      -14.802892
+ 1219.999990ps      -14.908742
+ 1229.999991ps      -15.416946
+ 1239.999992ps      -16.360577
+ 1249.999992ps      -17.745922
+ 1259.999993ps      -19.768269
+ 1269.999994ps      -23.268778
+ 1279.999995ps      -27.260293
+ 1289.999996ps      -29.755288
+ 1299.999997ps       -30.47767
+ 1309.999997ps      -30.154243
+ 1319.999998ps      -29.156147
+ 1329.999999ps      -27.650553
+ 1340.000000ps      -25.808432
+ 1350.000001ps      -23.749821
+ 1360.000002ps      -21.600198
+ 1370.000002ps      -19.575917
+ 1380.000003ps      -17.709063
+ 1390.000004ps      -16.072764
+ 1400.000005ps      -14.694616
+ 1410.000006ps      -13.536812
+ 1420.000006ps      -12.644226
+ 1430.000007ps      -11.989734
+ 1440.000008ps      -11.572741
+ 1450.000009ps       -11.36236
+ 1460.000010ps      -11.432413
+ 1470.000011ps      -11.738786
+ 1480.000011ps      -12.350764
+ 1490.000012ps      -13.371587
+ 1500.000013ps      -14.944929
+ 1510.000014ps      -17.236709
+ 1520.000015ps      -20.359359
+ 1530.000016ps       -23.12803
+ 1540.000016ps      -25.254884
+ 1550.000017ps      -27.002442
+ 1560.000018ps      -28.320289
+ 1570.000019ps      -28.942683
+ 1580.000020ps      -28.855285
+ 1590.000021ps       -28.22614
+ 1600.000021ps      -27.269807
+ 1610.000022ps      -26.046111
+ 1620.000023ps      -24.590961
+ 1630.000024ps      -22.967275
+ 1640.000025ps      -21.365759
+ 1650.000025ps       -19.82571
+ 1660.000026ps      -18.421782
+ 1670.000027ps      -17.198816
+ 1680.000028ps      -16.215351
+ 1690.000029ps      -15.465015
+ 1700.000030ps      -14.913143
+ 1710.000030ps      -14.639658
+ 1720.000031ps      -14.693311
+ 1730.000032ps      -15.186545
+ 1740.000033ps      -16.106138
+ 1750.000034ps      -17.477896
+ 1760.000035ps      -19.541127
+ 1770.000035ps      -23.098551
+ 1780.000036ps      -27.128543
+ 1790.000037ps      -29.658174
+ 1800.000038ps      -30.411361
+ 1810.000039ps      -30.117779
+ 1820.000040ps      -29.149606
+ 1830.000040ps      -27.640853
+ 1840.000041ps        -25.7799
+ 1850.000042ps      -23.700376
+ 1860.000043ps      -21.525009
+ 1869.999933ps       -19.46576
+ 1879.999934ps      -17.573564
+ 1889.999934ps      -15.912294
+ 1899.999935ps      -14.531607
+ 1909.999936ps      -13.409901
+ 1919.999937ps      -12.546047
+ 1929.999938ps      -11.907113
+ 1939.999938ps      -11.489931
+ 1949.999939ps      -11.303025
+ 1959.999940ps      -11.391582
+ 1969.999941ps      -11.714781
+ 1979.999942ps      -12.314921
+ 1989.999943ps      -13.286681
+ 1999.999943ps      -14.832457
+ 2009.999944ps      -17.106646
+ 2019.999945ps      -20.169199
+ 2029.999946ps       -22.91569
+ 2039.999947ps      -25.070966
+ 2049.999948ps      -26.833143
+ 2059.999948ps      -28.178017
+ 2069.999949ps      -28.853842
+ 2079.999950ps      -28.809208
+ 2089.999951ps      -28.191873
+ 2099.999952ps      -27.254723
+ 2109.999953ps      -26.055324
+ 2119.999953ps      -24.617151
+ 2129.999954ps      -22.998237
+ 2139.999955ps      -21.367253
+ 2149.999956ps      -19.828704
+ 2159.999957ps      -18.418898
+ 2169.999958ps      -17.207032
+ 2179.999958ps      -16.170421
+ 2189.999959ps      -15.352531
+ 2199.999960ps      -14.806735
+ 2209.999961ps      -14.601526
+ 2219.999962ps      -14.726673
+ 2229.999962ps      -15.250047
+ 2239.999963ps      -16.180855
+ 2249.999964ps       -17.54572
+ 2259.999965ps      -19.581152
+ 2269.999966ps      -23.103875
+ 2279.999967ps      -27.096877
+ 2289.999967ps      -29.592273
+ 2299.999968ps      -30.318888
+ 2309.999969ps       -30.01032
+ 2319.999970ps      -29.033482
+ 2329.999971ps      -27.535845
+ 2339.999972ps      -25.693957
+ 2349.999972ps      -23.639874
+ 2359.999973ps      -21.486865
+ 2369.999974ps       -19.44985
+ 2379.999975ps      -17.570473
+ 2389.999976ps      -15.896948
+ 2399.999977ps      -14.498185
+ 2409.999977ps      -13.342368
+ 2419.999978ps      -12.430232
+ 2429.999979ps      -11.754974
+ 2439.999980ps      -11.315208
+ 2449.999981ps      -11.115572
+ 2459.999981ps      -11.192533
+ 2469.999982ps      -11.510434
+ 2479.999983ps      -12.114654
+ 2489.999984ps      -13.119224
+ 2499.999985ps      -14.661813
+ 2509.999986ps      -16.912931
+ 2519.999986ps      -19.994842
+ 2529.999987ps      -22.751559
+ 2539.999988ps      -24.924219
+ 2549.999989ps      -26.721032
+ 2559.999990ps      -28.084835
+ 2569.999991ps      -28.772554
+ 2579.999991ps      -28.706912
+ 2589.999992ps      -28.052155
+ 2599.999993ps      -27.077214
+ 2609.999994ps      -25.841996
+ 2619.999995ps      -24.368477
+ 2629.999996ps      -22.736165
+ 2639.999996ps      -21.102604
+ 2649.999997ps      -19.549417
+ 2659.999998ps      -18.135824
+ 2669.999999ps      -16.898123
+ 2680.000000ps      -15.871559
+ 2690.000001ps      -15.098395
+ 2700.000001ps      -14.604669
+ 2710.000002ps      -14.434679
+ 2720.000003ps      -14.588158
+ 2730.000004ps      -15.137103
+ 2740.000005ps      -16.069422
+ 2750.000005ps      -17.424343
+ 2760.000006ps      -19.456909
+ 2770.000007ps      -22.992121
+ 2780.000008ps      -27.017496
+ 2790.000009ps      -29.545607
+ 2800.000010ps      -30.291249
+ 2810.000010ps      -29.987467
+ 2820.000011ps      -29.002723
+ 2830.000012ps      -27.496179
+ 2840.000013ps      -25.641566
+ 2850.000014ps      -23.581752
+ 2860.000015ps      -21.434712
+ 2870.000015ps       -19.38835
+ 2880.000016ps      -17.504794
+ 2890.000017ps      -15.849721
+ 2900.000018ps      -14.461793
+ 2910.000019ps      -13.331943
+ 2920.000020ps        -12.4678
+ 2930.000020ps      -11.834803
+ 2940.000021ps      -11.434267
+ 2950.000022ps      -11.264734
+ 2960.000023ps      -11.360712
+ 2970.000024ps      -11.699126
+ 2980.000025ps      -12.358719
+ 2990.000025ps      -13.357006
+ 3000.000026ps      -14.897376
+ 3010.000027ps      -17.140495
+ 3020.000028ps      -20.182426
+ 3030.000029ps      -22.925787
+ 3040.000029ps      -25.054858
+ 3050.000030ps      -26.784636
+ 3060.000031ps      -28.076593
+ 3070.000032ps       -28.70418
+ 3080.000033ps      -28.606178
+ 3090.000034ps      -27.982596
+ 3100.000034ps      -27.087234
+ 3110.000035ps      -25.899273
+ 3120.000036ps      -24.492114
+ 3130.000037ps      -22.912116
+ 3140.000038ps      -21.314692
+ 3150.000039ps      -19.776404
+ 3160.000039ps       -18.34307
+ 3170.000040ps      -17.092475
+ 3180.000041ps      -16.025271
+ 3190.000042ps       -15.24959
+ 3200.000043ps      -14.718054
+ 3210.000044ps      -14.460901
+ 3220.000044ps      -14.494615
+ 3230.000045ps      -14.988938
+ 3240.000046ps      -15.936135
+ 3250.000047ps      -17.349728
+ 3260.000048ps      -19.436286
+ 3270.000049ps      -22.998199
+ 3280.000049ps      -27.026825
+ 3290.000050ps      -29.543657
+ 3300.000051ps      -30.278827
+ 3310.000052ps      -29.971418
+ 3320.000053ps      -28.991699
+ 3330.000053ps      -27.490242
+ 3340.000054ps      -25.654624
+ 3350.000055ps      -23.607478
+ 3360.000056ps      -21.460907
+ 3370.000057ps      -19.435891
+ 3380.000058ps       -17.57327
+ 3390.000058ps      -15.930844
+ 3400.000059ps      -14.559741
+ 3410.000060ps      -13.439415
+ 3420.000061ps      -12.568704
+ 3430.000062ps      -11.937206
+ 3440.000063ps      -11.510329
+ 3450.000063ps      -11.329063
+ 3460.000064ps      -11.383798
+ 3470.000065ps      -11.682288
+ 3480.000066ps      -12.270092
+ 3490.000067ps      -13.258212
+ 3500.000068ps      -14.815538
+ 3510.000068ps      -17.088587
+ 3520.000069ps      -20.185075
+ 3530.000070ps      -22.939857
+ 3540.000071ps      -25.088805
+ 3550.000072ps      -26.848508
+ 3560.000073ps      -28.152432
+ 3570.000073ps      -28.795971
+ 3580.000074ps      -28.721791
+ 3590.000075ps      -28.078904
+ 3600.000076ps      -27.150953
+ 3610.000077ps      -25.961627
+ 3620.000077ps      -24.535127
+ 3630.000078ps      -22.933009
+ 3640.000079ps      -21.354461
+ 3650.000080ps      -19.808525
+ 3660.000081ps      -18.392475
+ 3670.000082ps      -17.139053
+ 3680.000082ps      -16.131505
+ 3690.000083ps      -15.341071
+ 3700.000084ps      -14.792323
+ 3710.000085ps      -14.517947
+ 3720.000086ps      -14.566981
+ 3729.999865ps      -15.045247
+ 3739.999865ps      -15.980155
+ 3749.999866ps      -17.364831
+ 3759.999867ps      -19.425662
+ 3769.999868ps      -22.967856
+ 3779.999869ps       -26.99206
+ 3789.999869ps      -29.510372
+ 3799.999870ps      -30.253708
+ 3809.999871ps      -29.953563
+ 3819.999872ps      -28.973752
+ 3829.999873ps      -27.473616
+ 3839.999874ps      -25.629626
+ 3849.999874ps      -23.570731
+ 3859.999875ps       -21.42236
+ 3869.999876ps      -19.375921
+ 3879.999877ps      -17.483636
+ 3889.999878ps      -15.809799
+ 3899.999879ps       -14.40934
+ 3909.999879ps      -13.270263
+ 3919.999880ps      -12.388787
+ 3929.999881ps       -11.74076
+ 3939.999882ps      -11.316117
+ 3949.999883ps      -11.107305
+ 3959.999884ps      -11.168485
+ 3969.999884ps      -11.443903
+ 3979.999885ps      -12.023922
+ 3989.999886ps       -13.00986
+ 3999.999887ps      -14.553749
+ 4009.999888ps      -16.835092
+ 4019.999889ps      -19.972934
+ 4029.999889ps       -22.81911
+ 4039.999890ps      -25.051481
+ 4049.999891ps      -26.907171
+ 4059.999892ps      -28.292275
+ 4069.999893ps      -28.963663
+ 4079.999893ps      -28.869673
+ 4089.999894ps      -28.221478
+ 4099.999895ps      -27.249485
+ 4109.999896ps      -26.001114
+ 4119.999897ps      -24.531588
+ 4129.999898ps      -22.911817
+ 4139.999898ps      -21.293612
+ 4149.999899ps      -19.745846
+ 4159.999900ps      -18.351306
+ 4169.999901ps      -17.145066
+ 4179.999902ps       -16.17935
+ 4189.999903ps      -15.474708
+ 4199.999903ps      -15.009844
+ 4209.999904ps      -14.805371
+ 4219.999905ps      -14.917564
+ 4229.999906ps      -15.421677
+ 4239.999907ps      -16.306891
+ 4249.999908ps       -17.64376
+ 4259.999908ps      -19.669282
+ 4269.999909ps      -23.186547
+ 4279.999910ps      -27.189098
+ 4289.999911ps      -29.700491
+ 4299.999912ps      -30.429233
+ 4309.999913ps      -30.123312
+ 4319.999913ps      -29.133341
+ 4329.999914ps      -27.626393
+ 4339.999915ps      -25.779772
+ 4349.999916ps      -23.714331
+ 4359.999917ps      -21.549153
+ 4369.999917ps      -19.506934
+ 4379.999918ps      -17.618812
+ 4389.999919ps      -15.947369
+ 4399.999920ps      -14.547111
+ 4409.999921ps      -13.394931
+ 4419.999922ps       -12.51367
+ 4429.999922ps      -11.865057
+ 4439.999923ps      -11.440487
+ 4449.999924ps       -11.21758
+ 4459.999925ps      -11.256222
+ 4469.999926ps       -11.53776
+ 4479.999927ps      -12.109384
+ 4489.999927ps      -13.074829
+ 4499.999928ps      -14.605687
+ 4509.999929ps      -16.872476
+ 4519.999930ps       -19.94376
+ 4529.999931ps      -22.687086
+ 4539.999932ps      -24.844165
+ 4549.999932ps      -26.617905
+ 4559.999933ps      -27.942489
+ 4569.999934ps      -28.602797
+ 4579.999935ps      -28.555925
+ 4589.999936ps      -27.924585
+ 4599.999937ps      -26.978835
+ 4609.999937ps      -25.760984
+ 4619.999938ps      -24.318443
+ 4629.999939ps      -22.654117
+ 4639.999940ps      -21.002963
+ 4649.999941ps      -19.429282
+ 4659.999941ps      -18.026038
+ 4669.999942ps      -16.819717
+ 4679.999943ps      -15.821085
+ 4689.999944ps      -15.033295
+ 4699.999945ps      -14.515988
+ 4709.999946ps      -14.319738
+ 4719.999946ps      -14.447432
+ 4729.999947ps       -15.00659
+ 4739.999948ps      -15.976484
+ 4749.999949ps       -17.38882
+ 4759.999950ps      -19.458925
+ 4769.999951ps       -22.99654
+ 4779.999951ps      -27.020171
+ 4789.999952ps      -29.544207
+ 4799.999953ps      -30.282953
+ 4809.999954ps      -29.986397
+ 4819.999955ps      -28.999518
+ 4829.999956ps      -27.501005
+ 4839.999956ps      -25.653316
+ 4849.999957ps      -23.598135
+ 4859.999958ps      -21.450079
+ 4869.999959ps      -19.415207
+ 4879.999960ps      -17.536208
+ 4889.999961ps      -15.873366
+ 4899.999961ps       -14.47742
+ 4909.999962ps      -13.314741
+ 4919.999963ps      -12.420256
+ 4929.999964ps      -11.762469
+ 4939.999965ps      -11.349769
+ 4949.999965ps       -11.14824
+ 4959.999966ps      -11.202046
+ 4969.999967ps      -11.491735
+ 4979.999968ps      -12.094915
+ 4989.999969ps      -13.102288
+ 4999.999970ps      -14.691001
+ 5009.999970ps       -17.01075
+ 5019.999971ps      -20.143356
+ 5029.999972ps      -22.968653
+ 5039.999973ps      -25.167225
+ 5049.999974ps      -26.939878
+ 5059.999975ps      -28.226613
+ 5069.999975ps      -28.821969
+ 5079.999976ps      -28.681736
+ 5089.999977ps      -28.010768
+ 5099.999978ps       -27.04391
+ 5109.999979ps      -25.840872
+ 5119.999980ps      -24.416408
+ 5129.999980ps       -22.81903
+ 5139.999981ps      -21.237607
+ 5149.999982ps      -19.716657
+ 5159.999983ps      -18.368556
+ 5169.999984ps      -17.187363
+ 5179.999985ps      -16.202769
+ 5189.999985ps      -15.447756
+ 5199.999986ps      -14.915851
+ 5209.999987ps      -14.672819
+ 5219.999988ps      -14.703409
+ 5229.999989ps      -15.153055
+ 5239.999989ps      -16.030473
+ 5249.999990ps      -17.381141
+ 5259.999991ps      -19.425834
+ 5269.999992ps      -22.975381
+ 5279.999993ps      -26.996596
+ 5289.999994ps      -29.514647
+ 5299.999994ps      -30.247245
+ 5309.999995ps      -29.939198
+ 5319.999996ps      -28.958814
+ 5329.999997ps      -27.461121
+ 5339.999998ps      -25.617476
+ 5349.999999ps      -23.550834
+ 5359.999999ps      -21.402499
+ 5370.000000ps      -19.371386
+ 5380.000001ps      -17.508964
+ 5390.000002ps      -15.860797
+ 5400.000003ps      -14.486315
+ 5410.000004ps      -13.359275
+ 5420.000004ps        -12.4808
+ 5430.000005ps      -11.851227
+ 5440.000006ps      -11.458999
+ 5450.000007ps      -11.265844
+ 5460.000008ps       -11.34679
+ 5470.000009ps      -11.640517
+ 5480.000009ps      -12.218621
+ 5490.000010ps      -13.166271
+ 5500.000011ps       -14.65613
+ 5510.000012ps      -16.848355
+ 5520.000013ps      -19.877784
+ 5530.000013ps      -22.612826
+ 5540.000014ps      -24.783183
+ 5550.000015ps      -26.568723
+ 5560.000016ps      -27.914695
+ 5570.000017ps      -28.576898
+ 5580.000018ps      -28.531821
+ 5590.000018ps      -27.925879
+ 5600.000019ps      -27.015461
+ 5610.000020ps      -25.823506
+ 5620.000021ps      -24.377781
+ 5630.000022ps      -22.753742
+ 5640.000023ps      -21.101832
+ 5650.000023ps      -19.482767
+ 5660.000024ps      -17.984919
+ 5670.000025ps      -16.677158
+ 5680.000026ps      -15.642864
+ 5690.000027ps      -14.877257
+ 5700.000028ps      -14.401427
+ 5710.000028ps      -14.209587
+ 5720.000029ps      -14.324998
+ 5730.000030ps      -14.869692
+ 5740.000031ps      -15.841625
+ 5750.000032ps      -17.257346
+ 5760.000032ps      -19.344684
+ 5770.000033ps       -22.91912
+ 5780.000034ps      -26.954714
+ 5790.000035ps      -29.483313
+ 5800.000036ps      -30.229624
+ 5810.000037ps      -29.937397
+ 5820.000037ps      -28.967121
+ 5830.000038ps      -27.482152
+ 5840.000039ps      -25.653949
+ 5850.000040ps      -23.616375
+ 5860.000041ps      -21.491861
+ 5870.000042ps      -19.477327
+ 5880.000042ps      -17.620007
+ 5890.000043ps      -15.972899
+ 5900.000044ps      -14.589921
+ 5910.000045ps      -13.437587
+ 5920.000046ps      -12.537603
+ 5930.000047ps      -11.850244
+ 5940.000047ps      -11.416211
+ 5950.000048ps      -11.197215
+ 5960.000049ps       -11.25946
+ 5970.000050ps      -11.550033
+ 5980.000051ps      -12.137255
+ 5990.000052ps      -13.124689
+ 6000.000052ps      -14.678272
+ 6010.000053ps      -16.952455
+ 6020.000054ps      -20.063301
+ 6030.000055ps      -22.868142
+ 6040.000056ps      -25.049688
+ 6050.000056ps      -26.844381
+ 6060.000057ps      -28.149285
+ 6070.000058ps       -28.76568
+ 6080.000059ps      -28.638815
+ 6090.000060ps      -27.979622
+ 6100.000061ps      -27.013354
+ 6110.000061ps       -25.78998
+ 6120.000062ps      -24.377906
+ 6130.000063ps      -22.793388
+ 6140.000064ps      -21.181669
+ 6150.000065ps       -19.63916
+ 6160.000066ps       -18.22538
+ 6170.000066ps       -17.01024
+ 6180.000067ps      -16.022357
+ 6190.000068ps      -15.276803
+ 6200.000069ps      -14.740273
+ 6210.000070ps      -14.499298
+ 6220.000071ps      -14.561996
+ 6230.000071ps      -15.055153
+ 6240.000072ps      -15.966392
+ 6250.000073ps      -17.341166
+ 6260.000074ps      -19.397711
+ 6270.000075ps      -22.948173
+ 6280.000076ps      -26.973468
+ 6290.000076ps      -29.503587
+ 6300.000077ps      -30.252642
+ 6310.000078ps       -29.95876
+ 6320.000079ps      -28.971855
+ 6330.000080ps      -27.467843
+ 6340.000080ps      -25.617582
+ 6350.000081ps      -23.545109
+ 6360.000082ps      -21.389639
+ 6370.000083ps      -19.348815
+ 6380.000084ps       -17.48056
+ 6390.000085ps      -15.816236
+ 6400.000085ps      -14.426662
+ 6410.000086ps      -13.277392
+ 6420.000087ps      -12.361186
+ 6430.000088ps      -11.673336
+ 6440.000089ps      -11.229281
+ 6450.000090ps      -11.019763
+ 6460.000090ps        -11.0882
+ 6470.000091ps      -11.392185
+ 6480.000092ps      -11.988443
+ 6490.000093ps      -12.986289
+ 6500.000094ps      -14.542883
+ 6510.000095ps      -16.829902
+ 6520.000095ps      -19.940885
+ 6530.000096ps      -22.737133
+ 6540.000097ps      -24.944851
+ 6550.000098ps      -26.726294
+ 6560.000099ps      -28.075054
+ 6570.000100ps      -28.713625
+ 6580.000100ps      -28.613432
+ 6590.000101ps      -27.949864
+ 6600.000102ps      -26.993016
+ 6610.000103ps      -25.756741
+ 6620.000104ps      -24.319302
+ 6630.000104ps      -22.698366
+ 6640.000105ps      -21.099841
+ 6650.000106ps      -19.551832
+ 6660.000107ps      -18.124928
+ 6670.000108ps      -16.866189
+ 6680.000109ps      -15.884103
+ 6690.000109ps      -15.146559
+ 6700.000110ps      -14.659662
+ 6710.000111ps      -14.435617
+ 6720.000112ps      -14.509181
+ 6730.000113ps      -14.997825
+ 6740.000114ps      -15.912514
+ 6750.000114ps      -17.279135
+ 6760.000115ps      -19.356534
+ 6770.000116ps       -22.91811
+ 6780.000117ps       -26.95636
+ 6790.000118ps      -29.485193
+ 6800.000119ps      -30.223706
+ 6810.000119ps       -29.91805
+ 6820.000120ps      -28.923641
+ 6830.000121ps      -27.416152
+ 6840.000122ps      -25.564984
+ 6850.000123ps      -23.502505
+ 6860.000124ps      -21.353679
+ 6870.000124ps      -19.317845
+ 6880.000125ps      -17.438446
+ 6890.000126ps      -15.783201
+ 6900.000127ps      -14.386192
+ 6910.000128ps       -13.23892
+ 6920.000128ps      -12.347195
+ 6930.000129ps      -11.705116
+ 6940.000130ps      -11.293002
+ 6950.000131ps      -11.109508
+ 6960.000132ps       -11.18224
+ 6970.000133ps      -11.474256
+ 6980.000133ps       -12.04958
+ 6990.000134ps       -13.01754
+ 7000.000135ps      -14.534629
+ 7010.000136ps      -16.775237
+ 7020.000137ps        -19.8607
+ 7030.000138ps      -22.654058
+ 7040.000138ps       -24.83612
+ 7050.000139ps       -26.63292
+ 7060.000140ps      -27.971563
+ 7070.000141ps       -28.61727
+ 7080.000142ps      -28.518884
+ 7090.000143ps      -27.874835
+ 7100.000143ps      -26.904678
+ 7110.000144ps      -25.674094
+ 7120.000145ps      -24.202732
+ 7130.000146ps      -22.567437
+ 7140.000147ps       -20.94426
+ 7150.000148ps      -19.396381
+ 7160.000148ps      -17.984772
+ 7170.000149ps      -16.753349
+ 7180.000150ps      -15.755296
+ 7190.000151ps      -15.026475
+ 7200.000152ps      -14.541674
+ 7210.000152ps      -14.343818
+ 7220.000153ps      -14.452617
+ 7230.000154ps       -14.96578
+ 7240.000155ps       -15.90159
+ 7250.000156ps      -17.291076
+ 7260.000157ps      -19.364516
+ 7270.000157ps      -22.927908
+ 7280.000158ps      -26.966985
+ 7290.000159ps      -29.489719
+ 7300.000160ps      -30.228318
+ 7310.000161ps      -29.918566
+ 7320.000162ps      -28.930268
+ 7330.000162ps      -27.425398
+ 7340.000163ps      -25.573529
+ 7350.000164ps      -23.514641
+ 7360.000165ps      -21.353498
+ 7370.000166ps      -19.310259
+ 7380.000167ps       -17.43997
+ 7390.000167ps      -15.783841
+ 7400.000168ps       -14.40015
+ 7410.000169ps      -13.263318
+ 7420.000170ps      -12.385107
+ 7430.000171ps      -11.749461
+ 7440.000171ps      -11.329331
+ 7450.000172ps      -11.119442
+ 7459.999729ps      -11.173815
+ 7469.999730ps      -11.471875
+ 7479.999731ps      -12.074648
+ 7489.999732ps      -13.099243
+ 7499.999732ps      -14.684796
+ 7509.999733ps      -16.993659
+ 7519.999734ps      -20.121777
+ 7529.999735ps      -22.902666
+ 7539.999736ps       -25.04683
+ 7549.999737ps      -26.787288
+ 7559.999737ps      -28.096719
+ 7569.999738ps      -28.707494
+ 7579.999739ps      -28.610367
+ 7589.999740ps      -27.986806
+ 7599.999741ps      -27.049997
+ 7609.999741ps      -25.855907
+ 7619.999742ps      -24.429593
+ 7629.999743ps      -22.803973
+ 7639.999744ps      -21.203695
+ 7649.999745ps      -19.666109
+ 7659.999746ps      -18.292551
+ 7669.999746ps      -17.084288
+ 7679.999747ps      -16.089546
+ 7689.999748ps      -15.300807
+ 7699.999749ps      -14.741646
+ 7709.999750ps      -14.460233
+ 7719.999751ps      -14.532202
+ 7729.999751ps      -15.029613
+ 7739.999752ps       -15.96959
+ 7749.999753ps      -17.342965
+ 7759.999754ps       -19.39532
+ 7769.999755ps      -22.937275
+ 7779.999756ps      -26.960821
+ 7789.999756ps      -29.478683
+ 7799.999757ps      -30.215865
+ 7809.999758ps      -29.913069
+ 7819.999759ps       -28.92926
+ 7829.999760ps      -27.431873
+ 7839.999761ps      -25.589545
+ 7849.999761ps      -23.539081
+ 7859.999762ps      -21.393198
+ 7869.999763ps       -19.35896
+ 7879.999764ps      -17.484384
+ 7889.999765ps      -15.839989
+ 7899.999765ps      -14.452112
+ 7909.999766ps      -13.321538
+ 7919.999767ps      -12.431926
+ 7929.999768ps      -11.779386
+ 7939.999769ps      -11.345865
+ 7949.999770ps      -11.133682
+ 7959.999770ps      -11.204818
+ 7969.999771ps      -11.519921
+ 7979.999772ps      -12.090053
+ 7989.999773ps      -12.944563
+ 7999.999774ps      -13.794398
+ 8009.999775ps      -14.312068
+ 8019.999775ps      -14.606383
+ 8029.999776ps      -14.793429
+ 8039.999777ps      -14.916293
+ 8049.999778ps      -14.999659
+ 8059.999779ps      -15.057313
+ 8069.999780ps      -15.097591
+ 8079.999780ps      -15.126033
+ 8089.999781ps      -15.146318
+ 8099.999782ps      -15.160917
+ 8109.999783ps      -15.171512
+ 8119.999784ps      -15.179256
+ 8129.999785ps      -15.184953
+ 8139.999785ps      -15.189168
+ 8149.999786ps        -15.1923
+ 8159.999787ps      -15.194636
+ 8169.999788ps      -15.196383
+ 8179.999789ps      -15.197689
+ 8189.999789ps      -15.198665
+ 8199.999790ps      -15.199393
+ 8209.999791ps      -15.199931
+ 8219.999792ps      -15.200327
+ 8229.999793ps      -15.200612
+ 8239.999794ps      -15.200814
+ 8249.999794ps      -15.200951
+ 8259.999795ps      -15.201038
+ 8269.999796ps      -15.201086
+ 8279.999797ps      -15.201105
+ 8289.999798ps      -15.201102
+ 8299.999799ps       -15.20108
+ 8309.999799ps      -15.201046
+)

Icursig11 PAR_1_1_VDD075NNE 0 pwl(
+ 0.000000ps       8.2624536
+ 10.000000ps       9.1245896
+ 20.000000ps       12.845488
+ 29.999999ps       18.429764
+ 40.000000ps       23.487771
+ 50.000001ps       27.387217
+ 59.999998ps        30.31245
+ 69.999999ps       32.205601
+ 80.000000ps       33.015439
+ 90.000001ps       33.010896
+ 100.000001ps       32.403553
+ 110.000002ps       31.217467
+ 119.999996ps       29.508317
+ 129.999997ps       27.430335
+ 139.999998ps       25.112897
+ 149.999999ps       22.838748
+ 159.999999ps       20.701879
+ 170.000000ps       18.760985
+ 180.000001ps       17.014728
+ 190.000002ps       15.578556
+ 200.000003ps       14.466192
+ 210.000003ps       13.685988
+ 220.000004ps       13.229478
+ 230.000005ps        13.09653
+ 239.999992ps       13.327236
+ 249.999993ps        13.99064
+ 259.999994ps       15.150328
+ 269.999995ps       16.902808
+ 279.999995ps       18.420903
+ 289.999996ps       19.408341
+ 299.999997ps       20.105475
+ 309.999998ps        20.48946
+ 319.999999ps       20.441594
+ 330.000000ps       19.995192
+ 340.000000ps       19.270789
+ 350.000001ps       18.330941
+ 360.000002ps       17.290255
+ 370.000003ps       16.155369
+ 380.000004ps       15.007278
+ 390.000005ps        13.89827
+ 400.000005ps       12.912476
+ 410.000006ps       12.105675
+ 420.000007ps       11.458169
+ 430.000008ps       11.001324
+ 440.000009ps       10.778758
+ 450.000009ps       10.801272
+ 460.000010ps       11.084819
+ 469.999983ps       11.677892
+ 479.999984ps       12.648757
+ 489.999985ps       14.071102
+ 499.999986ps       15.972853
+ 509.999987ps       18.599296
+ 519.999988ps       22.858797
+ 529.999988ps       27.926392
+ 539.999989ps       31.871614
+ 549.999990ps       34.375793
+ 559.999991ps        35.91314
+ 569.999992ps       36.553009
+ 579.999992ps       36.373694
+ 589.999993ps       35.567158
+ 599.999994ps        34.34096
+ 609.999995ps       32.692944
+ 619.999996ps       30.666225
+ 629.999997ps       28.342958
+ 639.999997ps       25.877639
+ 649.999998ps       23.505815
+ 659.999999ps       21.223603
+ 670.000000ps       19.179172
+ 680.000001ps       17.406012
+ 690.000002ps       15.935238
+ 700.000002ps       14.777402
+ 710.000003ps       13.933822
+ 720.000004ps        13.40121
+ 730.000005ps       13.176517
+ 740.000006ps       13.322231
+ 750.000007ps       13.933565
+ 760.000007ps       15.087295
+ 770.000008ps       16.869961
+ 780.000009ps       18.396037
+ 790.000010ps       19.388718
+ 800.000011ps       20.087605
+ 810.000012ps       20.470177
+ 820.000012ps       20.444183
+ 830.000013ps       20.014838
+ 840.000014ps       19.303984
+ 850.000015ps       18.392237
+ 860.000016ps        17.35954
+ 870.000016ps       16.243611
+ 880.000017ps       15.130037
+ 890.000018ps       14.059269
+ 900.000019ps       13.102972
+ 910.000020ps       12.289419
+ 920.000021ps       11.634395
+ 930.000021ps       11.148194
+ 939.999967ps       10.886771
+ 949.999968ps       10.839447
+ 959.999968ps       11.087567
+ 969.999969ps       11.653926
+ 979.999970ps       12.629651
+ 989.999971ps       14.037732
+ 999.999972ps        15.93939
+ 1009.999973ps       18.576727
+ 1019.999973ps       22.845029
+ 1029.999974ps       27.922831
+ 1039.999975ps        31.89923
+ 1049.999976ps       34.391793
+ 1059.999977ps       35.917382
+ 1069.999978ps       36.595901
+ 1079.999978ps       36.486955
+ 1089.999979ps       35.726948
+ 1099.999980ps        34.46695
+ 1109.999981ps       32.771953
+ 1119.999982ps       30.691917
+ 1129.999982ps       28.317929
+ 1139.999983ps       25.836104
+ 1149.999984ps       23.482575
+ 1159.999985ps       21.275077
+ 1169.999986ps       19.300271
+ 1179.999987ps       17.575473
+ 1189.999987ps        16.09657
+ 1199.999988ps        14.91289
+ 1209.999989ps       14.075074
+ 1219.999990ps       13.528494
+ 1229.999991ps       13.295729
+ 1239.999992ps          13.458
+ 1249.999992ps       14.069382
+ 1259.999993ps        15.18258
+ 1269.999994ps        16.90442
+ 1279.999995ps       18.407806
+ 1289.999996ps       19.379151
+ 1299.999997ps       20.066442
+ 1309.999997ps       20.441902
+ 1319.999998ps       20.400322
+ 1329.999999ps       19.957069
+ 1340.000000ps       19.242973
+ 1350.000001ps       18.328381
+ 1360.000002ps       17.299119
+ 1370.000002ps       16.174687
+ 1380.000003ps       15.047229
+ 1390.000004ps       13.956961
+ 1400.000005ps       12.990322
+ 1410.000006ps       12.158403
+ 1420.000006ps       11.497123
+ 1430.000007ps       11.020778
+ 1440.000008ps       10.776444
+ 1450.000009ps       10.774942
+ 1460.000010ps       11.056895
+ 1470.000011ps       11.669341
+ 1480.000011ps       12.697631
+ 1490.000012ps       14.161335
+ 1500.000013ps        16.10666
+ 1510.000014ps       18.776614
+ 1520.000015ps       23.083092
+ 1530.000016ps       28.136688
+ 1540.000016ps       32.019225
+ 1550.000017ps       34.473531
+ 1560.000018ps       35.963481
+ 1570.000019ps       36.590376
+ 1580.000020ps       36.412711
+ 1590.000021ps       35.637997
+ 1600.000021ps       34.406999
+ 1610.000022ps       32.761289
+ 1620.000023ps       30.741706
+ 1630.000024ps       28.433092
+ 1640.000025ps       25.986964
+ 1650.000025ps        23.63002
+ 1660.000026ps       21.370691
+ 1670.000027ps       19.332395
+ 1680.000028ps       17.586724
+ 1690.000029ps       16.091741
+ 1700.000030ps       14.842529
+ 1710.000030ps        13.92634
+ 1720.000031ps       13.340756
+ 1730.000032ps       13.114357
+ 1740.000033ps        13.25811
+ 1750.000034ps        13.86689
+ 1760.000035ps       15.019715
+ 1770.000035ps       16.795716
+ 1780.000036ps        18.31952
+ 1790.000037ps       19.298881
+ 1800.000038ps       19.999413
+ 1810.000039ps       20.384983
+ 1820.000040ps       20.361545
+ 1830.000040ps       19.931464
+ 1840.000041ps       19.215075
+ 1850.000042ps       18.283484
+ 1860.000043ps       17.228083
+ 1869.999933ps       16.082983
+ 1879.999934ps       14.945031
+ 1889.999934ps       13.845164
+ 1899.999935ps       12.860202
+ 1909.999936ps       12.034881
+ 1919.999937ps       11.385374
+ 1929.999938ps       10.931328
+ 1939.999938ps       10.697812
+ 1949.999939ps       10.708817
+ 1959.999940ps       11.016449
+ 1969.999941ps       11.631771
+ 1979.999942ps       12.634043
+ 1989.999943ps       14.071278
+ 1999.999943ps       15.991257
+ 2009.999944ps       18.644952
+ 2019.999945ps       22.897882
+ 2029.999946ps       27.940654
+ 2039.999947ps       31.861263
+ 2049.999948ps        34.33193
+ 2059.999948ps       35.868233
+ 2069.999949ps       36.563998
+ 2079.999950ps       36.425727
+ 2089.999951ps       35.661372
+ 2099.999952ps        34.43131
+ 2109.999953ps       32.781403
+ 2119.999953ps       30.754266
+ 2129.999954ps       28.435529
+ 2139.999955ps        25.96072
+ 2149.999956ps       23.600476
+ 2159.999957ps       21.372106
+ 2169.999958ps       19.381695
+ 2179.999958ps       17.581745
+ 2189.999959ps       16.022049
+ 2199.999960ps       14.768471
+ 2209.999961ps       13.925828
+ 2219.999962ps       13.402323
+ 2229.999962ps       13.192364
+ 2239.999963ps       13.338226
+ 2249.999964ps       13.938876
+ 2259.999965ps       15.068192
+ 2269.999966ps       16.811491
+ 2279.999967ps       18.309119
+ 2289.999967ps       19.267373
+ 2299.999968ps       19.958889
+ 2309.999969ps       20.344788
+ 2319.999970ps       20.319311
+ 2329.999971ps       19.892243
+ 2339.999972ps       19.190466
+ 2349.999972ps       18.286787
+ 2359.999973ps       17.265585
+ 2369.999974ps       16.144627
+ 2379.999975ps       15.003545
+ 2389.999976ps       13.886927
+ 2399.999977ps       12.884779
+ 2409.999977ps       12.036387
+ 2419.999978ps       11.366526
+ 2429.999979ps       10.879449
+ 2439.999980ps       10.626485
+ 2449.999981ps       10.629439
+ 2459.999981ps       10.930269
+ 2469.999982ps       11.557879
+ 2479.999983ps       12.582357
+ 2489.999984ps       14.037597
+ 2499.999985ps        15.95501
+ 2509.999986ps       18.584911
+ 2519.999986ps       22.836701
+ 2529.999987ps       27.887735
+ 2539.999988ps       31.799764
+ 2549.999989ps         34.2831
+ 2559.999990ps       35.812079
+ 2569.999991ps       36.480267
+ 2579.999991ps       36.338886
+ 2589.999992ps       35.551832
+ 2599.999993ps       34.301928
+ 2609.999994ps        32.64042
+ 2619.999995ps       30.590603
+ 2629.999996ps       28.259829
+ 2639.999996ps       25.799743
+ 2649.999997ps       23.439605
+ 2659.999998ps       21.182964
+ 2669.999999ps        19.14238
+ 2680.000000ps       17.331503
+ 2690.000001ps       15.799295
+ 2700.000001ps       14.616153
+ 2710.000002ps       13.789572
+ 2720.000003ps       13.298803
+ 2730.000004ps       13.117313
+ 2740.000005ps       13.272521
+ 2750.000005ps       13.857971
+ 2760.000006ps       14.978286
+ 2770.000007ps       16.729321
+ 2780.000008ps       18.254988
+ 2790.000009ps       19.243393
+ 2800.000010ps       19.947297
+ 2810.000010ps       20.339172
+ 2820.000011ps       20.312096
+ 2830.000012ps        19.87775
+ 2840.000013ps       19.161671
+ 2850.000014ps       18.248451
+ 2860.000015ps       17.215017
+ 2870.000015ps       16.074868
+ 2880.000016ps       14.931377
+ 2890.000017ps       13.833646
+ 2900.000018ps       12.853341
+ 2910.000019ps        12.03184
+ 2920.000020ps       11.388142
+ 2930.000020ps       10.928357
+ 2940.000021ps        10.70778
+ 2950.000022ps       10.737753
+ 2960.000023ps       11.055697
+ 2970.000024ps       11.695534
+ 2980.000025ps       12.756784
+ 2990.000025ps       14.227419
+ 3000.000026ps       16.140393
+ 3010.000027ps       18.756586
+ 3020.000028ps       22.992725
+ 3030.000029ps       28.038783
+ 3040.000029ps       31.938057
+ 3050.000030ps       34.364935
+ 3060.000031ps       35.830994
+ 3070.000032ps       36.489661
+ 3080.000033ps       36.311802
+ 3090.000034ps        35.51597
+ 3100.000034ps       34.317933
+ 3110.000035ps       32.692569
+ 3120.000036ps       30.675752
+ 3130.000037ps       28.389856
+ 3140.000038ps       25.963266
+ 3150.000039ps       23.608621
+ 3160.000039ps       21.355608
+ 3170.000040ps       19.297173
+ 3180.000041ps       17.480055
+ 3190.000042ps       15.951678
+ 3200.000043ps       14.733193
+ 3210.000044ps       13.821178
+ 3220.000044ps       13.221081
+ 3230.000045ps       12.979268
+ 3240.000046ps       13.144295
+ 3250.000047ps       13.773146
+ 3260.000048ps       14.943542
+ 3270.000049ps        16.71705
+ 3280.000049ps       18.246477
+ 3290.000050ps       19.223749
+ 3300.000051ps        19.92193
+ 3310.000052ps       20.305473
+ 3320.000053ps       20.277496
+ 3330.000053ps       19.845203
+ 3340.000054ps       19.139965
+ 3350.000055ps       18.234328
+ 3360.000056ps       17.210076
+ 3370.000057ps       16.095929
+ 3380.000058ps       14.970104
+ 3390.000058ps       13.893207
+ 3400.000059ps       12.934245
+ 3410.000060ps       12.137836
+ 3420.000061ps       11.500518
+ 3430.000062ps       11.042517
+ 3440.000063ps       10.787695
+ 3450.000063ps       10.804973
+ 3460.000064ps       11.074539
+ 3470.000065ps       11.667013
+ 3480.000066ps       12.661581
+ 3490.000067ps       14.101831
+ 3500.000068ps       16.031697
+ 3510.000068ps       18.674935
+ 3520.000069ps       22.931235
+ 3530.000070ps       27.974709
+ 3540.000071ps       31.877034
+ 3550.000072ps       34.357944
+ 3560.000073ps       35.857059
+ 3570.000073ps       36.495699
+ 3580.000074ps       36.340225
+ 3590.000075ps       35.572508
+ 3600.000076ps       34.379177
+ 3610.000077ps       32.747027
+ 3620.000077ps       30.747097
+ 3630.000078ps       28.432881
+ 3640.000079ps       25.997603
+ 3650.000080ps       23.646965
+ 3660.000081ps        21.38232
+ 3670.000082ps        19.32433
+ 3680.000082ps       17.526345
+ 3690.000083ps       16.002069
+ 3700.000084ps       14.760679
+ 3710.000085ps       13.857336
+ 3720.000086ps       13.268045
+ 3729.999865ps       13.030431
+ 3739.999865ps        13.18194
+ 3749.999866ps       13.809864
+ 3759.999867ps       14.953592
+ 3769.999868ps       16.711271
+ 3779.999869ps        18.23188
+ 3789.999869ps       19.214897
+ 3799.999870ps       19.910491
+ 3809.999871ps       20.296791
+ 3819.999872ps       20.272751
+ 3829.999873ps       19.839248
+ 3839.999874ps        19.12966
+ 3849.999874ps       18.216941
+ 3859.999875ps       17.186969
+ 3869.999876ps       16.053915
+ 3879.999877ps       14.905629
+ 3889.999878ps       13.791866
+ 3899.999879ps        12.79183
+ 3909.999879ps       11.952345
+ 3919.999880ps       11.296574
+ 3929.999881ps       10.824782
+ 3939.999882ps       10.586301
+ 3949.999883ps       10.571094
+ 3959.999884ps       10.852925
+ 3969.999884ps       11.431292
+ 3979.999885ps       12.427581
+ 3989.999886ps       13.877152
+ 3999.999887ps       15.809449
+ 4009.999888ps       18.481375
+ 4019.999889ps       22.793437
+ 4029.999889ps       27.923462
+ 4039.999890ps       31.926177
+ 4049.999891ps       34.468819
+ 4059.999892ps       36.028014
+ 4069.999893ps       36.694935
+ 4079.999893ps       36.499927
+ 4089.999894ps       35.673837
+ 4099.999895ps       34.400894
+ 4109.999896ps       32.695861
+ 4119.999897ps       30.658671
+ 4129.999898ps       28.309061
+ 4139.999898ps       25.841003
+ 4149.999899ps       23.488108
+ 4159.999900ps       21.255579
+ 4169.999901ps       19.245641
+ 4179.999902ps        17.50659
+ 4189.999903ps       16.039261
+ 4199.999903ps       14.879325
+ 4209.999904ps        14.04942
+ 4219.999905ps       13.518188
+ 4229.999906ps       13.282847
+ 4239.999907ps       13.386991
+ 4249.999908ps       13.957797
+ 4259.999908ps       15.071671
+ 4269.999909ps       16.815142
+ 4279.999910ps       18.322914
+ 4289.999911ps       19.293291
+ 4299.999912ps       19.985452
+ 4309.999913ps        20.36401
+ 4319.999913ps       20.327567
+ 4329.999914ps       19.887731
+ 4339.999915ps       19.170806
+ 4349.999916ps       18.247839
+ 4359.999917ps       17.206736
+ 4369.999917ps        16.07468
+ 4379.999918ps       14.933122
+ 4389.999919ps       13.814617
+ 4399.999920ps       12.824055
+ 4409.999921ps       12.006178
+ 4419.999922ps       11.355971
+ 4429.999922ps       10.905539
+ 4439.999923ps       10.678446
+ 4449.999924ps       10.668467
+ 4459.999925ps       10.921604
+ 4469.999926ps       11.496948
+ 4479.999927ps       12.464859
+ 4489.999927ps       13.890117
+ 4499.999928ps       15.798537
+ 4509.999929ps        18.44616
+ 4519.999930ps       22.701713
+ 4529.999931ps       27.751406
+ 4539.999932ps       31.663657
+ 4549.999932ps        34.14403
+ 4559.999933ps       35.653622
+ 4569.999934ps       36.317298
+ 4579.999935ps       36.192916
+ 4589.999936ps       35.435375
+ 4599.999937ps       34.210988
+ 4609.999937ps       32.564413
+ 4619.999938ps       30.519708
+ 4629.999939ps       28.167772
+ 4639.999940ps       25.682443
+ 4649.999941ps       23.297379
+ 4659.999941ps       21.056733
+ 4669.999942ps       19.044286
+ 4679.999943ps       17.271525
+ 4689.999944ps       15.763592
+ 4699.999945ps       14.547002
+ 4709.999946ps       13.688728
+ 4719.999946ps       13.182176
+ 4729.999947ps       13.002893
+ 4739.999948ps       13.194492
+ 4749.999949ps       13.841837
+ 4759.999950ps       14.985053
+ 4769.999951ps       16.742178
+ 4779.999951ps       18.251111
+ 4789.999952ps       19.233532
+ 4799.999953ps       19.930836
+ 4809.999954ps       20.315597
+ 4819.999955ps       20.285167
+ 4829.999956ps       19.854226
+ 4839.999956ps       19.142241
+ 4849.999957ps       18.232477
+ 4859.999958ps       17.200558
+ 4869.999959ps       16.081212
+ 4879.999960ps       14.946097
+ 4889.999961ps       13.848322
+ 4899.999961ps       12.847878
+ 4909.999962ps       11.994877
+ 4919.999963ps       11.323313
+ 4929.999964ps       10.838563
+ 4939.999965ps       10.588527
+ 4949.999965ps       10.574773
+ 4959.999966ps       10.856919
+ 4969.999967ps       11.459905
+ 4979.999968ps        12.48321
+ 4989.999969ps       13.957963
+ 4999.999970ps       15.926208
+ 5009.999970ps       18.619597
+ 5019.999971ps         22.9422
+ 5029.999972ps        28.06051
+ 5039.999973ps       32.033153
+ 5049.999974ps       34.509516
+ 5059.999975ps       35.981268
+ 5069.999975ps       36.588106
+ 5079.999976ps       36.371104
+ 5089.999977ps       35.560339
+ 5099.999978ps       34.331895
+ 5109.999979ps       32.668713
+ 5119.999980ps       30.627672
+ 5129.999980ps       28.338574
+ 5139.999981ps       25.900437
+ 5149.999982ps       23.572074
+ 5159.999983ps       21.369141
+ 5169.999984ps       19.385287
+ 5179.999985ps         17.6331
+ 5189.999985ps       16.135362
+ 5199.999986ps       14.920537
+ 5209.999987ps       14.032304
+ 5219.999988ps       13.434592
+ 5229.999989ps       13.164789
+ 5239.999989ps       13.263416
+ 5249.999990ps       13.840099
+ 5259.999991ps       14.977385
+ 5269.999992ps       16.743178
+ 5279.999993ps       18.268516
+ 5289.999994ps         19.2448
+ 5299.999994ps        19.93732
+ 5309.999995ps       20.320064
+ 5319.999996ps       20.290176
+ 5329.999997ps       19.859463
+ 5339.999998ps       19.149592
+ 5349.999999ps       18.241021
+ 5359.999999ps       17.210643
+ 5370.000000ps       16.092164
+ 5380.000001ps       14.964465
+ 5390.000002ps       13.875994
+ 5400.000003ps       12.901939
+ 5410.000004ps       12.079096
+ 5420.000004ps       11.427902
+ 5430.000005ps       10.974578
+ 5440.000006ps       10.778174
+ 5450.000007ps       10.796771
+ 5460.000008ps       11.105759
+ 5470.000009ps        11.70038
+ 5480.000009ps       12.682068
+ 5490.000010ps        14.08617
+ 5500.000011ps       15.955125
+ 5510.000012ps       18.531095
+ 5520.000013ps       22.732745
+ 5530.000013ps       27.763274
+ 5540.000014ps       31.678516
+ 5550.000015ps       34.169552
+ 5560.000016ps       35.699118
+ 5570.000017ps       36.364415
+ 5580.000018ps       36.216582
+ 5590.000018ps       35.464241
+ 5600.000019ps       34.263869
+ 5610.000020ps       32.646034
+ 5620.000021ps       30.630253
+ 5630.000022ps       28.302022
+ 5640.000023ps       25.815713
+ 5650.000023ps       23.392131
+ 5660.000024ps        21.06961
+ 5670.000025ps        18.97601
+ 5680.000026ps       17.169068
+ 5690.000027ps       15.662751
+ 5700.000028ps       14.472918
+ 5710.000028ps       13.640276
+ 5720.000029ps       13.113525
+ 5730.000030ps       12.924295
+ 5740.000031ps       13.104811
+ 5750.000032ps        13.75664
+ 5760.000032ps       14.923422
+ 5770.000033ps       16.710496
+ 5780.000034ps        18.23955
+ 5790.000035ps       19.227306
+ 5800.000036ps        19.93426
+ 5810.000037ps       20.323777
+ 5820.000037ps        20.31129
+ 5830.000038ps        19.90081
+ 5840.000039ps        19.20909
+ 5850.000040ps       18.321055
+ 5860.000041ps       17.313779
+ 5870.000042ps       16.216687
+ 5880.000042ps       15.108181
+ 5890.000043ps       14.018397
+ 5900.000044ps       13.034995
+ 5910.000045ps       12.194392
+ 5920.000046ps       11.519485
+ 5930.000047ps       11.000572
+ 5940.000047ps       10.725389
+ 5950.000048ps       10.695938
+ 5960.000049ps       10.976767
+ 5970.000050ps       11.572582
+ 5980.000051ps       12.577404
+ 5990.000052ps        14.03761
+ 6000.000052ps       15.955277
+ 6010.000053ps       18.611069
+ 6020.000054ps       22.898566
+ 6030.000055ps       27.997582
+ 6040.000056ps       31.957132
+ 6050.000056ps       34.432217
+ 6060.000057ps       35.923952
+ 6070.000058ps       36.555104
+ 6080.000059ps       36.356145
+ 6090.000060ps       35.549508
+ 6100.000061ps       34.320601
+ 6110.000061ps       32.651352
+ 6120.000062ps       30.626886
+ 6130.000063ps       28.310658
+ 6140.000064ps       25.858849
+ 6150.000065ps       23.498853
+ 6160.000066ps       21.242817
+ 6170.000066ps       19.210571
+ 6180.000067ps       17.452245
+ 6190.000068ps       15.944337
+ 6200.000069ps       14.720713
+ 6210.000070ps        13.84074
+ 6220.000071ps       13.269872
+ 6230.000071ps       13.041015
+ 6240.000072ps       13.174441
+ 6250.000073ps       13.782175
+ 6260.000074ps       14.928744
+ 6270.000075ps       16.700024
+ 6280.000076ps       18.232554
+ 6290.000076ps       19.226751
+ 6300.000077ps       19.934087
+ 6310.000078ps       20.325508
+ 6320.000079ps       20.290522
+ 6330.000080ps       19.851236
+ 6340.000080ps       19.134641
+ 6350.000081ps        18.21456
+ 6360.000082ps       17.178064
+ 6370.000083ps       16.048785
+ 6380.000084ps       14.917846
+ 6390.000085ps       13.819955
+ 6400.000085ps       12.835842
+ 6410.000086ps        12.00548
+ 6420.000087ps       11.327944
+ 6430.000088ps        10.83578
+ 6440.000089ps       10.576896
+ 6450.000090ps       10.565179
+ 6460.000090ps       10.854006
+ 6470.000091ps       11.457981
+ 6480.000092ps       12.462262
+ 6490.000093ps       13.913374
+ 6500.000094ps       15.839261
+ 6510.000095ps       18.491274
+ 6520.000095ps       22.778872
+ 6530.000096ps       27.869107
+ 6540.000097ps          31.818
+ 6550.000098ps       34.325779
+ 6560.000099ps       35.858242
+ 6570.000100ps       36.502794
+ 6580.000100ps       36.308901
+ 6590.000101ps       35.498926
+ 6600.000102ps       34.252945
+ 6610.000103ps       32.573104
+ 6620.000104ps       30.572539
+ 6630.000104ps       28.276449
+ 6640.000105ps       25.825954
+ 6650.000106ps       23.463503
+ 6660.000107ps       21.198708
+ 6670.000108ps       19.145469
+ 6680.000109ps       17.385575
+ 6690.000109ps       15.907147
+ 6700.000110ps       14.712624
+ 6710.000111ps       13.840398
+ 6720.000112ps       13.272392
+ 6730.000113ps       13.028356
+ 6740.000114ps       13.166392
+ 6750.000114ps       13.777779
+ 6760.000115ps       14.935808
+ 6770.000116ps       16.713953
+ 6780.000117ps       18.239578
+ 6790.000118ps        19.22878
+ 6800.000119ps       19.924257
+ 6810.000119ps       20.304981
+ 6820.000120ps       20.267317
+ 6830.000121ps       19.825604
+ 6840.000122ps       19.105529
+ 6850.000123ps       18.187123
+ 6860.000124ps       17.151977
+ 6870.000124ps       16.028276
+ 6880.000125ps       14.893582
+ 6890.000126ps       13.804242
+ 6900.000127ps       12.806499
+ 6910.000128ps       11.964602
+ 6920.000128ps        11.29238
+ 6930.000129ps       10.818388
+ 6940.000130ps       10.586451
+ 6950.000131ps       10.606373
+ 6960.000132ps       10.903992
+ 6970.000133ps       11.499478
+ 6980.000133ps       12.489125
+ 6990.000134ps       13.922525
+ 7000.000135ps       15.818173
+ 7010.000136ps       18.445115
+ 7020.000137ps       22.713303
+ 7030.000138ps       27.805531
+ 7040.000138ps       31.748323
+ 7050.000139ps       34.249701
+ 7060.000140ps       35.781853
+ 7070.000141ps       36.422255
+ 7080.000142ps        36.20908
+ 7090.000143ps       35.422703
+ 7100.000143ps       34.189501
+ 7110.000144ps        32.52608
+ 7120.000145ps       30.484021
+ 7130.000146ps        28.14496
+ 7140.000147ps       25.674143
+ 7150.000148ps       23.281796
+ 7160.000148ps       21.035307
+ 7170.000149ps       18.996836
+ 7180.000150ps       17.215546
+ 7190.000151ps       15.744132
+ 7200.000152ps       14.557715
+ 7210.000152ps       13.718982
+ 7220.000153ps       13.182516
+ 7230.000154ps       12.966444
+ 7240.000155ps        13.12291
+ 7250.000156ps       13.744281
+ 7260.000157ps       14.909597
+ 7270.000157ps       16.688312
+ 7280.000158ps       18.227646
+ 7290.000159ps       19.215003
+ 7300.000160ps       19.912522
+ 7310.000161ps       20.292508
+ 7320.000162ps       20.256495
+ 7330.000162ps       19.810566
+ 7340.000163ps        19.09264
+ 7350.000164ps       18.174671
+ 7360.000165ps       17.141348
+ 7370.000166ps       16.013958
+ 7380.000167ps       14.881589
+ 7390.000167ps       13.794165
+ 7400.000168ps       12.824784
+ 7410.000169ps       12.010774
+ 7420.000170ps       11.367604
+ 7430.000171ps       10.912906
+ 7440.000171ps       10.673692
+ 7450.000172ps       10.663034
+ 7459.999729ps       10.935212
+ 7469.999730ps       11.532861
+ 7479.999731ps       12.541314
+ 7489.999732ps       14.019946
+ 7499.999732ps       15.973581
+ 7509.999733ps       18.648275
+ 7519.999734ps       22.955096
+ 7529.999735ps       28.026188
+ 7539.999736ps       31.926237
+ 7549.999737ps       34.376954
+ 7559.999737ps       35.868165
+ 7569.999738ps       36.503387
+ 7579.999739ps       36.342061
+ 7589.999740ps       35.567392
+ 7599.999741ps       34.331826
+ 7609.999741ps        32.68242
+ 7619.999742ps       30.651294
+ 7629.999743ps       28.333897
+ 7639.999744ps        25.90307
+ 7649.999745ps       23.584113
+ 7659.999746ps       21.372371
+ 7669.999746ps       19.364786
+ 7679.999747ps       17.594216
+ 7689.999748ps       16.059777
+ 7699.999749ps       14.802334
+ 7709.999750ps        13.88243
+ 7719.999751ps       13.313649
+ 7729.999751ps       13.084677
+ 7739.999752ps         13.2361
+ 7749.999753ps        13.83898
+ 7759.999754ps        14.97178
+ 7769.999755ps         16.7318
+ 7779.999756ps       18.263363
+ 7789.999756ps       19.253656
+ 7799.999757ps       19.958601
+ 7809.999758ps       20.346255
+ 7819.999759ps       20.317873
+ 7829.999760ps       19.887668
+ 7839.999761ps         19.1786
+ 7849.999761ps        18.27397
+ 7859.999762ps       17.248361
+ 7869.999763ps       16.126814
+ 7879.999764ps       14.987606
+ 7889.999765ps       13.907542
+ 7899.999765ps       12.911216
+ 7909.999766ps       12.087352
+ 7919.999767ps       11.428443
+ 7929.999768ps       10.959652
+ 7939.999769ps       10.702937
+ 7949.999770ps       10.684276
+ 7959.999770ps       10.972532
+ 7969.999771ps        11.59156
+ 7979.999772ps       12.617846
+ 7989.999773ps       14.165223
+ 7999.999774ps       15.713302
+ 8009.999775ps       16.725447
+ 8019.999775ps       17.366198
+ 8029.999776ps       17.770265
+ 8039.999777ps       18.042439
+ 8049.999778ps       18.231501
+ 8059.999779ps       18.365807
+ 8069.999780ps       18.462817
+ 8079.999780ps       18.533917
+ 8089.999781ps       18.586701
+ 8099.999782ps       18.626341
+ 8109.999783ps        18.65643
+ 8119.999784ps       18.679497
+ 8129.999785ps       18.697349
+ 8139.999785ps        18.71129
+ 8149.999786ps       18.722272
+ 8159.999787ps       18.730996
+ 8169.999788ps       18.737984
+ 8179.999789ps       18.743625
+ 8189.999789ps       18.748214
+ 8199.999790ps       18.751974
+ 8209.999791ps       18.755077
+ 8219.999792ps       18.757655
+ 8229.999793ps       18.759811
+ 8239.999794ps       18.761626
+ 8249.999794ps       18.763161
+ 8259.999795ps       18.764467
+ 8269.999796ps       18.765584
+ 8279.999797ps       18.766544
+ 8289.999798ps       18.767372
+ 8299.999799ps        18.76809
+ 8309.999799ps       18.768714
+)

Icursig12 PAR_2_1_VSS 0 pwl(
+ 0.000000ps      -9.5685294
+ 10.000000ps      -10.830637
+ 20.000000ps      -13.187403
+ 29.999999ps      -15.392633
+ 40.000000ps      -17.144262
+ 50.000001ps      -18.554429
+ 59.999998ps      -19.418071
+ 69.999999ps      -19.436333
+ 80.000000ps      -18.771442
+ 90.000001ps      -17.766945
+ 100.000001ps      -16.670037
+ 110.000002ps      -15.655022
+ 119.999996ps      -14.707953
+ 129.999997ps      -13.940835
+ 139.999998ps      -13.419253
+ 149.999999ps      -13.222794
+ 159.999999ps      -13.347526
+ 170.000000ps      -13.840551
+ 180.000001ps      -14.785089
+ 190.000002ps      -16.049033
+ 200.000003ps      -17.610987
+ 210.000003ps      -19.298443
+ 220.000004ps      -20.845403
+ 230.000005ps      -22.347085
+ 239.999992ps      -23.514783
+ 249.999993ps      -24.447419
+ 259.999994ps      -25.253233
+ 269.999995ps      -26.251348
+ 279.999995ps      -26.884326
+ 289.999996ps      -26.070439
+ 299.999997ps       -24.19326
+ 309.999998ps      -21.975395
+ 319.999999ps      -19.724036
+ 330.000000ps      -17.630841
+ 340.000000ps      -15.769893
+ 350.000001ps      -14.188316
+ 360.000002ps      -12.900378
+ 370.000003ps       -11.93584
+ 380.000004ps      -11.255441
+ 390.000005ps      -10.852978
+ 400.000005ps      -10.714601
+ 410.000006ps       -10.85744
+ 420.000007ps      -11.309127
+ 430.000008ps      -12.073581
+ 440.000009ps      -13.119797
+ 450.000009ps      -14.420984
+ 460.000010ps      -15.939233
+ 469.999983ps      -17.647341
+ 479.999984ps      -19.413296
+ 489.999985ps      -21.134373
+ 499.999986ps      -22.888465
+ 509.999987ps      -24.689023
+ 519.999988ps      -26.406876
+ 529.999988ps      -27.345885
+ 539.999989ps      -27.523517
+ 549.999990ps      -27.140398
+ 559.999991ps      -26.245801
+ 569.999992ps       -24.76611
+ 579.999992ps      -22.926121
+ 589.999993ps      -20.977912
+ 599.999994ps      -19.168039
+ 609.999995ps      -17.614437
+ 619.999996ps       -16.27124
+ 629.999997ps      -15.188881
+ 639.999997ps      -14.431131
+ 649.999998ps      -14.058884
+ 659.999999ps      -14.058733
+ 670.000000ps      -14.438073
+ 680.000001ps      -15.287357
+ 690.000002ps      -16.454402
+ 700.000002ps      -17.939819
+ 710.000003ps      -19.548412
+ 720.000004ps      -21.043621
+ 730.000005ps      -22.503398
+ 740.000006ps      -23.649016
+ 750.000007ps       -24.58515
+ 760.000007ps      -25.400602
+ 770.000008ps      -26.430656
+ 780.000009ps      -27.100068
+ 790.000010ps      -26.313348
+ 800.000011ps      -24.458457
+ 810.000012ps      -22.239109
+ 820.000012ps      -19.990759
+ 830.000013ps      -17.904653
+ 840.000014ps      -16.013117
+ 850.000015ps      -14.412203
+ 860.000016ps      -13.108245
+ 870.000016ps      -12.115272
+ 880.000017ps       -11.40334
+ 890.000018ps      -10.961758
+ 900.000019ps      -10.777083
+ 910.000020ps       -10.87422
+ 920.000021ps      -11.304026
+ 930.000021ps      -12.049441
+ 939.999967ps      -13.067505
+ 949.999968ps      -14.332991
+ 959.999968ps      -15.847099
+ 969.999969ps      -17.570327
+ 979.999970ps      -19.359811
+ 989.999971ps      -21.064903
+ 999.999972ps      -22.791376
+ 1009.999973ps      -24.586478
+ 1019.999973ps      -26.294464
+ 1029.999974ps      -27.251679
+ 1039.999975ps      -27.431127
+ 1049.999976ps      -27.057421
+ 1059.999977ps      -26.137673
+ 1069.999978ps      -24.651723
+ 1079.999978ps      -22.820219
+ 1089.999979ps      -20.895056
+ 1099.999980ps      -19.109004
+ 1109.999981ps      -17.540768
+ 1119.999982ps      -16.197814
+ 1129.999982ps      -15.135943
+ 1139.999983ps      -14.416221
+ 1149.999984ps      -14.069444
+ 1159.999985ps      -14.073338
+ 1169.999986ps       -14.47645
+ 1179.999987ps      -15.323604
+ 1189.999987ps      -16.482565
+ 1199.999988ps      -17.933334
+ 1209.999989ps      -19.527367
+ 1219.999990ps      -21.023891
+ 1229.999991ps      -22.500175
+ 1239.999992ps      -23.658402
+ 1249.999992ps      -24.588658
+ 1259.999993ps       -25.38746
+ 1269.999994ps      -26.382262
+ 1279.999995ps      -27.017682
+ 1289.999996ps      -26.210266
+ 1299.999997ps      -24.347519
+ 1309.999997ps      -22.149114
+ 1319.999998ps       -19.91761
+ 1329.999999ps      -17.835531
+ 1340.000000ps      -15.975229
+ 1350.000001ps      -14.355157
+ 1360.000002ps      -13.036277
+ 1370.000002ps      -12.030988
+ 1380.000003ps       -11.30336
+ 1390.000004ps      -10.892128
+ 1400.000005ps      -10.769132
+ 1410.000006ps      -10.952888
+ 1420.000006ps      -11.455478
+ 1430.000007ps      -12.240948
+ 1440.000008ps       -13.31919
+ 1450.000009ps      -14.614425
+ 1460.000010ps      -16.123848
+ 1470.000011ps      -17.811095
+ 1480.000011ps      -19.582956
+ 1490.000012ps      -21.311664
+ 1500.000013ps      -23.049178
+ 1510.000014ps      -24.869111
+ 1520.000015ps      -26.586326
+ 1530.000016ps      -27.532454
+ 1540.000016ps      -27.698726
+ 1550.000017ps      -27.307563
+ 1560.000018ps      -26.431807
+ 1570.000019ps      -24.969764
+ 1580.000020ps      -23.137968
+ 1590.000021ps      -21.216496
+ 1600.000021ps       -19.41901
+ 1610.000022ps      -17.856865
+ 1620.000023ps      -16.495396
+ 1630.000024ps      -15.396609
+ 1640.000025ps      -14.633772
+ 1650.000025ps      -14.258194
+ 1660.000026ps      -14.209265
+ 1670.000027ps      -14.529738
+ 1680.000028ps      -15.309429
+ 1690.000029ps      -16.451767
+ 1700.000030ps      -17.901048
+ 1710.000030ps      -19.473939
+ 1720.000031ps      -20.929472
+ 1730.000032ps      -22.373582
+ 1740.000033ps      -23.509437
+ 1750.000034ps      -24.426784
+ 1760.000035ps      -25.223353
+ 1770.000035ps      -26.219536
+ 1780.000036ps      -26.860958
+ 1790.000037ps      -26.056698
+ 1800.000038ps      -24.201302
+ 1810.000039ps      -21.997406
+ 1820.000040ps      -19.756512
+ 1830.000040ps      -17.651969
+ 1840.000041ps      -15.781437
+ 1850.000042ps       -14.18041
+ 1860.000043ps      -12.888323
+ 1869.999933ps      -11.885367
+ 1879.999934ps      -11.177242
+ 1889.999934ps      -10.757723
+ 1899.999935ps      -10.618129
+ 1909.999936ps      -10.776666
+ 1919.999937ps      -11.275631
+ 1929.999938ps      -12.085921
+ 1939.999938ps      -13.204529
+ 1949.999939ps      -14.546257
+ 1959.999940ps      -16.127741
+ 1969.999941ps      -17.849212
+ 1979.999942ps      -19.594473
+ 1989.999943ps      -21.235235
+ 1999.999943ps      -22.859377
+ 2009.999944ps       -24.54324
+ 2019.999945ps      -26.198007
+ 2029.999946ps      -27.160797
+ 2039.999947ps      -27.366688
+ 2049.999948ps      -27.056061
+ 2059.999948ps      -26.232928
+ 2069.999949ps      -24.844855
+ 2079.999950ps      -23.059377
+ 2089.999951ps      -21.176883
+ 2099.999952ps      -19.422592
+ 2109.999953ps      -17.871305
+ 2119.999953ps        -16.5315
+ 2129.999954ps      -15.410518
+ 2139.999955ps      -14.581606
+ 2149.999956ps      -14.147021
+ 2159.999957ps      -14.070577
+ 2169.999958ps      -14.369731
+ 2179.999958ps      -15.149075
+ 2189.999959ps      -16.289253
+ 2199.999960ps       -17.75557
+ 2209.999961ps      -19.367941
+ 2219.999962ps      -20.865359
+ 2229.999962ps      -22.331545
+ 2239.999963ps      -23.467106
+ 2249.999964ps      -24.383212
+ 2259.999965ps      -25.183701
+ 2269.999966ps      -26.181512
+ 2279.999967ps      -26.823331
+ 2289.999967ps       -26.01594
+ 2299.999968ps      -24.152469
+ 2309.999969ps      -21.947972
+ 2319.999970ps      -19.710525
+ 2329.999971ps      -17.629658
+ 2339.999972ps      -15.768071
+ 2349.999972ps      -14.190173
+ 2359.999973ps      -12.911134
+ 2369.999974ps      -11.932505
+ 2379.999975ps      -11.229029
+ 2389.999976ps      -10.808348
+ 2399.999977ps       -10.63896
+ 2409.999977ps      -10.757549
+ 2419.999978ps      -11.195463
+ 2429.999979ps      -11.931557
+ 2439.999980ps      -12.945632
+ 2449.999981ps      -14.201982
+ 2459.999981ps      -15.705978
+ 2469.999982ps      -17.386381
+ 2479.999983ps      -19.161034
+ 2489.999984ps      -20.902806
+ 2499.999985ps      -22.694407
+ 2509.999986ps      -24.551763
+ 2519.999986ps      -26.307517
+ 2529.999987ps       -27.30984
+ 2539.999988ps      -27.497444
+ 2549.999989ps      -27.128399
+ 2559.999990ps      -26.221618
+ 2569.999991ps      -24.723578
+ 2579.999991ps      -22.826079
+ 2589.999992ps      -20.843542
+ 2599.999993ps      -19.002662
+ 2609.999994ps      -17.398157
+ 2619.999995ps      -16.049957
+ 2629.999996ps      -14.985843
+ 2639.999996ps      -14.255321
+ 2649.999997ps      -13.909139
+ 2659.999998ps      -13.923903
+ 2669.999999ps      -14.323617
+ 2680.000000ps      -15.193781
+ 2690.000001ps      -16.393788
+ 2700.000001ps      -17.876742
+ 2710.000002ps      -19.492484
+ 2720.000003ps      -20.964909
+ 2730.000004ps      -22.412396
+ 2740.000005ps      -23.537986
+ 2750.000005ps      -24.449222
+ 2760.000006ps      -25.238055
+ 2770.000007ps      -26.224067
+ 2780.000008ps      -26.856647
+ 2790.000009ps      -26.045816
+ 2800.000010ps      -24.178122
+ 2810.000010ps      -21.967255
+ 2820.000011ps      -19.730739
+ 2830.000012ps      -17.626455
+ 2840.000013ps      -15.748338
+ 2850.000014ps      -14.155489
+ 2860.000015ps      -12.874834
+ 2870.000015ps      -11.910964
+ 2880.000016ps      -11.241968
+ 2890.000017ps      -10.851915
+ 2900.000018ps      -10.731517
+ 2910.000019ps      -10.886593
+ 2920.000020ps      -11.343655
+ 2930.000020ps      -12.084993
+ 2940.000021ps      -13.102201
+ 2950.000022ps      -14.363179
+ 2960.000023ps      -15.842258
+ 2970.000024ps      -17.499266
+ 2980.000025ps      -19.249067
+ 2990.000025ps      -20.931651
+ 3000.000026ps      -22.640965
+ 3010.000027ps      -24.418276
+ 3020.000028ps      -26.145775
+ 3030.000029ps      -27.143384
+ 3040.000029ps      -27.351543
+ 3050.000030ps      -27.004695
+ 3060.000031ps      -26.147212
+ 3070.000032ps      -24.716216
+ 3080.000033ps      -22.873973
+ 3090.000034ps      -20.954869
+ 3100.000034ps      -19.129651
+ 3110.000035ps      -17.528796
+ 3120.000036ps      -16.141318
+ 3130.000037ps      -15.018899
+ 3140.000038ps      -14.237646
+ 3150.000039ps      -13.878124
+ 3160.000039ps      -13.882841
+ 3170.000040ps      -14.270557
+ 3180.000041ps      -15.107957
+ 3190.000042ps      -16.281809
+ 3200.000043ps        -17.7556
+ 3210.000044ps      -19.363981
+ 3220.000044ps      -20.863628
+ 3230.000045ps      -22.334573
+ 3240.000046ps       -23.48055
+ 3250.000047ps      -24.397482
+ 3260.000048ps      -25.191189
+ 3270.000049ps      -26.176974
+ 3280.000049ps        -26.8076
+ 3290.000050ps       -25.99137
+ 3300.000051ps      -24.119939
+ 3310.000052ps      -21.907604
+ 3320.000053ps      -19.664276
+ 3330.000053ps      -17.562825
+ 3340.000054ps      -15.693363
+ 3350.000055ps      -14.109521
+ 3360.000056ps      -12.824803
+ 3370.000057ps      -11.852346
+ 3380.000058ps      -11.173269
+ 3390.000058ps      -10.771058
+ 3400.000059ps      -10.628059
+ 3410.000060ps      -10.772389
+ 3420.000061ps      -11.230501
+ 3430.000062ps      -11.994224
+ 3440.000063ps      -13.053041
+ 3450.000063ps      -14.379813
+ 3460.000064ps      -15.943283
+ 3470.000065ps      -17.697014
+ 3480.000066ps      -19.482201
+ 3490.000067ps      -21.222354
+ 3500.000068ps      -22.946402
+ 3510.000068ps      -24.719571
+ 3520.000069ps      -26.373415
+ 3530.000070ps      -27.295104
+ 3540.000071ps       -27.44126
+ 3550.000072ps      -27.067052
+ 3560.000073ps       -26.19045
+ 3570.000073ps      -24.739093
+ 3580.000074ps      -22.906039
+ 3590.000075ps      -21.007031
+ 3600.000076ps       -19.23553
+ 3610.000077ps      -17.689912
+ 3620.000077ps      -16.375758
+ 3630.000078ps      -15.337886
+ 3640.000079ps      -14.600411
+ 3650.000080ps      -14.210096
+ 3660.000081ps       -14.13767
+ 3670.000082ps        -14.4311
+ 3680.000082ps      -15.206685
+ 3690.000083ps      -16.353866
+ 3700.000084ps      -17.828566
+ 3710.000085ps      -19.435958
+ 3720.000086ps      -20.914676
+ 3729.999865ps       -22.36735
+ 3739.999865ps      -23.499849
+ 3749.999866ps      -24.406383
+ 3759.999867ps      -25.196371
+ 3769.999868ps      -26.188874
+ 3779.999869ps      -26.826409
+ 3789.999869ps      -26.016763
+ 3799.999870ps      -24.150804
+ 3809.999871ps      -21.947211
+ 3819.999872ps       -19.71395
+ 3829.999873ps        -17.6366
+ 3839.999874ps      -15.791798
+ 3849.999874ps      -14.221719
+ 3859.999875ps      -12.945883
+ 3869.999876ps      -11.966482
+ 3879.999877ps      -11.276124
+ 3889.999878ps       -10.86783
+ 3899.999879ps      -10.695145
+ 3909.999879ps      -10.793166
+ 3919.999880ps      -11.207181
+ 3929.999881ps      -11.948071
+ 3939.999882ps       -12.97173
+ 3949.999883ps      -14.244311
+ 3959.999884ps      -15.775269
+ 3969.999884ps      -17.490252
+ 3979.999885ps        -19.2339
+ 3989.999886ps        -20.9109
+ 3999.999887ps      -22.571392
+ 4009.999888ps      -24.311295
+ 4019.999889ps      -26.007698
+ 4029.999889ps       -27.01152
+ 4039.999890ps      -27.253697
+ 4049.999891ps      -26.947542
+ 4059.999892ps      -26.104055
+ 4069.999893ps      -24.644969
+ 4079.999893ps       -22.80267
+ 4089.999894ps       -20.88692
+ 4099.999895ps       -19.09689
+ 4109.999896ps      -17.549959
+ 4119.999897ps      -16.224937
+ 4129.999898ps       -15.16311
+ 4139.999898ps      -14.383637
+ 4149.999899ps      -13.971419
+ 4159.999900ps      -13.921038
+ 4169.999901ps      -14.280935
+ 4179.999902ps       -15.13606
+ 4189.999903ps      -16.323485
+ 4199.999903ps      -17.831701
+ 4209.999904ps      -19.477073
+ 4219.999905ps      -20.995553
+ 4229.999906ps      -22.493916
+ 4239.999907ps      -23.648195
+ 4249.999908ps      -24.584984
+ 4259.999908ps      -25.379094
+ 4269.999909ps      -26.374949
+ 4279.999910ps      -27.001298
+ 4289.999911ps      -26.187969
+ 4299.999912ps      -24.319062
+ 4309.999913ps      -22.106912
+ 4319.999913ps       -19.86599
+ 4329.999914ps      -17.777912
+ 4339.999915ps      -15.909976
+ 4349.999916ps      -14.312181
+ 4359.999917ps      -13.014425
+ 4369.999917ps      -12.036158
+ 4379.999918ps       -11.35308
+ 4389.999919ps      -10.976644
+ 4399.999920ps      -10.847013
+ 4409.999921ps      -11.001953
+ 4419.999922ps      -11.477468
+ 4429.999922ps      -12.247679
+ 4439.999923ps      -13.317401
+ 4449.999924ps      -14.590449
+ 4459.999925ps      -16.108413
+ 4469.999926ps      -17.800105
+ 4479.999927ps      -19.547874
+ 4489.999927ps      -21.228573
+ 4499.999928ps      -22.950253
+ 4509.999929ps      -24.722022
+ 4519.999930ps      -26.413982
+ 4529.999931ps      -27.352339
+ 4539.999932ps      -27.524158
+ 4549.999932ps        -27.1532
+ 4559.999933ps      -26.264913
+ 4569.999934ps      -24.814792
+ 4579.999935ps      -22.980782
+ 4589.999936ps      -21.079523
+ 4599.999937ps      -19.297389
+ 4609.999937ps      -17.718914
+ 4619.999938ps      -16.371336
+ 4629.999939ps      -15.279567
+ 4639.999940ps      -14.500956
+ 4649.999941ps      -14.075562
+ 4659.999941ps      -14.021666
+ 4669.999942ps      -14.349761
+ 4679.999943ps      -15.174903
+ 4689.999944ps      -16.324228
+ 4699.999945ps      -17.802779
+ 4709.999946ps      -19.405031
+ 4719.999946ps      -20.900166
+ 4729.999947ps      -22.372128
+ 4739.999948ps      -23.521842
+ 4749.999949ps      -24.448298
+ 4759.999950ps      -25.248134
+ 4769.999951ps      -26.253425
+ 4779.999951ps      -26.902142
+ 4789.999952ps      -26.104921
+ 4799.999953ps      -24.241591
+ 4809.999954ps      -22.040664
+ 4819.999955ps      -19.798783
+ 4829.999956ps      -17.717193
+ 4839.999956ps        -15.8425
+ 4849.999957ps      -14.259174
+ 4859.999958ps      -12.976496
+ 4869.999959ps      -11.994301
+ 4879.999960ps      -11.291785
+ 4889.999961ps      -10.865527
+ 4899.999961ps      -10.687714
+ 4909.999962ps      -10.785811
+ 4919.999963ps      -11.220499
+ 4929.999964ps      -11.984333
+ 4939.999965ps      -13.038986
+ 4949.999965ps      -14.352832
+ 4959.999966ps      -15.915908
+ 4969.999967ps      -17.674594
+ 4979.999968ps      -19.450176
+ 4989.999969ps      -21.140152
+ 4999.999970ps      -22.819097
+ 5009.999970ps      -24.535202
+ 5019.999971ps      -26.178363
+ 5029.999972ps      -27.119512
+ 5039.999973ps      -27.300231
+ 5049.999974ps      -26.934744
+ 5059.999975ps      -26.058854
+ 5069.999975ps      -24.590223
+ 5079.999976ps      -22.754301
+ 5089.999977ps       -20.84273
+ 5099.999978ps      -19.086511
+ 5109.999979ps      -17.556836
+ 5119.999980ps      -16.274437
+ 5129.999980ps       -15.25389
+ 5139.999981ps      -14.522035
+ 5149.999982ps      -14.121403
+ 5159.999983ps      -14.060595
+ 5169.999984ps      -14.410845
+ 5179.999985ps      -15.230244
+ 5189.999985ps      -16.377191
+ 5199.999986ps      -17.831933
+ 5209.999987ps      -19.419282
+ 5219.999988ps      -20.897256
+ 5229.999989ps      -22.346588
+ 5239.999989ps      -23.479676
+ 5249.999990ps      -24.391054
+ 5259.999991ps      -25.181103
+ 5269.999992ps      -26.170577
+ 5279.999993ps      -26.810563
+ 5289.999994ps      -26.005202
+ 5299.999994ps      -24.143719
+ 5309.999995ps      -21.942027
+ 5319.999996ps      -19.707999
+ 5329.999997ps      -17.622683
+ 5339.999998ps       -15.74985
+ 5349.999999ps      -14.154889
+ 5359.999999ps      -12.861975
+ 5370.000000ps      -11.885005
+ 5380.000001ps      -11.192868
+ 5390.000002ps      -10.794535
+ 5400.000003ps      -10.658732
+ 5410.000004ps      -10.800585
+ 5420.000004ps      -11.266846
+ 5430.000005ps      -12.069704
+ 5440.000006ps      -13.148264
+ 5450.000007ps      -14.456769
+ 5460.000008ps      -15.963885
+ 5470.000009ps      -17.630801
+ 5480.000009ps      -19.359554
+ 5490.000010ps      -21.026092
+ 5500.000011ps      -22.731853
+ 5510.000012ps      -24.538455
+ 5520.000013ps      -26.269367
+ 5530.000013ps      -27.243144
+ 5540.000014ps      -27.472286
+ 5550.000015ps      -27.134861
+ 5560.000016ps      -26.265802
+ 5570.000017ps      -24.786057
+ 5580.000018ps      -22.958065
+ 5590.000018ps      -21.073434
+ 5600.000019ps      -19.293171
+ 5610.000020ps      -17.715838
+ 5620.000021ps      -16.298485
+ 5630.000022ps      -15.157179
+ 5640.000023ps      -14.358102
+ 5650.000023ps      -13.933584
+ 5660.000024ps       -13.86299
+ 5670.000025ps      -14.213469
+ 5680.000026ps      -15.077816
+ 5690.000027ps      -16.284914
+ 5700.000028ps      -17.781316
+ 5710.000028ps      -19.389412
+ 5720.000029ps      -20.883459
+ 5730.000030ps      -22.352248
+ 5740.000031ps       -23.49503
+ 5750.000032ps      -24.409358
+ 5760.000032ps      -25.203951
+ 5770.000033ps      -26.197751
+ 5780.000034ps      -26.836397
+ 5790.000035ps      -26.032378
+ 5800.000036ps      -24.161171
+ 5810.000037ps      -21.949094
+ 5820.000037ps      -19.699897
+ 5830.000038ps      -17.600073
+ 5840.000039ps      -15.730822
+ 5850.000040ps      -14.143503
+ 5860.000041ps      -12.866992
+ 5870.000042ps       -11.90192
+ 5880.000042ps       -11.23413
+ 5890.000043ps      -10.828024
+ 5900.000044ps      -10.687871
+ 5910.000045ps      -10.825458
+ 5920.000046ps      -11.295857
+ 5930.000047ps      -12.082055
+ 5940.000047ps      -13.154106
+ 5950.000048ps       -14.48051
+ 5960.000049ps      -15.993402
+ 5970.000050ps      -17.657406
+ 5980.000051ps      -19.356294
+ 5990.000052ps      -21.006768
+ 6000.000052ps      -22.641176
+ 6010.000053ps      -24.391605
+ 6020.000054ps      -26.094939
+ 6030.000055ps      -27.112733
+ 6040.000056ps      -27.350991
+ 6050.000056ps      -27.070371
+ 6060.000057ps      -26.232442
+ 6070.000058ps       -24.79654
+ 6080.000059ps       -22.95502
+ 6090.000060ps      -21.058304
+ 6100.000061ps      -19.263965
+ 6110.000061ps      -17.707513
+ 6120.000062ps      -16.334292
+ 6130.000063ps       -15.20252
+ 6140.000064ps      -14.374367
+ 6150.000065ps      -13.953165
+ 6160.000066ps      -13.902225
+ 6170.000066ps      -14.257495
+ 6180.000067ps      -15.111777
+ 6190.000068ps      -16.314569
+ 6200.000069ps      -17.804883
+ 6210.000070ps      -19.415642
+ 6220.000071ps      -20.906345
+ 6230.000071ps      -22.368095
+ 6240.000072ps      -23.512747
+ 6250.000073ps      -24.428371
+ 6260.000074ps      -25.224759
+ 6270.000075ps      -26.218779
+ 6280.000076ps      -26.858879
+ 6290.000076ps      -26.055175
+ 6300.000077ps      -24.196742
+ 6310.000078ps      -21.999579
+ 6320.000079ps      -19.759579
+ 6330.000080ps      -17.666751
+ 6340.000080ps      -15.786139
+ 6350.000081ps      -14.175109
+ 6360.000082ps      -12.879689
+ 6370.000083ps      -11.901067
+ 6380.000084ps      -11.207647
+ 6390.000085ps      -10.813424
+ 6400.000085ps      -10.668309
+ 6410.000086ps      -10.819201
+ 6420.000087ps      -11.298112
+ 6430.000088ps      -12.092679
+ 6440.000089ps        -13.1858
+ 6450.000090ps       -14.52056
+ 6460.000090ps      -16.083718
+ 6470.000091ps      -17.807403
+ 6480.000092ps      -19.548447
+ 6490.000093ps      -21.228295
+ 6500.000094ps      -22.933398
+ 6510.000095ps       -24.72907
+ 6520.000095ps      -26.429252
+ 6530.000096ps      -27.392207
+ 6540.000097ps      -27.589864
+ 6550.000098ps      -27.228247
+ 6560.000099ps      -26.348888
+ 6570.000100ps      -24.881057
+ 6580.000100ps      -23.049937
+ 6590.000101ps      -21.159021
+ 6600.000102ps      -19.414624
+ 6610.000103ps      -17.866246
+ 6620.000104ps      -16.537128
+ 6630.000104ps      -15.432861
+ 6640.000105ps      -14.614662
+ 6650.000106ps       -14.17316
+ 6660.000107ps      -14.096472
+ 6670.000108ps      -14.433353
+ 6680.000109ps      -15.264562
+ 6690.000109ps       -16.40547
+ 6700.000110ps      -17.835786
+ 6710.000111ps      -19.405867
+ 6720.000112ps      -20.874863
+ 6730.000113ps        -22.3298
+ 6740.000114ps      -23.460125
+ 6750.000114ps      -24.370536
+ 6760.000115ps      -25.154002
+ 6770.000116ps      -26.142486
+ 6780.000117ps      -26.774182
+ 6790.000118ps      -25.958679
+ 6800.000119ps      -24.087594
+ 6810.000119ps      -21.875842
+ 6820.000120ps      -19.634308
+ 6830.000121ps      -17.551041
+ 6840.000122ps      -15.693372
+ 6850.000123ps       -14.10913
+ 6860.000124ps      -12.828195
+ 6870.000124ps      -11.865011
+ 6880.000125ps      -11.191937
+ 6890.000126ps      -10.795909
+ 6900.000127ps      -10.649095
+ 6910.000128ps      -10.785491
+ 6920.000128ps      -11.251689
+ 6930.000129ps       -12.02567
+ 6940.000130ps      -13.067927
+ 6950.000131ps      -14.355771
+ 6960.000132ps      -15.886606
+ 6970.000133ps      -17.575218
+ 6980.000133ps      -19.320528
+ 6990.000134ps      -20.992152
+ 7000.000135ps      -22.670463
+ 7010.000136ps      -24.384451
+ 7020.000137ps      -26.067794
+ 7030.000138ps      -27.044147
+ 7040.000138ps       -27.27192
+ 7050.000139ps      -26.962325
+ 7060.000140ps      -26.137923
+ 7070.000141ps      -24.709096
+ 7080.000142ps      -22.893678
+ 7090.000143ps      -20.969865
+ 7100.000143ps      -19.130495
+ 7110.000144ps      -17.524863
+ 7120.000145ps      -16.155778
+ 7130.000146ps      -15.063851
+ 7140.000147ps      -14.285298
+ 7150.000148ps      -13.879324
+ 7160.000148ps      -13.837946
+ 7170.000149ps      -14.183969
+ 7180.000150ps      -15.014904
+ 7190.000151ps      -16.192477
+ 7200.000152ps      -17.688511
+ 7210.000152ps      -19.318488
+ 7220.000153ps      -20.833788
+ 7230.000154ps      -22.301019
+ 7240.000155ps      -23.446785
+ 7250.000156ps      -24.360408
+ 7260.000157ps        -25.1548
+ 7270.000157ps      -26.146292
+ 7280.000158ps      -26.780812
+ 7290.000159ps      -25.968234
+ 7300.000160ps      -24.099375
+ 7310.000161ps      -21.888263
+ 7320.000162ps      -19.646007
+ 7330.000162ps      -17.558351
+ 7340.000163ps      -15.701634
+ 7350.000164ps      -14.125908
+ 7360.000165ps      -12.844933
+ 7370.000166ps      -11.874815
+ 7380.000167ps       -11.17613
+ 7390.000167ps      -10.763413
+ 7400.000168ps      -10.605118
+ 7410.000169ps      -10.729295
+ 7420.000170ps      -11.177636
+ 7430.000171ps      -11.938788
+ 7440.000171ps      -12.983961
+ 7450.000172ps      -14.283228
+ 7459.999729ps      -15.828693
+ 7469.999730ps      -17.578587
+ 7479.999731ps      -19.379825
+ 7489.999732ps      -21.129893
+ 7499.999732ps      -22.872136
+ 7509.999733ps      -24.679685
+ 7519.999734ps      -26.378472
+ 7529.999735ps      -27.295241
+ 7539.999736ps         -27.449
+ 7549.999737ps      -27.080761
+ 7559.999737ps      -26.191581
+ 7569.999738ps      -24.723043
+ 7579.999739ps      -22.880337
+ 7589.999740ps       -20.96089
+ 7599.999741ps         -19.169
+ 7609.999741ps      -17.600811
+ 7619.999742ps      -16.289179
+ 7629.999743ps      -15.265213
+ 7639.999744ps      -14.519857
+ 7649.999745ps       -14.13166
+ 7659.999746ps      -14.067164
+ 7669.999746ps       -14.40056
+ 7679.999747ps      -15.214382
+ 7689.999748ps      -16.356081
+ 7699.999749ps      -17.802459
+ 7709.999750ps      -19.391172
+ 7719.999751ps      -20.882415
+ 7729.999751ps      -22.354792
+ 7739.999752ps       -23.50358
+ 7749.999753ps      -24.421489
+ 7759.999754ps      -25.218372
+ 7769.999755ps      -26.211543
+ 7779.999756ps      -26.843067
+ 7789.999756ps      -26.030515
+ 7799.999757ps      -24.160468
+ 7809.999758ps      -21.952911
+ 7819.999759ps       -19.69984
+ 7829.999760ps      -17.610489
+ 7839.999761ps      -15.743048
+ 7849.999761ps      -14.148301
+ 7859.999762ps      -12.852874
+ 7869.999763ps      -11.860801
+ 7879.999764ps      -11.164759
+ 7889.999765ps       -10.76611
+ 7899.999765ps      -10.634519
+ 7909.999766ps      -10.784298
+ 7919.999767ps      -11.244047
+ 7929.999768ps      -12.014443
+ 7939.999769ps      -13.059488
+ 7949.999770ps      -14.332378
+ 7959.999770ps      -15.848177
+ 7969.999771ps      -17.563406
+ 7979.999772ps      -19.310259
+ 7989.999773ps      -20.974252
+ 7999.999774ps      -22.105106
+ 8009.999775ps       -22.40983
+ 8019.999775ps      -22.381001
+ 8029.999776ps      -22.421382
+ 8039.999777ps       -22.45622
+ 8049.999778ps      -22.495116
+ 8059.999779ps       -22.53213
+ 8069.999780ps      -22.564084
+ 8079.999780ps      -22.590789
+ 8089.999781ps      -22.612808
+ 8099.999782ps      -22.630865
+ 8109.999783ps      -22.645657
+ 8119.999784ps      -22.657792
+ 8129.999785ps      -22.667776
+ 8139.999785ps      -22.676021
+ 8149.999786ps      -22.682861
+ 8159.999787ps       -22.68856
+ 8169.999788ps      -22.693333
+ 8179.999789ps       -22.69735
+ 8189.999789ps      -22.700744
+ 8199.999790ps      -22.703627
+ 8209.999791ps      -22.706086
+ 8219.999792ps      -22.708193
+ 8229.999793ps      -22.710006
+ 8239.999794ps      -22.711572
+ 8249.999794ps      -22.712929
+ 8259.999795ps       -22.71411
+ 8269.999796ps       -22.71514
+ 8279.999797ps      -22.716041
+ 8289.999798ps      -22.716832
+ 8299.999799ps      -22.717528
+ 8309.999799ps      -22.718141
+)

Icursig13 PAR_2_1_VDD075NNE 0 pwl(
+ 0.000000ps       9.0107809
+ 10.000000ps       9.7077374
+ 20.000000ps       12.550548
+ 29.999999ps       16.605494
+ 40.000000ps       19.919489
+ 50.000001ps       22.268125
+ 59.999998ps       23.738751
+ 69.999999ps       24.268135
+ 80.000000ps       24.054724
+ 90.000001ps       23.279474
+ 100.000001ps       22.134798
+ 110.000002ps       20.729431
+ 119.999996ps       19.135894
+ 129.999997ps       17.531352
+ 139.999998ps       16.129484
+ 149.999999ps       15.097039
+ 159.999999ps       14.467514
+ 170.000000ps       14.249041
+ 180.000001ps       14.341759
+ 190.000002ps       14.774095
+ 200.000003ps       15.382901
+ 210.000003ps        16.19803
+ 220.000004ps       17.198114
+ 230.000005ps       18.167876
+ 239.999992ps       19.083215
+ 249.999993ps       19.978199
+ 259.999994ps       20.844982
+ 269.999995ps       21.739193
+ 279.999995ps        22.08509
+ 289.999996ps       21.812706
+ 299.999997ps       21.114496
+ 309.999998ps       20.074152
+ 319.999999ps       18.761694
+ 330.000000ps       17.330057
+ 340.000000ps       15.923865
+ 350.000001ps       14.660239
+ 360.000002ps        13.60047
+ 370.000003ps        12.81849
+ 380.000004ps       12.304262
+ 390.000005ps       12.117396
+ 400.000005ps       12.318812
+ 410.000006ps       12.899255
+ 420.000007ps       13.898752
+ 430.000008ps       15.467648
+ 440.000009ps       17.406895
+ 450.000009ps       19.702999
+ 460.000010ps       22.199732
+ 469.999983ps        24.67236
+ 479.999984ps       27.252893
+ 489.999985ps       29.651606
+ 499.999986ps        32.02863
+ 509.999987ps       34.324239
+ 519.999988ps       36.865436
+ 529.999988ps       39.084009
+ 539.999989ps       39.844405
+ 549.999990ps       39.308331
+ 559.999991ps       37.851553
+ 569.999992ps       35.658708
+ 579.999992ps       33.058651
+ 589.999993ps       30.258653
+ 599.999994ps       27.439311
+ 609.999995ps       24.698191
+ 619.999996ps       22.097408
+ 629.999997ps       19.756261
+ 639.999997ps       17.847308
+ 649.999998ps       16.412865
+ 659.999999ps       15.499356
+ 670.000000ps       15.044663
+ 680.000001ps       14.973239
+ 690.000002ps       15.262559
+ 700.000002ps       15.766912
+ 710.000003ps       16.497354
+ 720.000004ps       17.420697
+ 730.000005ps       18.333789
+ 740.000006ps       19.200454
+ 750.000007ps       20.058649
+ 760.000007ps       20.918211
+ 770.000008ps       21.808005
+ 780.000009ps       22.182813
+ 790.000010ps       21.933509
+ 800.000011ps       21.246565
+ 810.000012ps       20.225899
+ 820.000012ps       18.930629
+ 830.000013ps       17.506358
+ 840.000014ps       16.072465
+ 850.000015ps       14.761181
+ 860.000016ps       13.668272
+ 870.000016ps       12.861835
+ 880.000017ps       12.337438
+ 890.000018ps       12.113187
+ 900.000019ps       12.266379
+ 910.000020ps       12.799108
+ 920.000021ps       13.762707
+ 930.000021ps       15.300893
+ 939.999967ps        17.23377
+ 949.999968ps       19.505471
+ 959.999968ps       21.993551
+ 969.999969ps       24.474841
+ 979.999970ps       27.047373
+ 989.999971ps       29.464266
+ 999.999972ps        31.82783
+ 1009.999973ps       34.120144
+ 1019.999973ps        36.67859
+ 1029.999974ps       38.923754
+ 1039.999975ps       39.712093
+ 1049.999976ps       39.146692
+ 1059.999977ps       37.690462
+ 1069.999978ps       35.498708
+ 1079.999978ps       32.887249
+ 1089.999979ps       30.093596
+ 1099.999980ps       27.266948
+ 1109.999981ps        24.53813
+ 1119.999982ps       21.963748
+ 1129.999982ps       19.675666
+ 1139.999983ps       17.822758
+ 1149.999984ps       16.429422
+ 1159.999985ps       15.519599
+ 1169.999986ps        15.08424
+ 1179.999987ps        15.00791
+ 1189.999987ps       15.275079
+ 1199.999988ps        15.72612
+ 1209.999989ps       16.410725
+ 1219.999990ps       17.322214
+ 1229.999991ps       18.249006
+ 1239.999992ps       19.142414
+ 1249.999992ps       20.023762
+ 1259.999993ps       20.889163
+ 1269.999994ps       21.782991
+ 1279.999995ps       22.139846
+ 1289.999996ps       21.877865
+ 1299.999997ps       21.202638
+ 1309.999997ps       20.185353
+ 1319.999998ps       18.900655
+ 1329.999999ps       17.472063
+ 1340.000000ps       16.066067
+ 1350.000001ps       14.745434
+ 1360.000002ps       13.647552
+ 1370.000002ps       12.821073
+ 1380.000003ps       12.260828
+ 1390.000004ps       12.060215
+ 1400.000005ps       12.273701
+ 1410.000006ps       12.897819
+ 1420.000006ps       13.936651
+ 1430.000007ps       15.532784
+ 1440.000008ps       17.526257
+ 1450.000009ps        19.83667
+ 1460.000010ps       22.330696
+ 1470.000011ps       24.820008
+ 1480.000011ps       27.411083
+ 1490.000012ps       29.822895
+ 1500.000013ps       32.195041
+ 1510.000014ps        34.50058
+ 1520.000015ps       37.028331
+ 1530.000016ps       39.272073
+ 1540.000016ps       40.023327
+ 1550.000017ps       39.478962
+ 1560.000018ps       38.039687
+ 1570.000019ps       35.880284
+ 1580.000020ps       33.292124
+ 1590.000021ps       30.505478
+ 1600.000021ps       27.701104
+ 1610.000022ps       24.946977
+ 1620.000023ps       22.349236
+ 1630.000024ps       19.985718
+ 1640.000025ps       18.054743
+ 1650.000025ps        16.63063
+ 1660.000026ps        15.68584
+ 1670.000027ps       15.167177
+ 1680.000028ps       15.027727
+ 1690.000029ps       15.259881
+ 1700.000030ps       15.722108
+ 1710.000030ps       16.401283
+ 1720.000031ps       17.281588
+ 1730.000032ps       18.166105
+ 1740.000033ps       19.026225
+ 1750.000034ps       19.884185
+ 1760.000035ps       20.727137
+ 1770.000035ps       21.611473
+ 1780.000036ps       21.976329
+ 1790.000037ps       21.713785
+ 1800.000038ps       21.037886
+ 1810.000039ps       20.017204
+ 1820.000040ps       18.721458
+ 1830.000040ps        17.28391
+ 1840.000041ps       15.877726
+ 1850.000042ps       14.564315
+ 1860.000043ps       13.474634
+ 1869.999933ps        12.63641
+ 1879.999934ps       12.088334
+ 1889.999934ps       11.874905
+ 1899.999935ps       12.078065
+ 1909.999936ps       12.683276
+ 1919.999937ps       13.728483
+ 1929.999938ps       15.350388
+ 1939.999938ps       17.391407
+ 1949.999939ps       19.765027
+ 1959.999940ps       22.343883
+ 1969.999941ps       24.837125
+ 1979.999942ps       27.381608
+ 1989.999943ps       29.721658
+ 1999.999943ps       31.959369
+ 2009.999944ps        34.13066
+ 2019.999945ps       36.622637
+ 2029.999946ps        38.86824
+ 2039.999947ps       39.671831
+ 2049.999948ps        39.19164
+ 2059.999948ps       37.816278
+ 2069.999949ps       35.700453
+ 2079.999950ps        33.14963
+ 2089.999951ps        30.41861
+ 2099.999952ps       27.679311
+ 2109.999953ps       24.975424
+ 2119.999953ps       22.398366
+ 2129.999954ps        19.99799
+ 2139.999955ps       18.023044
+ 2149.999956ps       16.552505
+ 2159.999957ps       15.574083
+ 2169.999958ps       15.042751
+ 2179.999958ps       14.878648
+ 2189.999959ps       15.109938
+ 2199.999960ps       15.579592
+ 2209.999961ps       16.297487
+ 2219.999962ps       17.210798
+ 2229.999962ps       18.111982
+ 2239.999963ps       18.978252
+ 2249.999964ps       19.839221
+ 2259.999965ps         20.6898
+ 2269.999966ps       21.569847
+ 2279.999967ps       21.928209
+ 2289.999967ps       21.660644
+ 2299.999968ps       20.976858
+ 2309.999969ps       19.956232
+ 2319.999970ps       18.660057
+ 2329.999971ps        17.24077
+ 2339.999972ps       15.847446
+ 2349.999972ps       14.567752
+ 2359.999973ps       13.513242
+ 2369.999974ps        12.70459
+ 2379.999975ps       12.173363
+ 2389.999976ps       11.966046
+ 2399.999977ps       12.145264
+ 2409.999977ps       12.700142
+ 2419.999978ps       13.689013
+ 2429.999979ps       15.225645
+ 2439.999980ps       17.139414
+ 2449.999981ps       19.400719
+ 2459.999981ps       21.883658
+ 2469.999982ps       24.339843
+ 2479.999983ps       26.945128
+ 2489.999984ps       29.367125
+ 2499.999985ps       31.784173
+ 2509.999986ps       34.140303
+ 2519.999986ps       36.718117
+ 2529.999987ps       39.016167
+ 2539.999988ps       39.814209
+ 2549.999989ps        39.29491
+ 2559.999990ps       37.839938
+ 2569.999991ps       35.647244
+ 2579.999991ps       33.008368
+ 2589.999992ps       30.166349
+ 2599.999993ps        27.27437
+ 2609.999994ps       24.473645
+ 2619.999995ps       21.881258
+ 2629.999996ps       19.559732
+ 2639.999996ps       17.665488
+ 2649.999997ps       16.260511
+ 2659.999998ps       15.367781
+ 2669.999999ps       14.934456
+ 2680.000000ps       14.883849
+ 2690.000001ps       15.187547
+ 2700.000001ps       15.688745
+ 2710.000002ps       16.408412
+ 2720.000003ps       17.307543
+ 2730.000004ps       18.201683
+ 2740.000005ps       19.052357
+ 2750.000005ps       19.898255
+ 2760.000006ps       20.734852
+ 2770.000007ps       21.609185
+ 2780.000008ps       21.960032
+ 2790.000009ps       21.685144
+ 2800.000010ps       20.998932
+ 2810.000010ps       19.969215
+ 2820.000011ps       18.671743
+ 2830.000012ps       17.225288
+ 2840.000013ps       15.807983
+ 2850.000014ps       14.515444
+ 2860.000015ps       13.447423
+ 2870.000015ps       12.658198
+ 2880.000016ps       12.153379
+ 2890.000017ps       11.968717
+ 2900.000018ps       12.181193
+ 2910.000019ps       12.779307
+ 2920.000020ps       13.788732
+ 2930.000020ps       15.335206
+ 2940.000021ps       17.268506
+ 2950.000022ps       19.541566
+ 2960.000023ps       22.002262
+ 2970.000024ps       24.435362
+ 2980.000025ps         26.9614
+ 2990.000025ps       29.344749
+ 3000.000026ps       31.687667
+ 3010.000027ps        33.96146
+ 3020.000028ps       36.501397
+ 3030.000029ps       38.825582
+ 3040.000029ps       39.632148
+ 3050.000030ps       39.135343
+ 3060.000031ps       37.718225
+ 3070.000032ps       35.574074
+ 3080.000033ps        32.99687
+ 3090.000034ps       30.217696
+ 3100.000034ps       27.369828
+ 3110.000035ps       24.595211
+ 3120.000036ps       21.956251
+ 3130.000037ps       19.579174
+ 3140.000038ps       17.665882
+ 3150.000039ps       16.259547
+ 3160.000039ps       15.356123
+ 3170.000040ps       14.909547
+ 3180.000041ps       14.822003
+ 3190.000042ps        15.08349
+ 3200.000043ps       15.560875
+ 3210.000044ps       16.278061
+ 3220.000044ps       17.196684
+ 3230.000045ps        18.11579
+ 3240.000046ps       18.985511
+ 3250.000047ps       19.840679
+ 3260.000048ps       20.681036
+ 3270.000049ps       21.554169
+ 3280.000049ps       21.901263
+ 3290.000050ps        21.62056
+ 3300.000051ps       20.924611
+ 3310.000052ps       19.893164
+ 3320.000053ps         18.5953
+ 3330.000053ps       17.156531
+ 3340.000054ps       15.758409
+ 3350.000055ps       14.479011
+ 3360.000056ps       13.413588
+ 3370.000057ps       12.619582
+ 3380.000058ps       12.112058
+ 3390.000058ps       11.929555
+ 3400.000059ps       12.128512
+ 3410.000060ps       12.705871
+ 3420.000061ps       13.697783
+ 3430.000062ps        15.26062
+ 3440.000063ps       17.223354
+ 3450.000063ps       19.558455
+ 3460.000064ps       22.110867
+ 3470.000065ps        24.63908
+ 3480.000066ps       27.244447
+ 3490.000067ps       29.686597
+ 3500.000068ps       32.048389
+ 3510.000068ps       34.326577
+ 3520.000069ps       36.827041
+ 3530.000070ps       39.047649
+ 3540.000071ps        39.79078
+ 3550.000072ps        39.24115
+ 3560.000073ps       37.807994
+ 3570.000073ps       35.655536
+ 3580.000074ps       33.057016
+ 3590.000075ps       30.300914
+ 3600.000076ps       27.494187
+ 3610.000077ps        24.76807
+ 3620.000077ps       22.203072
+ 3630.000078ps       19.907425
+ 3640.000079ps       18.000991
+ 3650.000080ps       16.558759
+ 3660.000081ps       15.591962
+ 3670.000082ps       15.061439
+ 3680.000082ps       14.917126
+ 3690.000083ps       15.171081
+ 3700.000084ps       15.660158
+ 3710.000085ps       16.366516
+ 3720.000086ps       17.266478
+ 3729.999865ps       18.157381
+ 3739.999865ps       19.016696
+ 3749.999866ps       19.857345
+ 3759.999867ps        20.68998
+ 3769.999868ps       21.564084
+ 3779.999869ps       21.912384
+ 3789.999869ps       21.634262
+ 3799.999870ps       20.945053
+ 3809.999871ps       19.924055
+ 3819.999872ps       18.633333
+ 3829.999873ps       17.221029
+ 3839.999874ps       15.842633
+ 3849.999874ps       14.571422
+ 3859.999875ps       13.511068
+ 3869.999876ps        12.70728
+ 3879.999877ps       12.185358
+ 3889.999878ps       11.978344
+ 3899.999879ps       12.139846
+ 3909.999879ps       12.678623
+ 3919.999880ps       13.639385
+ 3929.999881ps       15.177036
+ 3939.999882ps       17.110306
+ 3949.999883ps       19.404731
+ 3959.999884ps       21.917791
+ 3969.999884ps       24.419859
+ 3979.999885ps       26.970557
+ 3989.999886ps       29.349564
+ 3999.999887ps       31.669154
+ 4009.999888ps       33.932798
+ 4019.999889ps       36.466097
+ 4029.999889ps       38.750535
+ 4039.999890ps         39.5728
+ 4049.999891ps       39.072341
+ 4059.999892ps       37.643569
+ 4069.999893ps       35.483782
+ 4079.999893ps       32.885162
+ 4089.999894ps       30.113017
+ 4099.999895ps       27.296877
+ 4109.999896ps       24.573103
+ 4119.999897ps       22.008018
+ 4129.999898ps       19.681018
+ 4139.999898ps       17.748414
+ 4149.999899ps       16.295798
+ 4159.999900ps       15.339493
+ 4169.999901ps        14.87153
+ 4179.999902ps       14.801308
+ 4189.999903ps       15.086042
+ 4199.999903ps        15.59872
+ 4209.999904ps       16.338676
+ 4219.999905ps       17.281856
+ 4229.999906ps        18.21136
+ 4239.999907ps        19.09378
+ 4249.999908ps       19.962628
+ 4259.999908ps       20.803594
+ 4269.999909ps       21.681815
+ 4279.999910ps       22.027702
+ 4289.999911ps       21.748938
+ 4299.999912ps       21.056507
+ 4309.999913ps       20.025093
+ 4319.999913ps       18.728318
+ 4329.999914ps       17.300873
+ 4339.999915ps       15.906996
+ 4349.999916ps         14.6227
+ 4359.999917ps        13.55238
+ 4369.999917ps        12.76096
+ 4379.999918ps       12.244504
+ 4389.999919ps       12.057878
+ 4399.999920ps       12.265716
+ 4409.999921ps       12.846621
+ 4419.999922ps       13.865632
+ 4429.999922ps       15.435485
+ 4439.999923ps       17.399283
+ 4449.999924ps       19.682488
+ 4459.999925ps       22.189793
+ 4469.999926ps       24.658402
+ 4479.999927ps       27.226369
+ 4489.999927ps       29.612114
+ 4499.999928ps        31.98122
+ 4509.999929ps       34.265344
+ 4519.999930ps       36.791577
+ 4529.999931ps       39.040154
+ 4539.999932ps       39.824158
+ 4549.999932ps       39.293503
+ 4559.999933ps       37.864033
+ 4569.999934ps       35.686383
+ 4579.999935ps       33.085799
+ 4589.999936ps       30.320734
+ 4599.999937ps       27.513167
+ 4609.999937ps       24.762427
+ 4619.999938ps       22.162535
+ 4629.999939ps         19.8189
+ 4639.999940ps       17.892041
+ 4649.999941ps       16.430931
+ 4659.999941ps       15.466186
+ 4669.999942ps       14.968752
+ 4679.999943ps       14.865214
+ 4689.999944ps       15.116558
+ 4699.999945ps        15.60476
+ 4709.999946ps       16.322399
+ 4719.999946ps       17.244521
+ 4729.999947ps       18.167891
+ 4739.999948ps       19.046775
+ 4749.999949ps       19.918105
+ 4759.999950ps       20.772619
+ 4769.999951ps       21.668561
+ 4779.999951ps       22.037483
+ 4789.999952ps       21.782487
+ 4799.999953ps       21.102085
+ 4809.999954ps       20.075704
+ 4819.999955ps       18.766787
+ 4829.999956ps       17.331225
+ 4839.999956ps       15.911988
+ 4849.999957ps       14.617457
+ 4859.999958ps       13.544615
+ 4869.999959ps       12.738334
+ 4879.999960ps       12.204362
+ 4889.999961ps       12.003224
+ 4899.999961ps       12.177669
+ 4909.999962ps       12.722222
+ 4919.999963ps       13.697478
+ 4929.999964ps       15.260034
+ 4939.999965ps       17.232626
+ 4949.999965ps       19.562052
+ 4959.999966ps       22.112098
+ 4969.999967ps       24.652271
+ 4979.999968ps       27.237159
+ 4989.999969ps       29.610315
+ 4999.999970ps       31.909521
+ 5009.999970ps       34.106535
+ 5019.999971ps       36.598063
+ 5029.999972ps       38.845733
+ 5039.999973ps       39.646134
+ 5049.999974ps       39.105625
+ 5059.999975ps       37.674067
+ 5069.999975ps        35.47775
+ 5079.999976ps       32.890169
+ 5089.999977ps       30.141541
+ 5099.999978ps       27.372197
+ 5109.999979ps       24.666785
+ 5119.999980ps       22.134386
+ 5129.999980ps       19.866279
+ 5139.999981ps        17.99297
+ 5149.999982ps       16.560637
+ 5159.999983ps       15.590583
+ 5169.999984ps       15.102067
+ 5179.999985ps       14.984817
+ 5189.999985ps       15.222973
+ 5199.999986ps       15.685345
+ 5209.999987ps       16.367238
+ 5219.999988ps       17.263784
+ 5229.999989ps        18.16257
+ 5239.999989ps       19.019734
+ 5249.999990ps       19.870138
+ 5259.999991ps       20.711658
+ 5269.999992ps       21.584827
+ 5279.999993ps       21.936961
+ 5289.999994ps       21.667132
+ 5299.999994ps       20.977702
+ 5309.999995ps       19.957031
+ 5319.999996ps       18.665764
+ 5329.999997ps       17.238955
+ 5339.999998ps       15.835863
+ 5349.999999ps       14.562738
+ 5359.999999ps       13.497344
+ 5370.000000ps        12.71169
+ 5380.000001ps       12.185694
+ 5390.000002ps       11.989943
+ 5400.000003ps       12.185961
+ 5410.000004ps       12.763586
+ 5420.000004ps       13.777576
+ 5430.000005ps       15.373999
+ 5440.000006ps       17.360046
+ 5450.000007ps       19.686503
+ 5460.000008ps       22.179056
+ 5470.000009ps       24.626162
+ 5480.000009ps       27.170699
+ 5490.000010ps       29.519278
+ 5500.000011ps       31.853081
+ 5510.000012ps       34.175237
+ 5520.000013ps       36.740258
+ 5530.000013ps       39.004504
+ 5540.000014ps       39.806423
+ 5550.000015ps       39.313382
+ 5560.000016ps       37.900703
+ 5570.000017ps       35.737466
+ 5580.000018ps       33.141696
+ 5590.000018ps         30.3907
+ 5600.000019ps       27.604731
+ 5610.000020ps        24.83777
+ 5620.000021ps       22.185803
+ 5630.000022ps       19.779063
+ 5640.000023ps       17.822545
+ 5650.000023ps       16.336838
+ 5660.000024ps        15.36254
+ 5670.000025ps       14.885062
+ 5680.000026ps       14.826584
+ 5690.000027ps        15.12737
+ 5700.000028ps       15.628081
+ 5710.000028ps       16.347847
+ 5720.000029ps       17.267817
+ 5730.000030ps       18.175496
+ 5740.000031ps       19.038633
+ 5750.000032ps       19.894221
+ 5760.000032ps       20.733103
+ 5770.000033ps       21.608413
+ 5780.000034ps       21.964817
+ 5790.000035ps       21.693964
+ 5800.000036ps       21.002582
+ 5810.000037ps       19.976961
+ 5820.000037ps       18.672864
+ 5830.000038ps       17.234595
+ 5840.000039ps       15.833003
+ 5850.000040ps       14.539254
+ 5860.000041ps       13.465539
+ 5870.000042ps        12.66255
+ 5880.000042ps       12.155999
+ 5890.000043ps        11.95811
+ 5900.000044ps       12.163525
+ 5910.000045ps       12.743589
+ 5920.000046ps       13.766622
+ 5930.000047ps       15.356042
+ 5940.000047ps       17.332911
+ 5950.000048ps       19.660191
+ 5960.000049ps       22.156057
+ 5970.000050ps       24.594205
+ 5980.000051ps       27.100868
+ 5990.000052ps       29.456807
+ 6000.000052ps       31.721368
+ 6010.000053ps       33.968435
+ 6020.000054ps       36.512359
+ 6030.000055ps       38.842599
+ 6040.000056ps       39.705293
+ 6050.000056ps       39.229223
+ 6060.000057ps       37.842599
+ 6070.000058ps        35.68522
+ 6080.000059ps       33.092978
+ 6090.000060ps       30.332226
+ 6100.000061ps       27.532515
+ 6110.000061ps       24.790844
+ 6120.000062ps       22.178579
+ 6130.000063ps       19.799289
+ 6140.000064ps       17.835473
+ 6150.000065ps       16.385332
+ 6160.000066ps       15.431986
+ 6170.000066ps       14.951125
+ 6180.000067ps        14.89108
+ 6190.000068ps       15.192621
+ 6200.000069ps       15.688141
+ 6210.000070ps       16.392569
+ 6220.000071ps       17.289048
+ 6230.000071ps       18.201104
+ 6240.000072ps       19.071698
+ 6250.000073ps       19.928726
+ 6260.000074ps       20.769734
+ 6270.000075ps       21.649054
+ 6280.000076ps       22.003119
+ 6290.000076ps       21.732282
+ 6300.000077ps       21.050387
+ 6310.000078ps       20.034964
+ 6320.000079ps       18.740437
+ 6330.000080ps       17.307738
+ 6340.000080ps       15.895213
+ 6350.000081ps       14.591692
+ 6360.000082ps       13.516217
+ 6370.000083ps       12.717559
+ 6380.000084ps       12.189237
+ 6390.000085ps       11.991905
+ 6400.000085ps       12.181425
+ 6410.000086ps        12.76102
+ 6420.000087ps        13.77922
+ 6430.000088ps       15.370629
+ 6440.000089ps       17.361556
+ 6450.000090ps        19.70188
+ 6460.000090ps       22.247315
+ 6470.000091ps       24.762127
+ 6480.000092ps       27.331415
+ 6490.000093ps       29.718293
+ 6500.000094ps       32.064982
+ 6510.000095ps       34.359983
+ 6520.000095ps       36.898222
+ 6530.000096ps       39.157343
+ 6540.000097ps       39.931743
+ 6550.000098ps        39.41954
+ 6560.000099ps       37.974759
+ 6570.000100ps       35.811737
+ 6580.000100ps       33.215455
+ 6590.000101ps       30.452983
+ 6600.000102ps         27.6848
+ 6610.000103ps       24.967067
+ 6620.000104ps        22.39102
+ 6630.000104ps       20.034951
+ 6640.000105ps       18.053948
+ 6650.000106ps       16.571275
+ 6660.000107ps       15.599364
+ 6670.000108ps       15.114615
+ 6680.000109ps       15.010407
+ 6690.000109ps       15.259208
+ 6700.000110ps       15.700377
+ 6710.000111ps       16.373998
+ 6720.000112ps       17.270339
+ 6730.000113ps       18.159402
+ 6740.000114ps       19.013771
+ 6750.000114ps       19.857194
+ 6760.000115ps       20.686129
+ 6770.000116ps       21.553561
+ 6780.000117ps       21.904279
+ 6790.000118ps       21.625704
+ 6800.000119ps       20.931153
+ 6810.000119ps       19.903878
+ 6820.000120ps       18.610007
+ 6830.000121ps       17.191941
+ 6840.000122ps       15.794903
+ 6850.000123ps       14.504321
+ 6860.000124ps       13.428731
+ 6870.000124ps       12.633858
+ 6880.000125ps        12.12483
+ 6890.000126ps        11.94182
+ 6900.000127ps        12.14815
+ 6910.000128ps       12.739566
+ 6920.000128ps       13.761253
+ 6930.000129ps       15.332341
+ 6940.000130ps       17.285428
+ 6950.000131ps       19.587912
+ 6960.000132ps       22.088942
+ 6970.000133ps       24.545726
+ 6980.000133ps         27.0818
+ 6990.000134ps       29.456158
+ 7000.000135ps       31.772585
+ 7010.000136ps       33.998955
+ 7020.000137ps       36.520294
+ 7030.000138ps       38.780571
+ 7040.000138ps       39.602466
+ 7050.000139ps       39.138741
+ 7060.000140ps        37.77688
+ 7070.000141ps       35.642616
+ 7080.000142ps       33.074646
+ 7090.000143ps       30.278049
+ 7100.000143ps       27.424462
+ 7110.000144ps        24.62187
+ 7120.000145ps       22.003403
+ 7130.000146ps       19.668445
+ 7140.000147ps       17.728796
+ 7150.000148ps       16.280091
+ 7160.000148ps       15.339608
+ 7170.000149ps       14.855317
+ 7180.000150ps       14.761484
+ 7190.000151ps        15.03607
+ 7200.000152ps       15.542589
+ 7210.000152ps       16.273492
+ 7220.000153ps        17.19649
+ 7230.000154ps       18.114211
+ 7240.000155ps       18.981292
+ 7250.000156ps       19.832953
+ 7260.000157ps       20.675356
+ 7270.000157ps       21.552576
+ 7280.000158ps       21.900144
+ 7290.000159ps       21.624785
+ 7300.000160ps       20.934299
+ 7310.000161ps       19.906534
+ 7320.000162ps       18.611989
+ 7330.000162ps       17.192555
+ 7340.000163ps       15.807237
+ 7350.000164ps       14.538856
+ 7360.000165ps       13.484241
+ 7370.000166ps        12.69326
+ 7380.000167ps       12.162754
+ 7390.000167ps       11.952157
+ 7400.000168ps       12.130603
+ 7410.000169ps       12.680764
+ 7420.000170ps       13.671005
+ 7430.000171ps       15.226682
+ 7440.000171ps       17.178328
+ 7450.000172ps       19.490997
+ 7459.999729ps       22.019307
+ 7469.999730ps       24.562325
+ 7479.999731ps       27.173973
+ 7489.999732ps       29.608235
+ 7499.999732ps       31.974229
+ 7509.999733ps       34.290523
+ 7519.999734ps       36.816745
+ 7529.999735ps       39.044971
+ 7539.999736ps       39.796434
+ 7549.999737ps       39.257871
+ 7559.999737ps       37.807493
+ 7569.999738ps       35.623398
+ 7579.999739ps       33.025169
+ 7589.999740ps       30.261816
+ 7599.999741ps       27.431043
+ 7609.999741ps       24.695506
+ 7619.999742ps       22.138374
+ 7629.999743ps       19.854342
+ 7639.999744ps       17.961033
+ 7649.999745ps       16.521866
+ 7659.999746ps       15.555266
+ 7669.999746ps       15.064245
+ 7679.999747ps       14.953983
+ 7689.999748ps       15.196839
+ 7699.999749ps       15.652675
+ 7709.999750ps       16.344513
+ 7719.999751ps        17.27301
+ 7729.999751ps       18.184114
+ 7739.999752ps       19.056868
+ 7749.999753ps       19.915271
+ 7759.999754ps       20.758798
+ 7769.999755ps       21.638309
+ 7779.999756ps       21.991347
+ 7789.999756ps       21.715038
+ 7799.999757ps       21.038195
+ 7809.999758ps       20.016847
+ 7819.999759ps       18.696073
+ 7829.999760ps       17.260712
+ 7839.999761ps       15.852103
+ 7849.999761ps       14.557907
+ 7859.999762ps        13.46588
+ 7869.999763ps       12.649616
+ 7879.999764ps       12.140857
+ 7889.999765ps       11.948952
+ 7899.999765ps       12.150905
+ 7909.999766ps        12.74173
+ 7919.999767ps       13.754436
+ 7929.999768ps       15.335816
+ 7939.999769ps       17.291373
+ 7949.999770ps       19.579791
+ 7959.999770ps       22.079127
+ 7969.999771ps       24.567487
+ 7979.999772ps       27.154733
+ 7989.999773ps       29.785767
+ 7999.999774ps       31.746395
+ 8009.999775ps       32.779394
+ 8019.999775ps         33.2377
+ 8029.999776ps       33.598149
+ 8039.999777ps       33.855952
+ 8049.999778ps       34.051325
+ 8059.999779ps       34.201609
+ 8069.999780ps       34.316745
+ 8079.999780ps       34.405388
+ 8089.999781ps        34.47414
+ 8099.999782ps         34.5279
+ 8109.999783ps        34.57029
+ 8119.999784ps          34.604
+ 8129.999785ps       34.631032
+ 8139.999785ps       34.652887
+ 8149.999786ps       34.670699
+ 8159.999787ps       34.685329
+ 8169.999788ps       34.697433
+ 8179.999789ps        34.70752
+ 8189.999789ps       34.715981
+ 8199.999790ps       34.723124
+ 8209.999791ps       34.729189
+ 8219.999792ps       34.734369
+ 8229.999793ps       34.738815
+ 8239.999794ps       34.742649
+ 8249.999794ps        34.74597
+ 8259.999795ps        34.74886
+ 8269.999796ps       34.751382
+ 8279.999797ps       34.753592
+ 8289.999798ps       34.755534
+ 8299.999799ps       34.757245
+ 8309.999799ps       34.758758
+)

Icursig14 PAR_3_1_VSS 0 pwl(
+ 0.000000ps      -8.6340226
+ 10.000000ps      -9.0492228
+ 20.000000ps      -9.8513436
+ 29.999999ps      -10.732427
+ 40.000000ps      -11.389108
+ 50.000001ps      -11.828474
+ 59.999998ps      -12.033828
+ 69.999999ps      -12.028235
+ 80.000000ps      -12.005566
+ 90.000001ps      -12.048075
+ 100.000001ps      -12.249185
+ 110.000002ps       -12.67918
+ 119.999996ps      -13.408038
+ 129.999997ps      -14.538432
+ 139.999998ps      -16.024058
+ 149.999999ps      -17.660824
+ 159.999999ps      -19.309898
+ 170.000000ps      -20.907561
+ 180.000001ps      -22.476392
+ 190.000002ps      -23.882507
+ 200.000003ps      -25.054939
+ 210.000003ps      -25.889499
+ 220.000004ps      -26.130478
+ 230.000005ps      -25.743293
+ 239.999992ps      -24.770976
+ 249.999993ps       -23.31929
+ 259.999994ps      -21.654016
+ 269.999995ps       -19.88035
+ 279.999995ps      -18.141803
+ 289.999996ps      -16.468014
+ 299.999997ps       -14.92645
+ 309.999998ps       -13.60823
+ 319.999999ps      -12.549128
+ 330.000000ps      -11.766594
+ 340.000000ps      -11.284326
+ 350.000001ps      -11.106278
+ 360.000002ps      -11.207136
+ 370.000003ps      -11.637134
+ 380.000004ps      -12.426794
+ 390.000005ps      -13.531138
+ 400.000005ps      -14.911422
+ 410.000006ps      -16.418478
+ 420.000007ps      -18.056525
+ 430.000008ps      -19.815041
+ 440.000009ps      -21.516079
+ 450.000009ps      -23.118987
+ 460.000010ps      -24.489385
+ 469.999983ps      -25.511595
+ 479.999984ps      -26.121168
+ 489.999985ps      -26.371039
+ 499.999986ps      -26.265075
+ 509.999987ps      -25.849692
+ 519.999988ps      -25.061361
+ 529.999988ps      -23.893466
+ 539.999989ps      -22.409958
+ 549.999990ps      -20.748745
+ 559.999991ps      -19.086818
+ 569.999992ps      -17.543366
+ 579.999992ps      -16.289111
+ 589.999993ps      -15.368382
+ 599.999994ps      -14.799121
+ 609.999995ps      -14.599228
+ 619.999996ps      -14.807119
+ 629.999997ps      -15.575743
+ 639.999997ps      -16.778381
+ 649.999998ps      -18.181172
+ 659.999999ps      -19.675329
+ 670.000000ps      -21.155446
+ 680.000001ps      -22.617636
+ 690.000002ps      -23.950236
+ 700.000002ps      -25.073679
+ 710.000003ps      -25.877891
+ 720.000004ps      -26.113238
+ 730.000005ps      -25.725481
+ 740.000006ps      -24.757155
+ 750.000007ps      -23.311453
+ 760.000007ps      -21.657997
+ 770.000008ps      -19.909487
+ 780.000009ps      -18.185924
+ 790.000010ps      -16.529384
+ 800.000011ps      -14.987852
+ 810.000012ps      -13.664645
+ 820.000012ps      -12.598531
+ 830.000013ps      -11.793125
+ 840.000014ps      -11.270378
+ 850.000015ps      -11.021411
+ 860.000016ps      -11.081497
+ 870.000016ps      -11.460612
+ 880.000017ps      -12.190188
+ 890.000018ps      -13.244965
+ 900.000019ps      -14.596877
+ 910.000020ps      -16.119415
+ 920.000021ps      -17.730536
+ 930.000021ps      -19.463462
+ 939.999967ps      -21.174583
+ 949.999968ps      -22.805032
+ 959.999968ps      -24.169714
+ 969.999969ps      -25.225582
+ 979.999970ps       -25.85904
+ 989.999971ps      -26.046555
+ 999.999972ps      -25.811072
+ 1009.999973ps      -25.264238
+ 1019.999973ps      -24.461216
+ 1029.999974ps      -23.326919
+ 1039.999975ps      -21.885545
+ 1049.999976ps      -20.259726
+ 1059.999977ps      -18.650493
+ 1069.999978ps      -17.193083
+ 1079.999978ps      -15.976592
+ 1089.999979ps      -15.030863
+ 1099.999980ps      -14.450543
+ 1109.999981ps      -14.310866
+ 1119.999982ps      -14.581024
+ 1129.999982ps       -15.35941
+ 1139.999983ps      -16.564353
+ 1149.999984ps      -18.012241
+ 1159.999985ps      -19.537715
+ 1169.999986ps      -21.035374
+ 1179.999987ps      -22.524181
+ 1189.999987ps      -23.868479
+ 1199.999988ps       -24.99151
+ 1209.999989ps      -25.791694
+ 1219.999990ps      -26.011254
+ 1229.999991ps      -25.607922
+ 1239.999992ps      -24.629635
+ 1249.999992ps      -23.170005
+ 1259.999993ps      -21.505442
+ 1269.999994ps      -19.747761
+ 1279.999995ps      -18.010255
+ 1289.999996ps      -16.357765
+ 1299.999997ps      -14.827684
+ 1309.999997ps      -13.517705
+ 1319.999998ps      -12.466059
+ 1329.999999ps      -11.681374
+ 1340.000000ps      -11.185405
+ 1350.000001ps      -10.984851
+ 1360.000002ps      -11.070481
+ 1370.000002ps      -11.458166
+ 1380.000003ps      -12.178364
+ 1390.000004ps      -13.249818
+ 1400.000005ps      -14.658212
+ 1410.000006ps      -16.206714
+ 1420.000006ps      -17.868892
+ 1430.000007ps        -19.6719
+ 1440.000008ps       -21.44278
+ 1450.000009ps      -23.075637
+ 1460.000010ps      -24.464224
+ 1470.000011ps      -25.491296
+ 1480.000011ps      -26.093786
+ 1490.000012ps      -26.300663
+ 1500.000013ps      -26.139814
+ 1510.000014ps       -25.70918
+ 1520.000015ps      -24.908151
+ 1530.000016ps      -23.737925
+ 1540.000016ps      -22.275919
+ 1550.000017ps      -20.663205
+ 1560.000018ps      -19.077604
+ 1570.000019ps      -17.605746
+ 1580.000020ps       -16.36135
+ 1590.000021ps        -15.4454
+ 1600.000021ps      -14.900605
+ 1610.000022ps      -14.735963
+ 1620.000023ps      -14.930391
+ 1630.000024ps      -15.616854
+ 1640.000025ps      -16.743702
+ 1650.000025ps      -18.134811
+ 1660.000026ps      -19.610671
+ 1670.000027ps      -21.074022
+ 1680.000028ps      -22.537836
+ 1690.000029ps       -23.87004
+ 1700.000030ps       -24.98255
+ 1710.000030ps      -25.779315
+ 1720.000031ps      -25.999047
+ 1730.000032ps      -25.596902
+ 1740.000033ps      -24.616452
+ 1750.000034ps      -23.156522
+ 1760.000035ps      -21.489961
+ 1770.000035ps      -19.730212
+ 1780.000036ps      -18.000497
+ 1790.000037ps       -16.35154
+ 1800.000038ps      -14.834611
+ 1810.000039ps      -13.540824
+ 1820.000040ps      -12.506202
+ 1830.000040ps       -11.70839
+ 1840.000041ps      -11.200167
+ 1850.000042ps      -10.958687
+ 1860.000043ps      -11.014561
+ 1869.999933ps      -11.389919
+ 1879.999934ps      -12.115671
+ 1889.999934ps      -13.204472
+ 1899.999935ps      -14.579392
+ 1909.999936ps      -16.134576
+ 1919.999937ps      -17.795895
+ 1929.999938ps      -19.604694
+ 1939.999938ps      -21.391861
+ 1949.999939ps      -23.062399
+ 1959.999940ps      -24.472873
+ 1969.999941ps      -25.498253
+ 1979.999942ps      -26.065662
+ 1989.999943ps      -26.196785
+ 1999.999943ps      -25.921503
+ 2009.999944ps      -25.358823
+ 2019.999945ps      -24.509712
+ 2029.999946ps      -23.378757
+ 2039.999947ps      -21.970407
+ 2049.999948ps      -20.406126
+ 2059.999948ps      -18.846074
+ 2069.999949ps       -17.41908
+ 2079.999950ps      -16.232274
+ 2089.999951ps      -15.384783
+ 2099.999952ps      -14.871353
+ 2109.999953ps      -14.731743
+ 2119.999953ps      -14.940878
+ 2129.999954ps      -15.642013
+ 2139.999955ps      -16.771425
+ 2149.999956ps      -18.145216
+ 2159.999957ps       -19.61889
+ 2169.999958ps      -21.086144
+ 2179.999958ps       -22.54692
+ 2189.999959ps      -23.885711
+ 2199.999960ps      -25.007149
+ 2209.999961ps      -25.812575
+ 2219.999962ps      -26.039742
+ 2229.999962ps      -25.645605
+ 2239.999963ps      -24.669776
+ 2249.999964ps      -23.208726
+ 2259.999965ps      -21.543632
+ 2269.999966ps      -19.772333
+ 2279.999967ps      -18.032539
+ 2289.999967ps      -16.367267
+ 2299.999968ps      -14.821781
+ 2309.999969ps      -13.507565
+ 2319.999970ps      -12.447143
+ 2329.999971ps      -11.650685
+ 2339.999972ps      -11.135776
+ 2349.999972ps      -10.907093
+ 2359.999973ps      -10.992336
+ 2369.999974ps      -11.403222
+ 2379.999975ps      -12.167206
+ 2389.999976ps      -13.286347
+ 2399.999977ps      -14.687466
+ 2409.999977ps      -16.250425
+ 2419.999978ps      -17.897702
+ 2429.999979ps      -19.659204
+ 2439.999980ps       -21.40492
+ 2449.999981ps      -23.010033
+ 2459.999981ps      -24.371416
+ 2469.999982ps      -25.386016
+ 2479.999983ps      -26.002979
+ 2489.999984ps      -26.242031
+ 2499.999985ps      -26.152137
+ 2509.999986ps      -25.725636
+ 2519.999986ps       -24.92149
+ 2529.999987ps       -23.76498
+ 2539.999988ps      -22.298368
+ 2549.999989ps      -20.653835
+ 2559.999990ps      -19.041643
+ 2569.999991ps      -17.557403
+ 2579.999991ps      -16.329848
+ 2589.999992ps      -15.394208
+ 2599.999993ps      -14.806429
+ 2609.999994ps      -14.585519
+ 2619.999995ps      -14.773013
+ 2629.999996ps      -15.487272
+ 2639.999996ps      -16.663133
+ 2649.999997ps      -18.080852
+ 2659.999998ps      -19.590485
+ 2669.999999ps      -21.085052
+ 2680.000000ps      -22.560563
+ 2690.000001ps      -23.907516
+ 2700.000001ps      -25.030797
+ 2710.000002ps      -25.835138
+ 2720.000003ps      -26.062624
+ 2730.000004ps      -25.664591
+ 2740.000005ps      -24.691514
+ 2750.000005ps      -23.235586
+ 2760.000006ps      -21.565787
+ 2770.000007ps      -19.797369
+ 2780.000008ps      -18.058227
+ 2790.000009ps      -16.397897
+ 2800.000010ps      -14.864755
+ 2810.000010ps      -13.561485
+ 2820.000011ps       -12.50865
+ 2830.000012ps      -11.724518
+ 2840.000013ps      -11.198368
+ 2850.000014ps       -10.96817
+ 2860.000015ps       -11.01634
+ 2870.000015ps      -11.369845
+ 2880.000016ps      -12.057039
+ 2890.000017ps      -13.079599
+ 2900.000018ps      -14.401773
+ 2910.000019ps      -15.884029
+ 2920.000020ps      -17.502257
+ 2930.000020ps      -19.257437
+ 2940.000021ps      -21.001356
+ 2950.000022ps       -22.66714
+ 2960.000023ps      -24.094724
+ 2970.000024ps      -25.172686
+ 2980.000025ps      -25.803705
+ 2990.000025ps      -25.990667
+ 3000.000026ps      -25.748754
+ 3010.000027ps      -25.164436
+ 3020.000028ps      -24.291565
+ 3030.000029ps      -23.138658
+ 3040.000029ps      -21.665144
+ 3050.000030ps      -20.052038
+ 3060.000031ps      -18.452085
+ 3070.000032ps      -16.985842
+ 3080.000033ps      -15.787426
+ 3090.000034ps       -14.89917
+ 3100.000034ps      -14.394566
+ 3110.000035ps      -14.275281
+ 3120.000036ps      -14.577573
+ 3130.000037ps      -15.396516
+ 3140.000038ps      -16.602947
+ 3150.000039ps      -18.030405
+ 3160.000039ps      -19.537025
+ 3170.000040ps      -21.031493
+ 3180.000041ps        -22.5122
+ 3190.000042ps      -23.857867
+ 3200.000043ps      -24.985519
+ 3210.000044ps      -25.787394
+ 3220.000044ps      -26.019479
+ 3230.000045ps      -25.612894
+ 3240.000046ps      -24.632674
+ 3250.000047ps      -23.169001
+ 3260.000048ps      -21.499622
+ 3270.000049ps      -19.732069
+ 3280.000049ps      -17.996163
+ 3290.000050ps      -16.341393
+ 3300.000051ps      -14.815803
+ 3310.000052ps      -13.523671
+ 3320.000053ps      -12.483345
+ 3330.000053ps       -11.71805
+ 3340.000054ps      -11.218642
+ 3350.000055ps      -11.021888
+ 3360.000056ps      -11.129523
+ 3370.000057ps      -11.561193
+ 3380.000058ps      -12.316864
+ 3390.000058ps       -13.40094
+ 3400.000059ps      -14.753375
+ 3410.000060ps      -16.243479
+ 3420.000061ps        -17.8433
+ 3430.000062ps       -19.56123
+ 3440.000063ps      -21.249455
+ 3450.000063ps      -22.867283
+ 3460.000064ps      -24.282344
+ 3470.000065ps      -25.367409
+ 3480.000066ps      -26.031405
+ 3490.000067ps        -26.3122
+ 3500.000068ps       -26.20149
+ 3510.000068ps      -25.755279
+ 3520.000069ps      -24.934288
+ 3530.000070ps      -23.769786
+ 3540.000071ps      -22.284424
+ 3550.000072ps      -20.630362
+ 3560.000073ps      -18.973911
+ 3570.000073ps      -17.455553
+ 3580.000074ps      -16.176735
+ 3590.000075ps      -15.222756
+ 3600.000076ps      -14.639063
+ 3610.000077ps      -14.478209
+ 3620.000077ps      -14.724682
+ 3630.000078ps      -15.504894
+ 3640.000079ps      -16.686255
+ 3650.000080ps      -18.095417
+ 3660.000081ps      -19.593134
+ 3670.000082ps      -21.085426
+ 3680.000082ps      -22.565567
+ 3690.000083ps      -23.918179
+ 3700.000084ps      -25.052103
+ 3710.000085ps      -25.866601
+ 3720.000086ps       -26.10323
+ 3729.999865ps      -25.712988
+ 3739.999865ps      -24.749364
+ 3749.999866ps      -23.305525
+ 3759.999867ps      -21.657244
+ 3769.999868ps      -19.904722
+ 3779.999869ps      -18.168496
+ 3789.999869ps      -16.510218
+ 3799.999870ps      -14.969177
+ 3809.999871ps      -13.657028
+ 3819.999872ps      -12.588034
+ 3829.999873ps       -11.78104
+ 3839.999874ps      -11.250668
+ 3849.999874ps      -11.022333
+ 3859.999875ps      -11.098155
+ 3869.999876ps      -11.514594
+ 3879.999877ps      -12.287366
+ 3889.999878ps      -13.404609
+ 3899.999879ps      -14.802052
+ 3909.999879ps      -16.370334
+ 3919.999880ps      -18.038201
+ 3929.999881ps      -19.828184
+ 3939.999882ps      -21.563284
+ 3949.999883ps       -23.22328
+ 3959.999884ps      -24.636233
+ 3969.999884ps      -25.675429
+ 3979.999885ps      -26.276413
+ 3989.999886ps      -26.448599
+ 3999.999887ps      -26.188928
+ 4009.999888ps      -25.626271
+ 4019.999889ps      -24.816519
+ 4029.999889ps      -23.691447
+ 4039.999890ps      -22.306801
+ 4049.999891ps      -20.769262
+ 4059.999892ps      -19.232832
+ 4069.999893ps      -17.822407
+ 4079.999893ps      -16.626845
+ 4089.999894ps      -15.731179
+ 4099.999895ps      -15.176537
+ 4109.999896ps      -15.004489
+ 4119.999897ps      -15.230056
+ 4129.999898ps      -15.949976
+ 4139.999898ps      -17.082162
+ 4149.999899ps      -18.454643
+ 4159.999900ps      -19.893981
+ 4169.999901ps      -21.314784
+ 4179.999902ps      -22.752293
+ 4189.999903ps      -24.077922
+ 4199.999903ps       -25.18486
+ 4209.999904ps      -25.979179
+ 4219.999905ps      -26.201045
+ 4229.999906ps      -25.805956
+ 4239.999907ps      -24.835335
+ 4249.999908ps      -23.380155
+ 4259.999908ps       -21.71789
+ 4269.999909ps      -19.961479
+ 4279.999910ps      -18.229522
+ 4289.999911ps      -16.565853
+ 4299.999912ps      -15.017085
+ 4309.999913ps      -13.689792
+ 4319.999913ps      -12.624172
+ 4329.999914ps      -11.837043
+ 4339.999915ps      -11.335166
+ 4349.999916ps      -11.124558
+ 4359.999917ps      -11.181227
+ 4369.999917ps      -11.560976
+ 4379.999918ps      -12.274974
+ 4389.999919ps      -13.331709
+ 4399.999920ps      -14.678282
+ 4409.999921ps      -16.177363
+ 4419.999922ps      -17.805824
+ 4429.999922ps      -19.556298
+ 4439.999923ps      -21.289454
+ 4449.999924ps      -22.926857
+ 4459.999925ps      -24.326094
+ 4469.999926ps      -25.376792
+ 4479.999927ps      -26.023659
+ 4489.999927ps       -26.27511
+ 4499.999928ps      -26.147359
+ 4509.999929ps      -25.690514
+ 4519.999930ps      -24.838458
+ 4529.999931ps      -23.624059
+ 4539.999932ps      -22.094237
+ 4549.999932ps      -20.405031
+ 4559.999933ps      -18.764124
+ 4569.999934ps      -17.275493
+ 4579.999935ps      -16.063248
+ 4589.999936ps      -15.154407
+ 4599.999937ps      -14.603531
+ 4609.999937ps      -14.432141
+ 4619.999938ps       -14.67901
+ 4629.999939ps      -15.457267
+ 4639.999940ps      -16.664554
+ 4649.999941ps      -18.094827
+ 4659.999941ps      -19.601942
+ 4669.999942ps       -21.08637
+ 4679.999943ps      -22.570721
+ 4689.999944ps      -23.925625
+ 4699.999945ps      -25.059596
+ 4709.999946ps      -25.875425
+ 4719.999946ps      -26.115525
+ 4729.999947ps      -25.724911
+ 4739.999948ps      -24.754532
+ 4749.999949ps      -23.298351
+ 4759.999950ps      -21.624795
+ 4769.999951ps      -19.855712
+ 4779.999951ps      -18.121715
+ 4789.999952ps      -16.462391
+ 4799.999953ps      -14.911094
+ 4809.999954ps      -13.582894
+ 4819.999955ps      -12.513861
+ 4829.999956ps      -11.708684
+ 4839.999956ps      -11.213397
+ 4849.999957ps      -11.011277
+ 4859.999958ps      -11.114314
+ 4869.999959ps      -11.527238
+ 4879.999960ps       -12.28032
+ 4889.999961ps      -13.369242
+ 4899.999961ps      -14.698472
+ 4909.999962ps      -16.165768
+ 4919.999963ps      -17.740134
+ 4929.999964ps      -19.443222
+ 4939.999965ps      -21.155191
+ 4949.999965ps      -22.845017
+ 4959.999966ps      -24.318511
+ 4969.999967ps      -25.402062
+ 4979.999968ps      -26.046106
+ 4989.999969ps       -26.23293
+ 4999.999970ps       -25.98093
+ 5009.999970ps      -25.398761
+ 5019.999971ps      -24.574806
+ 5029.999972ps       -23.44571
+ 5039.999973ps      -22.030914
+ 5049.999974ps      -20.445005
+ 5059.999975ps      -18.818189
+ 5069.999975ps      -17.286385
+ 5079.999976ps      -16.018198
+ 5089.999977ps      -15.093241
+ 5099.999978ps       -14.55788
+ 5109.999979ps      -14.467654
+ 5119.999980ps      -14.771176
+ 5129.999980ps      -15.537805
+ 5139.999981ps      -16.694851
+ 5149.999982ps      -18.096475
+ 5159.999983ps      -19.596153
+ 5169.999984ps      -21.088337
+ 5179.999985ps       -22.57305
+ 5189.999985ps      -23.922259
+ 5199.999986ps      -25.053195
+ 5209.999987ps      -25.867835
+ 5219.999988ps      -26.107107
+ 5229.999989ps      -25.723862
+ 5239.999989ps      -24.766458
+ 5249.999990ps      -23.329406
+ 5259.999991ps      -21.675384
+ 5269.999992ps      -19.927205
+ 5279.999993ps      -18.203693
+ 5289.999994ps      -16.541188
+ 5299.999994ps       -15.01005
+ 5309.999995ps      -13.681292
+ 5319.999996ps       -12.60153
+ 5329.999997ps      -11.799114
+ 5339.999998ps      -11.271235
+ 5349.999999ps      -11.044962
+ 5359.999999ps      -11.103547
+ 5370.000000ps      -11.483672
+ 5380.000001ps      -12.199885
+ 5390.000002ps       -13.27534
+ 5400.000003ps      -14.646963
+ 5410.000004ps      -16.179067
+ 5420.000004ps      -17.840168
+ 5430.000005ps      -19.603244
+ 5440.000006ps      -21.346902
+ 5450.000007ps      -22.953718
+ 5460.000008ps      -24.345317
+ 5470.000009ps      -25.366214
+ 5480.000009ps      -25.977351
+ 5490.000010ps      -26.225819
+ 5500.000011ps      -26.121808
+ 5510.000012ps       -25.67029
+ 5520.000013ps      -24.864588
+ 5530.000013ps      -23.672279
+ 5540.000014ps      -22.177285
+ 5550.000015ps      -20.542882
+ 5560.000016ps      -18.943227
+ 5570.000017ps      -17.472135
+ 5580.000018ps       -16.25992
+ 5590.000018ps      -15.338331
+ 5600.000019ps      -14.767832
+ 5610.000020ps      -14.578246
+ 5620.000021ps      -14.789118
+ 5630.000022ps       -15.52088
+ 5640.000023ps       -16.70428
+ 5650.000023ps      -18.130117
+ 5660.000024ps      -19.638294
+ 5670.000025ps      -21.112742
+ 5680.000026ps      -22.579005
+ 5690.000027ps      -23.913283
+ 5700.000028ps      -25.037368
+ 5710.000028ps      -25.841471
+ 5720.000029ps      -26.071376
+ 5730.000030ps      -25.674588
+ 5740.000031ps      -24.703221
+ 5750.000032ps      -23.247042
+ 5760.000032ps      -21.586413
+ 5770.000033ps      -19.821033
+ 5780.000034ps      -18.084073
+ 5790.000035ps      -16.416217
+ 5800.000036ps      -14.879391
+ 5810.000037ps      -13.576786
+ 5820.000037ps      -12.543309
+ 5830.000038ps      -11.772669
+ 5840.000039ps      -11.289286
+ 5850.000040ps      -11.064929
+ 5860.000041ps      -11.151644
+ 5870.000042ps      -11.561607
+ 5880.000042ps      -12.306486
+ 5890.000043ps      -13.377179
+ 5900.000044ps      -14.731923
+ 5910.000045ps      -16.205459
+ 5920.000046ps      -17.784525
+ 5930.000047ps      -19.493265
+ 5940.000047ps      -21.220027
+ 5950.000048ps      -22.865303
+ 5960.000049ps      -24.277393
+ 5970.000050ps       -25.34608
+ 5980.000051ps      -25.972928
+ 5990.000052ps      -26.181507
+ 6000.000052ps      -25.952065
+ 6010.000053ps      -25.405768
+ 6020.000054ps      -24.580763
+ 6030.000055ps      -23.460963
+ 6040.000056ps      -22.006693
+ 6050.000056ps      -20.381192
+ 6060.000057ps      -18.775094
+ 6070.000058ps      -17.302082
+ 6080.000059ps      -16.058893
+ 6090.000060ps      -15.127652
+ 6100.000061ps      -14.586498
+ 6110.000061ps      -14.462691
+ 6120.000062ps      -14.733177
+ 6130.000063ps      -15.502125
+ 6140.000064ps      -16.699467
+ 6150.000065ps      -18.130516
+ 6160.000066ps       -19.64773
+ 6170.000066ps      -21.129763
+ 6180.000067ps      -22.606944
+ 6190.000068ps      -23.940921
+ 6200.000069ps      -25.069683
+ 6210.000070ps      -25.876279
+ 6220.000071ps      -26.104769
+ 6230.000071ps      -25.706692
+ 6240.000072ps      -24.739069
+ 6250.000073ps       -23.29087
+ 6260.000074ps      -21.634735
+ 6270.000075ps      -19.882258
+ 6280.000076ps      -18.153326
+ 6290.000076ps      -16.489738
+ 6300.000077ps      -14.932151
+ 6310.000078ps      -13.605325
+ 6320.000079ps      -12.546325
+ 6330.000080ps       -11.75986
+ 6340.000080ps      -11.264885
+ 6350.000081ps      -11.058026
+ 6360.000082ps      -11.157988
+ 6370.000083ps      -11.555328
+ 6380.000084ps      -12.247855
+ 6390.000085ps        -13.2821
+ 6400.000085ps      -14.584907
+ 6410.000086ps      -16.044495
+ 6420.000087ps       -17.61698
+ 6430.000088ps      -19.339527
+ 6440.000089ps      -21.050176
+ 6450.000090ps       -22.67432
+ 6460.000090ps       -24.08956
+ 6470.000091ps      -25.176703
+ 6480.000092ps        -25.8455
+ 6490.000093ps      -26.144566
+ 6500.000094ps      -26.067109
+ 6510.000095ps      -25.645542
+ 6520.000095ps      -24.812568
+ 6530.000096ps      -23.612606
+ 6540.000097ps        -22.0691
+ 6550.000098ps      -20.361401
+ 6560.000099ps      -18.677918
+ 6570.000100ps      -17.156064
+ 6580.000100ps      -15.890669
+ 6590.000101ps      -14.955777
+ 6600.000102ps      -14.407767
+ 6610.000103ps      -14.253134
+ 6620.000104ps      -14.511892
+ 6630.000104ps      -15.314733
+ 6640.000105ps      -16.548214
+ 6650.000106ps      -18.004234
+ 6660.000107ps       -19.52548
+ 6670.000108ps      -21.020157
+ 6680.000109ps      -22.513684
+ 6690.000109ps      -23.871892
+ 6700.000110ps      -25.004968
+ 6710.000111ps      -25.817368
+ 6720.000112ps      -26.048365
+ 6730.000113ps      -25.653547
+ 6740.000114ps      -24.682785
+ 6750.000114ps       -23.22772
+ 6760.000115ps      -21.565257
+ 6770.000116ps      -19.803779
+ 6780.000117ps      -18.065989
+ 6790.000118ps      -16.394735
+ 6800.000119ps      -14.849404
+ 6810.000119ps      -13.528565
+ 6820.000120ps      -12.467179
+ 6830.000121ps      -11.669422
+ 6840.000122ps      -11.159959
+ 6850.000123ps       -10.93594
+ 6860.000124ps      -10.999053
+ 6870.000124ps       -11.38487
+ 6880.000125ps      -12.128888
+ 6890.000126ps      -13.216527
+ 6900.000127ps      -14.568715
+ 6910.000128ps      -16.075963
+ 6920.000128ps      -17.712605
+ 6930.000129ps      -19.481017
+ 6940.000130ps      -21.189441
+ 6950.000131ps       -22.80492
+ 6960.000132ps      -24.191427
+ 6970.000133ps      -25.223953
+ 6980.000133ps      -25.830375
+ 6990.000134ps      -26.026519
+ 7000.000135ps      -25.816683
+ 7010.000136ps      -25.284893
+ 7020.000137ps      -24.469799
+ 7030.000138ps       -23.32102
+ 7040.000138ps       -21.87757
+ 7050.000139ps      -20.284673
+ 7060.000140ps      -18.682908
+ 7070.000141ps       -17.19692
+ 7080.000142ps      -15.971128
+ 7090.000143ps      -15.088175
+ 7100.000143ps       -14.54073
+ 7110.000144ps        -14.3529
+ 7120.000145ps      -14.580309
+ 7130.000146ps      -15.349561
+ 7140.000147ps      -16.569321
+ 7150.000148ps       -18.01486
+ 7160.000148ps      -19.532142
+ 7170.000149ps      -21.025377
+ 7180.000150ps       -22.51011
+ 7190.000151ps       -23.85769
+ 7200.000152ps      -24.985685
+ 7210.000152ps      -25.789361
+ 7220.000153ps      -26.013918
+ 7230.000154ps      -25.609392
+ 7240.000155ps      -24.622402
+ 7250.000156ps      -23.151874
+ 7260.000157ps      -21.473691
+ 7270.000157ps      -19.706129
+ 7280.000158ps      -17.965394
+ 7290.000159ps      -16.311253
+ 7300.000160ps      -14.782202
+ 7310.000161ps      -13.483643
+ 7320.000162ps      -12.427489
+ 7330.000162ps      -11.650586
+ 7340.000163ps       -11.18375
+ 7350.000164ps      -10.988137
+ 7360.000165ps      -11.095306
+ 7370.000166ps      -11.527795
+ 7380.000167ps      -12.291785
+ 7390.000167ps      -13.379516
+ 7400.000168ps      -14.694807
+ 7410.000169ps      -16.171045
+ 7420.000170ps       -17.76027
+ 7430.000171ps       -19.48681
+ 7440.000171ps      -21.187851
+ 7450.000172ps      -22.846606
+ 7459.999729ps      -24.275364
+ 7469.999730ps      -25.334874
+ 7479.999731ps      -25.976829
+ 7489.999732ps       -26.23422
+ 7499.999732ps       -26.14023
+ 7509.999733ps      -25.694592
+ 7519.999734ps      -24.896489
+ 7529.999735ps      -23.722281
+ 7539.999736ps      -22.227352
+ 7549.999737ps      -20.567541
+ 7559.999737ps      -18.872175
+ 7569.999738ps      -17.305712
+ 7579.999739ps      -16.036954
+ 7589.999740ps      -15.132226
+ 7599.999741ps        -14.5731
+ 7609.999741ps      -14.397308
+ 7619.999742ps      -14.642774
+ 7629.999743ps      -15.416432
+ 7639.999744ps      -16.613447
+ 7649.999745ps      -18.034896
+ 7659.999746ps      -19.545515
+ 7669.999746ps      -21.032989
+ 7679.999747ps       -22.51078
+ 7689.999748ps      -23.855319
+ 7699.999749ps      -24.980317
+ 7709.999750ps      -25.782435
+ 7719.999751ps      -26.012472
+ 7729.999751ps       -25.61632
+ 7739.999752ps      -24.638853
+ 7749.999753ps      -23.178817
+ 7759.999754ps      -21.512925
+ 7769.999755ps      -19.751641
+ 7779.999756ps      -18.013513
+ 7789.999756ps      -16.357092
+ 7799.999757ps      -14.820405
+ 7809.999758ps      -13.509229
+ 7819.999759ps      -12.450381
+ 7829.999760ps      -11.659829
+ 7839.999761ps      -11.154772
+ 7849.999761ps      -10.912509
+ 7859.999762ps      -10.957435
+ 7869.999763ps      -11.322976
+ 7879.999764ps      -12.035202
+ 7889.999765ps      -13.080904
+ 7899.999765ps      -14.429528
+ 7909.999766ps      -15.943921
+ 7919.999767ps      -17.583962
+ 7929.999768ps      -19.344367
+ 7939.999769ps      -21.113428
+ 7949.999770ps      -22.783442
+ 7959.999770ps      -24.193088
+ 7969.999771ps      -25.247062
+ 7979.999772ps      -25.872613
+ 7989.999773ps      -26.148392
+ 7999.999774ps      -25.779641
+ 8009.999775ps      -24.972437
+ 8019.999775ps      -24.195353
+ 8029.999776ps      -23.775723
+ 8039.999777ps      -23.500042
+ 8049.999778ps      -23.324707
+ 8059.999779ps      -23.211601
+ 8069.999780ps      -23.136009
+ 8079.999780ps      -23.084463
+ 8089.999781ps      -23.048804
+ 8099.999782ps      -23.023863
+ 8109.999783ps      -23.006273
+ 8119.999784ps       -22.99379
+ 8129.999785ps      -22.984893
+ 8139.999785ps      -22.978537
+ 8149.999786ps      -22.973994
+ 8159.999787ps      -22.970753
+ 8169.999788ps      -22.968451
+ 8179.999789ps      -22.966829
+ 8189.999789ps      -22.965702
+ 8199.999790ps      -22.964936
+ 8209.999791ps      -22.964432
+ 8219.999792ps      -22.964119
+ 8229.999793ps      -22.963946
+ 8239.999794ps      -22.963874
+ 8249.999794ps      -22.963875
+ 8259.999795ps      -22.963929
+ 8269.999796ps       -22.96402
+ 8279.999797ps      -22.964136
+ 8289.999798ps      -22.964269
+ 8299.999799ps      -22.964414
+ 8309.999799ps      -22.964565
+)

Icursig15 PAR_3_1_VDD075NNE 0 pwl(
+ 0.000000ps       8.1060155
+ 10.000000ps       8.3779492
+ 20.000000ps       9.1640488
+ 29.999999ps       10.189354
+ 40.000000ps       11.081994
+ 50.000001ps       11.603553
+ 59.999998ps       11.821417
+ 69.999999ps       11.828312
+ 80.000000ps       11.742272
+ 90.000001ps       11.630669
+ 100.000001ps       11.569132
+ 110.000002ps       11.621132
+ 119.999996ps       11.836349
+ 129.999997ps       12.238728
+ 139.999998ps       12.857257
+ 149.999999ps       13.635262
+ 159.999999ps       14.494863
+ 170.000000ps       15.386653
+ 180.000001ps        16.33823
+ 190.000002ps       17.210533
+ 200.000003ps       17.951533
+ 210.000003ps       18.526756
+ 220.000004ps       18.847204
+ 230.000005ps       18.908331
+ 239.999992ps       18.729608
+ 249.999993ps       18.333358
+ 259.999994ps       17.757561
+ 269.999995ps       16.980822
+ 279.999995ps       16.059168
+ 289.999996ps       14.996293
+ 299.999997ps       13.892115
+ 309.999998ps       12.885902
+ 319.999999ps       12.065243
+ 330.000000ps       11.523481
+ 340.000000ps       11.285555
+ 350.000001ps       11.385901
+ 360.000002ps       11.876271
+ 370.000003ps       12.773299
+ 380.000004ps       14.224763
+ 390.000005ps       16.076996
+ 400.000005ps       18.169253
+ 410.000006ps       20.355848
+ 420.000007ps       22.616474
+ 430.000008ps       25.013868
+ 440.000009ps       27.406886
+ 450.000009ps       29.698955
+ 460.000010ps       31.744449
+ 469.999983ps       33.179323
+ 479.999984ps       33.936695
+ 489.999985ps       33.991827
+ 499.999986ps       33.458781
+ 509.999987ps       32.548431
+ 519.999988ps        31.35083
+ 529.999988ps       29.823128
+ 539.999989ps       27.980648
+ 549.999990ps       25.828602
+ 559.999991ps       23.556095
+ 569.999992ps       21.274451
+ 579.999992ps       19.131234
+ 589.999993ps        17.27601
+ 599.999994ps       15.759644
+ 609.999995ps       14.635225
+ 619.999996ps       13.974911
+ 629.999997ps       13.766394
+ 639.999997ps       13.938914
+ 649.999998ps        14.39418
+ 659.999999ps       15.026669
+ 670.000000ps        15.75463
+ 680.000001ps       16.561307
+ 690.000002ps       17.330458
+ 700.000002ps       17.997202
+ 710.000003ps       18.521358
+ 720.000004ps       18.808219
+ 730.000005ps       18.838075
+ 740.000006ps       18.638384
+ 750.000007ps       18.245266
+ 760.000007ps       17.670894
+ 770.000008ps        16.93058
+ 780.000009ps       16.038147
+ 790.000010ps       14.972308
+ 800.000011ps        13.85566
+ 810.000012ps       12.832913
+ 820.000012ps       12.002228
+ 830.000013ps       11.444045
+ 840.000014ps       11.183857
+ 850.000015ps       11.230363
+ 860.000016ps       11.674406
+ 870.000016ps       12.530756
+ 880.000017ps       13.921596
+ 890.000018ps       15.704522
+ 900.000019ps       17.773129
+ 910.000020ps       19.982967
+ 920.000021ps       22.204712
+ 930.000021ps       24.568823
+ 939.999967ps       26.992395
+ 949.999968ps       29.317275
+ 959.999968ps       31.362841
+ 969.999969ps       32.827952
+ 979.999970ps       33.582952
+ 989.999971ps       33.576898
+ 999.999972ps       32.927822
+ 1009.999973ps        31.91411
+ 1019.999973ps       30.680584
+ 1029.999974ps       29.174843
+ 1039.999975ps       27.383773
+ 1049.999976ps       25.258368
+ 1059.999977ps       23.023939
+ 1069.999978ps       20.825104
+ 1079.999978ps       18.717588
+ 1089.999979ps       16.837348
+ 1099.999980ps        15.32143
+ 1109.999981ps       14.270787
+ 1119.999982ps       13.674319
+ 1129.999982ps       13.479087
+ 1139.999983ps       13.664935
+ 1149.999984ps       14.153704
+ 1159.999985ps        14.80435
+ 1169.999986ps       15.555595
+ 1179.999987ps       16.387204
+ 1189.999987ps       17.171503
+ 1199.999988ps       17.846933
+ 1209.999989ps       18.372324
+ 1219.999990ps       18.646709
+ 1229.999991ps       18.658724
+ 1239.999992ps       18.445898
+ 1249.999992ps         18.0381
+ 1259.999993ps       17.443092
+ 1269.999994ps       16.686764
+ 1279.999995ps        15.77884
+ 1289.999996ps       14.723583
+ 1299.999997ps       13.625604
+ 1309.999997ps       12.632352
+ 1319.999998ps       11.826161
+ 1329.999999ps       11.279815
+ 1340.000000ps       11.016103
+ 1350.000001ps        11.08814
+ 1360.000002ps       11.562394
+ 1370.000002ps       12.423688
+ 1380.000003ps       13.807553
+ 1390.000004ps       15.626903
+ 1400.000005ps       17.757311
+ 1410.000006ps       19.987766
+ 1420.000006ps       22.267439
+ 1430.000007ps       24.686769
+ 1440.000008ps       27.157922
+ 1450.000009ps        29.50879
+ 1460.000010ps       31.586265
+ 1470.000011ps       33.027936
+ 1480.000011ps       33.778311
+ 1490.000012ps       33.794577
+ 1500.000013ps       33.212812
+ 1510.000014ps       32.302324
+ 1520.000015ps       31.091608
+ 1530.000016ps       29.575127
+ 1540.000016ps       27.761565
+ 1550.000017ps       25.639408
+ 1560.000018ps       23.452414
+ 1570.000019ps       21.243755
+ 1580.000020ps       19.128513
+ 1590.000021ps        17.27938
+ 1600.000021ps       15.806811
+ 1610.000022ps       14.743987
+ 1620.000023ps       14.065734
+ 1630.000024ps       13.777544
+ 1640.000025ps       13.873329
+ 1650.000025ps       14.300587
+ 1660.000026ps       14.909471
+ 1670.000027ps       15.615143
+ 1680.000028ps       16.415884
+ 1690.000029ps       17.183911
+ 1700.000030ps       17.848632
+ 1710.000030ps        18.36801
+ 1720.000031ps       18.642191
+ 1730.000032ps       18.654159
+ 1740.000033ps       18.438231
+ 1750.000034ps       18.028378
+ 1760.000035ps       17.430987
+ 1770.000035ps       16.670237
+ 1780.000036ps       15.768688
+ 1790.000037ps       14.719004
+ 1800.000038ps       13.638356
+ 1810.000039ps       12.640301
+ 1820.000040ps       11.839826
+ 1830.000040ps       11.295042
+ 1840.000041ps       11.045075
+ 1850.000042ps       11.095585
+ 1860.000043ps        11.53915
+ 1869.999933ps       12.385402
+ 1879.999934ps       13.768917
+ 1889.999934ps       15.590369
+ 1899.999935ps       17.681412
+ 1909.999936ps       19.908019
+ 1919.999937ps       22.182919
+ 1929.999938ps       24.616618
+ 1939.999938ps       27.098954
+ 1949.999939ps       29.460345
+ 1959.999940ps       31.543945
+ 1969.999941ps       32.992445
+ 1979.999942ps       33.719383
+ 1989.999943ps        33.66936
+ 1999.999943ps       33.002049
+ 2009.999944ps       31.991718
+ 2019.999945ps       30.750118
+ 2029.999946ps       29.268631
+ 2039.999947ps       27.504993
+ 2049.999948ps       25.411147
+ 2059.999948ps        23.22515
+ 2069.999949ps       21.050915
+ 2079.999950ps       18.985465
+ 2089.999951ps       17.188561
+ 2099.999952ps       15.730256
+ 2109.999953ps       14.654675
+ 2119.999953ps       13.986141
+ 2129.999954ps       13.731231
+ 2139.999955ps       13.851108
+ 2149.999956ps       14.270641
+ 2159.999957ps        14.87788
+ 2169.999958ps        15.59478
+ 2179.999958ps         16.4079
+ 2189.999959ps       17.185371
+ 2199.999960ps       17.862248
+ 2209.999961ps       18.394047
+ 2219.999962ps       18.679221
+ 2229.999962ps         18.7025
+ 2239.999963ps       18.498133
+ 2249.999964ps         18.0944
+ 2259.999965ps       17.506168
+ 2269.999966ps       16.735583
+ 2279.999967ps       15.826939
+ 2289.999967ps       14.757923
+ 2299.999968ps       13.639965
+ 2309.999969ps       12.625973
+ 2319.999970ps       11.804563
+ 2329.999971ps        11.24467
+ 2339.999972ps       10.981531
+ 2349.999972ps       11.045392
+ 2359.999973ps       11.514827
+ 2369.999974ps         12.3994
+ 2379.999975ps       13.822065
+ 2389.999976ps        15.67163
+ 2399.999977ps       17.794828
+ 2409.999977ps       20.028685
+ 2419.999978ps       22.311432
+ 2429.999979ps       24.696181
+ 2439.999980ps       27.136092
+ 2449.999981ps       29.458173
+ 2459.999981ps       31.489279
+ 2469.999982ps       32.920645
+ 2479.999983ps       33.693194
+ 2489.999984ps       33.723809
+ 2499.999985ps       33.204642
+ 2509.999986ps       32.302107
+ 2519.999986ps       31.097285
+ 2529.999987ps       29.565767
+ 2539.999988ps       27.748517
+ 2549.999989ps       25.619876
+ 2559.999990ps       23.387694
+ 2569.999991ps       21.173059
+ 2579.999991ps       19.068197
+ 2589.999992ps       17.210139
+ 2599.999993ps       15.699888
+ 2609.999994ps       14.594819
+ 2619.999995ps        13.92005
+ 2629.999996ps       13.656467
+ 2639.999996ps        13.79295
+ 2649.999997ps       14.259165
+ 2659.999998ps       14.892242
+ 2669.999999ps       15.620392
+ 2680.000000ps       16.434197
+ 2690.000001ps       17.212703
+ 2700.000001ps       17.888464
+ 2710.000002ps       18.414962
+ 2720.000003ps        18.69431
+ 2730.000004ps       18.711878
+ 2740.000005ps       18.505981
+ 2750.000005ps       18.105735
+ 2760.000006ps       17.509327
+ 2770.000007ps       16.744972
+ 2780.000008ps       15.834248
+ 2790.000009ps       14.777364
+ 2800.000010ps        13.67599
+ 2810.000010ps       12.680042
+ 2820.000011ps       11.874257
+ 2830.000012ps       11.337127
+ 2840.000013ps       11.053978
+ 2850.000014ps       11.093763
+ 2860.000015ps       11.520727
+ 2870.000015ps       12.347005
+ 2880.000016ps       13.701153
+ 2890.000017ps       15.467794
+ 2900.000018ps       17.508669
+ 2910.000019ps       19.672161
+ 2920.000020ps       21.886807
+ 2930.000020ps       24.268041
+ 2940.000021ps       26.714546
+ 2950.000022ps       29.081989
+ 2960.000023ps       31.206164
+ 2970.000024ps       32.709162
+ 2980.000025ps       33.484574
+ 2990.000025ps       33.500489
+ 3000.000026ps       32.859915
+ 3010.000027ps        31.81138
+ 3020.000028ps       30.522424
+ 3030.000029ps       28.981784
+ 3040.000029ps       27.155737
+ 3050.000030ps       25.013076
+ 3060.000031ps       22.773137
+ 3070.000032ps       20.565707
+ 3080.000033ps       18.479312
+ 3090.000034ps       16.667643
+ 3100.000034ps       15.221336
+ 3110.000035ps       14.210009
+ 3120.000036ps       13.643702
+ 3130.000037ps       13.495136
+ 3140.000038ps       13.697604
+ 3150.000039ps       14.169726
+ 3160.000039ps       14.805685
+ 3170.000040ps       15.545837
+ 3180.000041ps       16.366234
+ 3190.000042ps       17.152897
+ 3200.000043ps       17.834211
+ 3210.000044ps       18.366089
+ 3220.000044ps       18.651873
+ 3230.000045ps       18.668062
+ 3240.000046ps       18.457409
+ 3250.000047ps       18.050883
+ 3260.000048ps       17.450484
+ 3270.000049ps       16.683932
+ 3280.000049ps       15.776967
+ 3290.000050ps       14.718697
+ 3300.000051ps       13.615009
+ 3310.000052ps       12.621331
+ 3320.000053ps       11.831041
+ 3330.000053ps       11.309796
+ 3340.000054ps       11.061552
+ 3350.000055ps       11.147338
+ 3360.000056ps        11.63947
+ 3370.000057ps       12.555248
+ 3380.000058ps       13.978308
+ 3390.000058ps       15.799457
+ 3400.000059ps       17.870694
+ 3410.000060ps       20.031974
+ 3420.000061ps       22.249628
+ 3430.000062ps       24.577567
+ 3440.000063ps       26.970808
+ 3450.000063ps       29.294424
+ 3460.000064ps       31.391414
+ 3470.000065ps       32.891627
+ 3480.000066ps       33.709474
+ 3490.000067ps       33.783414
+ 3500.000068ps       33.259692
+ 3510.000068ps       32.356315
+ 3520.000069ps       31.144267
+ 3530.000070ps       29.619446
+ 3540.000071ps       27.780253
+ 3550.000072ps       25.628549
+ 3560.000073ps       23.368409
+ 3570.000073ps       21.098521
+ 3580.000074ps       18.938911
+ 3590.000075ps       17.040788
+ 3600.000076ps       15.539971
+ 3610.000077ps        14.46758
+ 3620.000077ps       13.859159
+ 3630.000078ps       13.666478
+ 3640.000079ps       13.823802
+ 3650.000080ps       14.267673
+ 3660.000081ps       14.892364
+ 3670.000082ps       15.624667
+ 3680.000082ps       16.449297
+ 3690.000083ps       17.233632
+ 3700.000084ps       17.915711
+ 3710.000085ps       18.453367
+ 3720.000086ps       18.746362
+ 3729.999865ps       18.776328
+ 3739.999865ps       18.588717
+ 3749.999866ps        18.20553
+ 3759.999867ps       17.637223
+ 3769.999868ps       16.891116
+ 3779.999869ps       15.987308
+ 3789.999869ps        14.93268
+ 3799.999870ps       13.832316
+ 3809.999871ps       12.821738
+ 3819.999872ps       11.983425
+ 3829.999873ps       11.405937
+ 3839.999874ps       11.111444
+ 3849.999874ps       11.169441
+ 3859.999875ps       11.631285
+ 3869.999876ps       12.514952
+ 3879.999877ps       13.948521
+ 3889.999878ps        15.80807
+ 3899.999879ps       17.935966
+ 3909.999879ps       20.197044
+ 3919.999880ps       22.486751
+ 3929.999881ps       24.915894
+ 3939.999882ps       27.350081
+ 3949.999883ps       29.715411
+ 3959.999884ps        31.79902
+ 3969.999884ps       33.239774
+ 3979.999885ps       33.987773
+ 3989.999886ps        33.96667
+ 3999.999887ps       33.323002
+ 4009.999888ps       32.317299
+ 4019.999889ps       31.079283
+ 4029.999889ps        29.57408
+ 4039.999890ps       27.814372
+ 4049.999891ps        25.75636
+ 4059.999892ps       23.590565
+ 4069.999893ps       21.419282
+ 4079.999893ps        19.33305
+ 4089.999894ps       17.494023
+ 4099.999895ps       15.992546
+ 4109.999896ps       14.903838
+ 4119.999897ps       14.252998
+ 4129.999898ps       13.998313
+ 4139.999898ps       14.110017
+ 4149.999899ps       14.515784
+ 4159.999900ps       15.088104
+ 4169.999901ps        15.75641
+ 4179.999902ps       16.537073
+ 4189.999903ps       17.298098
+ 4199.999903ps       17.967319
+ 4209.999904ps       18.493357
+ 4219.999905ps       18.778687
+ 4229.999906ps       18.803441
+ 4239.999907ps       18.605978
+ 4249.999908ps       18.212255
+ 4259.999908ps       17.623009
+ 4269.999909ps       16.861465
+ 4279.999910ps       15.958566
+ 4289.999911ps       14.895896
+ 4299.999912ps       13.780186
+ 4309.999913ps       12.755023
+ 4319.999913ps       11.928726
+ 4329.999914ps       11.377099
+ 4339.999915ps       11.118838
+ 4349.999916ps       11.190375
+ 4359.999917ps       11.636254
+ 4369.999917ps       12.486059
+ 4379.999918ps       13.851851
+ 4389.999919ps        15.65009
+ 4399.999920ps       17.725925
+ 4409.999921ps       19.912783
+ 4419.999922ps       22.173715
+ 4429.999922ps       24.552062
+ 4439.999923ps       26.985484
+ 4449.999924ps       29.330133
+ 4459.999925ps       31.416086
+ 4469.999926ps       32.870702
+ 4479.999927ps        33.66058
+ 4489.999927ps       33.697181
+ 4499.999928ps       33.162962
+ 4509.999929ps       32.247052
+ 4519.999930ps       31.019516
+ 4529.999931ps        29.45943
+ 4539.999932ps       27.584967
+ 4549.999932ps       25.411437
+ 4559.999933ps       23.145396
+ 4569.999934ps        20.92369
+ 4579.999935ps        18.82666
+ 4589.999936ps       16.999014
+ 4599.999937ps       15.514251
+ 4609.999937ps        14.44314
+ 4619.999938ps       13.819158
+ 4629.999939ps       13.617262
+ 4639.999940ps       13.793454
+ 4649.999941ps       14.266657
+ 4659.999941ps       14.897345
+ 4669.999942ps       15.626383
+ 4679.999943ps       16.445822
+ 4689.999944ps       17.240118
+ 4699.999945ps        17.92422
+ 4709.999946ps       18.462579
+ 4719.999946ps       18.757341
+ 4729.999947ps       18.781349
+ 4739.999948ps       18.577354
+ 4749.999949ps       18.176085
+ 4759.999950ps       17.575959
+ 4769.999951ps       16.805477
+ 4779.999951ps        15.89943
+ 4789.999952ps       14.834726
+ 4799.999953ps       13.711497
+ 4809.999954ps       12.685256
+ 4819.999955ps       11.861005
+ 4829.999956ps       11.305591
+ 4839.999956ps       11.062949
+ 4849.999957ps       11.148319
+ 4859.999958ps       11.636908
+ 4869.999959ps       12.524292
+ 4879.999960ps       13.946145
+ 4889.999961ps       15.771418
+ 4899.999961ps       17.817619
+ 4909.999962ps       19.962818
+ 4919.999963ps       22.135513
+ 4929.999964ps       24.474988
+ 4939.999965ps       26.881942
+ 4949.999965ps       29.273156
+ 4959.999966ps       31.415835
+ 4969.999967ps       32.929114
+ 4979.999968ps       33.710788
+ 4989.999969ps       33.732294
+ 4999.999970ps       33.086802
+ 5009.999970ps       32.058466
+ 5019.999971ps       30.817926
+ 5029.999972ps       29.318354
+ 5039.999973ps       27.542125
+ 5049.999974ps       25.436283
+ 5059.999975ps       23.187402
+ 5069.999975ps       20.916524
+ 5079.999976ps       18.778569
+ 5089.999977ps       16.920169
+ 5099.999978ps       15.461222
+ 5109.999979ps       14.462674
+ 5119.999980ps       13.891617
+ 5129.999980ps       13.696554
+ 5139.999981ps       13.844247
+ 5149.999982ps       14.281489
+ 5159.999983ps       14.909692
+ 5169.999984ps       15.640325
+ 5179.999985ps        16.46865
+ 5189.999985ps       17.256156
+ 5199.999986ps       17.946812
+ 5209.999987ps       18.487919
+ 5219.999988ps       18.783024
+ 5229.999989ps       18.817486
+ 5239.999989ps        18.63248
+ 5249.999990ps       18.251511
+ 5259.999991ps       17.668194
+ 5269.999992ps       16.918845
+ 5279.999993ps       16.019699
+ 5289.999994ps       14.954086
+ 5299.999994ps       13.849786
+ 5309.999995ps        12.82788
+ 5319.999996ps       11.999364
+ 5329.999997ps       11.436264
+ 5339.999998ps       11.154838
+ 5349.999999ps       11.214774
+ 5359.999999ps       11.660795
+ 5370.000000ps       12.508512
+ 5380.000001ps       13.885546
+ 5390.000002ps       15.699968
+ 5400.000003ps       17.797879
+ 5410.000004ps       20.002242
+ 5420.000004ps       22.283199
+ 5430.000005ps        24.65816
+ 5440.000006ps       27.095024
+ 5450.000007ps       29.420549
+ 5460.000008ps       31.482302
+ 5470.000009ps       32.929461
+ 5480.000009ps       33.702928
+ 5490.000010ps       33.751097
+ 5500.000011ps       33.211457
+ 5510.000012ps       32.304571
+ 5520.000013ps       31.085145
+ 5530.000013ps       29.554614
+ 5540.000014ps       27.723211
+ 5550.000015ps        25.58836
+ 5560.000016ps       23.375299
+ 5570.000017ps       21.161968
+ 5580.000018ps       19.055265
+ 5590.000018ps       17.208787
+ 5600.000019ps       15.705246
+ 5610.000020ps       14.609218
+ 5620.000021ps       13.952345
+ 5630.000022ps       13.705558
+ 5640.000023ps       13.856374
+ 5650.000023ps       14.331072
+ 5660.000024ps       14.959904
+ 5670.000025ps       15.680782
+ 5680.000026ps       16.484951
+ 5690.000027ps       17.255848
+ 5700.000028ps       17.930338
+ 5710.000028ps       18.459366
+ 5720.000029ps       18.743925
+ 5730.000030ps       18.764966
+ 5740.000031ps       18.559826
+ 5750.000032ps       18.159034
+ 5760.000032ps       17.576397
+ 5770.000033ps       16.815014
+ 5780.000034ps       15.913195
+ 5790.000035ps        14.84446
+ 5800.000036ps       13.736006
+ 5810.000037ps       12.740217
+ 5820.000037ps       11.938867
+ 5830.000038ps       11.411319
+ 5840.000039ps       11.177866
+ 5850.000040ps       11.237431
+ 5860.000041ps        11.70124
+ 5870.000042ps       12.591541
+ 5880.000042ps       13.997362
+ 5890.000043ps       15.808744
+ 5900.000044ps        17.88117
+ 5910.000045ps       20.039534
+ 5920.000046ps       22.232306
+ 5930.000047ps       24.587706
+ 5940.000047ps         27.0132
+ 5950.000048ps       29.359387
+ 5960.000049ps       31.459202
+ 5970.000050ps       32.919599
+ 5980.000051ps       33.673972
+ 5990.000052ps       33.688901
+ 6000.000052ps       33.086598
+ 6010.000053ps        32.06833
+ 6020.000054ps       30.847389
+ 6030.000055ps       29.347106
+ 6040.000056ps       27.539654
+ 6050.000056ps       25.402726
+ 6060.000057ps       23.174384
+ 6070.000058ps        20.95517
+ 6080.000059ps       18.836973
+ 6090.000060ps       16.971514
+ 6100.000061ps       15.501647
+ 6110.000061ps       14.462219
+ 6120.000062ps       13.859321
+ 6130.000063ps       13.653285
+ 6140.000064ps       13.823263
+ 6150.000065ps       14.295367
+ 6160.000066ps       14.938194
+ 6170.000066ps           15.67
+ 6180.000067ps       16.491802
+ 6190.000068ps       17.274096
+ 6200.000069ps       17.952395
+ 6210.000070ps       18.484452
+ 6220.000071ps       18.766648
+ 6230.000071ps       18.787467
+ 6240.000072ps       18.585439
+ 6250.000073ps       18.184909
+ 6260.000074ps       17.600978
+ 6270.000075ps       16.849734
+ 6280.000076ps       15.949494
+ 6290.000076ps       14.881623
+ 6300.000077ps       13.760108
+ 6310.000078ps       12.744364
+ 6320.000079ps        11.93257
+ 6330.000080ps       11.389421
+ 6340.000080ps       11.142722
+ 6350.000081ps       11.221024
+ 6360.000082ps       11.694855
+ 6370.000083ps       12.569328
+ 6380.000084ps         13.9327
+ 6390.000085ps       15.703827
+ 6400.000085ps       17.719179
+ 6410.000086ps       19.852224
+ 6420.000087ps       22.054192
+ 6430.000088ps       24.405137
+ 6440.000089ps       26.819704
+ 6450.000090ps       29.153585
+ 6460.000090ps       31.244511
+ 6470.000091ps       32.740326
+ 6480.000092ps       33.565047
+ 6490.000093ps       33.643727
+ 6500.000094ps       33.159011
+ 6510.000095ps       32.265098
+ 6520.000095ps       31.046355
+ 6530.000096ps       29.502601
+ 6540.000097ps       27.610695
+ 6550.000098ps       25.414215
+ 6560.000099ps       23.112134
+ 6570.000100ps       20.854107
+ 6580.000100ps       18.706428
+ 6590.000101ps       16.846878
+ 6600.000102ps       15.362112
+ 6610.000103ps       14.299723
+ 6620.000104ps       13.692066
+ 6630.000104ps        13.50864
+ 6640.000105ps       13.723568
+ 6650.000106ps       14.218603
+ 6660.000107ps       14.864859
+ 6670.000108ps       15.604739
+ 6680.000109ps       16.433846
+ 6690.000109ps       17.220285
+ 6700.000110ps       17.902897
+ 6710.000111ps       18.438389
+ 6720.000112ps       18.721193
+ 6730.000113ps       18.739005
+ 6740.000114ps       18.534603
+ 6750.000114ps       18.130634
+ 6760.000115ps       17.537087
+ 6770.000116ps       16.774773
+ 6780.000117ps       15.867761
+ 6790.000118ps       14.802527
+ 6800.000119ps       13.695544
+ 6810.000119ps       12.677043
+ 6820.000120ps       11.857774
+ 6830.000121ps       11.303651
+ 6840.000122ps       11.046535
+ 6850.000123ps       11.108762
+ 6860.000124ps       11.561572
+ 6870.000124ps       12.408626
+ 6880.000125ps       13.799733
+ 6890.000126ps       15.613501
+ 6900.000127ps       17.686072
+ 6910.000128ps       19.869282
+ 6920.000128ps       22.109265
+ 6930.000129ps       24.498196
+ 6940.000130ps        26.90811
+ 6950.000131ps       29.235512
+ 6960.000132ps       31.314983
+ 6970.000133ps       32.776143
+ 6980.000133ps       33.529465
+ 6990.000134ps       33.552844
+ 7000.000135ps       32.947567
+ 7010.000136ps       31.951145
+ 7020.000137ps       30.712392
+ 7030.000138ps       29.206654
+ 7040.000138ps       27.403379
+ 7050.000139ps       25.287231
+ 7060.000140ps       23.060429
+ 7070.000141ps       20.829659
+ 7080.000142ps       18.716866
+ 7090.000143ps        16.89826
+ 7100.000143ps       15.423929
+ 7110.000144ps       14.332242
+ 7120.000145ps       13.693394
+ 7130.000146ps       13.501468
+ 7140.000147ps       13.703665
+ 7150.000148ps       14.192163
+ 7160.000148ps       14.837911
+ 7170.000149ps       15.577104
+ 7180.000150ps       16.406147
+ 7190.000151ps       17.192315
+ 7200.000152ps       17.877593
+ 7210.000152ps       18.408291
+ 7220.000153ps       18.695747
+ 7230.000154ps       18.711303
+ 7240.000155ps       18.490157
+ 7250.000156ps       18.069731
+ 7260.000157ps       17.461702
+ 7270.000157ps       16.688183
+ 7280.000158ps       15.773716
+ 7290.000159ps       14.714881
+ 7300.000160ps       13.622819
+ 7310.000161ps       12.627382
+ 7320.000162ps       11.821445
+ 7330.000162ps       11.301661
+ 7340.000163ps       11.088589
+ 7350.000164ps       11.185637
+ 7360.000165ps       11.675036
+ 7370.000166ps        12.56651
+ 7380.000167ps       13.990487
+ 7390.000167ps       15.816948
+ 7400.000168ps       17.862433
+ 7410.000169ps       20.014343
+ 7420.000170ps       22.215605
+ 7430.000171ps       24.549546
+ 7440.000171ps       26.956046
+ 7450.000172ps       29.302074
+ 7459.999729ps       31.400478
+ 7469.999730ps       32.872115
+ 7479.999731ps       33.678388
+ 7489.999732ps       33.753238
+ 7499.999732ps       33.241908
+ 7509.999733ps       32.342544
+ 7519.999734ps        31.13512
+ 7529.999735ps       29.611168
+ 7539.999736ps       27.774048
+ 7549.999737ps       25.611326
+ 7559.999737ps       23.300724
+ 7569.999738ps       20.993932
+ 7579.999739ps       18.845973
+ 7589.999740ps       17.017458
+ 7599.999741ps       15.529072
+ 7609.999741ps       14.446894
+ 7619.999742ps       13.815632
+ 7629.999743ps       13.600066
+ 7639.999744ps       13.772547
+ 7649.999745ps       14.244496
+ 7659.999746ps       14.887229
+ 7669.999746ps       15.619243
+ 7679.999747ps       16.438194
+ 7689.999748ps       17.216451
+ 7699.999749ps       17.889598
+ 7709.999750ps       18.419616
+ 7719.999751ps       18.702315
+ 7729.999751ps       18.721122
+ 7739.999752ps        18.51093
+ 7749.999753ps       18.105581
+ 7759.999754ps       17.510684
+ 7769.999755ps       16.760841
+ 7779.999756ps       15.857154
+ 7789.999756ps       14.801214
+ 7799.999757ps       13.694406
+ 7809.999758ps       12.694974
+ 7819.999759ps       11.871227
+ 7829.999760ps       11.318871
+ 7839.999761ps       11.057164
+ 7849.999761ps       11.094953
+ 7859.999762ps       11.524404
+ 7869.999763ps       12.380907
+ 7879.999764ps       13.758719
+ 7889.999765ps       15.543175
+ 7899.999765ps       17.605933
+ 7909.999766ps       19.801113
+ 7919.999767ps       22.059001
+ 7929.999768ps       24.459609
+ 7939.999769ps       26.899828
+ 7949.999770ps       29.286244
+ 7959.999770ps       31.380289
+ 7969.999771ps       32.832691
+ 7979.999772ps       33.590568
+ 7989.999773ps       33.755002
+ 7999.999774ps       33.089148
+ 8009.999775ps       32.188755
+ 8019.999775ps       31.286743
+ 8029.999776ps        30.79878
+ 8039.999777ps       30.477529
+ 8049.999778ps        30.27367
+ 8059.999779ps       30.143231
+ 8069.999780ps        30.05692
+ 8079.999780ps       29.998695
+ 8089.999781ps       29.958932
+ 8099.999782ps       29.931548
+ 8109.999783ps       29.912593
+ 8119.999784ps        29.89944
+ 8129.999785ps       29.890318
+ 8139.999785ps       29.884013
+ 8149.999786ps       29.879689
+ 8159.999787ps        29.87676
+ 8169.999788ps       29.874815
+ 8179.999789ps       29.873564
+ 8189.999789ps       29.872801
+ 8199.999790ps        29.87238
+ 8209.999791ps       29.872196
+ 8219.999792ps       29.872175
+ 8229.999793ps       29.872263
+ 8239.999794ps       29.872422
+ 8249.999794ps       29.872625
+ 8259.999795ps       29.872853
+ 8269.999796ps       29.873093
+ 8279.999797ps       29.873335
+ 8289.999798ps       29.873573
+ 8299.999799ps       29.873803
+ 8309.999799ps       29.874022
+)

Icursig16 PAR_0_0_VSS 0 pwl(
+ 0.000000ps     -0.69656273
+ 10.000000ps     -0.80058302
+ 20.000000ps      -1.0122013
+ 29.999999ps      -1.2715679
+ 40.000000ps      -1.5508949
+ 50.000001ps      -1.8118533
+ 59.999998ps      -2.0382674
+ 69.999999ps        -2.31205
+ 80.000000ps       -2.675207
+ 90.000001ps      -3.0831423
+ 100.000001ps       -3.473764
+ 110.000002ps      -3.8090172
+ 119.999996ps      -4.0162731
+ 129.999997ps      -4.0405217
+ 139.999998ps      -3.9635665
+ 149.999999ps      -3.8884947
+ 159.999999ps      -3.9066566
+ 170.000000ps      -4.0258792
+ 180.000001ps      -4.2859213
+ 190.000002ps      -4.5443382
+ 200.000003ps      -4.7117198
+ 210.000003ps      -4.7462096
+ 220.000004ps      -4.6981964
+ 230.000005ps      -4.5644782
+ 239.999992ps      -4.4021528
+ 249.999993ps      -4.1801586
+ 259.999994ps      -3.8700566
+ 269.999995ps      -3.5399297
+ 279.999995ps      -3.1561007
+ 289.999996ps      -2.7976769
+ 299.999997ps      -2.4743297
+ 309.999998ps      -2.2275468
+ 319.999999ps      -2.0759179
+ 330.000000ps      -2.0157263
+ 340.000000ps      -2.0469476
+ 350.000001ps      -2.1737317
+ 360.000002ps      -2.3524022
+ 370.000003ps      -2.6060688
+ 380.000004ps      -2.8996497
+ 390.000005ps      -3.1832198
+ 400.000005ps      -3.4523313
+ 410.000006ps      -3.6675835
+ 420.000007ps      -3.8331467
+ 430.000008ps      -3.9425594
+ 440.000009ps      -3.9920974
+ 450.000009ps      -4.0280358
+ 460.000010ps      -4.0688677
+ 469.999983ps      -4.1438714
+ 479.999984ps       -4.193505
+ 489.999985ps      -4.2193163
+ 499.999986ps      -4.1929631
+ 509.999987ps       -4.114997
+ 519.999988ps      -3.9976982
+ 529.999988ps      -3.8698336
+ 539.999989ps      -3.7584725
+ 549.999990ps       -3.667875
+ 559.999991ps      -3.5964073
+ 569.999992ps      -3.6433153
+ 579.999992ps      -3.8298886
+ 589.999993ps      -4.1084004
+ 599.999994ps      -4.4093609
+ 609.999995ps      -4.6863801
+ 619.999996ps      -4.8336588
+ 629.999997ps         -4.7828
+ 639.999997ps      -4.6453768
+ 649.999998ps      -4.4779031
+ 659.999999ps      -4.3782236
+ 670.000000ps      -4.3438412
+ 680.000001ps      -4.4815234
+ 690.000002ps      -4.6554721
+ 700.000002ps      -4.7744098
+ 710.000003ps      -4.7785683
+ 720.000004ps      -4.7110655
+ 730.000005ps      -4.5657578
+ 740.000006ps       -4.395484
+ 750.000007ps      -4.1701091
+ 760.000007ps      -3.8542967
+ 770.000008ps      -3.5223321
+ 780.000009ps      -3.1363425
+ 790.000010ps      -2.7717009
+ 800.000011ps      -2.4491521
+ 810.000012ps      -2.1997684
+ 820.000012ps      -2.0469302
+ 830.000013ps      -1.9857728
+ 840.000014ps      -2.0115353
+ 850.000015ps      -2.1380209
+ 860.000016ps      -2.3204951
+ 870.000016ps      -2.5849081
+ 880.000017ps      -2.8844466
+ 890.000018ps      -3.1787383
+ 900.000019ps      -3.4570158
+ 910.000020ps      -3.6662636
+ 920.000021ps      -3.8069356
+ 930.000021ps      -3.8676254
+ 939.999967ps       -3.854897
+ 949.999968ps      -3.8318247
+ 959.999968ps      -3.8062498
+ 969.999969ps      -3.8103214
+ 979.999970ps      -3.8433692
+ 989.999971ps      -3.8930423
+ 999.999972ps      -3.9109029
+ 1009.999973ps      -3.8910632
+ 1019.999973ps      -3.8392333
+ 1029.999974ps      -3.7561181
+ 1039.999975ps      -3.6682356
+ 1049.999976ps       -3.561294
+ 1059.999977ps      -3.4698821
+ 1069.999978ps      -3.4972632
+ 1079.999978ps      -3.6637489
+ 1089.999979ps      -3.9144514
+ 1099.999980ps        -4.17962
+ 1109.999981ps      -4.3990502
+ 1119.999982ps      -4.4892467
+ 1129.999982ps      -4.3978928
+ 1139.999983ps      -4.2283364
+ 1149.999984ps      -4.0778177
+ 1159.999985ps      -4.0575783
+ 1169.999986ps      -4.1460802
+ 1179.999987ps      -4.3816771
+ 1189.999987ps      -4.6157498
+ 1199.999988ps      -4.7638232
+ 1209.999989ps       -4.783402
+ 1219.999990ps       -4.724883
+ 1229.999991ps      -4.5828229
+ 1239.999992ps      -4.4126998
+ 1249.999992ps      -4.1859576
+ 1259.999993ps      -3.8681137
+ 1269.999994ps      -3.5341572
+ 1279.999995ps      -3.1469966
+ 1289.999996ps      -2.7800949
+ 1299.999997ps      -2.4606345
+ 1309.999997ps      -2.2090493
+ 1319.999998ps      -2.0516937
+ 1329.999999ps      -1.9905343
+ 1340.000000ps      -2.0201753
+ 1350.000001ps      -2.1517282
+ 1360.000002ps      -2.3398803
+ 1370.000002ps      -2.6009526
+ 1380.000003ps      -2.8985432
+ 1390.000004ps      -3.1964868
+ 1400.000005ps       -3.488668
+ 1410.000006ps      -3.7142143
+ 1420.000006ps      -3.8847342
+ 1430.000007ps      -3.9911957
+ 1440.000008ps      -4.0290682
+ 1450.000009ps      -4.0394657
+ 1460.000010ps      -4.0424095
+ 1470.000011ps      -4.0638189
+ 1480.000011ps      -4.0828567
+ 1490.000012ps      -4.1104245
+ 1500.000013ps      -4.1106999
+ 1510.000014ps       -4.074555
+ 1520.000015ps      -4.0086611
+ 1530.000016ps      -3.9098825
+ 1540.000016ps      -3.8090361
+ 1550.000017ps      -3.7146843
+ 1560.000018ps        -3.63771
+ 1570.000019ps      -3.6783685
+ 1580.000020ps      -3.8501926
+ 1590.000021ps        -4.12248
+ 1600.000021ps      -4.4355729
+ 1610.000022ps      -4.6953447
+ 1620.000023ps      -4.8076837
+ 1630.000024ps      -4.7155229
+ 1640.000025ps      -4.5215207
+ 1650.000025ps       -4.339777
+ 1660.000026ps      -4.2648459
+ 1670.000027ps      -4.2973439
+ 1680.000028ps      -4.4804968
+ 1690.000029ps       -4.674992
+ 1700.000030ps      -4.7972794
+ 1710.000030ps      -4.8003337
+ 1720.000031ps      -4.7291216
+ 1730.000032ps      -4.5795151
+ 1740.000033ps       -4.406523
+ 1750.000034ps      -4.1780611
+ 1760.000035ps      -3.8633547
+ 1770.000035ps      -3.5331242
+ 1780.000036ps      -3.1498119
+ 1790.000037ps      -2.7904497
+ 1800.000038ps      -2.4654835
+ 1810.000039ps      -2.2158985
+ 1820.000040ps      -2.0590565
+ 1830.000040ps      -1.9962874
+ 1840.000041ps      -2.0165024
+ 1850.000042ps       -2.145025
+ 1860.000043ps      -2.3296465
+ 1869.999933ps        -2.59666
+ 1879.999934ps      -2.8993568
+ 1889.999934ps      -3.1941931
+ 1899.999935ps      -3.4751309
+ 1909.999936ps      -3.6905176
+ 1919.999937ps       -3.844621
+ 1929.999938ps      -3.9289348
+ 1939.999938ps      -3.9302283
+ 1949.999939ps      -3.9062291
+ 1959.999940ps      -3.8911312
+ 1969.999941ps      -3.9178272
+ 1979.999942ps      -3.9484975
+ 1989.999943ps      -3.9835961
+ 1999.999943ps       -3.998515
+ 2009.999944ps      -3.9620305
+ 2019.999945ps      -3.8855388
+ 2029.999946ps      -3.7822716
+ 2039.999947ps      -3.6933786
+ 2049.999948ps      -3.6113721
+ 2059.999948ps      -3.5369169
+ 2069.999949ps      -3.5785248
+ 2079.999950ps      -3.7647844
+ 2089.999951ps      -4.0259738
+ 2099.999952ps      -4.3070797
+ 2109.999953ps      -4.5397452
+ 2119.999953ps      -4.6232183
+ 2129.999954ps      -4.5236177
+ 2139.999955ps      -4.3573401
+ 2149.999956ps      -4.2136249
+ 2159.999957ps      -4.1648522
+ 2169.999958ps      -4.2046949
+ 2179.999958ps      -4.3972726
+ 2189.999959ps      -4.6130733
+ 2199.999960ps      -4.7520428
+ 2209.999961ps      -4.7685423
+ 2219.999962ps      -4.7080479
+ 2229.999962ps      -4.5656901
+ 2239.999963ps      -4.3939222
+ 2249.999964ps      -4.1653134
+ 2259.999965ps      -3.8470405
+ 2269.999966ps      -3.5147093
+ 2279.999967ps      -3.1291054
+ 2289.999967ps      -2.7652844
+ 2299.999968ps      -2.4497418
+ 2309.999969ps      -2.2039077
+ 2319.999970ps      -2.0506742
+ 2329.999971ps      -1.9962404
+ 2339.999972ps       -2.031197
+ 2349.999972ps      -2.1680912
+ 2359.999973ps       -2.369825
+ 2369.999974ps      -2.6432969
+ 2379.999975ps      -2.9554751
+ 2389.999976ps      -3.2626499
+ 2399.999977ps      -3.5609576
+ 2409.999977ps      -3.7784947
+ 2419.999978ps      -3.9297374
+ 2429.999979ps      -4.0095253
+ 2439.999980ps      -4.0140535
+ 2449.999981ps      -3.9953462
+ 2459.999981ps      -3.9944587
+ 2469.999982ps      -4.0327467
+ 2479.999983ps      -4.0586255
+ 2489.999984ps      -4.0845238
+ 2499.999985ps      -4.0868326
+ 2509.999986ps      -4.0535963
+ 2519.999986ps      -3.9836185
+ 2529.999987ps      -3.8974247
+ 2539.999988ps      -3.8139807
+ 2549.999989ps      -3.7227281
+ 2559.999990ps      -3.6556333
+ 2569.999991ps      -3.7140838
+ 2579.999991ps      -3.8864209
+ 2589.999992ps      -4.1328279
+ 2599.999993ps      -4.3900007
+ 2609.999994ps      -4.6148722
+ 2619.999995ps       -4.724222
+ 2629.999996ps       -4.636098
+ 2639.999996ps      -4.4709442
+ 2649.999997ps      -4.2917544
+ 2659.999998ps      -4.2059804
+ 2669.999999ps      -4.2104159
+ 2680.000000ps      -4.3955136
+ 2690.000001ps      -4.6088028
+ 2700.000001ps      -4.7465025
+ 2710.000002ps      -4.7614665
+ 2720.000003ps      -4.7009555
+ 2730.000004ps      -4.5582729
+ 2740.000005ps      -4.3886971
+ 2750.000005ps      -4.1621375
+ 2760.000006ps      -3.8456892
+ 2770.000007ps       -3.513202
+ 2780.000008ps       -3.126464
+ 2790.000009ps      -2.7609314
+ 2800.000010ps      -2.4401075
+ 2810.000010ps      -2.1988664
+ 2820.000011ps      -2.0395744
+ 2830.000012ps       -1.978514
+ 2840.000013ps      -2.0071363
+ 2850.000014ps      -2.1429681
+ 2860.000015ps      -2.3391244
+ 2870.000015ps      -2.6194163
+ 2880.000016ps      -2.9356796
+ 2890.000017ps      -3.2424684
+ 2900.000018ps      -3.5489802
+ 2910.000019ps      -3.7691455
+ 2920.000020ps      -3.9215773
+ 2930.000020ps      -3.9951314
+ 2940.000021ps      -3.9853794
+ 2950.000022ps      -3.9661242
+ 2960.000023ps      -3.9551681
+ 2970.000024ps      -3.9692321
+ 2980.000025ps      -4.0119325
+ 2990.000025ps      -4.0703198
+ 3000.000026ps      -4.0806145
+ 3010.000027ps      -4.0385886
+ 3020.000028ps      -3.9659117
+ 3030.000029ps        -3.87307
+ 3040.000029ps       -3.790153
+ 3050.000030ps      -3.7056282
+ 3060.000031ps      -3.6358287
+ 3070.000032ps      -3.6861498
+ 3080.000033ps      -3.8697752
+ 3090.000034ps      -4.1334638
+ 3100.000034ps       -4.404537
+ 3110.000035ps      -4.6140666
+ 3120.000036ps      -4.6963736
+ 3130.000037ps      -4.6042216
+ 3140.000038ps      -4.4321989
+ 3150.000039ps       -4.274441
+ 3160.000039ps      -4.2196055
+ 3170.000040ps      -4.2608221
+ 3180.000041ps         -4.4438
+ 3190.000042ps      -4.6391532
+ 3200.000043ps      -4.7668587
+ 3210.000044ps      -4.7772956
+ 3220.000044ps      -4.7137738
+ 3230.000045ps      -4.5707291
+ 3240.000046ps       -4.400134
+ 3250.000047ps      -4.1747586
+ 3260.000048ps      -3.8559255
+ 3270.000049ps      -3.5230936
+ 3280.000049ps      -3.1373491
+ 3290.000050ps      -2.7702744
+ 3300.000051ps      -2.4438565
+ 3310.000052ps      -2.1964678
+ 3320.000053ps      -2.0569193
+ 3330.000053ps      -1.9954175
+ 3340.000054ps       -2.018838
+ 3350.000055ps      -2.1482015
+ 3360.000056ps      -2.3515878
+ 3370.000057ps      -2.6562448
+ 3380.000058ps      -2.9900652
+ 3390.000058ps      -3.3253375
+ 3400.000059ps      -3.6571928
+ 3410.000060ps      -3.9259805
+ 3420.000061ps      -4.1095703
+ 3430.000062ps      -4.1742669
+ 3440.000063ps      -4.1421157
+ 3450.000063ps      -4.0816159
+ 3460.000064ps      -4.0091969
+ 3470.000065ps      -3.9673617
+ 3480.000066ps      -3.9651205
+ 3490.000067ps      -3.9956246
+ 3500.000068ps      -4.0183516
+ 3510.000068ps       -4.012095
+ 3520.000069ps       -3.987831
+ 3530.000070ps      -3.9323375
+ 3540.000071ps      -3.8771254
+ 3550.000072ps      -3.8146549
+ 3560.000073ps       -3.760648
+ 3570.000073ps      -3.8188382
+ 3580.000074ps      -4.0246508
+ 3590.000075ps      -4.2932642
+ 3600.000076ps      -4.5346707
+ 3610.000077ps      -4.6948506
+ 3620.000077ps      -4.7242874
+ 3630.000078ps       -4.593814
+ 3640.000079ps      -4.3841447
+ 3650.000080ps      -4.1855412
+ 3660.000081ps      -4.1053671
+ 3670.000082ps       -4.151463
+ 3680.000082ps      -4.3688162
+ 3690.000083ps      -4.6002409
+ 3700.000084ps      -4.7488467
+ 3710.000085ps      -4.7693486
+ 3720.000086ps      -4.7117215
+ 3729.999865ps      -4.5724943
+ 3739.999865ps      -4.4024432
+ 3749.999866ps      -4.1741119
+ 3759.999867ps      -3.8572746
+ 3769.999868ps      -3.5239335
+ 3779.999869ps      -3.1386511
+ 3789.999869ps      -2.7768078
+ 3799.999870ps      -2.4519271
+ 3809.999871ps       -2.203004
+ 3819.999872ps       -2.049834
+ 3829.999873ps      -1.9883674
+ 3839.999874ps      -2.0174783
+ 3849.999874ps      -2.1536139
+ 3859.999875ps      -2.3598325
+ 3869.999876ps      -2.6404927
+ 3879.999877ps      -2.9643001
+ 3889.999878ps       -3.296257
+ 3899.999879ps      -3.6192413
+ 3909.999879ps      -3.8662115
+ 3919.999880ps      -4.0366592
+ 3929.999881ps      -4.1348996
+ 3939.999882ps       -4.170289
+ 3949.999883ps      -4.1704679
+ 3959.999884ps      -4.1784912
+ 3969.999884ps      -4.2296507
+ 3979.999885ps      -4.2803083
+ 3989.999886ps      -4.3253339
+ 3999.999887ps      -4.3332283
+ 4009.999888ps      -4.2887355
+ 4019.999889ps      -4.1945563
+ 4029.999889ps      -4.1046312
+ 4039.999890ps      -4.0182777
+ 4049.999891ps      -3.9387429
+ 4059.999892ps      -3.9032433
+ 4069.999893ps      -3.9812319
+ 4079.999893ps      -4.1939352
+ 4089.999894ps      -4.4704251
+ 4099.999895ps      -4.7509143
+ 4109.999896ps      -4.9993495
+ 4119.999897ps      -5.1084391
+ 4129.999898ps      -5.0160923
+ 4139.999898ps       -4.832358
+ 4149.999899ps      -4.6519568
+ 4159.999900ps      -4.5776096
+ 4169.999901ps      -4.5808089
+ 4179.999902ps      -4.7317559
+ 4189.999903ps       -4.890073
+ 4199.999903ps      -4.9813341
+ 4209.999904ps      -4.9626278
+ 4219.999905ps      -4.8805614
+ 4229.999906ps      -4.7200353
+ 4239.999907ps      -4.5362917
+ 4249.999908ps       -4.299352
+ 4259.999908ps      -3.9782172
+ 4269.999909ps      -3.6402033
+ 4279.999910ps      -3.2497317
+ 4289.999911ps      -2.8804372
+ 4299.999912ps      -2.5524014
+ 4309.999913ps      -2.3048774
+ 4319.999913ps      -2.1441821
+ 4329.999914ps      -2.0786671
+ 4339.999915ps      -2.1096143
+ 4349.999916ps      -2.2615546
+ 4359.999917ps      -2.4667406
+ 4369.999917ps      -2.7594555
+ 4379.999918ps      -3.0730672
+ 4389.999919ps      -3.3771373
+ 4399.999920ps      -3.6691426
+ 4409.999921ps      -3.8720763
+ 4419.999922ps      -3.9845602
+ 4429.999922ps      -4.0418854
+ 4439.999923ps      -4.0455629
+ 4449.999924ps      -4.0374219
+ 4459.999925ps      -4.0487371
+ 4469.999926ps      -4.1079192
+ 4479.999927ps      -4.1979147
+ 4489.999927ps      -4.3068429
+ 4499.999928ps       -4.333938
+ 4509.999929ps      -4.2930796
+ 4519.999930ps      -4.2017618
+ 4529.999931ps      -4.0651279
+ 4539.999932ps      -3.9107649
+ 4549.999932ps      -3.7874044
+ 4559.999933ps      -3.7081798
+ 4569.999934ps      -3.7497632
+ 4579.999935ps      -3.9095491
+ 4589.999936ps      -4.1479506
+ 4599.999937ps       -4.390975
+ 4609.999937ps       -4.615696
+ 4619.999938ps       -4.733405
+ 4629.999939ps      -4.6719752
+ 4639.999940ps      -4.5265983
+ 4649.999941ps      -4.4077395
+ 4659.999941ps      -4.4181231
+ 4669.999942ps      -4.4656012
+ 4679.999943ps      -4.6176838
+ 4689.999944ps      -4.7476497
+ 4699.999945ps      -4.8388816
+ 4709.999946ps      -4.8300573
+ 4719.999946ps      -4.7527084
+ 4729.999947ps      -4.5989106
+ 4739.999948ps      -4.4199001
+ 4749.999949ps      -4.1879432
+ 4759.999950ps       -3.869628
+ 4769.999951ps      -3.5352568
+ 4779.999951ps      -3.1499675
+ 4789.999952ps      -2.7840181
+ 4799.999953ps      -2.4621323
+ 4809.999954ps      -2.2129546
+ 4819.999955ps      -2.0539459
+ 4829.999956ps       -1.991134
+ 4839.999956ps      -2.0176425
+ 4849.999957ps      -2.1429049
+ 4859.999958ps      -2.3324567
+ 4869.999959ps      -2.6179052
+ 4879.999960ps      -2.9512369
+ 4889.999961ps       -3.288623
+ 4899.999961ps      -3.6224723
+ 4909.999962ps      -3.8976945
+ 4919.999963ps      -4.1124424
+ 4929.999964ps      -4.2557799
+ 4939.999965ps      -4.2836284
+ 4949.999965ps      -4.2504823
+ 4959.999966ps      -4.1909372
+ 4969.999967ps      -4.1287212
+ 4979.999968ps      -4.0709181
+ 4989.999969ps      -4.0475795
+ 4999.999970ps       -4.030218
+ 5009.999970ps      -3.9895576
+ 5019.999971ps       -3.941684
+ 5029.999972ps      -3.8857145
+ 5039.999973ps      -3.8367641
+ 5049.999974ps      -3.7844304
+ 5059.999975ps      -3.7498266
+ 5069.999975ps       -3.839683
+ 5079.999976ps      -4.0630516
+ 5089.999977ps        -4.36633
+ 5099.999978ps      -4.6828152
+ 5109.999979ps      -4.9071965
+ 5119.999980ps      -4.9375447
+ 5129.999980ps      -4.7374522
+ 5139.999981ps      -4.4575354
+ 5149.999982ps      -4.2301924
+ 5159.999983ps      -4.1317796
+ 5169.999984ps      -4.1653323
+ 5179.999985ps      -4.3622433
+ 5189.999985ps       -4.581036
+ 5199.999986ps      -4.7249706
+ 5209.999987ps      -4.7452246
+ 5219.999988ps      -4.6875296
+ 5229.999989ps      -4.5465073
+ 5239.999989ps      -4.3764219
+ 5249.999990ps      -4.1503136
+ 5259.999991ps      -3.8343875
+ 5269.999992ps      -3.5011938
+ 5279.999993ps      -3.1157289
+ 5289.999994ps      -2.7525439
+ 5299.999994ps      -2.4311553
+ 5309.999995ps      -2.1927783
+ 5319.999996ps      -2.0341115
+ 5329.999997ps      -1.9796874
+ 5339.999998ps      -2.0078136
+ 5349.999999ps      -2.1333369
+ 5359.999999ps      -2.3193781
+ 5370.000000ps      -2.5944106
+ 5380.000001ps      -2.9171677
+ 5390.000002ps      -3.2404198
+ 5400.000003ps      -3.5593383
+ 5410.000004ps      -3.8169048
+ 5420.000004ps      -4.0050107
+ 5430.000005ps      -4.1200849
+ 5440.000006ps      -4.1200825
+ 5450.000007ps      -4.0745691
+ 5460.000008ps      -4.0244961
+ 5470.000009ps      -3.9987417
+ 5480.000009ps      -3.9726545
+ 5490.000010ps      -3.9874277
+ 5500.000011ps      -4.0092111
+ 5510.000012ps      -3.9950136
+ 5520.000013ps      -3.9428143
+ 5530.000013ps      -3.8780004
+ 5540.000014ps      -3.8116681
+ 5550.000015ps      -3.7465791
+ 5560.000016ps      -3.6907184
+ 5570.000017ps      -3.7507413
+ 5580.000018ps      -3.9557839
+ 5590.000018ps      -4.2292545
+ 5600.000019ps      -4.5220294
+ 5610.000020ps      -4.7174774
+ 5620.000021ps      -4.7554634
+ 5630.000022ps      -4.6005904
+ 5640.000023ps      -4.3886388
+ 5650.000023ps      -4.1908581
+ 5660.000024ps      -4.1062384
+ 5670.000025ps       -4.136973
+ 5680.000026ps      -4.3477837
+ 5690.000027ps      -4.5753629
+ 5700.000028ps       -4.720995
+ 5710.000028ps      -4.7408922
+ 5720.000029ps      -4.6824285
+ 5730.000030ps      -4.5419581
+ 5740.000031ps      -4.3739727
+ 5750.000032ps      -4.1487783
+ 5760.000032ps      -3.8333823
+ 5770.000033ps      -3.5019028
+ 5780.000034ps      -3.1173246
+ 5790.000035ps      -2.7532025
+ 5800.000036ps      -2.4316147
+ 5810.000037ps      -2.1911562
+ 5820.000037ps      -2.0314898
+ 5830.000038ps      -1.9774136
+ 5840.000039ps      -2.0060524
+ 5850.000040ps      -2.1403829
+ 5860.000041ps       -2.329616
+ 5870.000042ps      -2.5969813
+ 5880.000042ps      -2.9004017
+ 5890.000043ps      -3.2020701
+ 5900.000044ps      -3.4904538
+ 5910.000045ps      -3.7213283
+ 5920.000046ps      -3.8969727
+ 5930.000047ps      -4.0129893
+ 5940.000047ps      -4.0648718
+ 5950.000048ps       -4.116598
+ 5960.000049ps      -4.1652728
+ 5970.000050ps      -4.2398313
+ 5980.000051ps      -4.2998373
+ 5990.000052ps      -4.3396245
+ 6000.000052ps      -4.2991188
+ 6010.000053ps      -4.1967128
+ 6020.000054ps      -4.0616346
+ 6030.000055ps      -3.9307159
+ 6040.000056ps      -3.8195881
+ 6050.000056ps      -3.7335606
+ 6060.000057ps       -3.676883
+ 6070.000058ps      -3.7425433
+ 6080.000059ps      -3.9522906
+ 6090.000060ps      -4.2339969
+ 6100.000061ps      -4.5432217
+ 6110.000061ps      -4.8149413
+ 6120.000062ps       -4.965598
+ 6130.000063ps      -4.9226523
+ 6140.000064ps       -4.777343
+ 6150.000065ps       -4.593745
+ 6160.000066ps      -4.4980165
+ 6170.000066ps      -4.4577989
+ 6180.000067ps      -4.5741942
+ 6190.000068ps      -4.7127011
+ 6200.000069ps      -4.8085141
+ 6210.000070ps       -4.802422
+ 6220.000071ps      -4.7278088
+ 6230.000071ps      -4.5756147
+ 6240.000072ps      -4.3983407
+ 6250.000073ps      -4.1652408
+ 6260.000074ps      -3.8442078
+ 6270.000075ps      -3.5103274
+ 6280.000076ps      -3.1239278
+ 6290.000076ps      -2.7589295
+ 6300.000077ps      -2.4347038
+ 6310.000078ps       -2.188831
+ 6320.000079ps      -2.0394343
+ 6330.000080ps      -1.9749018
+ 6340.000080ps       -2.003452
+ 6350.000081ps      -2.1309969
+ 6360.000082ps      -2.3288163
+ 6370.000083ps      -2.5981142
+ 6380.000084ps      -2.9143675
+ 6390.000085ps      -3.2335981
+ 6400.000085ps      -3.5516079
+ 6410.000086ps      -3.8194296
+ 6420.000087ps       -4.019708
+ 6430.000088ps      -4.1401312
+ 6440.000089ps      -4.1992962
+ 6450.000090ps      -4.2138822
+ 6460.000090ps      -4.2124511
+ 6470.000091ps      -4.2300869
+ 6480.000092ps       -4.232188
+ 6490.000093ps      -4.2095675
+ 6500.000094ps      -4.1835052
+ 6510.000095ps      -4.1249631
+ 6520.000095ps      -4.0416536
+ 6530.000096ps      -3.9597392
+ 6540.000097ps      -3.8843518
+ 6550.000098ps      -3.8106935
+ 6560.000099ps      -3.7650681
+ 6570.000100ps      -3.8412335
+ 6580.000100ps      -4.0610864
+ 6590.000101ps      -4.3509111
+ 6600.000102ps      -4.6397027
+ 6610.000103ps      -4.8979489
+ 6620.000104ps      -5.0043755
+ 6630.000104ps      -4.9142074
+ 6640.000105ps      -4.6923887
+ 6650.000106ps      -4.4616707
+ 6660.000107ps      -4.3249657
+ 6670.000108ps      -4.3035406
+ 6680.000109ps      -4.4689956
+ 6690.000109ps      -4.6615974
+ 6700.000110ps      -4.7828515
+ 6710.000111ps      -4.7872939
+ 6720.000112ps      -4.7169576
+ 6730.000113ps      -4.5681105
+ 6740.000114ps      -4.3919627
+ 6750.000114ps      -4.1628151
+ 6760.000115ps      -3.8439467
+ 6770.000116ps      -3.5093678
+ 6780.000117ps      -3.1225529
+ 6790.000118ps      -2.7571681
+ 6800.000119ps      -2.4362389
+ 6810.000119ps       -2.193483
+ 6820.000120ps      -2.0360033
+ 6830.000121ps      -1.9764603
+ 6840.000122ps       -2.001122
+ 6850.000123ps      -2.1247833
+ 6860.000124ps      -2.3133026
+ 6870.000124ps      -2.5819302
+ 6880.000125ps      -2.9089785
+ 6890.000126ps      -3.2441322
+ 6900.000127ps      -3.5744082
+ 6910.000128ps      -3.8523342
+ 6920.000128ps      -4.0553181
+ 6930.000129ps       -4.187875
+ 6940.000130ps      -4.2413691
+ 6950.000131ps      -4.2356722
+ 6960.000132ps      -4.2160013
+ 6970.000133ps      -4.1985194
+ 6980.000133ps      -4.1800093
+ 6990.000134ps      -4.1801697
+ 7000.000135ps      -4.1812591
+ 7010.000136ps      -4.1279691
+ 7020.000137ps      -4.0617575
+ 7030.000138ps      -3.9810517
+ 7040.000138ps      -3.9044792
+ 7050.000139ps      -3.8273938
+ 7060.000140ps      -3.7868576
+ 7070.000141ps       -3.856736
+ 7080.000142ps       -4.078392
+ 7090.000143ps      -4.3804849
+ 7100.000143ps      -4.7039859
+ 7110.000144ps      -4.9604323
+ 7120.000145ps      -5.0359092
+ 7130.000146ps      -4.8976706
+ 7140.000147ps      -4.6291091
+ 7150.000148ps      -4.4039622
+ 7160.000148ps      -4.3064717
+ 7170.000149ps      -4.3420118
+ 7180.000150ps      -4.5236416
+ 7190.000151ps      -4.7039337
+ 7200.000152ps      -4.8089519
+ 7210.000152ps      -4.8024054
+ 7220.000153ps      -4.7292534
+ 7230.000154ps      -4.5777677
+ 7240.000155ps      -4.4001426
+ 7250.000156ps      -4.1683417
+ 7260.000157ps      -3.8479864
+ 7270.000157ps      -3.5134882
+ 7280.000158ps       -3.125896
+ 7290.000159ps      -2.7582897
+ 7300.000160ps      -2.4384618
+ 7310.000161ps      -2.1910545
+ 7320.000162ps      -2.0384924
+ 7330.000162ps      -1.9790635
+ 7340.000163ps      -2.0043178
+ 7350.000164ps       -2.137605
+ 7360.000165ps       -2.311905
+ 7370.000166ps      -2.5674562
+ 7380.000167ps      -2.8561309
+ 7390.000167ps      -3.1383087
+ 7400.000168ps      -3.4054598
+ 7410.000169ps      -3.6060933
+ 7420.000170ps      -3.7420306
+ 7430.000171ps      -3.8125496
+ 7440.000171ps      -3.8133733
+ 7450.000172ps       -3.797715
+ 7459.999729ps       -3.794624
+ 7469.999730ps      -3.8166218
+ 7479.999731ps      -3.8617839
+ 7489.999732ps      -3.9201563
+ 7499.999732ps      -3.9562732
+ 7509.999733ps      -3.9427638
+ 7519.999734ps      -3.8902433
+ 7529.999735ps      -3.7943629
+ 7539.999736ps      -3.6771458
+ 7549.999737ps      -3.5566163
+ 7559.999737ps      -3.4488053
+ 7569.999738ps      -3.4659913
+ 7579.999739ps      -3.6230134
+ 7589.999740ps       -3.882431
+ 7599.999741ps       -4.165357
+ 7609.999741ps      -4.4127644
+ 7619.999742ps      -4.5277956
+ 7629.999743ps      -4.4613805
+ 7639.999744ps      -4.2949939
+ 7649.999745ps      -4.1478619
+ 7659.999746ps      -4.1191092
+ 7669.999746ps      -4.2000238
+ 7679.999747ps      -4.4235283
+ 7689.999748ps      -4.6381936
+ 7699.999749ps      -4.7698541
+ 7709.999750ps      -4.7810769
+ 7719.999751ps      -4.7176467
+ 7729.999751ps      -4.5711981
+ 7739.999752ps      -4.3984471
+ 7749.999753ps      -4.1705475
+ 7759.999754ps      -3.8528057
+ 7769.999755ps      -3.5189725
+ 7779.999756ps      -3.1348895
+ 7789.999756ps      -2.7696254
+ 7799.999757ps        -2.44607
+ 7809.999758ps       -2.198559
+ 7819.999759ps      -2.0403262
+ 7829.999760ps      -1.9881058
+ 7839.999761ps      -2.0164766
+ 7849.999761ps      -2.1490896
+ 7859.999762ps      -2.3458543
+ 7869.999763ps      -2.6198398
+ 7879.999764ps      -2.9366723
+ 7889.999765ps      -3.2462654
+ 7899.999765ps      -3.5493363
+ 7909.999766ps      -3.7729899
+ 7919.999767ps      -3.9425535
+ 7929.999768ps      -4.0433339
+ 7939.999769ps      -4.0666622
+ 7949.999770ps      -4.0624138
+ 7959.999770ps      -4.0678903
+ 7969.999771ps      -4.0997871
+ 7979.999772ps      -4.1380715
+ 7989.999773ps      -4.1516766
+ 7999.999774ps      -4.0799526
+ 8009.999775ps       -3.923342
+ 8019.999775ps      -3.7697671
+ 8029.999776ps      -3.6612954
+ 8039.999777ps      -3.5920797
+ 8049.999778ps      -3.5467803
+ 8059.999779ps      -3.5162285
+ 8069.999780ps       -3.495199
+ 8079.999780ps      -3.4804214
+ 8089.999781ps      -3.4698169
+ 8099.999782ps      -3.4620466
+ 8109.999783ps      -3.4562358
+ 8119.999784ps      -3.4518039
+ 8129.999785ps        -3.44836
+ 8139.999785ps      -3.4456362
+ 8149.999786ps      -3.4434461
+ 8159.999787ps      -3.4416578
+ 8169.999788ps      -3.4401767
+ 8179.999789ps      -3.4389337
+ 8189.999789ps      -3.4378776
+ 8199.999790ps      -3.4369701
+ 8209.999791ps      -3.4361824
+ 8219.999792ps      -3.4354919
+ 8229.999793ps      -3.4348813
+ 8239.999794ps      -3.4343371
+ 8249.999794ps      -3.4338485
+ 8259.999795ps      -3.4334068
+ 8269.999796ps      -3.4330051
+ 8279.999797ps      -3.4326377
+ 8289.999798ps         -3.4323
+ 8299.999799ps      -3.4319882
+ 8309.999799ps      -3.4316989
+)

.ends

.SUBCKT PowerModel PAR_0_0_VDD075NNE PAR_1_0_VSS PAR_1_0_VDD075NNE PAR_2_0_VSS PAR_2_0_VDD075NNE
+ PAR_3_0_VSS PAR_3_0_VDD075NNE PAR_0_1_VSS PAR_0_1_VDD075NNE PAR_1_1_VSS
+ PAR_1_1_VDD075NNE PAR_2_1_VSS PAR_2_1_VDD075NNE PAR_3_1_VSS PAR_3_1_VDD075NNE
+ PAR_0_0_VSS
**********************************************************
* Ansys RedHawk-SC Chip Power Model [Accurate RC reduction]
* Model Subcircuit of Die PDN
* Copyright (c) 2002-2023 ANSYS, Inc.
**********************************************************

* Pad name : Subckt terminal : net
* VDD075NNE_02114   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02106   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02107   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02108   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02109   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02110   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02111   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02112   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02113   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02105   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02115   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02116   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01456   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01457   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01458   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01459   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01460   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01461   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01946   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01954   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01953   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01952   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01951   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01950   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01949   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01948   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01947   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01462   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01945   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01944   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01943   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01942   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01941   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02103   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02104   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02161   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01466   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01467   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01468   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01469   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02157   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02158   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02159   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02160   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01465   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02162   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02163   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02164   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02165   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02166   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02167   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02168   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02169   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01893   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01463   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01900   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01899   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01898   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01897   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01896   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01895   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01894   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01415   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01892   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01891   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01890   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01889   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01888   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01887   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01464   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01359   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02000   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01999   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01998   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01997   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01996   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01995   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01357   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01358   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02001   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01360   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01361   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01307   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01306   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01305   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01304   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01303   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01302   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01355   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02002   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02003   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02004   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02005   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02006   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02007   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02008   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01356   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01301   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01354   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01353   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01352   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01351   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01350   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01349   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01348   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01406   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02059   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02060   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02061   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02062   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01402   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01403   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01404   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01405   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02058   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01407   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01408   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01409   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01410   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01411   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01412   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01413   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01414   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02050   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01300   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01299   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01298   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01297   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01296   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01295   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01294   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02049   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01510   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02051   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02052   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02053   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02054   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02055   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02056   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02057   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01620   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01784   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01783   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01782   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01781   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01780   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01779   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01618   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01619   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01785   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01621   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01622   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01623   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01624   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01625   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01626   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01627   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01628   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01786   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01787   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01788   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01789   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01790   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01791   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01792   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01577   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01576   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01575   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01574   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01573   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01572   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02224   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02223   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01726   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01685   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01684   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01683   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01682   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01681   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01680   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01679   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01678   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01677   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01676   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01675   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01674   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01673   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01672   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01725   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01511   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01727   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01728   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01729   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01730   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01731   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01732   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01733   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01734   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01735   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01736   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01737   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01738   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01631   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01630   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01629   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01833   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01841   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01840   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01839   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01838   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01837   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01836   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01835   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01834   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01842   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01564   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01565   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01566   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01567   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01568   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01569   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01570   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01571   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01519   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02170   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01512   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01513   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01514   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01515   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01516   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01517   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01518   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02221   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01520   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01521   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01522   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01523   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01846   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01845   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01844   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_01843   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02213   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02211   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02217   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02218   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02216   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02215   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02219   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02214   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02212   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02220   PAR_0_0_VDD075NNE   VDD075NNE
* VDD075NNE_02222   PAR_0_0_VDD075NNE   VDD075NNE
* VSS_02851   PAR_1_0_VSS   VSS
* VSS_03122   PAR_1_0_VSS   VSS
* VSS_03130   PAR_1_0_VSS   VSS
* VSS_02854   PAR_1_0_VSS   VSS
* VSS_02852   PAR_1_0_VSS   VSS
* VSS_03029   PAR_1_0_VSS   VSS
* VSS_03030   PAR_1_0_VSS   VSS
* VSS_02853   PAR_1_0_VSS   VSS
* VSS_03123   PAR_1_0_VSS   VSS
* VSS_03035   PAR_1_0_VSS   VSS
* VSS_02941   PAR_1_0_VSS   VSS
* VSS_02942   PAR_1_0_VSS   VSS
* VSS_02943   PAR_1_0_VSS   VSS
* VSS_02570   PAR_1_0_VSS   VSS
* VSS_02841   PAR_1_0_VSS   VSS
* VSS_02842   PAR_1_0_VSS   VSS
* VSS_02843   PAR_1_0_VSS   VSS
* VSS_02844   PAR_1_0_VSS   VSS
* VSS_02845   PAR_1_0_VSS   VSS
* VSS_02846   PAR_1_0_VSS   VSS
* VSS_02847   PAR_1_0_VSS   VSS
* VSS_02848   PAR_1_0_VSS   VSS
* VSS_02849   PAR_1_0_VSS   VSS
* VSS_02850   PAR_1_0_VSS   VSS
* VSS_02936   PAR_1_0_VSS   VSS
* VSS_03023   PAR_1_0_VSS   VSS
* VSS_03024   PAR_1_0_VSS   VSS
* VSS_03025   PAR_1_0_VSS   VSS
* VSS_03026   PAR_1_0_VSS   VSS
* VSS_02940   PAR_1_0_VSS   VSS
* VSS_02939   PAR_1_0_VSS   VSS
* VSS_02938   PAR_1_0_VSS   VSS
* VSS_02937   PAR_1_0_VSS   VSS
* VSS_03022   PAR_1_0_VSS   VSS
* VSS_02935   PAR_1_0_VSS   VSS
* VSS_03125   PAR_1_0_VSS   VSS
* VSS_03124   PAR_1_0_VSS   VSS
* VSS_02934   PAR_1_0_VSS   VSS
* VSS_02933   PAR_1_0_VSS   VSS
* VSS_02932   PAR_1_0_VSS   VSS
* VSS_02931   PAR_1_0_VSS   VSS
* VSS_02930   PAR_1_0_VSS   VSS
* VSS_03027   PAR_1_0_VSS   VSS
* VSS_03028   PAR_1_0_VSS   VSS
* VSS_03126   PAR_1_0_VSS   VSS
* VSS_03127   PAR_1_0_VSS   VSS
* VSS_03128   PAR_1_0_VSS   VSS
* VSS_03129   PAR_1_0_VSS   VSS
* VSS_03117   PAR_1_0_VSS   VSS
* VSS_03118   PAR_1_0_VSS   VSS
* VSS_03119   PAR_1_0_VSS   VSS
* VSS_03120   PAR_1_0_VSS   VSS
* VSS_03121   PAR_1_0_VSS   VSS
* VSS_03031   PAR_1_0_VSS   VSS
* VSS_03032   PAR_1_0_VSS   VSS
* VSS_03033   PAR_1_0_VSS   VSS
* VSS_03034   PAR_1_0_VSS   VSS
* VSS_03790   PAR_1_0_VSS   VSS
* VSS_03701   PAR_1_0_VSS   VSS
* VSS_04173   PAR_1_0_VSS   VSS
* VSS_04172   PAR_1_0_VSS   VSS
* VSS_04171   PAR_1_0_VSS   VSS
* VSS_04170   PAR_1_0_VSS   VSS
* VSS_04169   PAR_1_0_VSS   VSS
* VSS_03783   PAR_1_0_VSS   VSS
* VSS_03784   PAR_1_0_VSS   VSS
* VSS_03785   PAR_1_0_VSS   VSS
* VSS_03786   PAR_1_0_VSS   VSS
* VSS_03787   PAR_1_0_VSS   VSS
* VSS_03788   PAR_1_0_VSS   VSS
* VSS_03789   PAR_1_0_VSS   VSS
* VSS_03700   PAR_1_0_VSS   VSS
* VSS_03791   PAR_1_0_VSS   VSS
* VSS_03792   PAR_1_0_VSS   VSS
* VSS_03793   PAR_1_0_VSS   VSS
* VSS_03794   PAR_1_0_VSS   VSS
* VSS_03795   PAR_1_0_VSS   VSS
* VSS_03796   PAR_1_0_VSS   VSS
* VSS_04168   PAR_1_0_VSS   VSS
* VSS_04167   PAR_1_0_VSS   VSS
* VSS_04166   PAR_1_0_VSS   VSS
* VSS_04165   PAR_1_0_VSS   VSS
* VSS_04164   PAR_1_0_VSS   VSS
* VSS_02659   PAR_1_0_VSS   VSS
* VSS_03878   PAR_1_0_VSS   VSS
* VSS_04175   PAR_1_0_VSS   VSS
* VSS_03597   PAR_1_0_VSS   VSS
* VSS_03598   PAR_1_0_VSS   VSS
* VSS_03599   PAR_1_0_VSS   VSS
* VSS_03601   PAR_1_0_VSS   VSS
* VSS_03602   PAR_1_0_VSS   VSS
* VSS_03603   PAR_1_0_VSS   VSS
* VSS_03604   PAR_1_0_VSS   VSS
* VSS_03605   PAR_1_0_VSS   VSS
* VSS_03606   PAR_1_0_VSS   VSS
* VSS_04260   PAR_1_0_VSS   VSS
* VSS_04259   PAR_1_0_VSS   VSS
* VSS_04258   PAR_1_0_VSS   VSS
* VSS_04176   PAR_1_0_VSS   VSS
* VSS_03879   PAR_1_0_VSS   VSS
* VSS_04174   PAR_1_0_VSS   VSS
* VSS_03688   PAR_1_0_VSS   VSS
* VSS_03689   PAR_1_0_VSS   VSS
* VSS_03690   PAR_1_0_VSS   VSS
* VSS_03691   PAR_1_0_VSS   VSS
* VSS_03692   PAR_1_0_VSS   VSS
* VSS_03693   PAR_1_0_VSS   VSS
* VSS_03694   PAR_1_0_VSS   VSS
* VSS_03695   PAR_1_0_VSS   VSS
* VSS_03696   PAR_1_0_VSS   VSS
* VSS_03697   PAR_1_0_VSS   VSS
* VSS_03698   PAR_1_0_VSS   VSS
* VSS_03699   PAR_1_0_VSS   VSS
* VSS_04069   PAR_1_0_VSS   VSS
* VSS_02670   PAR_1_0_VSS   VSS
* VSS_02671   PAR_1_0_VSS   VSS
* VSS_02672   PAR_1_0_VSS   VSS
* VSS_03978   PAR_1_0_VSS   VSS
* VSS_03979   PAR_1_0_VSS   VSS
* VSS_03980   PAR_1_0_VSS   VSS
* VSS_03981   PAR_1_0_VSS   VSS
* VSS_03982   PAR_1_0_VSS   VSS
* VSS_03983   PAR_1_0_VSS   VSS
* VSS_03984   PAR_1_0_VSS   VSS
* VSS_03985   PAR_1_0_VSS   VSS
* VSS_03986   PAR_1_0_VSS   VSS
* VSS_04068   PAR_1_0_VSS   VSS
* VSS_02669   PAR_1_0_VSS   VSS
* VSS_04070   PAR_1_0_VSS   VSS
* VSS_04071   PAR_1_0_VSS   VSS
* VSS_04072   PAR_1_0_VSS   VSS
* VSS_04073   PAR_1_0_VSS   VSS
* VSS_04074   PAR_1_0_VSS   VSS
* VSS_04075   PAR_1_0_VSS   VSS
* VSS_04076   PAR_1_0_VSS   VSS
* VSS_04077   PAR_1_0_VSS   VSS
* VSS_04078   PAR_1_0_VSS   VSS
* VSS_04079   PAR_1_0_VSS   VSS
* VSS_04080   PAR_1_0_VSS   VSS
* VSS_04081   PAR_1_0_VSS   VSS
* VSS_04163   PAR_1_0_VSS   VSS
* VSS_03974   PAR_1_0_VSS   VSS
* VSS_03880   PAR_1_0_VSS   VSS
* VSS_03881   PAR_1_0_VSS   VSS
* VSS_03882   PAR_1_0_VSS   VSS
* VSS_03883   PAR_1_0_VSS   VSS
* VSS_03884   PAR_1_0_VSS   VSS
* VSS_03885   PAR_1_0_VSS   VSS
* VSS_03886   PAR_1_0_VSS   VSS
* VSS_03887   PAR_1_0_VSS   VSS
* VSS_03888   PAR_1_0_VSS   VSS
* VSS_03889   PAR_1_0_VSS   VSS
* VSS_03890   PAR_1_0_VSS   VSS
* VSS_03891   PAR_1_0_VSS   VSS
* VSS_03973   PAR_1_0_VSS   VSS
* VSS_03600   PAR_1_0_VSS   VSS
* VSS_03975   PAR_1_0_VSS   VSS
* VSS_03976   PAR_1_0_VSS   VSS
* VSS_03977   PAR_1_0_VSS   VSS
* VSS_02660   PAR_1_0_VSS   VSS
* VSS_02661   PAR_1_0_VSS   VSS
* VSS_02662   PAR_1_0_VSS   VSS
* VSS_02663   PAR_1_0_VSS   VSS
* VSS_02664   PAR_1_0_VSS   VSS
* VSS_02665   PAR_1_0_VSS   VSS
* VSS_02666   PAR_1_0_VSS   VSS
* VSS_02667   PAR_1_0_VSS   VSS
* VSS_02668   PAR_1_0_VSS   VSS
* VSS_03403   PAR_1_0_VSS   VSS
* VSS_03309   PAR_1_0_VSS   VSS
* VSS_03310   PAR_1_0_VSS   VSS
* VSS_03311   PAR_1_0_VSS   VSS
* VSS_03312   PAR_1_0_VSS   VSS
* VSS_03313   PAR_1_0_VSS   VSS
* VSS_03314   PAR_1_0_VSS   VSS
* VSS_03315   PAR_1_0_VSS   VSS
* VSS_03316   PAR_1_0_VSS   VSS
* VSS_03317   PAR_1_0_VSS   VSS
* VSS_03318   PAR_1_0_VSS   VSS
* VSS_03319   PAR_1_0_VSS   VSS
* VSS_03320   PAR_1_0_VSS   VSS
* VSS_03321   PAR_1_0_VSS   VSS
* VSS_03227   PAR_1_0_VSS   VSS
* VSS_03404   PAR_1_0_VSS   VSS
* VSS_03405   PAR_1_0_VSS   VSS
* VSS_03406   PAR_1_0_VSS   VSS
* VSS_03407   PAR_1_0_VSS   VSS
* VSS_02763   PAR_1_0_VSS   VSS
* VSS_02762   PAR_1_0_VSS   VSS
* VSS_02761   PAR_1_0_VSS   VSS
* VSS_02760   PAR_1_0_VSS   VSS
* VSS_02759   PAR_1_0_VSS   VSS
* VSS_02758   PAR_1_0_VSS   VSS
* VSS_02757   PAR_1_0_VSS   VSS
* VSS_02756   PAR_1_0_VSS   VSS
* VSS_03214   PAR_1_0_VSS   VSS
* VSS_02571   PAR_1_0_VSS   VSS
* VSS_02572   PAR_1_0_VSS   VSS
* VSS_02573   PAR_1_0_VSS   VSS
* VSS_02574   PAR_1_0_VSS   VSS
* VSS_02575   PAR_1_0_VSS   VSS
* VSS_02576   PAR_1_0_VSS   VSS
* VSS_02577   PAR_1_0_VSS   VSS
* VSS_02578   PAR_1_0_VSS   VSS
* VSS_02579   PAR_1_0_VSS   VSS
* VSS_02580   PAR_1_0_VSS   VSS
* VSS_02581   PAR_1_0_VSS   VSS
* VSS_02582   PAR_1_0_VSS   VSS
* VSS_02583   PAR_1_0_VSS   VSS
* VSS_02751   PAR_1_0_VSS   VSS
* VSS_03215   PAR_1_0_VSS   VSS
* VSS_03216   PAR_1_0_VSS   VSS
* VSS_03217   PAR_1_0_VSS   VSS
* VSS_03218   PAR_1_0_VSS   VSS
* VSS_03219   PAR_1_0_VSS   VSS
* VSS_03220   PAR_1_0_VSS   VSS
* VSS_03221   PAR_1_0_VSS   VSS
* VSS_03222   PAR_1_0_VSS   VSS
* VSS_03223   PAR_1_0_VSS   VSS
* VSS_03224   PAR_1_0_VSS   VSS
* VSS_03225   PAR_1_0_VSS   VSS
* VSS_03226   PAR_1_0_VSS   VSS
* VSS_03596   PAR_1_0_VSS   VSS
* VSS_03413   PAR_1_0_VSS   VSS
* VSS_03414   PAR_1_0_VSS   VSS
* VSS_03415   PAR_1_0_VSS   VSS
* VSS_03498   PAR_1_0_VSS   VSS
* VSS_03499   PAR_1_0_VSS   VSS
* VSS_03500   PAR_1_0_VSS   VSS
* VSS_03501   PAR_1_0_VSS   VSS
* VSS_02750   PAR_1_0_VSS   VSS
* VSS_03502   PAR_1_0_VSS   VSS
* VSS_03503   PAR_1_0_VSS   VSS
* VSS_03504   PAR_1_0_VSS   VSS
* VSS_03416   PAR_1_0_VSS   VSS
* VSS_03595   PAR_1_0_VSS   VSS
* VSS_03505   PAR_1_0_VSS   VSS
* VSS_03506   PAR_1_0_VSS   VSS
* VSS_03507   PAR_1_0_VSS   VSS
* VSS_03508   PAR_1_0_VSS   VSS
* VSS_03509   PAR_1_0_VSS   VSS
* VSS_03510   PAR_1_0_VSS   VSS
* VSS_03511   PAR_1_0_VSS   VSS
* VSS_03593   PAR_1_0_VSS   VSS
* VSS_03594   PAR_1_0_VSS   VSS
* VSS_04265   PAR_1_0_VSS   VSS
* VSS_02754   PAR_1_0_VSS   VSS
* VSS_02753   PAR_1_0_VSS   VSS
* VSS_02752   PAR_1_0_VSS   VSS
* VSS_03408   PAR_1_0_VSS   VSS
* VSS_03409   PAR_1_0_VSS   VSS
* VSS_03410   PAR_1_0_VSS   VSS
* VSS_04271   PAR_1_0_VSS   VSS
* VSS_04270   PAR_1_0_VSS   VSS
* VSS_04269   PAR_1_0_VSS   VSS
* VSS_02755   PAR_1_0_VSS   VSS
* VSS_04268   PAR_1_0_VSS   VSS
* VSS_04267   PAR_1_0_VSS   VSS
* VSS_04266   PAR_1_0_VSS   VSS
* VSS_03412   PAR_1_0_VSS   VSS
* VSS_04264   PAR_1_0_VSS   VSS
* VSS_04263   PAR_1_0_VSS   VSS
* VSS_04262   PAR_1_0_VSS   VSS
* VSS_04261   PAR_1_0_VSS   VSS
* VSS_03411   PAR_1_0_VSS   VSS
* VDD075NNE_01692   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01532   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01686   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01687   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01688   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01528   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01689   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01690   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01693   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01691   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01644   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01643   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01642   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01639   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01638   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01637   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01636   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01635   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01634   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01633   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01641   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01632   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01640   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01419   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01370   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01371   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01372   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01373   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01374   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01308   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01416   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01417   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01418   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01369   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01420   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01421   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01422   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01423   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01424   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01425   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01426   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01427   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01310   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01319   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01318   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01317   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01316   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01315   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01314   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01313   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01312   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01311   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01428   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01309   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01362   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01363   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01364   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01365   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01366   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01367   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01368   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01581   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01530   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01531   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01533   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01534   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01535   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01536   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01578   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01579   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01580   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01529   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01582   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01583   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01584   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01585   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01586   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01587   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01588   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01589   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01479   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01470   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01471   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01472   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01473   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01474   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01475   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01476   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01477   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01478   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01590   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01480   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01481   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01482   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01524   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01525   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01526   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01527   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01320   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02128   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01858   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01859   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02179   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02178   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02177   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02176   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02175   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02174   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02173   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02172   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02171   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02129   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01857   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02127   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02126   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02125   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01901   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01902   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01903   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01904   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01905   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01906   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01907   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01908   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02124   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02183   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01795   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01796   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01797   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01798   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01799   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01800   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01801   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01802   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01803   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01804   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01805   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02225   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02123   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02182   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02181   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02180   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01847   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01848   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01849   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01851   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01852   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01853   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01854   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01855   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01856   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02021   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01966   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01967   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02072   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02071   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02070   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02069   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02068   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02067   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02066   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02065   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02064   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02063   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01965   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02020   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02019   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02018   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02017   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02016   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02015   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02014   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02013   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02012   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02011   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02010   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02009   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02075   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02122   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02121   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02120   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02119   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01909   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01910   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01911   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01912   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01913   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02118   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02117   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01694   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01850   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02074   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02073   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01955   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01956   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01957   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01958   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01959   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01960   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01961   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01962   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01963   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01964   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01747   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02234   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02235   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01794   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01793   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02236   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02237   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01751   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01750   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01749   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01748   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01695   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01724   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01739   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01740   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01741   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01742   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01743   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01744   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01745   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01746   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01696   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_01697   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02226   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02227   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02228   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02229   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02230   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02231   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02233   PAR_1_0_VDD075NNE   VDD075NNE
* VDD075NNE_02232   PAR_1_0_VDD075NNE   VDD075NNE
* VSS_04179   PAR_2_0_VSS   VSS
* VSS_04180   PAR_2_0_VSS   VSS
* VSS_03322   PAR_2_0_VSS   VSS
* VSS_03323   PAR_2_0_VSS   VSS
* VSS_03324   PAR_2_0_VSS   VSS
* VSS_03325   PAR_2_0_VSS   VSS
* VSS_03326   PAR_2_0_VSS   VSS
* VSS_03327   PAR_2_0_VSS   VSS
* VSS_03328   PAR_2_0_VSS   VSS
* VSS_03239   PAR_2_0_VSS   VSS
* VSS_03330   PAR_2_0_VSS   VSS
* VSS_04181   PAR_2_0_VSS   VSS
* VSS_04182   PAR_2_0_VSS   VSS
* VSS_03240   PAR_2_0_VSS   VSS
* VSS_04281   PAR_2_0_VSS   VSS
* VSS_02764   PAR_2_0_VSS   VSS
* VSS_03238   PAR_2_0_VSS   VSS
* VSS_03237   PAR_2_0_VSS   VSS
* VSS_03236   PAR_2_0_VSS   VSS
* VSS_03235   PAR_2_0_VSS   VSS
* VSS_03234   PAR_2_0_VSS   VSS
* VSS_03233   PAR_2_0_VSS   VSS
* VSS_04091   PAR_2_0_VSS   VSS
* VSS_03426   PAR_2_0_VSS   VSS
* VSS_04085   PAR_2_0_VSS   VSS
* VSS_04086   PAR_2_0_VSS   VSS
* VSS_04087   PAR_2_0_VSS   VSS
* VSS_04088   PAR_2_0_VSS   VSS
* VSS_04089   PAR_2_0_VSS   VSS
* VSS_04284   PAR_2_0_VSS   VSS
* VSS_04283   PAR_2_0_VSS   VSS
* VSS_04282   PAR_2_0_VSS   VSS
* VSS_04090   PAR_2_0_VSS   VSS
* VSS_03331   PAR_2_0_VSS   VSS
* VSS_04092   PAR_2_0_VSS   VSS
* VSS_04093   PAR_2_0_VSS   VSS
* VSS_04094   PAR_2_0_VSS   VSS
* VSS_02673   PAR_2_0_VSS   VSS
* VSS_04177   PAR_2_0_VSS   VSS
* VSS_04178   PAR_2_0_VSS   VSS
* VSS_03232   PAR_2_0_VSS   VSS
* VSS_03334   PAR_2_0_VSS   VSS
* VSS_03333   PAR_2_0_VSS   VSS
* VSS_03332   PAR_2_0_VSS   VSS
* VSS_02771   PAR_2_0_VSS   VSS
* VSS_02586   PAR_2_0_VSS   VSS
* VSS_02585   PAR_2_0_VSS   VSS
* VSS_02584   PAR_2_0_VSS   VSS
* VSS_04272   PAR_2_0_VSS   VSS
* VSS_04273   PAR_2_0_VSS   VSS
* VSS_04274   PAR_2_0_VSS   VSS
* VSS_02765   PAR_2_0_VSS   VSS
* VSS_02766   PAR_2_0_VSS   VSS
* VSS_02767   PAR_2_0_VSS   VSS
* VSS_02768   PAR_2_0_VSS   VSS
* VSS_02769   PAR_2_0_VSS   VSS
* VSS_02770   PAR_2_0_VSS   VSS
* VSS_02587   PAR_2_0_VSS   VSS
* VSS_02772   PAR_2_0_VSS   VSS
* VSS_02773   PAR_2_0_VSS   VSS
* VSS_02774   PAR_2_0_VSS   VSS
* VSS_02775   PAR_2_0_VSS   VSS
* VSS_02776   PAR_2_0_VSS   VSS
* VSS_04275   PAR_2_0_VSS   VSS
* VSS_04276   PAR_2_0_VSS   VSS
* VSS_04277   PAR_2_0_VSS   VSS
* VSS_04278   PAR_2_0_VSS   VSS
* VSS_03143   PAR_2_0_VSS   VSS
* VSS_03142   PAR_2_0_VSS   VSS
* VSS_03141   PAR_2_0_VSS   VSS
* VSS_04279   PAR_2_0_VSS   VSS
* VSS_04183   PAR_2_0_VSS   VSS
* VSS_04184   PAR_2_0_VSS   VSS
* VSS_04185   PAR_2_0_VSS   VSS
* VSS_04186   PAR_2_0_VSS   VSS
* VSS_04187   PAR_2_0_VSS   VSS
* VSS_04188   PAR_2_0_VSS   VSS
* VSS_04189   PAR_2_0_VSS   VSS
* VSS_02596   PAR_2_0_VSS   VSS
* VSS_02595   PAR_2_0_VSS   VSS
* VSS_02594   PAR_2_0_VSS   VSS
* VSS_02593   PAR_2_0_VSS   VSS
* VSS_04280   PAR_2_0_VSS   VSS
* VSS_03140   PAR_2_0_VSS   VSS
* VSS_03137   PAR_2_0_VSS   VSS
* VSS_03138   PAR_2_0_VSS   VSS
* VSS_03139   PAR_2_0_VSS   VSS
* VSS_02592   PAR_2_0_VSS   VSS
* VSS_02591   PAR_2_0_VSS   VSS
* VSS_03231   PAR_2_0_VSS   VSS
* VSS_03230   PAR_2_0_VSS   VSS
* VSS_03229   PAR_2_0_VSS   VSS
* VSS_03228   PAR_2_0_VSS   VSS
* VSS_02590   PAR_2_0_VSS   VSS
* VSS_02589   PAR_2_0_VSS   VSS
* VSS_02588   PAR_2_0_VSS   VSS
* VSS_03710   PAR_2_0_VSS   VSS
* VSS_03805   PAR_2_0_VSS   VSS
* VSS_03804   PAR_2_0_VSS   VSS
* VSS_03803   PAR_2_0_VSS   VSS
* VSS_03802   PAR_2_0_VSS   VSS
* VSS_03801   PAR_2_0_VSS   VSS
* VSS_03800   PAR_2_0_VSS   VSS
* VSS_03799   PAR_2_0_VSS   VSS
* VSS_03798   PAR_2_0_VSS   VSS
* VSS_03797   PAR_2_0_VSS   VSS
* VSS_03714   PAR_2_0_VSS   VSS
* VSS_03713   PAR_2_0_VSS   VSS
* VSS_03712   PAR_2_0_VSS   VSS
* VSS_03711   PAR_2_0_VSS   VSS
* VSS_03806   PAR_2_0_VSS   VSS
* VSS_03709   PAR_2_0_VSS   VSS
* VSS_03708   PAR_2_0_VSS   VSS
* VSS_03707   PAR_2_0_VSS   VSS
* VSS_03706   PAR_2_0_VSS   VSS
* VSS_03705   PAR_2_0_VSS   VSS
* VSS_03704   PAR_2_0_VSS   VSS
* VSS_03703   PAR_2_0_VSS   VSS
* VSS_03702   PAR_2_0_VSS   VSS
* VSS_03987   PAR_2_0_VSS   VSS
* VSS_03329   PAR_2_0_VSS   VSS
* VSS_03988   PAR_2_0_VSS   VSS
* VSS_03989   PAR_2_0_VSS   VSS
* VSS_02676   PAR_2_0_VSS   VSS
* VSS_03902   PAR_2_0_VSS   VSS
* VSS_03903   PAR_2_0_VSS   VSS
* VSS_03904   PAR_2_0_VSS   VSS
* VSS_03900   PAR_2_0_VSS   VSS
* VSS_03899   PAR_2_0_VSS   VSS
* VSS_03898   PAR_2_0_VSS   VSS
* VSS_03897   PAR_2_0_VSS   VSS
* VSS_03896   PAR_2_0_VSS   VSS
* VSS_03895   PAR_2_0_VSS   VSS
* VSS_03894   PAR_2_0_VSS   VSS
* VSS_03893   PAR_2_0_VSS   VSS
* VSS_03892   PAR_2_0_VSS   VSS
* VSS_03990   PAR_2_0_VSS   VSS
* VSS_02677   PAR_2_0_VSS   VSS
* VSS_02678   PAR_2_0_VSS   VSS
* VSS_02679   PAR_2_0_VSS   VSS
* VSS_02680   PAR_2_0_VSS   VSS
* VSS_02681   PAR_2_0_VSS   VSS
* VSS_02682   PAR_2_0_VSS   VSS
* VSS_02683   PAR_2_0_VSS   VSS
* VSS_02684   PAR_2_0_VSS   VSS
* VSS_02685   PAR_2_0_VSS   VSS
* VSS_03809   PAR_2_0_VSS   VSS
* VSS_03808   PAR_2_0_VSS   VSS
* VSS_03807   PAR_2_0_VSS   VSS
* VSS_03512   PAR_2_0_VSS   VSS
* VSS_03607   PAR_2_0_VSS   VSS
* VSS_03524   PAR_2_0_VSS   VSS
* VSS_03523   PAR_2_0_VSS   VSS
* VSS_03522   PAR_2_0_VSS   VSS
* VSS_03521   PAR_2_0_VSS   VSS
* VSS_03520   PAR_2_0_VSS   VSS
* VSS_03519   PAR_2_0_VSS   VSS
* VSS_03518   PAR_2_0_VSS   VSS
* VSS_03517   PAR_2_0_VSS   VSS
* VSS_03516   PAR_2_0_VSS   VSS
* VSS_03515   PAR_2_0_VSS   VSS
* VSS_03514   PAR_2_0_VSS   VSS
* VSS_03513   PAR_2_0_VSS   VSS
* VSS_03608   PAR_2_0_VSS   VSS
* VSS_03429   PAR_2_0_VSS   VSS
* VSS_03428   PAR_2_0_VSS   VSS
* VSS_03427   PAR_2_0_VSS   VSS
* VSS_03901   PAR_2_0_VSS   VSS
* VSS_03425   PAR_2_0_VSS   VSS
* VSS_03424   PAR_2_0_VSS   VSS
* VSS_03423   PAR_2_0_VSS   VSS
* VSS_03422   PAR_2_0_VSS   VSS
* VSS_03421   PAR_2_0_VSS   VSS
* VSS_03420   PAR_2_0_VSS   VSS
* VSS_03419   PAR_2_0_VSS   VSS
* VSS_03418   PAR_2_0_VSS   VSS
* VSS_04083   PAR_2_0_VSS   VSS
* VSS_03991   PAR_2_0_VSS   VSS
* VSS_03992   PAR_2_0_VSS   VSS
* VSS_03993   PAR_2_0_VSS   VSS
* VSS_03994   PAR_2_0_VSS   VSS
* VSS_03995   PAR_2_0_VSS   VSS
* VSS_03996   PAR_2_0_VSS   VSS
* VSS_03997   PAR_2_0_VSS   VSS
* VSS_03998   PAR_2_0_VSS   VSS
* VSS_03999   PAR_2_0_VSS   VSS
* VSS_02675   PAR_2_0_VSS   VSS
* VSS_02674   PAR_2_0_VSS   VSS
* VSS_04082   PAR_2_0_VSS   VSS
* VSS_03417   PAR_2_0_VSS   VSS
* VSS_04084   PAR_2_0_VSS   VSS
* VSS_03619   PAR_2_0_VSS   VSS
* VSS_03618   PAR_2_0_VSS   VSS
* VSS_03617   PAR_2_0_VSS   VSS
* VSS_03616   PAR_2_0_VSS   VSS
* VSS_03615   PAR_2_0_VSS   VSS
* VSS_03614   PAR_2_0_VSS   VSS
* VSS_03613   PAR_2_0_VSS   VSS
* VSS_03612   PAR_2_0_VSS   VSS
* VSS_03611   PAR_2_0_VSS   VSS
* VSS_03610   PAR_2_0_VSS   VSS
* VSS_03609   PAR_2_0_VSS   VSS
* VSS_03041   PAR_2_0_VSS   VSS
* VSS_03134   PAR_2_0_VSS   VSS
* VSS_02953   PAR_2_0_VSS   VSS
* VSS_02952   PAR_2_0_VSS   VSS
* VSS_02950   PAR_2_0_VSS   VSS
* VSS_02949   PAR_2_0_VSS   VSS
* VSS_02948   PAR_2_0_VSS   VSS
* VSS_03044   PAR_2_0_VSS   VSS
* VSS_03045   PAR_2_0_VSS   VSS
* VSS_02954   PAR_2_0_VSS   VSS
* VSS_03135   PAR_2_0_VSS   VSS
* VSS_03136   PAR_2_0_VSS   VSS
* VSS_03043   PAR_2_0_VSS   VSS
* VSS_03042   PAR_2_0_VSS   VSS
* VSS_02951   PAR_2_0_VSS   VSS
* VSS_03040   PAR_2_0_VSS   VSS
* VSS_03039   PAR_2_0_VSS   VSS
* VSS_02944   PAR_2_0_VSS   VSS
* VSS_02945   PAR_2_0_VSS   VSS
* VSS_03046   PAR_2_0_VSS   VSS
* VSS_03047   PAR_2_0_VSS   VSS
* VSS_03048   PAR_2_0_VSS   VSS
* VSS_02946   PAR_2_0_VSS   VSS
* VSS_02947   PAR_2_0_VSS   VSS
* VSS_03038   PAR_2_0_VSS   VSS
* VSS_03037   PAR_2_0_VSS   VSS
* VSS_03036   PAR_2_0_VSS   VSS
* VSS_03133   PAR_2_0_VSS   VSS
* VSS_02956   PAR_2_0_VSS   VSS
* VSS_02955   PAR_2_0_VSS   VSS
* VSS_02855   PAR_2_0_VSS   VSS
* VSS_02856   PAR_2_0_VSS   VSS
* VSS_02857   PAR_2_0_VSS   VSS
* VSS_02858   PAR_2_0_VSS   VSS
* VSS_02859   PAR_2_0_VSS   VSS
* VSS_02860   PAR_2_0_VSS   VSS
* VSS_02861   PAR_2_0_VSS   VSS
* VSS_02862   PAR_2_0_VSS   VSS
* VSS_02863   PAR_2_0_VSS   VSS
* VSS_02865   PAR_2_0_VSS   VSS
* VSS_02866   PAR_2_0_VSS   VSS
* VSS_02867   PAR_2_0_VSS   VSS
* VSS_03132   PAR_2_0_VSS   VSS
* VSS_02864   PAR_2_0_VSS   VSS
* VSS_03131   PAR_2_0_VSS   VSS
* VDD075NNE_01490   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01698   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02242   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02241   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01867   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01483   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01484   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02240   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02243   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01491   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01492   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01493   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01494   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01485   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01486   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01487   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01488   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01489   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01710   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02089   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01699   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01700   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01701   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01702   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01703   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01873   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01872   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01704   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01705   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01706   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01707   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01708   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01709   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02139   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01871   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01870   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01869   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01868   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02130   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02131   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02132   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02133   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02134   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02135   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02136   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02137   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02138   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01651   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01539   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01538   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01537   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02189   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02190   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02191   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02192   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02193   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01540   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01860   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01861   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01862   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01863   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01864   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01865   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01866   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02187   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01650   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01649   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01648   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01647   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01646   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02184   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02185   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02186   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02194   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02188   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01546   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01545   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01544   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01543   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01542   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01541   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02140   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01752   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01753   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01754   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01755   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01756   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02143   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02142   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02141   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01645   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02251   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02250   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02249   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02248   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02247   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02246   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02245   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01653   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02195   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02196   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02197   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01547   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01548   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01549   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01550   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01652   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02244   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01654   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01655   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01656   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01657   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01658   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01496   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01495   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02029   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01379   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01378   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01597   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02035   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02034   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02033   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02032   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02031   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02030   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01380   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02028   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02027   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02026   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02025   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02024   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02023   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02022   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01377   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01757   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01972   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01973   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01974   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01975   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01976   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01388   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01387   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01386   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01376   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01758   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01595   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01596   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01385   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01384   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01383   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01382   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01381   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01759   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01600   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01601   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01602   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01603   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01978   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01979   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01980   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01981   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01604   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01599   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01760   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02238   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02239   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01765   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01764   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01763   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01762   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01761   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01327   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01375   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01977   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01321   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01322   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01323   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01324   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01325   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01326   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01915   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01328   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01329   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01330   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01331   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01332   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01333   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01334   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01598   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01431   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01440   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01439   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01438   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01437   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01436   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01435   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01434   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01433   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01432   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01441   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01430   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01429   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02085   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02084   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02083   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02082   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02081   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02080   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01816   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01914   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01442   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02088   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02087   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02086   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01819   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01818   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01817   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01970   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01815   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01814   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01813   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01812   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01811   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01810   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01809   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01808   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02078   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01971   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01969   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01968   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01927   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01926   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01925   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01924   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01923   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01922   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01921   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01920   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01919   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01593   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01807   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01918   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01917   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01806   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01591   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01592   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01594   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_01916   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02076   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02077   PAR_2_0_VDD075NNE   VDD075NNE
* VDD075NNE_02079   PAR_2_0_VDD075NNE   VDD075NNE
* VSS_04001   PAR_3_0_VSS   VSS
* VSS_02968   PAR_3_0_VSS   VSS
* VSS_04013   PAR_3_0_VSS   VSS
* VSS_04012   PAR_3_0_VSS   VSS
* VSS_02967   PAR_3_0_VSS   VSS
* VSS_04677   PAR_3_0_VSS   VSS
* VSS_04003   PAR_3_0_VSS   VSS
* VSS_04002   PAR_3_0_VSS   VSS
* VSS_04011   PAR_3_0_VSS   VSS
* VSS_04000   PAR_3_0_VSS   VSS
* VSS_04004   PAR_3_0_VSS   VSS
* VSS_04005   PAR_3_0_VSS   VSS
* VSS_04006   PAR_3_0_VSS   VSS
* VSS_04007   PAR_3_0_VSS   VSS
* VSS_04008   PAR_3_0_VSS   VSS
* VSS_04009   PAR_3_0_VSS   VSS
* VSS_04010   PAR_3_0_VSS   VSS
* VSS_04294_4669   PAR_3_0_VSS   VSS
* VSS_04393   PAR_3_0_VSS   VSS
* VSS_04392   PAR_3_0_VSS   VSS
* VSS_04391   PAR_3_0_VSS   VSS
* VSS_04390   PAR_3_0_VSS   VSS
* VSS_04389   PAR_3_0_VSS   VSS
* VSS_04388   PAR_3_0_VSS   VSS
* VSS_04298   PAR_3_0_VSS   VSS
* VSS_04297_4672   PAR_3_0_VSS   VSS
* VSS_04297   PAR_3_0_VSS   VSS
* VSS_04296_4671   PAR_3_0_VSS   VSS
* VSS_04296   PAR_3_0_VSS   VSS
* VSS_04295_4670   PAR_3_0_VSS   VSS
* VSS_04295   PAR_3_0_VSS   VSS
* VSS_04394   PAR_3_0_VSS   VSS
* VSS_04294   PAR_3_0_VSS   VSS
* VSS_04293_4668   PAR_3_0_VSS   VSS
* VSS_04293   PAR_3_0_VSS   VSS
* VSS_04292_4667   PAR_3_0_VSS   VSS
* VSS_04292   PAR_3_0_VSS   VSS
* VSS_04291_4666   PAR_3_0_VSS   VSS
* VSS_04291   PAR_3_0_VSS   VSS
* VSS_04290_4665   PAR_3_0_VSS   VSS
* VSS_04290   PAR_3_0_VSS   VSS
* VSS_04289   PAR_3_0_VSS   VSS
* VSS_04288   PAR_3_0_VSS   VSS
* VSS_04287   PAR_3_0_VSS   VSS
* VSS_04577   PAR_3_0_VSS   VSS
* VSS_02778   PAR_3_0_VSS   VSS
* VSS_04676   PAR_3_0_VSS   VSS
* VSS_04675   PAR_3_0_VSS   VSS
* VSS_04674   PAR_3_0_VSS   VSS
* VSS_04673   PAR_3_0_VSS   VSS
* VSS_04672   PAR_3_0_VSS   VSS
* VSS_04671   PAR_3_0_VSS   VSS
* VSS_04670   PAR_3_0_VSS   VSS
* VSS_04624   PAR_3_0_VSS   VSS
* VSS_04581   PAR_3_0_VSS   VSS
* VSS_04580   PAR_3_0_VSS   VSS
* VSS_04579   PAR_3_0_VSS   VSS
* VSS_04578   PAR_3_0_VSS   VSS
* VSS_04286   PAR_3_0_VSS   VSS
* VSS_04576   PAR_3_0_VSS   VSS
* VSS_04575   PAR_3_0_VSS   VSS
* VSS_04574   PAR_3_0_VSS   VSS
* VSS_04490   PAR_3_0_VSS   VSS
* VSS_04489   PAR_3_0_VSS   VSS
* VSS_04488   PAR_3_0_VSS   VSS
* VSS_04487   PAR_3_0_VSS   VSS
* VSS_04486   PAR_3_0_VSS   VSS
* VSS_04485   PAR_3_0_VSS   VSS
* VSS_04484   PAR_3_0_VSS   VSS
* VSS_04483   PAR_3_0_VSS   VSS
* VSS_04395   PAR_3_0_VSS   VSS
* VSS_04108   PAR_3_0_VSS   VSS
* VSS_02598   PAR_3_0_VSS   VSS
* VSS_02599   PAR_3_0_VSS   VSS
* VSS_02600   PAR_3_0_VSS   VSS
* VSS_02601   PAR_3_0_VSS   VSS
* VSS_02602   PAR_3_0_VSS   VSS
* VSS_02603   PAR_3_0_VSS   VSS
* VSS_02604   PAR_3_0_VSS   VSS
* VSS_02605   PAR_3_0_VSS   VSS
* VSS_02606   PAR_3_0_VSS   VSS
* VSS_02607   PAR_3_0_VSS   VSS
* VSS_02608   PAR_3_0_VSS   VSS
* VSS_02609   PAR_3_0_VSS   VSS
* VSS_02610   PAR_3_0_VSS   VSS
* VSS_02966   PAR_3_0_VSS   VSS
* VSS_04107   PAR_3_0_VSS   VSS
* VSS_04106   PAR_3_0_VSS   VSS
* VSS_04105   PAR_3_0_VSS   VSS
* VSS_04104   PAR_3_0_VSS   VSS
* VSS_04103   PAR_3_0_VSS   VSS
* VSS_04102   PAR_3_0_VSS   VSS
* VSS_04101   PAR_3_0_VSS   VSS
* VSS_04100   PAR_3_0_VSS   VSS
* VSS_04099   PAR_3_0_VSS   VSS
* VSS_04098   PAR_3_0_VSS   VSS
* VSS_04097   PAR_3_0_VSS   VSS
* VSS_04096   PAR_3_0_VSS   VSS
* VSS_04197   PAR_3_0_VSS   VSS
* VSS_04285   PAR_3_0_VSS   VSS
* VSS_02957   PAR_3_0_VSS   VSS
* VSS_02958   PAR_3_0_VSS   VSS
* VSS_02959   PAR_3_0_VSS   VSS
* VSS_02960   PAR_3_0_VSS   VSS
* VSS_02597   PAR_3_0_VSS   VSS
* VSS_04203   PAR_3_0_VSS   VSS
* VSS_04202   PAR_3_0_VSS   VSS
* VSS_04201   PAR_3_0_VSS   VSS
* VSS_04200   PAR_3_0_VSS   VSS
* VSS_04199   PAR_3_0_VSS   VSS
* VSS_04198   PAR_3_0_VSS   VSS
* VSS_04095   PAR_3_0_VSS   VSS
* VSS_04196   PAR_3_0_VSS   VSS
* VSS_04195   PAR_3_0_VSS   VSS
* VSS_04194   PAR_3_0_VSS   VSS
* VSS_04193   PAR_3_0_VSS   VSS
* VSS_04192   PAR_3_0_VSS   VSS
* VSS_04191   PAR_3_0_VSS   VSS
* VSS_04190   PAR_3_0_VSS   VSS
* VSS_02961   PAR_3_0_VSS   VSS
* VSS_02962   PAR_3_0_VSS   VSS
* VSS_02963   PAR_3_0_VSS   VSS
* VSS_02964   PAR_3_0_VSS   VSS
* VSS_02965   PAR_3_0_VSS   VSS
* VSS_03061   PAR_3_0_VSS   VSS
* VSS_03436   PAR_3_0_VSS   VSS
* VSS_03435   PAR_3_0_VSS   VSS
* VSS_03434   PAR_3_0_VSS   VSS
* VSS_03433   PAR_3_0_VSS   VSS
* VSS_03432   PAR_3_0_VSS   VSS
* VSS_03431   PAR_3_0_VSS   VSS
* VSS_03430   PAR_3_0_VSS   VSS
* VSS_03057   PAR_3_0_VSS   VSS
* VSS_03058   PAR_3_0_VSS   VSS
* VSS_03059   PAR_3_0_VSS   VSS
* VSS_03060   PAR_3_0_VSS   VSS
* VSS_03437   PAR_3_0_VSS   VSS
* VSS_03062   PAR_3_0_VSS   VSS
* VSS_03348   PAR_3_0_VSS   VSS
* VSS_03347   PAR_3_0_VSS   VSS
* VSS_03346   PAR_3_0_VSS   VSS
* VSS_03345   PAR_3_0_VSS   VSS
* VSS_03344   PAR_3_0_VSS   VSS
* VSS_03343   PAR_3_0_VSS   VSS
* VSS_03342   PAR_3_0_VSS   VSS
* VSS_03341   PAR_3_0_VSS   VSS
* VSS_03340   PAR_3_0_VSS   VSS
* VSS_03529   PAR_3_0_VSS   VSS
* VSS_02698   PAR_3_0_VSS   VSS
* VSS_02699   PAR_3_0_VSS   VSS
* VSS_03538   PAR_3_0_VSS   VSS
* VSS_03537   PAR_3_0_VSS   VSS
* VSS_03536   PAR_3_0_VSS   VSS
* VSS_03535   PAR_3_0_VSS   VSS
* VSS_03534   PAR_3_0_VSS   VSS
* VSS_03533   PAR_3_0_VSS   VSS
* VSS_03532   PAR_3_0_VSS   VSS
* VSS_03531   PAR_3_0_VSS   VSS
* VSS_03530   PAR_3_0_VSS   VSS
* VSS_03339   PAR_3_0_VSS   VSS
* VSS_03528   PAR_3_0_VSS   VSS
* VSS_03527   PAR_3_0_VSS   VSS
* VSS_03526   PAR_3_0_VSS   VSS
* VSS_03525   PAR_3_0_VSS   VSS
* VSS_03443   PAR_3_0_VSS   VSS
* VSS_03442   PAR_3_0_VSS   VSS
* VSS_03441   PAR_3_0_VSS   VSS
* VSS_03440   PAR_3_0_VSS   VSS
* VSS_03439   PAR_3_0_VSS   VSS
* VSS_03438   PAR_3_0_VSS   VSS
* VSS_02789   PAR_3_0_VSS   VSS
* VSS_03152   PAR_3_0_VSS   VSS
* VSS_03151   PAR_3_0_VSS   VSS
* VSS_03150   PAR_3_0_VSS   VSS
* VSS_02777   PAR_3_0_VSS   VSS
* VSS_03149   PAR_3_0_VSS   VSS
* VSS_03148   PAR_3_0_VSS   VSS
* VSS_03147   PAR_3_0_VSS   VSS
* VSS_03146   PAR_3_0_VSS   VSS
* VSS_03145   PAR_3_0_VSS   VSS
* VSS_03144   PAR_3_0_VSS   VSS
* VSS_02790   PAR_3_0_VSS   VSS
* VSS_03153   PAR_3_0_VSS   VSS
* VSS_02788   PAR_3_0_VSS   VSS
* VSS_02787   PAR_3_0_VSS   VSS
* VSS_02786   PAR_3_0_VSS   VSS
* VSS_02785   PAR_3_0_VSS   VSS
* VSS_02784   PAR_3_0_VSS   VSS
* VSS_02783   PAR_3_0_VSS   VSS
* VSS_02782   PAR_3_0_VSS   VSS
* VSS_02781   PAR_3_0_VSS   VSS
* VSS_02780   PAR_3_0_VSS   VSS
* VSS_02779   PAR_3_0_VSS   VSS
* VSS_03247   PAR_3_0_VSS   VSS
* VSS_03338   PAR_3_0_VSS   VSS
* VSS_03337   PAR_3_0_VSS   VSS
* VSS_03336   PAR_3_0_VSS   VSS
* VSS_03335   PAR_3_0_VSS   VSS
* VSS_03254   PAR_3_0_VSS   VSS
* VSS_03253   PAR_3_0_VSS   VSS
* VSS_03252   PAR_3_0_VSS   VSS
* VSS_03251   PAR_3_0_VSS   VSS
* VSS_03250   PAR_3_0_VSS   VSS
* VSS_03249   PAR_3_0_VSS   VSS
* VSS_03248   PAR_3_0_VSS   VSS
* VSS_02697   PAR_3_0_VSS   VSS
* VSS_03246   PAR_3_0_VSS   VSS
* VSS_03245   PAR_3_0_VSS   VSS
* VSS_03244   PAR_3_0_VSS   VSS
* VSS_03243   PAR_3_0_VSS   VSS
* VSS_03242   PAR_3_0_VSS   VSS
* VSS_03241   PAR_3_0_VSS   VSS
* VSS_03157   PAR_3_0_VSS   VSS
* VSS_03156   PAR_3_0_VSS   VSS
* VSS_03155   PAR_3_0_VSS   VSS
* VSS_03154   PAR_3_0_VSS   VSS
* VSS_03815   PAR_3_0_VSS   VSS
* VSS_02686   PAR_3_0_VSS   VSS
* VSS_02687   PAR_3_0_VSS   VSS
* VSS_02688   PAR_3_0_VSS   VSS
* VSS_03823   PAR_3_0_VSS   VSS
* VSS_03822   PAR_3_0_VSS   VSS
* VSS_03821   PAR_3_0_VSS   VSS
* VSS_03820   PAR_3_0_VSS   VSS
* VSS_03819   PAR_3_0_VSS   VSS
* VSS_03818   PAR_3_0_VSS   VSS
* VSS_03817   PAR_3_0_VSS   VSS
* VSS_03816   PAR_3_0_VSS   VSS
* VSS_02874   PAR_3_0_VSS   VSS
* VSS_03814   PAR_3_0_VSS   VSS
* VSS_03813   PAR_3_0_VSS   VSS
* VSS_03812   PAR_3_0_VSS   VSS
* VSS_03811   PAR_3_0_VSS   VSS
* VSS_03810   PAR_3_0_VSS   VSS
* VSS_02873   PAR_3_0_VSS   VSS
* VSS_03728   PAR_3_0_VSS   VSS
* VSS_03727   PAR_3_0_VSS   VSS
* VSS_03726   PAR_3_0_VSS   VSS
* VSS_03725   PAR_3_0_VSS   VSS
* VSS_03910   PAR_3_0_VSS   VSS
* VSS_02970   PAR_3_0_VSS   VSS
* VSS_02881   PAR_3_0_VSS   VSS
* VSS_02880   PAR_3_0_VSS   VSS
* VSS_03918   PAR_3_0_VSS   VSS
* VSS_03917   PAR_3_0_VSS   VSS
* VSS_03916   PAR_3_0_VSS   VSS
* VSS_03915   PAR_3_0_VSS   VSS
* VSS_03914   PAR_3_0_VSS   VSS
* VSS_03913   PAR_3_0_VSS   VSS
* VSS_03912   PAR_3_0_VSS   VSS
* VSS_03911   PAR_3_0_VSS   VSS
* VSS_03724   PAR_3_0_VSS   VSS
* VSS_03909   PAR_3_0_VSS   VSS
* VSS_03908   PAR_3_0_VSS   VSS
* VSS_03907   PAR_3_0_VSS   VSS
* VSS_03906   PAR_3_0_VSS   VSS
* VSS_03905   PAR_3_0_VSS   VSS
* VSS_02879   PAR_3_0_VSS   VSS
* VSS_02878   PAR_3_0_VSS   VSS
* VSS_02877   PAR_3_0_VSS   VSS
* VSS_02876   PAR_3_0_VSS   VSS
* VSS_02875   PAR_3_0_VSS   VSS
* VSS_03053   PAR_3_0_VSS   VSS
* VSS_03626   PAR_3_0_VSS   VSS
* VSS_03625   PAR_3_0_VSS   VSS
* VSS_03624   PAR_3_0_VSS   VSS
* VSS_03623   PAR_3_0_VSS   VSS
* VSS_03622   PAR_3_0_VSS   VSS
* VSS_03621   PAR_3_0_VSS   VSS
* VSS_03620   PAR_3_0_VSS   VSS
* VSS_03049   PAR_3_0_VSS   VSS
* VSS_03050   PAR_3_0_VSS   VSS
* VSS_03051   PAR_3_0_VSS   VSS
* VSS_03052   PAR_3_0_VSS   VSS
* VSS_03627   PAR_3_0_VSS   VSS
* VSS_03054   PAR_3_0_VSS   VSS
* VSS_03055   PAR_3_0_VSS   VSS
* VSS_03056   PAR_3_0_VSS   VSS
* VSS_02690   PAR_3_0_VSS   VSS
* VSS_02691   PAR_3_0_VSS   VSS
* VSS_02692   PAR_3_0_VSS   VSS
* VSS_02693   PAR_3_0_VSS   VSS
* VSS_02694   PAR_3_0_VSS   VSS
* VSS_02695   PAR_3_0_VSS   VSS
* VSS_02696   PAR_3_0_VSS   VSS
* VSS_02870   PAR_3_0_VSS   VSS
* VSS_03723   PAR_3_0_VSS   VSS
* VSS_03722   PAR_3_0_VSS   VSS
* VSS_03721   PAR_3_0_VSS   VSS
* VSS_03720   PAR_3_0_VSS   VSS
* VSS_03719   PAR_3_0_VSS   VSS
* VSS_03718   PAR_3_0_VSS   VSS
* VSS_03717   PAR_3_0_VSS   VSS
* VSS_03716   PAR_3_0_VSS   VSS
* VSS_03715   PAR_3_0_VSS   VSS
* VSS_02872   PAR_3_0_VSS   VSS
* VSS_02871   PAR_3_0_VSS   VSS
* VSS_02969   PAR_3_0_VSS   VSS
* VSS_02869   PAR_3_0_VSS   VSS
* VSS_02868   PAR_3_0_VSS   VSS
* VSS_02689   PAR_3_0_VSS   VSS
* VSS_03633   PAR_3_0_VSS   VSS
* VSS_03632   PAR_3_0_VSS   VSS
* VSS_03631   PAR_3_0_VSS   VSS
* VSS_03630   PAR_3_0_VSS   VSS
* VSS_03629   PAR_3_0_VSS   VSS
* VSS_03628   PAR_3_0_VSS   VSS
* VDD075NNE_02309   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02091   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02099   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02098   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02097   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02096   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02095   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02094   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02093   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02092   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02100   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02090   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02048   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02047   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02046   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02045   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02044   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02043   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02042   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02149   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02198   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02156   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02155   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02154   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02153   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02152   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02151   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02150   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02041   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02148   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02147   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02146   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02145   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02144   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02102   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02101   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01933   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01982   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01940   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01939   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01938   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01937   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01936   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01935   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01934   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01983   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01932   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01931   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01930   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01929   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01928   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01886   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01885   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01884   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01991   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02040   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02039   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02038   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02037   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02036   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01994   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01993   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01992   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02199   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01990   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01989   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01988   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01987   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01986   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01985   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01984   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02284   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02292   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02291   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02290   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02289   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02288   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02287   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02286   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02285   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02293   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02283   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02282   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02281   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02280   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02279   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02278   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02277   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02276   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02301   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02310   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02308   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02307   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02306   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02305   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02304   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02303   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02302   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02275   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02300   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02299   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02298   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02297   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02296   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02295   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02294   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02208   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02257   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02256   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02255   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02254   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02253   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02252   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02210   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02209   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02258   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02207   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02206   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02205   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02204   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02203   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02202   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02201   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02200   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02266   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02274   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02273   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02272   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02271   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02270   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02269   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02268   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02267   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01335   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02265   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02264   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02263   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02262   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02261   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02260   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_02259   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01502   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01551   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01509   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01508   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01507   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01506   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01505   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01504   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01503   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01552   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01501   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01500   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01499   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01498   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01497   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01455   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01454   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01453   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01560   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01609   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01608   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01607   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01606   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01605   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01563   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01562   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01561   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01452   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01559   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01558   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01557   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01556   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01555   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01554   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01553   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01344   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01393   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01392   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01391   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01390   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01389   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01347   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01346   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01345   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01394   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01343   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01342   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01341   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01340   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01339   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01338   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01337   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01336   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01443   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01451   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01450   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01449   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01448   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01447   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01446   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01445   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01444   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01882   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01401   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01400   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01399   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01398   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01397   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01396   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01395   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01775   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01824   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01823   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01822   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01821   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01820   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01778   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01777   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01776   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01825   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01774   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01773   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01772   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01771   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01770   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01769   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01768   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01767   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01874   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01883   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01881   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01880   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01879   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01878   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01877   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01876   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01875   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01611   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01832   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01831   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01830   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01829   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01828   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01827   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01826   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01659   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01667   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01666   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01665   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01664   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01663   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01662   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01661   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01660   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01723   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01617   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01616   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01615   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01614   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01613   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01612   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01610   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01669   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01668   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01766   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01722   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01721   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01720   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01719   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01718   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01717   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01716   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01715   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01714   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01713   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01712   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01711   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01671   PAR_3_0_VDD075NNE   VDD075NNE
* VDD075NNE_01670   PAR_3_0_VDD075NNE   VDD075NNE
* VSS_02386   PAR_0_1_VSS   VSS
* VSS_02387   PAR_0_1_VSS   VSS
* VSS_02388   PAR_0_1_VSS   VSS
* VSS_02467   PAR_0_1_VSS   VSS
* VSS_02468   PAR_0_1_VSS   VSS
* VSS_02469   PAR_0_1_VSS   VSS
* VSS_02470   PAR_0_1_VSS   VSS
* VSS_02471   PAR_0_1_VSS   VSS
* VSS_02472   PAR_0_1_VSS   VSS
* VSS_02473   PAR_0_1_VSS   VSS
* VSS_02474   PAR_0_1_VSS   VSS
* VSS_02475   PAR_0_1_VSS   VSS
* VSS_02476   PAR_0_1_VSS   VSS
* VSS_02477   PAR_0_1_VSS   VSS
* VSS_02478   PAR_0_1_VSS   VSS
* VSS_02479   PAR_0_1_VSS   VSS
* VSS_02385   PAR_0_1_VSS   VSS
* VSS_01025   PAR_0_1_VSS   VSS
* VSS_01016   PAR_0_1_VSS   VSS
* VSS_01017   PAR_0_1_VSS   VSS
* VSS_01018   PAR_0_1_VSS   VSS
* VSS_01019   PAR_0_1_VSS   VSS
* VSS_01020   PAR_0_1_VSS   VSS
* VSS_01021   PAR_0_1_VSS   VSS
* VSS_01022   PAR_0_1_VSS   VSS
* VSS_01023   PAR_0_1_VSS   VSS
* VSS_01024   PAR_0_1_VSS   VSS
* VSS_01015   PAR_0_1_VSS   VSS
* VSS_01026   PAR_0_1_VSS   VSS
* VSS_01104   PAR_0_1_VSS   VSS
* VSS_01105   PAR_0_1_VSS   VSS
* VSS_01106   PAR_0_1_VSS   VSS
* VSS_01107   PAR_0_1_VSS   VSS
* VSS_01108   PAR_0_1_VSS   VSS
* VSS_01109   PAR_0_1_VSS   VSS
* VSS_01110   PAR_0_1_VSS   VSS
* VSS_00926   PAR_0_1_VSS   VSS
* VSS_00841   PAR_0_1_VSS   VSS
* VSS_00842   PAR_0_1_VSS   VSS
* VSS_00843   PAR_0_1_VSS   VSS
* VSS_00921   PAR_0_1_VSS   VSS
* VSS_00922   PAR_0_1_VSS   VSS
* VSS_00923   PAR_0_1_VSS   VSS
* VSS_00924   PAR_0_1_VSS   VSS
* VSS_00925   PAR_0_1_VSS   VSS
* VSS_01111   PAR_0_1_VSS   VSS
* VSS_00927   PAR_0_1_VSS   VSS
* VSS_00928   PAR_0_1_VSS   VSS
* VSS_00929   PAR_0_1_VSS   VSS
* VSS_00930   PAR_0_1_VSS   VSS
* VSS_00931   PAR_0_1_VSS   VSS
* VSS_00932   PAR_0_1_VSS   VSS
* VSS_00933   PAR_0_1_VSS   VSS
* VSS_01014   PAR_0_1_VSS   VSS
* VSS_01297   PAR_0_1_VSS   VSS
* VSS_01288   PAR_0_1_VSS   VSS
* VSS_01289   PAR_0_1_VSS   VSS
* VSS_01290   PAR_0_1_VSS   VSS
* VSS_01291   PAR_0_1_VSS   VSS
* VSS_01292   PAR_0_1_VSS   VSS
* VSS_01293   PAR_0_1_VSS   VSS
* VSS_01294   PAR_0_1_VSS   VSS
* VSS_01295   PAR_0_1_VSS   VSS
* VSS_01296   PAR_0_1_VSS   VSS
* VSS_01208   PAR_0_1_VSS   VSS
* VSS_01298   PAR_0_1_VSS   VSS
* VSS_01299   PAR_0_1_VSS   VSS
* VSS_01300   PAR_0_1_VSS   VSS
* VSS_01379   PAR_0_1_VSS   VSS
* VSS_01380   PAR_0_1_VSS   VSS
* VSS_01381   PAR_0_1_VSS   VSS
* VSS_01382   PAR_0_1_VSS   VSS
* VSS_01383   PAR_0_1_VSS   VSS
* VSS_01199   PAR_0_1_VSS   VSS
* VSS_01112   PAR_0_1_VSS   VSS
* VSS_01113   PAR_0_1_VSS   VSS
* VSS_01114   PAR_0_1_VSS   VSS
* VSS_01115   PAR_0_1_VSS   VSS
* VSS_01116   PAR_0_1_VSS   VSS
* VSS_01196   PAR_0_1_VSS   VSS
* VSS_01197   PAR_0_1_VSS   VSS
* VSS_01198   PAR_0_1_VSS   VSS
* VSS_00840   PAR_0_1_VSS   VSS
* VSS_01200   PAR_0_1_VSS   VSS
* VSS_01201   PAR_0_1_VSS   VSS
* VSS_01202   PAR_0_1_VSS   VSS
* VSS_01203   PAR_0_1_VSS   VSS
* VSS_01204   PAR_0_1_VSS   VSS
* VSS_01205   PAR_0_1_VSS   VSS
* VSS_01206   PAR_0_1_VSS   VSS
* VSS_01207   PAR_0_1_VSS   VSS
* VSS_00558   PAR_0_1_VSS   VSS
* VSS_00474   PAR_0_1_VSS   VSS
* VSS_00475   PAR_0_1_VSS   VSS
* VSS_00476   PAR_0_1_VSS   VSS
* VSS_00477   PAR_0_1_VSS   VSS
* VSS_00478   PAR_0_1_VSS   VSS
* VSS_00479   PAR_0_1_VSS   VSS
* VSS_00480   PAR_0_1_VSS   VSS
* VSS_00556   PAR_0_1_VSS   VSS
* VSS_00557   PAR_0_1_VSS   VSS
* VSS_00473   PAR_0_1_VSS   VSS
* VSS_00559   PAR_0_1_VSS   VSS
* VSS_00560   PAR_0_1_VSS   VSS
* VSS_00561   PAR_0_1_VSS   VSS
* VSS_00562   PAR_0_1_VSS   VSS
* VSS_00563   PAR_0_1_VSS   VSS
* VSS_00564   PAR_0_1_VSS   VSS
* VSS_00565   PAR_0_1_VSS   VSS
* VSS_00566   PAR_0_1_VSS   VSS
* VSS_00385   PAR_0_1_VSS   VSS
* VSS_00377   PAR_0_1_VSS   VSS
* VSS_00378   PAR_0_1_VSS   VSS
* VSS_00379   PAR_0_1_VSS   VSS
* VSS_00380   PAR_0_1_VSS   VSS
* VSS_00381   PAR_0_1_VSS   VSS
* VSS_00382   PAR_0_1_VSS   VSS
* VSS_00383   PAR_0_1_VSS   VSS
* VSS_00384   PAR_0_1_VSS   VSS
* VSS_00567   PAR_0_1_VSS   VSS
* VSS_00386   PAR_0_1_VSS   VSS
* VSS_00387   PAR_0_1_VSS   VSS
* VSS_00388   PAR_0_1_VSS   VSS
* VSS_00468   PAR_0_1_VSS   VSS
* VSS_00469   PAR_0_1_VSS   VSS
* VSS_00470   PAR_0_1_VSS   VSS
* VSS_00471   PAR_0_1_VSS   VSS
* VSS_00472   PAR_0_1_VSS   VSS
* VSS_00831   PAR_0_1_VSS   VSS
* VSS_00746   PAR_0_1_VSS   VSS
* VSS_00747   PAR_0_1_VSS   VSS
* VSS_00748   PAR_0_1_VSS   VSS
* VSS_00749   PAR_0_1_VSS   VSS
* VSS_00750   PAR_0_1_VSS   VSS
* VSS_00751   PAR_0_1_VSS   VSS
* VSS_00752   PAR_0_1_VSS   VSS
* VSS_00753   PAR_0_1_VSS   VSS
* VSS_00754   PAR_0_1_VSS   VSS
* VSS_00745   PAR_0_1_VSS   VSS
* VSS_00832   PAR_0_1_VSS   VSS
* VSS_00833   PAR_0_1_VSS   VSS
* VSS_00834   PAR_0_1_VSS   VSS
* VSS_00835   PAR_0_1_VSS   VSS
* VSS_00836   PAR_0_1_VSS   VSS
* VSS_00837   PAR_0_1_VSS   VSS
* VSS_00838   PAR_0_1_VSS   VSS
* VSS_00839   PAR_0_1_VSS   VSS
* VSS_00657   PAR_0_1_VSS   VSS
* VSS_00568   PAR_0_1_VSS   VSS
* VSS_00650   PAR_0_1_VSS   VSS
* VSS_00651   PAR_0_1_VSS   VSS
* VSS_00652   PAR_0_1_VSS   VSS
* VSS_00653   PAR_0_1_VSS   VSS
* VSS_00654   PAR_0_1_VSS   VSS
* VSS_00655   PAR_0_1_VSS   VSS
* VSS_00656   PAR_0_1_VSS   VSS
* VSS_01384   PAR_0_1_VSS   VSS
* VSS_00658   PAR_0_1_VSS   VSS
* VSS_00659   PAR_0_1_VSS   VSS
* VSS_00660   PAR_0_1_VSS   VSS
* VSS_00661   PAR_0_1_VSS   VSS
* VSS_00662   PAR_0_1_VSS   VSS
* VSS_00742   PAR_0_1_VSS   VSS
* VSS_00743   PAR_0_1_VSS   VSS
* VSS_00744   PAR_0_1_VSS   VSS
* VSS_02107   PAR_0_1_VSS   VSS
* VSS_02019   PAR_0_1_VSS   VSS
* VSS_02020   PAR_0_1_VSS   VSS
* VSS_02021   PAR_0_1_VSS   VSS
* VSS_02022   PAR_0_1_VSS   VSS
* VSS_02023   PAR_0_1_VSS   VSS
* VSS_02024   PAR_0_1_VSS   VSS
* VSS_02025   PAR_0_1_VSS   VSS
* VSS_02105   PAR_0_1_VSS   VSS
* VSS_02106   PAR_0_1_VSS   VSS
* VSS_02018   PAR_0_1_VSS   VSS
* VSS_02108   PAR_0_1_VSS   VSS
* VSS_02109   PAR_0_1_VSS   VSS
* VSS_02110   PAR_0_1_VSS   VSS
* VSS_02111   PAR_0_1_VSS   VSS
* VSS_02112   PAR_0_1_VSS   VSS
* VSS_02113   PAR_0_1_VSS   VSS
* VSS_02114   PAR_0_1_VSS   VSS
* VSS_02115   PAR_0_1_VSS   VSS
* VSS_01931   PAR_0_1_VSS   VSS
* VSS_01923   PAR_0_1_VSS   VSS
* VSS_01924   PAR_0_1_VSS   VSS
* VSS_01925   PAR_0_1_VSS   VSS
* VSS_01926   PAR_0_1_VSS   VSS
* VSS_01927   PAR_0_1_VSS   VSS
* VSS_01928   PAR_0_1_VSS   VSS
* VSS_01929   PAR_0_1_VSS   VSS
* VSS_01930   PAR_0_1_VSS   VSS
* VSS_02116   PAR_0_1_VSS   VSS
* VSS_01932   PAR_0_1_VSS   VSS
* VSS_01933   PAR_0_1_VSS   VSS
* VSS_01934   PAR_0_1_VSS   VSS
* VSS_02013   PAR_0_1_VSS   VSS
* VSS_02014   PAR_0_1_VSS   VSS
* VSS_02015   PAR_0_1_VSS   VSS
* VSS_02016   PAR_0_1_VSS   VSS
* VSS_02017   PAR_0_1_VSS   VSS
* VSS_02376   PAR_0_1_VSS   VSS
* VSS_02290   PAR_0_1_VSS   VSS
* VSS_02291   PAR_0_1_VSS   VSS
* VSS_02292   PAR_0_1_VSS   VSS
* VSS_02293   PAR_0_1_VSS   VSS
* VSS_02294   PAR_0_1_VSS   VSS
* VSS_02295   PAR_0_1_VSS   VSS
* VSS_02296   PAR_0_1_VSS   VSS
* VSS_02297   PAR_0_1_VSS   VSS
* VSS_02298   PAR_0_1_VSS   VSS
* VSS_02289   PAR_0_1_VSS   VSS
* VSS_02377   PAR_0_1_VSS   VSS
* VSS_02378   PAR_0_1_VSS   VSS
* VSS_02379   PAR_0_1_VSS   VSS
* VSS_02380   PAR_0_1_VSS   VSS
* VSS_02381   PAR_0_1_VSS   VSS
* VSS_02382   PAR_0_1_VSS   VSS
* VSS_02383   PAR_0_1_VSS   VSS
* VSS_02384   PAR_0_1_VSS   VSS
* VSS_02203   PAR_0_1_VSS   VSS
* VSS_02117   PAR_0_1_VSS   VSS
* VSS_02196   PAR_0_1_VSS   VSS
* VSS_02197   PAR_0_1_VSS   VSS
* VSS_02198   PAR_0_1_VSS   VSS
* VSS_02199   PAR_0_1_VSS   VSS
* VSS_02200   PAR_0_1_VSS   VSS
* VSS_02201   PAR_0_1_VSS   VSS
* VSS_02202   PAR_0_1_VSS   VSS
* VSS_01922   PAR_0_1_VSS   VSS
* VSS_02204   PAR_0_1_VSS   VSS
* VSS_02205   PAR_0_1_VSS   VSS
* VSS_02206   PAR_0_1_VSS   VSS
* VSS_02207   PAR_0_1_VSS   VSS
* VSS_02208   PAR_0_1_VSS   VSS
* VSS_02286   PAR_0_1_VSS   VSS
* VSS_02287   PAR_0_1_VSS   VSS
* VSS_02288   PAR_0_1_VSS   VSS
* VSS_01567   PAR_0_1_VSS   VSS
* VSS_01480   PAR_0_1_VSS   VSS
* VSS_01481   PAR_0_1_VSS   VSS
* VSS_01560   PAR_0_1_VSS   VSS
* VSS_01561   PAR_0_1_VSS   VSS
* VSS_01562   PAR_0_1_VSS   VSS
* VSS_01563   PAR_0_1_VSS   VSS
* VSS_01564   PAR_0_1_VSS   VSS
* VSS_01565   PAR_0_1_VSS   VSS
* VSS_01566   PAR_0_1_VSS   VSS
* VSS_01479   PAR_0_1_VSS   VSS
* VSS_01568   PAR_0_1_VSS   VSS
* VSS_01569   PAR_0_1_VSS   VSS
* VSS_01570   PAR_0_1_VSS   VSS
* VSS_01571   PAR_0_1_VSS   VSS
* VSS_01572   PAR_0_1_VSS   VSS
* VSS_01650   PAR_0_1_VSS   VSS
* VSS_01651   PAR_0_1_VSS   VSS
* VSS_01652   PAR_0_1_VSS   VSS
* VSS_01470   PAR_0_1_VSS   VSS
* VSS_01385   PAR_0_1_VSS   VSS
* VSS_01386   PAR_0_1_VSS   VSS
* VSS_01387   PAR_0_1_VSS   VSS
* VSS_01388   PAR_0_1_VSS   VSS
* VSS_01389   PAR_0_1_VSS   VSS
* VSS_01390   PAR_0_1_VSS   VSS
* VSS_01391   PAR_0_1_VSS   VSS
* VSS_01469   PAR_0_1_VSS   VSS
* VSS_01653   PAR_0_1_VSS   VSS
* VSS_01471   PAR_0_1_VSS   VSS
* VSS_01472   PAR_0_1_VSS   VSS
* VSS_01473   PAR_0_1_VSS   VSS
* VSS_01474   PAR_0_1_VSS   VSS
* VSS_01475   PAR_0_1_VSS   VSS
* VSS_01476   PAR_0_1_VSS   VSS
* VSS_01477   PAR_0_1_VSS   VSS
* VSS_01478   PAR_0_1_VSS   VSS
* VSS_01837   PAR_0_1_VSS   VSS
* VSS_01751   PAR_0_1_VSS   VSS
* VSS_01752   PAR_0_1_VSS   VSS
* VSS_01753   PAR_0_1_VSS   VSS
* VSS_01754   PAR_0_1_VSS   VSS
* VSS_01833   PAR_0_1_VSS   VSS
* VSS_01834   PAR_0_1_VSS   VSS
* VSS_01835   PAR_0_1_VSS   VSS
* VSS_01836   PAR_0_1_VSS   VSS
* VSS_01750   PAR_0_1_VSS   VSS
* VSS_01838   PAR_0_1_VSS   VSS
* VSS_01839   PAR_0_1_VSS   VSS
* VSS_01840   PAR_0_1_VSS   VSS
* VSS_01841   PAR_0_1_VSS   VSS
* VSS_01842   PAR_0_1_VSS   VSS
* VSS_01843   PAR_0_1_VSS   VSS
* VSS_01844   PAR_0_1_VSS   VSS
* VSS_01845   PAR_0_1_VSS   VSS
* VSS_01662   PAR_0_1_VSS   VSS
* VSS_01654   PAR_0_1_VSS   VSS
* VSS_01655   PAR_0_1_VSS   VSS
* VSS_01656   PAR_0_1_VSS   VSS
* VSS_01657   PAR_0_1_VSS   VSS
* VSS_01658   PAR_0_1_VSS   VSS
* VSS_01659   PAR_0_1_VSS   VSS
* VSS_01660   PAR_0_1_VSS   VSS
* VSS_01661   PAR_0_1_VSS   VSS
* VSS_00376   PAR_0_1_VSS   VSS
* VSS_01742   PAR_0_1_VSS   VSS
* VSS_01743   PAR_0_1_VSS   VSS
* VSS_01744   PAR_0_1_VSS   VSS
* VSS_01745   PAR_0_1_VSS   VSS
* VSS_01746   PAR_0_1_VSS   VSS
* VSS_01747   PAR_0_1_VSS   VSS
* VSS_01748   PAR_0_1_VSS   VSS
* VSS_01749   PAR_0_1_VSS   VSS
* VDD075NNE_00820   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01144   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01145   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01146   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01147   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01148   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01033   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00824   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00823   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00822   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00821   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01143   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00819   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00818   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00817   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00816   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00815   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00814   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00813   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00812   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00811   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01032   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01036   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00704   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00705   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00716   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00715   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00706   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00707   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01040   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01039   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01038   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01037   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01031   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01035   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01034   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01135   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01136   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01137   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01138   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01139   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01140   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01141   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01142   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00489   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00335   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00336   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00709   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00710   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00337   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00338   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00339   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00340   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00711   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00712   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00334   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00491   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00713   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00714   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00973   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00974   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00770   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00769   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00768   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00767   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00766   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00446   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01030   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01029   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01028   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01027   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00708   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00448   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00447   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00595   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00596   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00597   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00703   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00445   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00444   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00327   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00328   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00329   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00330   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00331   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00332   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00333   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00653   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00277   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00662   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00661   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00660   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00659   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00658   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00657   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00656   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00655   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00654   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00276   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00652   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00651   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00650   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00278   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00279   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00280   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00281   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00282   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00283   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00284   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00929   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00922   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00921   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00920   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00919   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00923   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00924   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00925   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00926   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00927   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00928   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00285   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00930   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00931   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00932   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01081   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00543   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00544   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00545   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00273   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00274   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00275   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00175   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00872   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00871   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00870   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00869   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00868   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00867   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00866   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00865   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00177   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00176   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00873   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00174   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00173   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00172   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00171   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00170   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00169   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00168   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00167   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00166   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00165   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01089   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00286   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01082   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00878   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00877   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01083   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01084   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01085   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01086   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01087   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01088   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00490   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01090   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01091   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01092   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01093   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01094   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00178   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00876   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00875   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00874   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01252   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00389   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00390   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00391   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00392   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00393   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01199   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01200   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01201   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00222   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01253   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00388   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01251   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01250   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01249   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01248   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01247   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01246   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01245   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00221   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00220   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00437   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00070   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01195   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01196   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01197   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01198   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00649   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00441   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00440   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00439   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00438   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00111   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00436   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00435   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00381   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00382   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00383   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00384   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00385   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00386   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00387   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00496   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01243   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01242   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01241   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01240   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00502   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00501   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00500   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00499   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00498   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00497   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01244   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00495   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00494   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00552   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00551   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00550   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00549   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00548   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00547   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00546   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00121   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00112   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00113   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00114   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00115   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00116   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00117   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00118   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00119   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00120   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00764   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00122   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00123   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00124   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00394   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00219   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00556   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00555   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00554   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00553   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00980   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00012   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00013   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00014   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00015   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00016   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00978   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00979   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00492   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00493   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00443   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00442   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00011   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00981   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00982   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00983   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00984   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00985   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00986   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00232   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00231   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00230   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00229   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00000   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00765   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00763   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00762   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00761   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00760   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00759   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00758   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00757   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00975   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00976   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00977   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00068   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00001   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00002   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00003   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00004   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00005   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00006   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00007   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00008   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00009   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00010   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01193   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01189   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00069   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00067   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00065   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00064   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01190   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01191   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01192   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00066   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_01194   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00057   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00058   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00059   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00060   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00061   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00062   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00063   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00225   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00605   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00604   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00603   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00602   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00601   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00600   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00599   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00598   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00224   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00606   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00607   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00226   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00608   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00223   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00228   PAR_0_1_VDD075NNE   VDD075NNE
* VDD075NNE_00227   PAR_0_1_VDD075NNE   VDD075NNE
* VSS_01760   PAR_1_1_VSS   VSS
* VSS_00668   PAR_1_1_VSS   VSS
* VSS_00667   PAR_1_1_VSS   VSS
* VSS_00670   PAR_1_1_VSS   VSS
* VSS_01761   PAR_1_1_VSS   VSS
* VSS_00671   PAR_1_1_VSS   VSS
* VSS_00666   PAR_1_1_VSS   VSS
* VSS_00665   PAR_1_1_VSS   VSS
* VSS_00664   PAR_1_1_VSS   VSS
* VSS_00663   PAR_1_1_VSS   VSS
* VSS_00941   PAR_1_1_VSS   VSS
* VSS_01128   PAR_1_1_VSS   VSS
* VSS_01763   PAR_1_1_VSS   VSS
* VSS_01762   PAR_1_1_VSS   VSS
* VSS_02302   PAR_1_1_VSS   VSS
* VSS_00938   PAR_1_1_VSS   VSS
* VSS_00939   PAR_1_1_VSS   VSS
* VSS_00940   PAR_1_1_VSS   VSS
* VSS_00669   PAR_1_1_VSS   VSS
* VSS_00942   PAR_1_1_VSS   VSS
* VSS_01768   PAR_1_1_VSS   VSS
* VSS_00937   PAR_1_1_VSS   VSS
* VSS_00936   PAR_1_1_VSS   VSS
* VSS_02303   PAR_1_1_VSS   VSS
* VSS_00934   PAR_1_1_VSS   VSS
* VSS_02301   PAR_1_1_VSS   VSS
* VSS_02300   PAR_1_1_VSS   VSS
* VSS_02299   PAR_1_1_VSS   VSS
* VSS_00935   PAR_1_1_VSS   VSS
* VSS_01767   PAR_1_1_VSS   VSS
* VSS_01766   PAR_1_1_VSS   VSS
* VSS_01765   PAR_1_1_VSS   VSS
* VSS_01764   PAR_1_1_VSS   VSS
* VSS_02131   PAR_1_1_VSS   VSS
* VSS_02035   PAR_1_1_VSS   VSS
* VSS_02034   PAR_1_1_VSS   VSS
* VSS_02033   PAR_1_1_VSS   VSS
* VSS_02032   PAR_1_1_VSS   VSS
* VSS_02031   PAR_1_1_VSS   VSS
* VSS_02030   PAR_1_1_VSS   VSS
* VSS_02029   PAR_1_1_VSS   VSS
* VSS_02028   PAR_1_1_VSS   VSS
* VSS_02027   PAR_1_1_VSS   VSS
* VSS_02026   PAR_1_1_VSS   VSS
* VSS_02128   PAR_1_1_VSS   VSS
* VSS_02129   PAR_1_1_VSS   VSS
* VSS_02130   PAR_1_1_VSS   VSS
* VSS_02036   PAR_1_1_VSS   VSS
* VSS_00768   PAR_1_1_VSS   VSS
* VSS_00767   PAR_1_1_VSS   VSS
* VSS_00766   PAR_1_1_VSS   VSS
* VSS_00765   PAR_1_1_VSS   VSS
* VSS_00764   PAR_1_1_VSS   VSS
* VSS_00763   PAR_1_1_VSS   VSS
* VSS_00762   PAR_1_1_VSS   VSS
* VSS_00761   PAR_1_1_VSS   VSS
* VSS_00760   PAR_1_1_VSS   VSS
* VSS_02209   PAR_1_1_VSS   VSS
* VSS_02210   PAR_1_1_VSS   VSS
* VSS_02211   PAR_1_1_VSS   VSS
* VSS_02212   PAR_1_1_VSS   VSS
* VSS_00848   PAR_1_1_VSS   VSS
* VSS_00845   PAR_1_1_VSS   VSS
* VSS_00844   PAR_1_1_VSS   VSS
* VSS_02126   PAR_1_1_VSS   VSS
* VSS_02125   PAR_1_1_VSS   VSS
* VSS_02124   PAR_1_1_VSS   VSS
* VSS_02123   PAR_1_1_VSS   VSS
* VSS_02122   PAR_1_1_VSS   VSS
* VSS_02121   PAR_1_1_VSS   VSS
* VSS_02120   PAR_1_1_VSS   VSS
* VSS_02119   PAR_1_1_VSS   VSS
* VSS_02118   PAR_1_1_VSS   VSS
* VSS_00846   PAR_1_1_VSS   VSS
* VSS_00847   PAR_1_1_VSS   VSS
* VSS_02213   PAR_1_1_VSS   VSS
* VSS_00849   PAR_1_1_VSS   VSS
* VSS_00850   PAR_1_1_VSS   VSS
* VSS_00851   PAR_1_1_VSS   VSS
* VSS_00852   PAR_1_1_VSS   VSS
* VSS_00853   PAR_1_1_VSS   VSS
* VSS_00854   PAR_1_1_VSS   VSS
* VSS_00855   PAR_1_1_VSS   VSS
* VSS_00856   PAR_1_1_VSS   VSS
* VSS_00857   PAR_1_1_VSS   VSS
* VSS_02127   PAR_1_1_VSS   VSS
* VSS_02039   PAR_1_1_VSS   VSS
* VSS_02038   PAR_1_1_VSS   VSS
* VSS_02037   PAR_1_1_VSS   VSS
* VSS_01846   PAR_1_1_VSS   VSS
* VSS_01859   PAR_1_1_VSS   VSS
* VSS_01858   PAR_1_1_VSS   VSS
* VSS_01857   PAR_1_1_VSS   VSS
* VSS_01856   PAR_1_1_VSS   VSS
* VSS_01855   PAR_1_1_VSS   VSS
* VSS_01854   PAR_1_1_VSS   VSS
* VSS_01853   PAR_1_1_VSS   VSS
* VSS_01852   PAR_1_1_VSS   VSS
* VSS_01851   PAR_1_1_VSS   VSS
* VSS_01850   PAR_1_1_VSS   VSS
* VSS_01849   PAR_1_1_VSS   VSS
* VSS_01848   PAR_1_1_VSS   VSS
* VSS_01847   PAR_1_1_VSS   VSS
* VSS_01935   PAR_1_1_VSS   VSS
* VSS_01209   PAR_1_1_VSS   VSS
* VSS_01210   PAR_1_1_VSS   VSS
* VSS_01211   PAR_1_1_VSS   VSS
* VSS_01212   PAR_1_1_VSS   VSS
* VSS_01213   PAR_1_1_VSS   VSS
* VSS_01214   PAR_1_1_VSS   VSS
* VSS_01215   PAR_1_1_VSS   VSS
* VSS_01216   PAR_1_1_VSS   VSS
* VSS_01217   PAR_1_1_VSS   VSS
* VSS_00676   PAR_1_1_VSS   VSS
* VSS_00675   PAR_1_1_VSS   VSS
* VSS_00674   PAR_1_1_VSS   VSS
* VSS_00673   PAR_1_1_VSS   VSS
* VSS_02222   PAR_1_1_VSS   VSS
* VSS_02214   PAR_1_1_VSS   VSS
* VSS_02215   PAR_1_1_VSS   VSS
* VSS_02216   PAR_1_1_VSS   VSS
* VSS_02217   PAR_1_1_VSS   VSS
* VSS_02218   PAR_1_1_VSS   VSS
* VSS_02219   PAR_1_1_VSS   VSS
* VSS_02220   PAR_1_1_VSS   VSS
* VSS_00759   PAR_1_1_VSS   VSS
* VSS_00758   PAR_1_1_VSS   VSS
* VSS_00757   PAR_1_1_VSS   VSS
* VSS_00756   PAR_1_1_VSS   VSS
* VSS_00755   PAR_1_1_VSS   VSS
* VSS_02221   PAR_1_1_VSS   VSS
* VSS_00672   PAR_1_1_VSS   VSS
* VSS_01948   PAR_1_1_VSS   VSS
* VSS_01947   PAR_1_1_VSS   VSS
* VSS_01946   PAR_1_1_VSS   VSS
* VSS_01945   PAR_1_1_VSS   VSS
* VSS_01944   PAR_1_1_VSS   VSS
* VSS_01943   PAR_1_1_VSS   VSS
* VSS_01942   PAR_1_1_VSS   VSS
* VSS_01941   PAR_1_1_VSS   VSS
* VSS_01940   PAR_1_1_VSS   VSS
* VSS_01939   PAR_1_1_VSS   VSS
* VSS_01938   PAR_1_1_VSS   VSS
* VSS_01937   PAR_1_1_VSS   VSS
* VSS_01936   PAR_1_1_VSS   VSS
* VSS_01040   PAR_1_1_VSS   VSS
* VSS_01484   PAR_1_1_VSS   VSS
* VSS_01483   PAR_1_1_VSS   VSS
* VSS_01482   PAR_1_1_VSS   VSS
* VSS_01221   PAR_1_1_VSS   VSS
* VSS_01030   PAR_1_1_VSS   VSS
* VSS_01031   PAR_1_1_VSS   VSS
* VSS_01032   PAR_1_1_VSS   VSS
* VSS_01033   PAR_1_1_VSS   VSS
* VSS_01034   PAR_1_1_VSS   VSS
* VSS_01035   PAR_1_1_VSS   VSS
* VSS_01036   PAR_1_1_VSS   VSS
* VSS_01037   PAR_1_1_VSS   VSS
* VSS_01038   PAR_1_1_VSS   VSS
* VSS_01039   PAR_1_1_VSS   VSS
* VSS_01485   PAR_1_1_VSS   VSS
* VSS_01222   PAR_1_1_VSS   VSS
* VSS_01405   PAR_1_1_VSS   VSS
* VSS_01404   PAR_1_1_VSS   VSS
* VSS_01403   PAR_1_1_VSS   VSS
* VSS_01402   PAR_1_1_VSS   VSS
* VSS_01401   PAR_1_1_VSS   VSS
* VSS_02480   PAR_1_1_VSS   VSS
* VSS_02481   PAR_1_1_VSS   VSS
* VSS_02482   PAR_1_1_VSS   VSS
* VSS_02483   PAR_1_1_VSS   VSS
* VSS_02484   PAR_1_1_VSS   VSS
* VSS_02485   PAR_1_1_VSS   VSS
* VSS_02486   PAR_1_1_VSS   VSS
* VSS_02402   PAR_1_1_VSS   VSS
* VSS_00492   PAR_1_1_VSS   VSS
* VSS_00491   PAR_1_1_VSS   VSS
* VSS_00490   PAR_1_1_VSS   VSS
* VSS_00489   PAR_1_1_VSS   VSS
* VSS_00488   PAR_1_1_VSS   VSS
* VSS_00487   PAR_1_1_VSS   VSS
* VSS_00486   PAR_1_1_VSS   VSS
* VSS_00485   PAR_1_1_VSS   VSS
* VSS_00484   PAR_1_1_VSS   VSS
* VSS_00483   PAR_1_1_VSS   VSS
* VSS_00482   PAR_1_1_VSS   VSS
* VSS_00481   PAR_1_1_VSS   VSS
* VSS_02401   PAR_1_1_VSS   VSS
* VSS_01400   PAR_1_1_VSS   VSS
* VSS_01027   PAR_1_1_VSS   VSS
* VSS_01495   PAR_1_1_VSS   VSS
* VSS_01494   PAR_1_1_VSS   VSS
* VSS_01028   PAR_1_1_VSS   VSS
* VSS_01029   PAR_1_1_VSS   VSS
* VSS_01493   PAR_1_1_VSS   VSS
* VSS_01492   PAR_1_1_VSS   VSS
* VSS_01491   PAR_1_1_VSS   VSS
* VSS_01490   PAR_1_1_VSS   VSS
* VSS_01489   PAR_1_1_VSS   VSS
* VSS_01488   PAR_1_1_VSS   VSS
* VSS_01487   PAR_1_1_VSS   VSS
* VSS_01486   PAR_1_1_VSS   VSS
* VSS_01307   PAR_1_1_VSS   VSS
* VSS_00391   PAR_1_1_VSS   VSS
* VSS_00390   PAR_1_1_VSS   VSS
* VSS_00389   PAR_1_1_VSS   VSS
* VSS_01312   PAR_1_1_VSS   VSS
* VSS_01311   PAR_1_1_VSS   VSS
* VSS_01310   PAR_1_1_VSS   VSS
* VSS_01117   PAR_1_1_VSS   VSS
* VSS_01118   PAR_1_1_VSS   VSS
* VSS_01119   PAR_1_1_VSS   VSS
* VSS_01120   PAR_1_1_VSS   VSS
* VSS_01121   PAR_1_1_VSS   VSS
* VSS_01122   PAR_1_1_VSS   VSS
* VSS_01309   PAR_1_1_VSS   VSS
* VSS_01308   PAR_1_1_VSS   VSS
* VSS_00392   PAR_1_1_VSS   VSS
* VSS_01306   PAR_1_1_VSS   VSS
* VSS_01305   PAR_1_1_VSS   VSS
* VSS_01304   PAR_1_1_VSS   VSS
* VSS_01303   PAR_1_1_VSS   VSS
* VSS_01302   PAR_1_1_VSS   VSS
* VSS_01301   PAR_1_1_VSS   VSS
* VSS_01123   PAR_1_1_VSS   VSS
* VSS_01124   PAR_1_1_VSS   VSS
* VSS_01125   PAR_1_1_VSS   VSS
* VSS_01126   PAR_1_1_VSS   VSS
* VSS_01127   PAR_1_1_VSS   VSS
* VSS_01130   PAR_1_1_VSS   VSS
* VSS_01129   PAR_1_1_VSS   VSS
* VSS_00400   PAR_1_1_VSS   VSS
* VSS_01399   PAR_1_1_VSS   VSS
* VSS_01398   PAR_1_1_VSS   VSS
* VSS_01397   PAR_1_1_VSS   VSS
* VSS_01396   PAR_1_1_VSS   VSS
* VSS_01395   PAR_1_1_VSS   VSS
* VSS_01394   PAR_1_1_VSS   VSS
* VSS_01393   PAR_1_1_VSS   VSS
* VSS_01392   PAR_1_1_VSS   VSS
* VSS_02487   PAR_1_1_VSS   VSS
* VSS_02488   PAR_1_1_VSS   VSS
* VSS_02489   PAR_1_1_VSS   VSS
* VSS_00402   PAR_1_1_VSS   VSS
* VSS_00401   PAR_1_1_VSS   VSS
* VSS_01758   PAR_1_1_VSS   VSS
* VSS_00399   PAR_1_1_VSS   VSS
* VSS_02490   PAR_1_1_VSS   VSS
* VSS_02491   PAR_1_1_VSS   VSS
* VSS_02492   PAR_1_1_VSS   VSS
* VSS_02493   PAR_1_1_VSS   VSS
* VSS_01314   PAR_1_1_VSS   VSS
* VSS_01313   PAR_1_1_VSS   VSS
* VSS_00398   PAR_1_1_VSS   VSS
* VSS_00397   PAR_1_1_VSS   VSS
* VSS_00396   PAR_1_1_VSS   VSS
* VSS_00395   PAR_1_1_VSS   VSS
* VSS_00394   PAR_1_1_VSS   VSS
* VSS_00393   PAR_1_1_VSS   VSS
* VSS_02392   PAR_1_1_VSS   VSS
* VSS_01667   PAR_1_1_VSS   VSS
* VSS_01666   PAR_1_1_VSS   VSS
* VSS_01665   PAR_1_1_VSS   VSS
* VSS_00579   PAR_1_1_VSS   VSS
* VSS_00580   PAR_1_1_VSS   VSS
* VSS_00581   PAR_1_1_VSS   VSS
* VSS_00582   PAR_1_1_VSS   VSS
* VSS_02389   PAR_1_1_VSS   VSS
* VSS_02390   PAR_1_1_VSS   VSS
* VSS_02391   PAR_1_1_VSS   VSS
* VSS_01668   PAR_1_1_VSS   VSS
* VSS_02393   PAR_1_1_VSS   VSS
* VSS_02394   PAR_1_1_VSS   VSS
* VSS_02395   PAR_1_1_VSS   VSS
* VSS_02396   PAR_1_1_VSS   VSS
* VSS_02397   PAR_1_1_VSS   VSS
* VSS_02398   PAR_1_1_VSS   VSS
* VSS_02399   PAR_1_1_VSS   VSS
* VSS_02400   PAR_1_1_VSS   VSS
* VSS_01586   PAR_1_1_VSS   VSS
* VSS_01585   PAR_1_1_VSS   VSS
* VSS_00572   PAR_1_1_VSS   VSS
* VSS_01674   PAR_1_1_VSS   VSS
* VSS_01675   PAR_1_1_VSS   VSS
* VSS_02310   PAR_1_1_VSS   VSS
* VSS_01673   PAR_1_1_VSS   VSS
* VSS_01672   PAR_1_1_VSS   VSS
* VSS_01671   PAR_1_1_VSS   VSS
* VSS_02309   PAR_1_1_VSS   VSS
* VSS_00569   PAR_1_1_VSS   VSS
* VSS_00570   PAR_1_1_VSS   VSS
* VSS_00571   PAR_1_1_VSS   VSS
* VSS_02308   PAR_1_1_VSS   VSS
* VSS_00573   PAR_1_1_VSS   VSS
* VSS_00574   PAR_1_1_VSS   VSS
* VSS_00575   PAR_1_1_VSS   VSS
* VSS_00576   PAR_1_1_VSS   VSS
* VSS_00577   PAR_1_1_VSS   VSS
* VSS_01676   PAR_1_1_VSS   VSS
* VSS_00578   PAR_1_1_VSS   VSS
* VSS_01670   PAR_1_1_VSS   VSS
* VSS_01669   PAR_1_1_VSS   VSS
* VSS_01218   PAR_1_1_VSS   VSS
* VSS_00946   PAR_1_1_VSS   VSS
* VSS_00945   PAR_1_1_VSS   VSS
* VSS_00944   PAR_1_1_VSS   VSS
* VSS_00943   PAR_1_1_VSS   VSS
* VSS_01576   PAR_1_1_VSS   VSS
* VSS_01575   PAR_1_1_VSS   VSS
* VSS_01574   PAR_1_1_VSS   VSS
* VSS_01573   PAR_1_1_VSS   VSS
* VSS_02307   PAR_1_1_VSS   VSS
* VSS_01219   PAR_1_1_VSS   VSS
* VSS_01220   PAR_1_1_VSS   VSS
* VSS_01755   PAR_1_1_VSS   VSS
* VSS_00494   PAR_1_1_VSS   VSS
* VSS_00493   PAR_1_1_VSS   VSS
* VSS_01756   PAR_1_1_VSS   VSS
* VSS_01757   PAR_1_1_VSS   VSS
* VSS_01759   PAR_1_1_VSS   VSS
* VSS_02304   PAR_1_1_VSS   VSS
* VSS_01584   PAR_1_1_VSS   VSS
* VSS_01583   PAR_1_1_VSS   VSS
* VSS_01582   PAR_1_1_VSS   VSS
* VSS_01581   PAR_1_1_VSS   VSS
* VSS_01580   PAR_1_1_VSS   VSS
* VSS_01579   PAR_1_1_VSS   VSS
* VSS_02306   PAR_1_1_VSS   VSS
* VSS_01577   PAR_1_1_VSS   VSS
* VSS_02305   PAR_1_1_VSS   VSS
* VSS_01664   PAR_1_1_VSS   VSS
* VSS_01663   PAR_1_1_VSS   VSS
* VSS_02311   PAR_1_1_VSS   VSS
* VSS_02312   PAR_1_1_VSS   VSS
* VSS_01578   PAR_1_1_VSS   VSS
* VSS_00947   PAR_1_1_VSS   VSS
* VDD075NNE_00670   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00664   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00663   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00242   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00241   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00240   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00239   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00238   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00237   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00235   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01096   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00407   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00406   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00405   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00404   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00403   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00402   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00401   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00233   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00234   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01256   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00236   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00400   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00399   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00398   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00397   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00396   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00395   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01254   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01255   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00457   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00296   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00297   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00298   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00299   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00287   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00674   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00675   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00455   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00456   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00295   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00458   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00459   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00460   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00461   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00245   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00244   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00454   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00453   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00189   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00187   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00186   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00185   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00184   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00183   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00182   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00181   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00180   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00179   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00452   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00190   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00288   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00289   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00290   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00291   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00292   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00293   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00294   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01264   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00351   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00352   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00353   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00188   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00669   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00668   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00667   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01266   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01265   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00350   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01263   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01262   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01261   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01260   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01259   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01258   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01257   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00666   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00344   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00451   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00450   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00449   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00243   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00191   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00341   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00342   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00343   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00665   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00345   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00346   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00347   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00348   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00349   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00673   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00672   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00671   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00564   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00888   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00889   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00890   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00891   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00568   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00567   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00566   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00565   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00887   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00563   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00562   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00561   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00560   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00559   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00727   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00726   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00725   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00728   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00831   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00832   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00833   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00834   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00835   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00836   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00837   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00729   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00724   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00879   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00880   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00881   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00882   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00883   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00884   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00885   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00886   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00993   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00718   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00717   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00987   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00988   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00989   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00990   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00991   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00992   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00945   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00994   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00995   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00996   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00997   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00998   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00999   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00558   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00557   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00936   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00723   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00722   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00721   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00720   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00719   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00933   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00934   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00935   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00830   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00937   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00938   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00939   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00940   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00941   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00942   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00943   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00944   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00081   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00130   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00129   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00128   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00127   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00126   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00125   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00083   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00082   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00131   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00080   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00079   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00078   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00077   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00076   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00075   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00074   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00073   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00613   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00621   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00620   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00619   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00618   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00617   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00616   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00615   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00614   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00072   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00612   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00611   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00137   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00136   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00135   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00134   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00133   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00132   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00780   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00772   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00773   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00774   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00775   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00776   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00777   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00778   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00779   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00771   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00781   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00782   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00783   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00825   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00826   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00827   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00828   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00829   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00024   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00071   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00610   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00609   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00029   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00028   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00027   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00026   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00025   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00504   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00023   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00022   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00021   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00020   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00019   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00018   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00017   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01154   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01160   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01159   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01158   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01149   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01150   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01151   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01152   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01153   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01161   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01205   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01206   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01053   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01207   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01208   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01209   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01210   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01211   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01103   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00510   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01102   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01101   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01100   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00509   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00508   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00507   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01202   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01203   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01204   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01095   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01099   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01097   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01098   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01052   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01107   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00511   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00512   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00513   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00514   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01041   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01042   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01043   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01044   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01045   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01046   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01047   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01048   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01049   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01050   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01106   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00515   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01105   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01104   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01157   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01156   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00503   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00505   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_00506   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01155   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01214   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01213   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01212   PAR_1_1_VDD075NNE   VDD075NNE
* VDD075NNE_01051   PAR_1_1_VDD075NNE   VDD075NNE
* VSS_02134   PAR_2_1_VSS   VSS
* VSS_02495   PAR_2_1_VSS   VSS
* VSS_02133   PAR_2_1_VSS   VSS
* VSS_02132   PAR_2_1_VSS   VSS
* VSS_01957   PAR_2_1_VSS   VSS
* VSS_01958   PAR_2_1_VSS   VSS
* VSS_01959   PAR_2_1_VSS   VSS
* VSS_01960   PAR_2_1_VSS   VSS
* VSS_01961   PAR_2_1_VSS   VSS
* VSS_01327   PAR_2_1_VSS   VSS
* VSS_02494   PAR_2_1_VSS   VSS
* VSS_02041   PAR_2_1_VSS   VSS
* VSS_01954   PAR_2_1_VSS   VSS
* VSS_01415   PAR_2_1_VSS   VSS
* VSS_01414   PAR_2_1_VSS   VSS
* VSS_01413   PAR_2_1_VSS   VSS
* VSS_01412   PAR_2_1_VSS   VSS
* VSS_01411   PAR_2_1_VSS   VSS
* VSS_01410   PAR_2_1_VSS   VSS
* VSS_01409   PAR_2_1_VSS   VSS
* VSS_01408   PAR_2_1_VSS   VSS
* VSS_01407   PAR_2_1_VSS   VSS
* VSS_01406   PAR_2_1_VSS   VSS
* VSS_01953   PAR_2_1_VSS   VSS
* VSS_02135   PAR_2_1_VSS   VSS
* VSS_01955   PAR_2_1_VSS   VSS
* VSS_01956   PAR_2_1_VSS   VSS
* VSS_02144   PAR_2_1_VSS   VSS
* VSS_02143   PAR_2_1_VSS   VSS
* VSS_02142   PAR_2_1_VSS   VSS
* VSS_02141   PAR_2_1_VSS   VSS
* VSS_02140   PAR_2_1_VSS   VSS
* VSS_02139   PAR_2_1_VSS   VSS
* VSS_02138   PAR_2_1_VSS   VSS
* VSS_02137   PAR_2_1_VSS   VSS
* VSS_02136   PAR_2_1_VSS   VSS
* VSS_02052   PAR_2_1_VSS   VSS
* VSS_01315   PAR_2_1_VSS   VSS
* VSS_02042   PAR_2_1_VSS   VSS
* VSS_02043   PAR_2_1_VSS   VSS
* VSS_02044   PAR_2_1_VSS   VSS
* VSS_02045   PAR_2_1_VSS   VSS
* VSS_02046   PAR_2_1_VSS   VSS
* VSS_02047   PAR_2_1_VSS   VSS
* VSS_02048   PAR_2_1_VSS   VSS
* VSS_01140   PAR_2_1_VSS   VSS
* VSS_01139   PAR_2_1_VSS   VSS
* VSS_02049   PAR_2_1_VSS   VSS
* VSS_02050   PAR_2_1_VSS   VSS
* VSS_02051   PAR_2_1_VSS   VSS
* VSS_01316   PAR_2_1_VSS   VSS
* VSS_01235   PAR_2_1_VSS   VSS
* VSS_01138   PAR_2_1_VSS   VSS
* VSS_01137   PAR_2_1_VSS   VSS
* VSS_01136   PAR_2_1_VSS   VSS
* VSS_01135   PAR_2_1_VSS   VSS
* VSS_01134   PAR_2_1_VSS   VSS
* VSS_01133   PAR_2_1_VSS   VSS
* VSS_01132   PAR_2_1_VSS   VSS
* VSS_01131   PAR_2_1_VSS   VSS
* VSS_01234   PAR_2_1_VSS   VSS
* VSS_01233   PAR_2_1_VSS   VSS
* VSS_01769   PAR_2_1_VSS   VSS
* VSS_01141   PAR_2_1_VSS   VSS
* VSS_02497   PAR_2_1_VSS   VSS
* VSS_02498   PAR_2_1_VSS   VSS
* VSS_02499   PAR_2_1_VSS   VSS
* VSS_02500   PAR_2_1_VSS   VSS
* VSS_02501   PAR_2_1_VSS   VSS
* VSS_02502   PAR_2_1_VSS   VSS
* VSS_02503   PAR_2_1_VSS   VSS
* VSS_02504   PAR_2_1_VSS   VSS
* VSS_02505   PAR_2_1_VSS   VSS
* VSS_02506   PAR_2_1_VSS   VSS
* VSS_01143   PAR_2_1_VSS   VSS
* VSS_01142   PAR_2_1_VSS   VSS
* VSS_02496   PAR_2_1_VSS   VSS
* VSS_02040   PAR_2_1_VSS   VSS
* VSS_01232   PAR_2_1_VSS   VSS
* VSS_01326   PAR_2_1_VSS   VSS
* VSS_01325   PAR_2_1_VSS   VSS
* VSS_01324   PAR_2_1_VSS   VSS
* VSS_01323   PAR_2_1_VSS   VSS
* VSS_01322   PAR_2_1_VSS   VSS
* VSS_01321   PAR_2_1_VSS   VSS
* VSS_01320   PAR_2_1_VSS   VSS
* VSS_01319   PAR_2_1_VSS   VSS
* VSS_01318   PAR_2_1_VSS   VSS
* VSS_01317   PAR_2_1_VSS   VSS
* VSS_02228   PAR_2_1_VSS   VSS
* VSS_01777   PAR_2_1_VSS   VSS
* VSS_01778   PAR_2_1_VSS   VSS
* VSS_02318   PAR_2_1_VSS   VSS
* VSS_02319   PAR_2_1_VSS   VSS
* VSS_02320   PAR_2_1_VSS   VSS
* VSS_02321   PAR_2_1_VSS   VSS
* VSS_02322   PAR_2_1_VSS   VSS
* VSS_02323   PAR_2_1_VSS   VSS
* VSS_02324   PAR_2_1_VSS   VSS
* VSS_02325   PAR_2_1_VSS   VSS
* VSS_01779   PAR_2_1_VSS   VSS
* VSS_01780   PAR_2_1_VSS   VSS
* VSS_02230   PAR_2_1_VSS   VSS
* VSS_02229   PAR_2_1_VSS   VSS
* VSS_01776   PAR_2_1_VSS   VSS
* VSS_02227   PAR_2_1_VSS   VSS
* VSS_01781   PAR_2_1_VSS   VSS
* VSS_01231   PAR_2_1_VSS   VSS
* VSS_01860   PAR_2_1_VSS   VSS
* VSS_01599   PAR_2_1_VSS   VSS
* VSS_01598   PAR_2_1_VSS   VSS
* VSS_01597   PAR_2_1_VSS   VSS
* VSS_01596   PAR_2_1_VSS   VSS
* VSS_01595   PAR_2_1_VSS   VSS
* VSS_01594   PAR_2_1_VSS   VSS
* VSS_01593   PAR_2_1_VSS   VSS
* VSS_01592   PAR_2_1_VSS   VSS
* VSS_01591   PAR_2_1_VSS   VSS
* VSS_01590   PAR_2_1_VSS   VSS
* VSS_01679   PAR_2_1_VSS   VSS
* VSS_01770   PAR_2_1_VSS   VSS
* VSS_01689   PAR_2_1_VSS   VSS
* VSS_01688   PAR_2_1_VSS   VSS
* VSS_01687   PAR_2_1_VSS   VSS
* VSS_01686   PAR_2_1_VSS   VSS
* VSS_01685   PAR_2_1_VSS   VSS
* VSS_02235   PAR_2_1_VSS   VSS
* VSS_02234   PAR_2_1_VSS   VSS
* VSS_02233   PAR_2_1_VSS   VSS
* VSS_01684   PAR_2_1_VSS   VSS
* VSS_01683   PAR_2_1_VSS   VSS
* VSS_01682   PAR_2_1_VSS   VSS
* VSS_01681   PAR_2_1_VSS   VSS
* VSS_01680   PAR_2_1_VSS   VSS
* VSS_01589   PAR_2_1_VSS   VSS
* VSS_01678   PAR_2_1_VSS   VSS
* VSS_01677   PAR_2_1_VSS   VSS
* VSS_02232   PAR_2_1_VSS   VSS
* VSS_02231   PAR_2_1_VSS   VSS
* VSS_02313   PAR_2_1_VSS   VSS
* VSS_02314   PAR_2_1_VSS   VSS
* VSS_02315   PAR_2_1_VSS   VSS
* VSS_02316   PAR_2_1_VSS   VSS
* VSS_02317   PAR_2_1_VSS   VSS
* VSS_01771   PAR_2_1_VSS   VSS
* VSS_01772   PAR_2_1_VSS   VSS
* VSS_01773   PAR_2_1_VSS   VSS
* VSS_01774   PAR_2_1_VSS   VSS
* VSS_01775   PAR_2_1_VSS   VSS
* VSS_02224   PAR_2_1_VSS   VSS
* VSS_02403   PAR_2_1_VSS   VSS
* VSS_02404   PAR_2_1_VSS   VSS
* VSS_02405   PAR_2_1_VSS   VSS
* VSS_02406   PAR_2_1_VSS   VSS
* VSS_02407   PAR_2_1_VSS   VSS
* VSS_02408   PAR_2_1_VSS   VSS
* VSS_02409   PAR_2_1_VSS   VSS
* VSS_02410   PAR_2_1_VSS   VSS
* VSS_02411   PAR_2_1_VSS   VSS
* VSS_02412   PAR_2_1_VSS   VSS
* VSS_02413   PAR_2_1_VSS   VSS
* VSS_02414   PAR_2_1_VSS   VSS
* VSS_01496   PAR_2_1_VSS   VSS
* VSS_02225   PAR_2_1_VSS   VSS
* VSS_01497   PAR_2_1_VSS   VSS
* VSS_02223   PAR_2_1_VSS   VSS
* VSS_01951   PAR_2_1_VSS   VSS
* VSS_01952   PAR_2_1_VSS   VSS
* VSS_02415   PAR_2_1_VSS   VSS
* VSS_01223   PAR_2_1_VSS   VSS
* VSS_01224   PAR_2_1_VSS   VSS
* VSS_01225   PAR_2_1_VSS   VSS
* VSS_01226   PAR_2_1_VSS   VSS
* VSS_01227   PAR_2_1_VSS   VSS
* VSS_01228   PAR_2_1_VSS   VSS
* VSS_01229   PAR_2_1_VSS   VSS
* VSS_01230   PAR_2_1_VSS   VSS
* VSS_01418   PAR_2_1_VSS   VSS
* VSS_01417   PAR_2_1_VSS   VSS
* VSS_01949   PAR_2_1_VSS   VSS
* VSS_01588   PAR_2_1_VSS   VSS
* VSS_01587   PAR_2_1_VSS   VSS
* VSS_01861   PAR_2_1_VSS   VSS
* VSS_01862   PAR_2_1_VSS   VSS
* VSS_01863   PAR_2_1_VSS   VSS
* VSS_01864   PAR_2_1_VSS   VSS
* VSS_01865   PAR_2_1_VSS   VSS
* VSS_01866   PAR_2_1_VSS   VSS
* VSS_01867   PAR_2_1_VSS   VSS
* VSS_01868   PAR_2_1_VSS   VSS
* VSS_01869   PAR_2_1_VSS   VSS
* VSS_01870   PAR_2_1_VSS   VSS
* VSS_01871   PAR_2_1_VSS   VSS
* VSS_01872   PAR_2_1_VSS   VSS
* VSS_01416   PAR_2_1_VSS   VSS
* VSS_01508   PAR_2_1_VSS   VSS
* VSS_01950   PAR_2_1_VSS   VSS
* VSS_02226   PAR_2_1_VSS   VSS
* VSS_01507   PAR_2_1_VSS   VSS
* VSS_01506   PAR_2_1_VSS   VSS
* VSS_01505   PAR_2_1_VSS   VSS
* VSS_01504   PAR_2_1_VSS   VSS
* VSS_01503   PAR_2_1_VSS   VSS
* VSS_01502   PAR_2_1_VSS   VSS
* VSS_01501   PAR_2_1_VSS   VSS
* VSS_01500   PAR_2_1_VSS   VSS
* VSS_01499   PAR_2_1_VSS   VSS
* VSS_01498   PAR_2_1_VSS   VSS
* VSS_00865   PAR_2_1_VSS   VSS
* VSS_00867   PAR_2_1_VSS   VSS
* VSS_01042   PAR_2_1_VSS   VSS
* VSS_01043   PAR_2_1_VSS   VSS
* VSS_01044   PAR_2_1_VSS   VSS
* VSS_01045   PAR_2_1_VSS   VSS
* VSS_01046   PAR_2_1_VSS   VSS
* VSS_01047   PAR_2_1_VSS   VSS
* VSS_01048   PAR_2_1_VSS   VSS
* VSS_01049   PAR_2_1_VSS   VSS
* VSS_01050   PAR_2_1_VSS   VSS
* VSS_01051   PAR_2_1_VSS   VSS
* VSS_01052   PAR_2_1_VSS   VSS
* VSS_00866   PAR_2_1_VSS   VSS
* VSS_00868   PAR_2_1_VSS   VSS
* VSS_00864   PAR_2_1_VSS   VSS
* VSS_00415   PAR_2_1_VSS   VSS
* VSS_00863   PAR_2_1_VSS   VSS
* VSS_00862   PAR_2_1_VSS   VSS
* VSS_01053   PAR_2_1_VSS   VSS
* VSS_00505   PAR_2_1_VSS   VSS
* VSS_00506   PAR_2_1_VSS   VSS
* VSS_00507   PAR_2_1_VSS   VSS
* VSS_00414   PAR_2_1_VSS   VSS
* VSS_00413   PAR_2_1_VSS   VSS
* VSS_00412   PAR_2_1_VSS   VSS
* VSS_00861   PAR_2_1_VSS   VSS
* VSS_00495   PAR_2_1_VSS   VSS
* VSS_00499   PAR_2_1_VSS   VSS
* VSS_00500   PAR_2_1_VSS   VSS
* VSS_00501   PAR_2_1_VSS   VSS
* VSS_00502   PAR_2_1_VSS   VSS
* VSS_00503   PAR_2_1_VSS   VSS
* VSS_00504   PAR_2_1_VSS   VSS
* VSS_00677   PAR_2_1_VSS   VSS
* VSS_00678   PAR_2_1_VSS   VSS
* VSS_00679   PAR_2_1_VSS   VSS
* VSS_00680   PAR_2_1_VSS   VSS
* VSS_00498   PAR_2_1_VSS   VSS
* VSS_00497   PAR_2_1_VSS   VSS
* VSS_00496   PAR_2_1_VSS   VSS
* VSS_00586   PAR_2_1_VSS   VSS
* VSS_00681   PAR_2_1_VSS   VSS
* VSS_00682   PAR_2_1_VSS   VSS
* VSS_00683   PAR_2_1_VSS   VSS
* VSS_00684   PAR_2_1_VSS   VSS
* VSS_00685   PAR_2_1_VSS   VSS
* VSS_00686   PAR_2_1_VSS   VSS
* VSS_00687   PAR_2_1_VSS   VSS
* VSS_01041   PAR_2_1_VSS   VSS
* VSS_00688   PAR_2_1_VSS   VSS
* VSS_00689   PAR_2_1_VSS   VSS
* VSS_00870   PAR_2_1_VSS   VSS
* VSS_00869   PAR_2_1_VSS   VSS
* VSS_00950   PAR_2_1_VSS   VSS
* VSS_00406   PAR_2_1_VSS   VSS
* VSS_00405   PAR_2_1_VSS   VSS
* VSS_00404   PAR_2_1_VSS   VSS
* VSS_00403   PAR_2_1_VSS   VSS
* VSS_00770   PAR_2_1_VSS   VSS
* VSS_00771   PAR_2_1_VSS   VSS
* VSS_00772   PAR_2_1_VSS   VSS
* VSS_00589   PAR_2_1_VSS   VSS
* VSS_00588   PAR_2_1_VSS   VSS
* VSS_00860   PAR_2_1_VSS   VSS
* VSS_00948   PAR_2_1_VSS   VSS
* VSS_00949   PAR_2_1_VSS   VSS
* VSS_00407   PAR_2_1_VSS   VSS
* VSS_00951   PAR_2_1_VSS   VSS
* VSS_00952   PAR_2_1_VSS   VSS
* VSS_00953   PAR_2_1_VSS   VSS
* VSS_00858   PAR_2_1_VSS   VSS
* VSS_00587   PAR_2_1_VSS   VSS
* VSS_00960   PAR_2_1_VSS   VSS
* VSS_00959   PAR_2_1_VSS   VSS
* VSS_00958   PAR_2_1_VSS   VSS
* VSS_00957   PAR_2_1_VSS   VSS
* VSS_00956   PAR_2_1_VSS   VSS
* VSS_00955   PAR_2_1_VSS   VSS
* VSS_00954   PAR_2_1_VSS   VSS
* VSS_00408   PAR_2_1_VSS   VSS
* VSS_00585   PAR_2_1_VSS   VSS
* VSS_00859   PAR_2_1_VSS   VSS
* VSS_00584   PAR_2_1_VSS   VSS
* VSS_00583   PAR_2_1_VSS   VSS
* VSS_00781   PAR_2_1_VSS   VSS
* VSS_00780   PAR_2_1_VSS   VSS
* VSS_00779   PAR_2_1_VSS   VSS
* VSS_00778   PAR_2_1_VSS   VSS
* VSS_00595   PAR_2_1_VSS   VSS
* VSS_00594   PAR_2_1_VSS   VSS
* VSS_00593   PAR_2_1_VSS   VSS
* VSS_00777   PAR_2_1_VSS   VSS
* VSS_00776   PAR_2_1_VSS   VSS
* VSS_00775   PAR_2_1_VSS   VSS
* VSS_00774   PAR_2_1_VSS   VSS
* VSS_00773   PAR_2_1_VSS   VSS
* VSS_00592   PAR_2_1_VSS   VSS
* VSS_00591   PAR_2_1_VSS   VSS
* VSS_00590   PAR_2_1_VSS   VSS
* VSS_00769   PAR_2_1_VSS   VSS
* VSS_00411   PAR_2_1_VSS   VSS
* VSS_00410   PAR_2_1_VSS   VSS
* VSS_00409   PAR_2_1_VSS   VSS
* VDD075NNE_01061   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01013   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01113   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01009   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01002   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01003   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01001   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01000   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01004   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01005   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01006   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01007   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01008   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01060   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01010   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01011   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01012   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01054   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01055   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01056   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01057   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01058   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01059   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00516   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00524   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00523   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00522   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00521   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00520   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00689   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01162   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01163   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01164   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01165   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01166   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00519   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00518   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00517   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00525   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01167   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01168   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01169   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01170   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01171   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01172   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01173   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01174   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01175   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00688   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00687   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00686   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01215   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01115   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01063   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01064   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01065   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01066   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01067   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00624   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01108   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01109   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01110   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01111   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01112   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00948   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01114   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01062   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01116   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01117   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01118   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01119   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01120   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01121   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00625   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00626   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00627   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00529   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00528   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00527   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00526   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00784   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00084   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00043   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00042   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00041   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00040   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00039   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00038   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00037   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00036   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00035   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00034   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00033   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00032   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00031   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00030   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00085   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00785   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00786   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00787   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00788   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00789   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00790   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00791   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00792   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00793   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00794   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00795   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00796   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00797   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00740   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00739   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00138   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00623   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00622   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00151   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00150   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00149   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00148   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00147   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00146   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00145   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00144   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00143   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00142   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00141   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00140   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00139   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00738   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00743   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00742   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00741   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00097   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00096   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00095   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00094   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00093   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00092   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00091   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00090   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00089   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00088   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00087   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00086   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00571   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00572   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00892   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00893   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00894   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00895   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00896   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00897   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00898   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00899   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00900   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00901   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00902   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00903   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00904   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00905   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00573   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00570   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00569   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00946   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00947   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00420   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00949   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00950   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00951   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00952   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00953   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00954   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00955   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00956   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00957   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00958   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00845   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00737   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00736   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00735   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00734   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00733   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00732   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00731   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00730   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00838   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00839   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00840   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00841   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00842   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00843   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00844   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00959   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00846   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00847   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00848   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00849   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00850   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00851   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00581   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00580   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00579   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00578   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00577   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00576   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00575   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00574   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01277   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00205   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00204   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00203   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00202   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00201   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00468   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00469   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01276   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00635   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01278   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01279   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01280   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00470   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00471   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00472   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00473   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00474   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00246   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00247   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00248   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00249   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00250   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00251   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00252   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00253   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00357   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01275   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01274   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01273   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01272   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01271   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01270   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00359   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00310   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00300   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00301   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00302   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00303   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00304   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00309   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00308   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00311   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00358   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00628   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00629   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00630   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00631   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00632   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00633   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01269   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00192   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00193   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00194   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00360   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00361   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00362   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00363   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00364   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00365   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00366   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00367   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00312   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00313   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00634   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00475   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00416   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01222   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01221   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01220   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01219   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01218   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01217   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01216   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00408   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00409   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00410   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00411   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00412   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00413   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00414   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00415   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01268   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00417   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00418   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00421   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00419   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00467   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00356   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00355   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00354   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00195   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00196   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00197   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00198   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00199   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00200   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01224   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01267   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00676   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00307   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00306   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00305   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00259   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00258   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00257   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00256   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00255   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00254   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00462   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00463   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00464   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00466   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01223   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01225   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01226   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_01227   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00685   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00684   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00683   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00682   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00681   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00680   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00679   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00678   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00677   PAR_2_1_VDD075NNE   VDD075NNE
* VDD075NNE_00465   PAR_2_1_VDD075NNE   VDD075NNE
* VSS_01509   PAR_3_1_VSS   VSS
* VSS_01510   PAR_3_1_VSS   VSS
* VSS_01511   PAR_3_1_VSS   VSS
* VSS_01512   PAR_3_1_VSS   VSS
* VSS_02425   PAR_3_1_VSS   VSS
* VSS_02416   PAR_3_1_VSS   VSS
* VSS_02417   PAR_3_1_VSS   VSS
* VSS_02418   PAR_3_1_VSS   VSS
* VSS_02419   PAR_3_1_VSS   VSS
* VSS_02420   PAR_3_1_VSS   VSS
* VSS_02421   PAR_3_1_VSS   VSS
* VSS_02422   PAR_3_1_VSS   VSS
* VSS_02423   PAR_3_1_VSS   VSS
* VSS_02424   PAR_3_1_VSS   VSS
* VSS_01422   PAR_3_1_VSS   VSS
* VSS_02335   PAR_3_1_VSS   VSS
* VSS_00965   PAR_3_1_VSS   VSS
* VSS_00964   PAR_3_1_VSS   VSS
* VSS_00963   PAR_3_1_VSS   VSS
* VSS_00962   PAR_3_1_VSS   VSS
* VSS_02339   PAR_3_1_VSS   VSS
* VSS_02338   PAR_3_1_VSS   VSS
* VSS_02337   PAR_3_1_VSS   VSS
* VSS_02336   PAR_3_1_VSS   VSS
* VSS_00966   PAR_3_1_VSS   VSS
* VSS_02334   PAR_3_1_VSS   VSS
* VSS_00508   PAR_3_1_VSS   VSS
* VSS_00509   PAR_3_1_VSS   VSS
* VSS_00510   PAR_3_1_VSS   VSS
* VSS_00511   PAR_3_1_VSS   VSS
* VSS_01600   PAR_3_1_VSS   VSS
* VSS_01601   PAR_3_1_VSS   VSS
* VSS_01602   PAR_3_1_VSS   VSS
* VSS_01522   PAR_3_1_VSS   VSS
* VSS_01514   PAR_3_1_VSS   VSS
* VSS_01515   PAR_3_1_VSS   VSS
* VSS_01516   PAR_3_1_VSS   VSS
* VSS_01517   PAR_3_1_VSS   VSS
* VSS_01518   PAR_3_1_VSS   VSS
* VSS_01519   PAR_3_1_VSS   VSS
* VSS_01520   PAR_3_1_VSS   VSS
* VSS_01521   PAR_3_1_VSS   VSS
* VSS_01513   PAR_3_1_VSS   VSS
* VSS_00974   PAR_3_1_VSS   VSS
* VSS_00973   PAR_3_1_VSS   VSS
* VSS_00972   PAR_3_1_VSS   VSS
* VSS_00971   PAR_3_1_VSS   VSS
* VSS_00970   PAR_3_1_VSS   VSS
* VSS_00969   PAR_3_1_VSS   VSS
* VSS_00968   PAR_3_1_VSS   VSS
* VSS_00967   PAR_3_1_VSS   VSS
* VSS_01341   PAR_3_1_VSS   VSS
* VSS_01329   PAR_3_1_VSS   VSS
* VSS_01330   PAR_3_1_VSS   VSS
* VSS_01331   PAR_3_1_VSS   VSS
* VSS_01332   PAR_3_1_VSS   VSS
* VSS_01333   PAR_3_1_VSS   VSS
* VSS_01334   PAR_3_1_VSS   VSS
* VSS_01335   PAR_3_1_VSS   VSS
* VSS_01336   PAR_3_1_VSS   VSS
* VSS_01337   PAR_3_1_VSS   VSS
* VSS_01338   PAR_3_1_VSS   VSS
* VSS_01339   PAR_3_1_VSS   VSS
* VSS_01340   PAR_3_1_VSS   VSS
* VSS_01328   PAR_3_1_VSS   VSS
* VSS_01153   PAR_3_1_VSS   VSS
* VSS_02520   PAR_3_1_VSS   VSS
* VSS_02519   PAR_3_1_VSS   VSS
* VSS_02518   PAR_3_1_VSS   VSS
* VSS_02517   PAR_3_1_VSS   VSS
* VSS_02516   PAR_3_1_VSS   VSS
* VSS_02515   PAR_3_1_VSS   VSS
* VSS_02514   PAR_3_1_VSS   VSS
* VSS_02513   PAR_3_1_VSS   VSS
* VSS_02512   PAR_3_1_VSS   VSS
* VSS_02511   PAR_3_1_VSS   VSS
* VSS_01247   PAR_3_1_VSS   VSS
* VSS_01236   PAR_3_1_VSS   VSS
* VSS_01237   PAR_3_1_VSS   VSS
* VSS_01238   PAR_3_1_VSS   VSS
* VSS_01239   PAR_3_1_VSS   VSS
* VSS_01240   PAR_3_1_VSS   VSS
* VSS_01241   PAR_3_1_VSS   VSS
* VSS_01242   PAR_3_1_VSS   VSS
* VSS_01243   PAR_3_1_VSS   VSS
* VSS_01244   PAR_3_1_VSS   VSS
* VSS_01245   PAR_3_1_VSS   VSS
* VSS_01246   PAR_3_1_VSS   VSS
* VSS_02510   PAR_3_1_VSS   VSS
* VSS_01248   PAR_3_1_VSS   VSS
* VSS_01249   PAR_3_1_VSS   VSS
* VSS_01144   PAR_3_1_VSS   VSS
* VSS_01145   PAR_3_1_VSS   VSS
* VSS_01146   PAR_3_1_VSS   VSS
* VSS_01147   PAR_3_1_VSS   VSS
* VSS_01148   PAR_3_1_VSS   VSS
* VSS_01149   PAR_3_1_VSS   VSS
* VSS_01150   PAR_3_1_VSS   VSS
* VSS_01151   PAR_3_1_VSS   VSS
* VSS_01152   PAR_3_1_VSS   VSS
* VSS_00421   PAR_3_1_VSS   VSS
* VSS_01426   PAR_3_1_VSS   VSS
* VSS_01427   PAR_3_1_VSS   VSS
* VSS_01428   PAR_3_1_VSS   VSS
* VSS_01429   PAR_3_1_VSS   VSS
* VSS_01430   PAR_3_1_VSS   VSS
* VSS_01431   PAR_3_1_VSS   VSS
* VSS_01432   PAR_3_1_VSS   VSS
* VSS_00416   PAR_3_1_VSS   VSS
* VSS_00417   PAR_3_1_VSS   VSS
* VSS_00418   PAR_3_1_VSS   VSS
* VSS_00419   PAR_3_1_VSS   VSS
* VSS_00420   PAR_3_1_VSS   VSS
* VSS_01425   PAR_3_1_VSS   VSS
* VSS_00422   PAR_3_1_VSS   VSS
* VSS_00423   PAR_3_1_VSS   VSS
* VSS_00424   PAR_3_1_VSS   VSS
* VSS_00425   PAR_3_1_VSS   VSS
* VSS_00426   PAR_3_1_VSS   VSS
* VSS_00427   PAR_3_1_VSS   VSS
* VSS_00428   PAR_3_1_VSS   VSS
* VSS_00429   PAR_3_1_VSS   VSS
* VSS_02429   PAR_3_1_VSS   VSS
* VSS_02428   PAR_3_1_VSS   VSS
* VSS_02427   PAR_3_1_VSS   VSS
* VSS_01059   PAR_3_1_VSS   VSS
* VSS_02509   PAR_3_1_VSS   VSS
* VSS_02508   PAR_3_1_VSS   VSS
* VSS_02507   PAR_3_1_VSS   VSS
* VSS_01067   PAR_3_1_VSS   VSS
* VSS_01066   PAR_3_1_VSS   VSS
* VSS_01065   PAR_3_1_VSS   VSS
* VSS_01064   PAR_3_1_VSS   VSS
* VSS_01063   PAR_3_1_VSS   VSS
* VSS_01062   PAR_3_1_VSS   VSS
* VSS_01061   PAR_3_1_VSS   VSS
* VSS_01060   PAR_3_1_VSS   VSS
* VSS_02426   PAR_3_1_VSS   VSS
* VSS_01058   PAR_3_1_VSS   VSS
* VSS_01057   PAR_3_1_VSS   VSS
* VSS_01056   PAR_3_1_VSS   VSS
* VSS_01055   PAR_3_1_VSS   VSS
* VSS_01054   PAR_3_1_VSS   VSS
* VSS_01419   PAR_3_1_VSS   VSS
* VSS_01420   PAR_3_1_VSS   VSS
* VSS_01421   PAR_3_1_VSS   VSS
* VSS_02060   PAR_3_1_VSS   VSS
* VSS_01423   PAR_3_1_VSS   VSS
* VSS_01424   PAR_3_1_VSS   VSS
* VSS_01882   PAR_3_1_VSS   VSS
* VSS_00697   PAR_3_1_VSS   VSS
* VSS_00698   PAR_3_1_VSS   VSS
* VSS_01873   PAR_3_1_VSS   VSS
* VSS_01874   PAR_3_1_VSS   VSS
* VSS_01875   PAR_3_1_VSS   VSS
* VSS_01876   PAR_3_1_VSS   VSS
* VSS_01877   PAR_3_1_VSS   VSS
* VSS_01878   PAR_3_1_VSS   VSS
* VSS_01879   PAR_3_1_VSS   VSS
* VSS_01880   PAR_3_1_VSS   VSS
* VSS_01881   PAR_3_1_VSS   VSS
* VSS_00696   PAR_3_1_VSS   VSS
* VSS_01883   PAR_3_1_VSS   VSS
* VSS_01884   PAR_3_1_VSS   VSS
* VSS_01885   PAR_3_1_VSS   VSS
* VSS_01886   PAR_3_1_VSS   VSS
* VSS_02152   PAR_3_1_VSS   VSS
* VSS_02151   PAR_3_1_VSS   VSS
* VSS_02150   PAR_3_1_VSS   VSS
* VSS_02149   PAR_3_1_VSS   VSS
* VSS_02148   PAR_3_1_VSS   VSS
* VSS_02147   PAR_3_1_VSS   VSS
* VSS_02146   PAR_3_1_VSS   VSS
* VSS_00690   PAR_3_1_VSS   VSS
* VSS_00881   PAR_3_1_VSS   VSS
* VSS_00880   PAR_3_1_VSS   VSS
* VSS_00879   PAR_3_1_VSS   VSS
* VSS_00878   PAR_3_1_VSS   VSS
* VSS_00877   PAR_3_1_VSS   VSS
* VSS_00876   PAR_3_1_VSS   VSS
* VSS_00875   PAR_3_1_VSS   VSS
* VSS_00874   PAR_3_1_VSS   VSS
* VSS_00873   PAR_3_1_VSS   VSS
* VSS_00872   PAR_3_1_VSS   VSS
* VSS_00871   PAR_3_1_VSS   VSS
* VSS_02145   PAR_3_1_VSS   VSS
* VSS_00691   PAR_3_1_VSS   VSS
* VSS_00692   PAR_3_1_VSS   VSS
* VSS_00693   PAR_3_1_VSS   VSS
* VSS_00694   PAR_3_1_VSS   VSS
* VSS_00695   PAR_3_1_VSS   VSS
* VSS_02158   PAR_3_1_VSS   VSS
* VSS_02157   PAR_3_1_VSS   VSS
* VSS_02156   PAR_3_1_VSS   VSS
* VSS_02155   PAR_3_1_VSS   VSS
* VSS_02154   PAR_3_1_VSS   VSS
* VSS_02153   PAR_3_1_VSS   VSS
* VSS_02065   PAR_3_1_VSS   VSS
* VSS_00785   PAR_3_1_VSS   VSS
* VSS_00786   PAR_3_1_VSS   VSS
* VSS_00787   PAR_3_1_VSS   VSS
* VSS_00788   PAR_3_1_VSS   VSS
* VSS_00789   PAR_3_1_VSS   VSS
* VSS_00790   PAR_3_1_VSS   VSS
* VSS_00791   PAR_3_1_VSS   VSS
* VSS_00792   PAR_3_1_VSS   VSS
* VSS_00793   PAR_3_1_VSS   VSS
* VSS_00794   PAR_3_1_VSS   VSS
* VSS_00795   PAR_3_1_VSS   VSS
* VSS_00784   PAR_3_1_VSS   VSS
* VSS_02064   PAR_3_1_VSS   VSS
* VSS_02063   PAR_3_1_VSS   VSS
* VSS_02062   PAR_3_1_VSS   VSS
* VSS_02053   PAR_3_1_VSS   VSS
* VSS_02054   PAR_3_1_VSS   VSS
* VSS_02055   PAR_3_1_VSS   VSS
* VSS_02056   PAR_3_1_VSS   VSS
* VSS_02057   PAR_3_1_VSS   VSS
* VSS_02058   PAR_3_1_VSS   VSS
* VSS_02059   PAR_3_1_VSS   VSS
* VSS_02061   PAR_3_1_VSS   VSS
* VSS_01968   PAR_3_1_VSS   VSS
* VSS_00699   PAR_3_1_VSS   VSS
* VSS_00700   PAR_3_1_VSS   VSS
* VSS_00701   PAR_3_1_VSS   VSS
* VSS_00702   PAR_3_1_VSS   VSS
* VSS_00703   PAR_3_1_VSS   VSS
* VSS_01962   PAR_3_1_VSS   VSS
* VSS_01963   PAR_3_1_VSS   VSS
* VSS_01964   PAR_3_1_VSS   VSS
* VSS_01965   PAR_3_1_VSS   VSS
* VSS_01966   PAR_3_1_VSS   VSS
* VSS_01967   PAR_3_1_VSS   VSS
* VSS_01604   PAR_3_1_VSS   VSS
* VSS_01969   PAR_3_1_VSS   VSS
* VSS_01970   PAR_3_1_VSS   VSS
* VSS_01971   PAR_3_1_VSS   VSS
* VSS_01972   PAR_3_1_VSS   VSS
* VSS_01973   PAR_3_1_VSS   VSS
* VSS_01974   PAR_3_1_VSS   VSS
* VSS_01975   PAR_3_1_VSS   VSS
* VSS_02066   PAR_3_1_VSS   VSS
* VSS_00782   PAR_3_1_VSS   VSS
* VSS_00783   PAR_3_1_VSS   VSS
* VSS_01610   PAR_3_1_VSS   VSS
* VSS_01693   PAR_3_1_VSS   VSS
* VSS_01694   PAR_3_1_VSS   VSS
* VSS_01695   PAR_3_1_VSS   VSS
* VSS_01696   PAR_3_1_VSS   VSS
* VSS_01697   PAR_3_1_VSS   VSS
* VSS_01698   PAR_3_1_VSS   VSS
* VSS_01699   PAR_3_1_VSS   VSS
* VSS_01700   PAR_3_1_VSS   VSS
* VSS_01701   PAR_3_1_VSS   VSS
* VSS_01612   PAR_3_1_VSS   VSS
* VSS_01611   PAR_3_1_VSS   VSS
* VSS_01692   PAR_3_1_VSS   VSS
* VSS_01609   PAR_3_1_VSS   VSS
* VSS_01608   PAR_3_1_VSS   VSS
* VSS_01607   PAR_3_1_VSS   VSS
* VSS_01606   PAR_3_1_VSS   VSS
* VSS_01605   PAR_3_1_VSS   VSS
* VSS_01603   PAR_3_1_VSS   VSS
* VSS_01702   PAR_3_1_VSS   VSS
* VSS_00596   PAR_3_1_VSS   VSS
* VSS_00597   PAR_3_1_VSS   VSS
* VSS_00598   PAR_3_1_VSS   VSS
* VSS_00599   PAR_3_1_VSS   VSS
* VSS_00514   PAR_3_1_VSS   VSS
* VSS_00515   PAR_3_1_VSS   VSS
* VSS_00516   PAR_3_1_VSS   VSS
* VSS_00517   PAR_3_1_VSS   VSS
* VSS_00518   PAR_3_1_VSS   VSS
* VSS_00519   PAR_3_1_VSS   VSS
* VSS_00520   PAR_3_1_VSS   VSS
* VSS_00521   PAR_3_1_VSS   VSS
* VSS_02330   PAR_3_1_VSS   VSS
* VSS_02329   PAR_3_1_VSS   VSS
* VSS_02328   PAR_3_1_VSS   VSS
* VSS_02327   PAR_3_1_VSS   VSS
* VSS_01703   PAR_3_1_VSS   VSS
* VSS_00513   PAR_3_1_VSS   VSS
* VSS_00512   PAR_3_1_VSS   VSS
* VSS_02331   PAR_3_1_VSS   VSS
* VSS_02332   PAR_3_1_VSS   VSS
* VSS_02333   PAR_3_1_VSS   VSS
* VSS_01613   PAR_3_1_VSS   VSS
* VSS_02326   PAR_3_1_VSS   VSS
* VSS_00961   PAR_3_1_VSS   VSS
* VSS_01690   PAR_3_1_VSS   VSS
* VSS_01691   PAR_3_1_VSS   VSS
* VSS_01786   PAR_3_1_VSS   VSS
* VSS_00608   PAR_3_1_VSS   VSS
* VSS_00600   PAR_3_1_VSS   VSS
* VSS_00882   PAR_3_1_VSS   VSS
* VSS_02240   PAR_3_1_VSS   VSS
* VSS_02239   PAR_3_1_VSS   VSS
* VSS_02238   PAR_3_1_VSS   VSS
* VSS_02237   PAR_3_1_VSS   VSS
* VSS_02236   PAR_3_1_VSS   VSS
* VSS_01782   PAR_3_1_VSS   VSS
* VSS_01783   PAR_3_1_VSS   VSS
* VSS_01784   PAR_3_1_VSS   VSS
* VSS_01785   PAR_3_1_VSS   VSS
* VSS_00609   PAR_3_1_VSS   VSS
* VSS_01787   PAR_3_1_VSS   VSS
* VSS_01788   PAR_3_1_VSS   VSS
* VSS_01789   PAR_3_1_VSS   VSS
* VSS_01790   PAR_3_1_VSS   VSS
* VSS_01791   PAR_3_1_VSS   VSS
* VSS_01792   PAR_3_1_VSS   VSS
* VSS_01793   PAR_3_1_VSS   VSS
* VSS_01794   PAR_3_1_VSS   VSS
* VSS_01795   PAR_3_1_VSS   VSS
* VSS_00884   PAR_3_1_VSS   VSS
* VSS_00883   PAR_3_1_VSS   VSS
* VSS_00606   PAR_3_1_VSS   VSS
* VSS_00601   PAR_3_1_VSS   VSS
* VSS_00602   PAR_3_1_VSS   VSS
* VSS_00603   PAR_3_1_VSS   VSS
* VSS_01154   PAR_3_1_VSS   VSS
* VSS_01155   PAR_3_1_VSS   VSS
* VSS_01156   PAR_3_1_VSS   VSS
* VSS_01157   PAR_3_1_VSS   VSS
* VSS_02249   PAR_3_1_VSS   VSS
* VSS_02248   PAR_3_1_VSS   VSS
* VSS_02243   PAR_3_1_VSS   VSS
* VSS_00607   PAR_3_1_VSS   VSS
* VSS_00605   PAR_3_1_VSS   VSS
* VSS_00604   PAR_3_1_VSS   VSS
* VSS_02241   PAR_3_1_VSS   VSS
* VSS_02242   PAR_3_1_VSS   VSS
* VSS_02247   PAR_3_1_VSS   VSS
* VSS_02244   PAR_3_1_VSS   VSS
* VSS_02245   PAR_3_1_VSS   VSS
* VSS_02246   PAR_3_1_VSS   VSS
* VDD075NNE_00745   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00746   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00747   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00748   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00750   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00751   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00752   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00749   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00753   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00162   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00690   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00702   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00636   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00701   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00700   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00699   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00698   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00697   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00696   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00695   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00694   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00693   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00692   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00691   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00744   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00648   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00647   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00646   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00645   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00644   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00643   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00642   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00641   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00640   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00639   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00638   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00637   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01125   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01074   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01075   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01076   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01077   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01078   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01079   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01080   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01122   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01123   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01124   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01073   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01126   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01127   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01128   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01129   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01130   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01131   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01132   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01133   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01134   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01176   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01021   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00970   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00971   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00972   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01014   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01015   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01016   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01017   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01018   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01019   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01020   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01177   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01022   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01023   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01024   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01025   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01026   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01068   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01069   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01070   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01071   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01072   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01290   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01239   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01281   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01282   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01283   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01284   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01285   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01286   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01287   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01288   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01289   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01238   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01291   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01292   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01293   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00163   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00164   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00206   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00207   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00208   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00209   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00210   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01188   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01178   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01179   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01180   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01181   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01182   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01183   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01184   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01185   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01186   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01187   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00969   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01228   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01229   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01230   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01231   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01232   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01233   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01234   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01235   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01236   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_01237   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00047   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00098   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00056   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00055   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00054   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00053   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00052   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00051   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00050   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00049   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00048   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00099   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00046   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00045   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00044   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00754   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00755   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00756   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00798   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00799   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00800   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00801   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00110   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00161   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00160   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00159   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00158   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00157   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00156   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00155   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00154   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00153   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00152   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00802   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00109   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00108   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00107   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00106   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00105   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00104   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00103   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00102   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00101   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00100   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00917   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00907   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00908   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00909   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00910   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00911   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00912   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00913   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00914   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00915   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00916   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00906   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00918   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00960   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00961   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00962   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00963   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00964   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00965   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00966   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00967   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00968   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00854   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00803   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00804   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00805   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00806   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00807   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00808   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00809   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00810   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00852   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00853   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00593   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00855   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00856   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00857   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00858   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00859   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00860   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00861   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00862   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00863   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00864   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00424   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00374   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00375   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00376   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00377   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00378   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00379   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00380   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00422   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00423   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00373   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00425   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00426   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00427   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00428   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00429   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00430   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00431   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00432   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00433   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00322   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00272   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00314   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00315   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00316   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00317   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00318   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00319   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00320   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00321   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00434   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00323   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00324   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00325   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00326   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00368   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00369   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00370   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00371   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00372   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00584   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00536   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00537   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00538   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00539   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00540   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00541   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00542   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00582   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00583   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00535   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00585   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00586   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00587   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00588   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00589   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00590   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00591   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00592   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00594   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00485   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00476   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00477   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00478   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00479   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00480   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00481   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00482   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00483   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00484   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00212   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00486   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00487   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00488   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00530   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00531   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00532   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00533   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00534   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00211   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00265   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00264   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00263   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00218   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00217   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00262   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00261   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00260   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00266   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00267   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00268   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00270   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00213   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00214   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00215   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00216   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00269   PAR_3_1_VDD075NNE   VDD075NNE
* VDD075NNE_00271   PAR_3_1_VDD075NNE   VDD075NNE
* VSS_02649   PAR_0_0_VSS   VSS
* VSS_02648   PAR_0_0_VSS   VSS
* VSS_02650   PAR_0_0_VSS   VSS
* VSS_02651   PAR_0_0_VSS   VSS
* VSS_02647   PAR_0_0_VSS   VSS
* VSS_04150   PAR_0_0_VSS   VSS
* VSS_03297   PAR_0_0_VSS   VSS
* VSS_04151   PAR_0_0_VSS   VSS
* VSS_04152   PAR_0_0_VSS   VSS
* VSS_04153   PAR_0_0_VSS   VSS
* VSS_04154   PAR_0_0_VSS   VSS
* VSS_04155   PAR_0_0_VSS   VSS
* VSS_04156   PAR_0_0_VSS   VSS
* VSS_04157   PAR_0_0_VSS   VSS
* VSS_04158   PAR_0_0_VSS   VSS
* VSS_04159   PAR_0_0_VSS   VSS
* VSS_04160   PAR_0_0_VSS   VSS
* VSS_04161   PAR_0_0_VSS   VSS
* VSS_04162   PAR_0_0_VSS   VSS
* VSS_02646   PAR_0_0_VSS   VSS
* VSS_03964   PAR_0_0_VSS   VSS
* VSS_03298   PAR_0_0_VSS   VSS
* VSS_03299   PAR_0_0_VSS   VSS
* VSS_03300   PAR_0_0_VSS   VSS
* VSS_04059   PAR_0_0_VSS   VSS
* VSS_03304   PAR_0_0_VSS   VSS
* VSS_03965   PAR_0_0_VSS   VSS
* VSS_03966   PAR_0_0_VSS   VSS
* VSS_03967   PAR_0_0_VSS   VSS
* VSS_03968   PAR_0_0_VSS   VSS
* VSS_03969   PAR_0_0_VSS   VSS
* VSS_03970   PAR_0_0_VSS   VSS
* VSS_03971   PAR_0_0_VSS   VSS
* VSS_03972   PAR_0_0_VSS   VSS
* VSS_03301   PAR_0_0_VSS   VSS
* VSS_04055   PAR_0_0_VSS   VSS
* VSS_04056   PAR_0_0_VSS   VSS
* VSS_04057   PAR_0_0_VSS   VSS
* VSS_04058   PAR_0_0_VSS   VSS
* VSS_02652   PAR_0_0_VSS   VSS
* VSS_04060   PAR_0_0_VSS   VSS
* VSS_04061   PAR_0_0_VSS   VSS
* VSS_04062   PAR_0_0_VSS   VSS
* VSS_04063   PAR_0_0_VSS   VSS
* VSS_04064   PAR_0_0_VSS   VSS
* VSS_04065   PAR_0_0_VSS   VSS
* VSS_04066   PAR_0_0_VSS   VSS
* VSS_04067   PAR_0_0_VSS   VSS
* VSS_02658   PAR_0_0_VSS   VSS
* VSS_02657   PAR_0_0_VSS   VSS
* VSS_02656   PAR_0_0_VSS   VSS
* VSS_02655   PAR_0_0_VSS   VSS
* VSS_02654   PAR_0_0_VSS   VSS
* VSS_02653   PAR_0_0_VSS   VSS
* VSS_03204   PAR_0_0_VSS   VSS
* VSS_03018   PAR_0_0_VSS   VSS
* VSS_03017   PAR_0_0_VSS   VSS
* VSS_03016   PAR_0_0_VSS   VSS
* VSS_03015   PAR_0_0_VSS   VSS
* VSS_03014   PAR_0_0_VSS   VSS
* VSS_03201   PAR_0_0_VSS   VSS
* VSS_03202   PAR_0_0_VSS   VSS
* VSS_03203   PAR_0_0_VSS   VSS
* VSS_03019   PAR_0_0_VSS   VSS
* VSS_03205   PAR_0_0_VSS   VSS
* VSS_03206   PAR_0_0_VSS   VSS
* VSS_03207   PAR_0_0_VSS   VSS
* VSS_03208   PAR_0_0_VSS   VSS
* VSS_03209   PAR_0_0_VSS   VSS
* VSS_03210   PAR_0_0_VSS   VSS
* VSS_02557   PAR_0_0_VSS   VSS
* VSS_02558   PAR_0_0_VSS   VSS
* VSS_03020   PAR_0_0_VSS   VSS
* VSS_03021   PAR_0_0_VSS   VSS
* VSS_03116   PAR_0_0_VSS   VSS
* VSS_03115   PAR_0_0_VSS   VSS
* VSS_03114   PAR_0_0_VSS   VSS
* VSS_03113   PAR_0_0_VSS   VSS
* VSS_03112   PAR_0_0_VSS   VSS
* VSS_03111   PAR_0_0_VSS   VSS
* VSS_03110   PAR_0_0_VSS   VSS
* VSS_03109   PAR_0_0_VSS   VSS
* VSS_03108   PAR_0_0_VSS   VSS
* VSS_03107   PAR_0_0_VSS   VSS
* VSS_03106   PAR_0_0_VSS   VSS
* VSS_03105   PAR_0_0_VSS   VSS
* VSS_03104   PAR_0_0_VSS   VSS
* VSS_04245   PAR_0_0_VSS   VSS
* VSS_04253   PAR_0_0_VSS   VSS
* VSS_04252   PAR_0_0_VSS   VSS
* VSS_04251   PAR_0_0_VSS   VSS
* VSS_04250   PAR_0_0_VSS   VSS
* VSS_04249   PAR_0_0_VSS   VSS
* VSS_04248   PAR_0_0_VSS   VSS
* VSS_04247   PAR_0_0_VSS   VSS
* VSS_04246   PAR_0_0_VSS   VSS
* VSS_04254   PAR_0_0_VSS   VSS
* VSS_03212   PAR_0_0_VSS   VSS
* VSS_03213   PAR_0_0_VSS   VSS
* VSS_03013   PAR_0_0_VSS   VSS
* VSS_03012   PAR_0_0_VSS   VSS
* VSS_03011   PAR_0_0_VSS   VSS
* VSS_03010   PAR_0_0_VSS   VSS
* VSS_03009   PAR_0_0_VSS   VSS
* VSS_03296   PAR_0_0_VSS   VSS
* VSS_04255   PAR_0_0_VSS   VSS
* VSS_04256   PAR_0_0_VSS   VSS
* VSS_04257   PAR_0_0_VSS   VSS
* VSS_03211   PAR_0_0_VSS   VSS
* VSS_02569   PAR_0_0_VSS   VSS
* VSS_02568   PAR_0_0_VSS   VSS
* VSS_02567   PAR_0_0_VSS   VSS
* VSS_02566   PAR_0_0_VSS   VSS
* VSS_02565   PAR_0_0_VSS   VSS
* VSS_02564   PAR_0_0_VSS   VSS
* VSS_02563   PAR_0_0_VSS   VSS
* VSS_02562   PAR_0_0_VSS   VSS
* VSS_02561   PAR_0_0_VSS   VSS
* VSS_02560   PAR_0_0_VSS   VSS
* VSS_02559   PAR_0_0_VSS   VSS
* VSS_03584   PAR_0_0_VSS   VSS
* VSS_03395   PAR_0_0_VSS   VSS
* VSS_03394   PAR_0_0_VSS   VSS
* VSS_03393   PAR_0_0_VSS   VSS
* VSS_03392   PAR_0_0_VSS   VSS
* VSS_03391   PAR_0_0_VSS   VSS
* VSS_02840   PAR_0_0_VSS   VSS
* VSS_02839   PAR_0_0_VSS   VSS
* VSS_02838   PAR_0_0_VSS   VSS
* VSS_02837   PAR_0_0_VSS   VSS
* VSS_02836   PAR_0_0_VSS   VSS
* VSS_02835   PAR_0_0_VSS   VSS
* VSS_03580   PAR_0_0_VSS   VSS
* VSS_03581   PAR_0_0_VSS   VSS
* VSS_03582   PAR_0_0_VSS   VSS
* VSS_03583   PAR_0_0_VSS   VSS
* VSS_02917   PAR_0_0_VSS   VSS
* VSS_03585   PAR_0_0_VSS   VSS
* VSS_03586   PAR_0_0_VSS   VSS
* VSS_03587   PAR_0_0_VSS   VSS
* VSS_03588   PAR_0_0_VSS   VSS
* VSS_03589   PAR_0_0_VSS   VSS
* VSS_03590   PAR_0_0_VSS   VSS
* VSS_03591   PAR_0_0_VSS   VSS
* VSS_03592   PAR_0_0_VSS   VSS
* VSS_02834   PAR_0_0_VSS   VSS
* VSS_03675   PAR_0_0_VSS   VSS
* VSS_03676   PAR_0_0_VSS   VSS
* VSS_03677   PAR_0_0_VSS   VSS
* VSS_03678   PAR_0_0_VSS   VSS
* VSS_03679   PAR_0_0_VSS   VSS
* VSS_03680   PAR_0_0_VSS   VSS
* VSS_02920   PAR_0_0_VSS   VSS
* VSS_03398   PAR_0_0_VSS   VSS
* VSS_03399   PAR_0_0_VSS   VSS
* VSS_03400   PAR_0_0_VSS   VSS
* VSS_03401   PAR_0_0_VSS   VSS
* VSS_03402   PAR_0_0_VSS   VSS
* VSS_03396   PAR_0_0_VSS   VSS
* VSS_02929   PAR_0_0_VSS   VSS
* VSS_02928   PAR_0_0_VSS   VSS
* VSS_02927   PAR_0_0_VSS   VSS
* VSS_02926   PAR_0_0_VSS   VSS
* VSS_02925   PAR_0_0_VSS   VSS
* VSS_02924   PAR_0_0_VSS   VSS
* VSS_02923   PAR_0_0_VSS   VSS
* VSS_02922   PAR_0_0_VSS   VSS
* VSS_02921   PAR_0_0_VSS   VSS
* VSS_03681   PAR_0_0_VSS   VSS
* VSS_02919   PAR_0_0_VSS   VSS
* VSS_02918   PAR_0_0_VSS   VSS
* VSS_03485   PAR_0_0_VSS   VSS
* VSS_03486   PAR_0_0_VSS   VSS
* VSS_03487   PAR_0_0_VSS   VSS
* VSS_03488   PAR_0_0_VSS   VSS
* VSS_03489   PAR_0_0_VSS   VSS
* VSS_03490   PAR_0_0_VSS   VSS
* VSS_03491   PAR_0_0_VSS   VSS
* VSS_03492   PAR_0_0_VSS   VSS
* VSS_03493   PAR_0_0_VSS   VSS
* VSS_03494   PAR_0_0_VSS   VSS
* VSS_03495   PAR_0_0_VSS   VSS
* VSS_03496   PAR_0_0_VSS   VSS
* VSS_03497   PAR_0_0_VSS   VSS
* VSS_03873   PAR_0_0_VSS   VSS
* VSS_02744   PAR_0_0_VSS   VSS
* VSS_02743   PAR_0_0_VSS   VSS
* VSS_02742   PAR_0_0_VSS   VSS
* VSS_02741   PAR_0_0_VSS   VSS
* VSS_02740   PAR_0_0_VSS   VSS
* VSS_02739   PAR_0_0_VSS   VSS
* VSS_02738   PAR_0_0_VSS   VSS
* VSS_03865   PAR_0_0_VSS   VSS
* VSS_03866   PAR_0_0_VSS   VSS
* VSS_03867   PAR_0_0_VSS   VSS
* VSS_03868   PAR_0_0_VSS   VSS
* VSS_03869   PAR_0_0_VSS   VSS
* VSS_03870   PAR_0_0_VSS   VSS
* VSS_03871   PAR_0_0_VSS   VSS
* VSS_03872   PAR_0_0_VSS   VSS
* VSS_02745   PAR_0_0_VSS   VSS
* VSS_03874   PAR_0_0_VSS   VSS
* VSS_03875   PAR_0_0_VSS   VSS
* VSS_03876   PAR_0_0_VSS   VSS
* VSS_03877   PAR_0_0_VSS   VSS
* VSS_02737   PAR_0_0_VSS   VSS
* VSS_03308   PAR_0_0_VSS   VSS
* VSS_03307   PAR_0_0_VSS   VSS
* VSS_03306   PAR_0_0_VSS   VSS
* VSS_03305   PAR_0_0_VSS   VSS
* VSS_03397   PAR_0_0_VSS   VSS
* VSS_03303   PAR_0_0_VSS   VSS
* VSS_03302   PAR_0_0_VSS   VSS
* VSS_03960   PAR_0_0_VSS   VSS
* VSS_03961   PAR_0_0_VSS   VSS
* VSS_03962   PAR_0_0_VSS   VSS
* VSS_03772   PAR_0_0_VSS   VSS
* VSS_03682   PAR_0_0_VSS   VSS
* VSS_03683   PAR_0_0_VSS   VSS
* VSS_03684   PAR_0_0_VSS   VSS
* VSS_03685   PAR_0_0_VSS   VSS
* VSS_03686   PAR_0_0_VSS   VSS
* VSS_03687   PAR_0_0_VSS   VSS
* VSS_02833   PAR_0_0_VSS   VSS
* VSS_02832   PAR_0_0_VSS   VSS
* VSS_02831   PAR_0_0_VSS   VSS
* VSS_02830   PAR_0_0_VSS   VSS
* VSS_02829   PAR_0_0_VSS   VSS
* VSS_02828   PAR_0_0_VSS   VSS
* VSS_03390   PAR_0_0_VSS   VSS
* VSS_03770   PAR_0_0_VSS   VSS
* VSS_03771   PAR_0_0_VSS   VSS
* VSS_03963   PAR_0_0_VSS   VSS
* VSS_03773   PAR_0_0_VSS   VSS
* VSS_03774   PAR_0_0_VSS   VSS
* VSS_03775   PAR_0_0_VSS   VSS
* VSS_03776   PAR_0_0_VSS   VSS
* VSS_03777   PAR_0_0_VSS   VSS
* VSS_03778   PAR_0_0_VSS   VSS
* VSS_03779   PAR_0_0_VSS   VSS
* VSS_03780   PAR_0_0_VSS   VSS
* VSS_03781   PAR_0_0_VSS   VSS
* VSS_03782   PAR_0_0_VSS   VSS
* VSS_02749   PAR_0_0_VSS   VSS
* VSS_02748   PAR_0_0_VSS   VSS
* VSS_02747   PAR_0_0_VSS   VSS
* VSS_02746   PAR_0_0_VSS   VSS

* No connection to global ground (Spice node 0) *
G0_1 PAR_0_0_VDD075NNE PAR_0_0_VSS PAR_0_0_VDD075NNE PAR_0_0_VSS -0.0184733093274
C0_1 PAR_0_0_VDD075NNE PAR_0_0_VSS 1.76518976662e-09
R_1_1 PAR_0_0_VDD075NNE n17 0.00023783977852
C_1_1 n17 PAR_0_0_VSS 5.93229268207e-08
R_2_1 PAR_0_0_VDD075NNE n18 0.000567318472783
C_2_1 n18 PAR_0_0_VSS 5.53865144867e-08
R_3_1 PAR_0_0_VDD075NNE n19 0.164732465067
C_3_1 n19 PAR_0_0_VSS 5.91605095037e-10
R_4_1 PAR_0_0_VDD075NNE n20 1.26295098032
R_7_1 PAR_0_0_VDD075NNE n20 1778000
C_4_1 n20 PAR_0_0_VSS 2.83672626402e-10
R_5_1 PAR_0_0_VDD075NNE n21 7.01645410484
R_8_1 PAR_0_0_VDD075NNE n21 1889000
C_5_1 n21 PAR_0_0_VSS 2.73268520813e-10
L_6_1 PAR_0_0_VDD075NNE n22 6.25714680802e-07
R_6_1 n22 PAR_0_0_VSS 54.1321445097
G0_2 PAR_1_0_VSS PAR_0_0_VDD075NNE PAR_1_0_VSS PAR_0_0_VDD075NNE -0.0558402389441
C0_2 PAR_1_0_VSS PAR_0_0_VDD075NNE 2.04397933727e-10
R_1_2 PAR_1_0_VSS n23 0.00440445437612
C_1_2 n23 PAR_0_0_VDD075NNE 3.20434372253e-09
R_2_2 PAR_1_0_VSS n24 0.0085152105941
C_2_2 n24 PAR_0_0_VDD075NNE 3.61256432818e-09
L_3_2 PAR_1_0_VSS n25 4.94108732509e-09
R_3_2 n25 PAR_0_0_VDD075NNE 24.7700425165
R_4_2 PAR_1_0_VSS n26 5.8466521971
R_9_2 PAR_1_0_VSS n26 1666000
C_4_2 n26 PAR_0_0_VDD075NNE 7.09382995646e-11
R_5_2 PAR_1_0_VSS n27 11.0735572606
R_10_2 PAR_1_0_VSS n27 1484000
C_5_2 n27 PAR_0_0_VDD075NNE 1.62207588336e-10
L_6_2 PAR_1_0_VSS n28 6.8552676963e-07
R_6_2 n28 PAR_0_0_VDD075NNE 64.645860991
R0_3 PAR_1_0_VSS PAR_0_0_VSS 0.00291787960813
L_1_3 PAR_1_0_VSS n29 1.42356097241e-13
R_1_3 n29 PAR_0_0_VSS 0.00596202697554
R_2_3 PAR_1_0_VSS n30 0.292414042655
C_2_3 n30 PAR_0_0_VSS 6.80099356271e-10
L_3_3 PAR_1_0_VSS n31 7.05642405359e-11
R_3_3 n31 PAR_0_0_VSS 0.181821965604
L_4_3 PAR_1_0_VSS n32 5.69297052758e-10
R_4_3 n32 PAR_0_0_VSS 0.161727071201
L_5_3 PAR_1_0_VSS n33 4.15267569018e-09
R_5_3 n33 PAR_0_0_VSS 0.421878738207
R0_4 PAR_1_0_VDD075NNE PAR_0_0_VDD075NNE 0.00344995455113
C0_4 PAR_1_0_VDD075NNE PAR_0_0_VDD075NNE 7.02017726412e-11
L_1_4 PAR_1_0_VDD075NNE n34 1.25873189806e-13
R_1_4 n34 PAR_0_0_VDD075NNE 0.00767694841026
L_2_4 PAR_1_0_VDD075NNE n35 4.3160027081e-13
R_2_4 n35 PAR_0_0_VDD075NNE 0.0134719580126
L_3_4 PAR_1_0_VDD075NNE n36 3.49462309769e-10
R_3_4 n36 PAR_0_0_VDD075NNE 3.98515797627
L_4_4 PAR_1_0_VDD075NNE n37 2.10535081218e-08
R_4_4 n37 PAR_0_0_VDD075NNE 57.7169286788
L_5_4 PAR_1_0_VDD075NNE n38 1.94837732047e-07
R_5_4 n38 PAR_0_0_VDD075NNE 157.736248977
L_6_4 PAR_1_0_VDD075NNE n39 4.93694304289e-05
R_6_4 n39 PAR_0_0_VDD075NNE 3633.16227217
G0_5 PAR_1_0_VDD075NNE PAR_1_0_VSS PAR_1_0_VDD075NNE PAR_1_0_VSS -0.013535635826
C0_5 PAR_1_0_VDD075NNE PAR_1_0_VSS 1.20459420361e-09
R_1_5 PAR_1_0_VDD075NNE n40 0.00023786896752
C_1_5 n40 PAR_1_0_VSS 5.53751034899e-08
R_2_5 PAR_1_0_VDD075NNE n41 0.000579957361358
C_2_5 n41 PAR_1_0_VSS 5.14861723937e-08
R_3_5 PAR_1_0_VDD075NNE n42 0.0916047212506
C_3_5 n42 PAR_1_0_VSS 7.88264476134e-10
R_4_5 PAR_1_0_VDD075NNE n43 2.97517254599
C_4_5 n43 PAR_1_0_VSS 1.17053469256e-10
R_5_5 PAR_1_0_VDD075NNE n44 9.36796986655
C_5_5 n44 PAR_1_0_VSS 1.66206326686e-10
L_6_5 PAR_1_0_VDD075NNE n45 8.22345041192e-07
R_6_5 n45 PAR_1_0_VSS 73.8790379495
G0_6 PAR_1_0_VDD075NNE PAR_0_0_VSS PAR_1_0_VDD075NNE PAR_0_0_VSS -0.0690790583589
C0_6 PAR_1_0_VDD075NNE PAR_0_0_VSS 1.26693911951e-10
R_1_6 PAR_1_0_VDD075NNE n46 0.0145612037667
C_1_6 n46 PAR_0_0_VSS 1.18949538638e-09
R_2_6 PAR_1_0_VDD075NNE n47 0.0211248790038
C_2_6 n47 PAR_0_0_VSS 1.53165524197e-09
L_3_6 PAR_1_0_VDD075NNE n48 2.44363040324e-09
R_3_6 n48 PAR_0_0_VSS 21.6614888507
R_4_6 PAR_1_0_VDD075NNE n49 5.48560002656
C_4_6 n49 PAR_0_0_VSS 7.33820126332e-11
R_5_6 PAR_1_0_VDD075NNE n50 12.2527426783
C_5_6 n50 PAR_0_0_VSS 1.77265419077e-10
L_6_6 PAR_1_0_VDD075NNE n51 4.25901408535e-07
R_6_6 n51 PAR_0_0_VSS 43.641093837
G0_7 PAR_2_0_VSS PAR_0_0_VDD075NNE PAR_2_0_VSS PAR_0_0_VDD075NNE -1.73636010747
C0_7 PAR_2_0_VSS PAR_0_0_VDD075NNE 1.29029114606e-10
R_1_7 PAR_2_0_VSS n52 0.787071331393
C_1_7 n52 PAR_0_0_VDD075NNE 1.75764123692e-11
L_2_7 PAR_2_0_VSS n53 2.35299644743e-11
R_2_7 n53 PAR_0_0_VDD075NNE 0.657513268774
R_3_7 PAR_2_0_VSS n54 5.38070605778
C_3_7 n54 PAR_0_0_VDD075NNE 2.83124322631e-11
L_4_7 PAR_2_0_VSS n55 4.5681822521e-09
R_4_7 n55 PAR_0_0_VDD075NNE 12.0308331141
R_5_7 PAR_2_0_VSS n56 4.44054635892
C_5_7 n56 PAR_0_0_VDD075NNE 1.71950700151e-10
L_6_7 PAR_2_0_VSS n57 1.21163817619e-08
R_6_7 n57 PAR_0_0_VDD075NNE 8.84119842145
R_7_7 PAR_2_0_VSS n58 18.2546692466
C_7_7 n58 PAR_0_0_VDD075NNE 1.64110626043e-10
L_8_7 PAR_2_0_VSS n59 4.79180818014e-07
R_8_7 n59 PAR_0_0_VDD075NNE 51.9435894597
R0_8 PAR_2_0_VSS PAR_1_0_VSS 0.00331887189638
L_1_8 PAR_2_0_VSS n60 1.19366202074e-13
R_1_8 n60 PAR_1_0_VSS 0.00514797718304
L_2_8 PAR_2_0_VSS n61 1.7098014768e-11
R_2_8 n61 PAR_1_0_VSS 0.20921456864
L_3_8 PAR_2_0_VSS n62 7.58148868207e-11
R_3_8 n62 PAR_1_0_VSS 0.244200709222
L_4_8 PAR_2_0_VSS n63 3.92674291374e-10
R_4_8 n63 PAR_1_0_VSS 0.583666572048
L_5_8 PAR_2_0_VSS n64 5.71140127114e-10
R_5_8 n64 PAR_1_0_VSS 0.257301210297
L_6_8 PAR_2_0_VSS n65 7.70123447147e-09
R_6_8 n65 PAR_1_0_VSS 0.885580342424
G0_9 PAR_2_0_VSS PAR_1_0_VDD075NNE PAR_2_0_VSS PAR_1_0_VDD075NNE -0.00852747614327
C0_9 PAR_2_0_VSS PAR_1_0_VDD075NNE 1.05794858591e-10
R_1_9 PAR_2_0_VSS n66 0.0116218625806
C_1_9 n66 PAR_1_0_VDD075NNE 1.77418466795e-09
R_2_9 PAR_2_0_VSS n67 0.0515358902426
C_2_9 n67 PAR_1_0_VDD075NNE 7.44719357351e-10
R_3_9 PAR_2_0_VSS n68 7.32163409851
C_3_9 n68 PAR_1_0_VDD075NNE 1.92358159315e-11
R_4_9 PAR_2_0_VSS n69 7.73677060224
C_4_9 n69 PAR_1_0_VDD075NNE 5.59246370885e-11
R_5_9 PAR_2_0_VSS n70 20.5994483472
C_5_9 n70 PAR_1_0_VDD075NNE 7.92715362294e-11
L_6_9 PAR_2_0_VSS n71 1.17378400151e-06
R_6_9 n71 PAR_1_0_VDD075NNE 117.267949379
R0_10 PAR_2_0_VSS PAR_0_0_VSS 0.901489099116
C0_10 PAR_2_0_VSS PAR_0_0_VSS 1.71355160611e-10
R_1_10 PAR_2_0_VSS n72 0.805030512053
C_1_10 n72 PAR_0_0_VSS 7.41427551296e-11
R_2_10 PAR_2_0_VSS n73 1.48785630196
C_2_10 n73 PAR_0_0_VSS 3.38450170223e-10
R_3_10 PAR_2_0_VSS n74 0.449635433249
C_3_10 n74 PAR_0_0_VSS 4.06416834943e-09
L_4_10 PAR_2_0_VSS n75 5.23173290892e-09
R_4_10 n75 PAR_0_0_VSS 1.04925710734
L_5_10 PAR_2_0_VSS n76 8.11861892065e-09
R_5_10 n76 PAR_0_0_VSS 0.841582601229
G0_11 PAR_2_0_VDD075NNE PAR_0_0_VDD075NNE PAR_2_0_VDD075NNE PAR_0_0_VDD075NNE -5.60200154636
C0_11 PAR_2_0_VDD075NNE PAR_0_0_VDD075NNE 1.107653288e-10
R_1_11 PAR_2_0_VDD075NNE n77 0.223158024302
C_1_11 n77 PAR_0_0_VDD075NNE 5.8816999555e-11
L_2_11 PAR_2_0_VDD075NNE n78 7.06894987052e-12
R_2_11 n78 PAR_0_0_VDD075NNE 0.193425625416
R_3_11 PAR_2_0_VDD075NNE n79 1.04051303389
C_3_11 n79 PAR_0_0_VDD075NNE 7.04054177582e-11
L_4_11 PAR_2_0_VDD075NNE n80 5.00321703597e-10
R_4_11 n80 PAR_0_0_VDD075NNE 2.97412848038
R_5_11 PAR_2_0_VDD075NNE n81 7.97991922576
C_5_11 n81 PAR_0_0_VDD075NNE 5.07512695272e-11
L_6_11 PAR_2_0_VDD075NNE n82 1.05013319745e-08
R_6_11 n82 PAR_0_0_VDD075NNE 11.0398636423
R_7_11 PAR_2_0_VDD075NNE n83 28.9912599153
C_7_11 n83 PAR_0_0_VDD075NNE 6.42453994404e-11
L_8_11 PAR_2_0_VDD075NNE n84 1.74247169236e-06
R_8_11 n84 PAR_0_0_VDD075NNE 193.762701377
G0_12 PAR_2_0_VDD075NNE PAR_1_0_VSS PAR_2_0_VDD075NNE PAR_1_0_VSS -0.0172654845886
C0_12 PAR_2_0_VDD075NNE PAR_1_0_VSS 2.10265965687e-10
R_1_12 PAR_2_0_VDD075NNE n85 0.00351009807921
C_1_12 n85 PAR_1_0_VSS 4.50510198974e-09
R_2_12 PAR_2_0_VDD075NNE n86 0.0131319102368
C_2_12 n86 PAR_1_0_VSS 2.5947969669e-09
R_3_12 PAR_2_0_VDD075NNE n87 2.4601780125
C_3_12 n87 PAR_1_0_VSS 4.12049228341e-11
R_4_12 PAR_2_0_VDD075NNE n88 5.93292498323
C_4_12 n88 PAR_1_0_VSS 7.04087381315e-11
R_5_12 PAR_2_0_VDD075NNE n89 10.7371160082
C_5_12 n89 PAR_1_0_VSS 1.59850543378e-10
L_6_12 PAR_2_0_VDD075NNE n90 5.82822533047e-07
R_6_12 n90 PAR_1_0_VSS 57.9190106655
R0_13 PAR_2_0_VDD075NNE PAR_1_0_VDD075NNE 0.00372480345999
C0_13 PAR_2_0_VDD075NNE PAR_1_0_VDD075NNE 6.95098514495e-11
L_1_13 PAR_2_0_VDD075NNE n91 9.70342160209e-14
R_1_13 n91 PAR_1_0_VDD075NNE 0.00595976323333
L_2_13 PAR_2_0_VDD075NNE n92 6.97519372043e-13
R_2_13 n92 PAR_1_0_VDD075NNE 0.0204058415365
L_3_13 PAR_2_0_VDD075NNE n93 1.63473101459e-10
R_3_13 n93 PAR_1_0_VDD075NNE 1.9593092863
L_4_13 PAR_2_0_VDD075NNE n94 2.55532879083e-08
R_4_13 n94 PAR_1_0_VDD075NNE 62.2560346305
L_5_13 PAR_2_0_VDD075NNE n95 3.01032673146e-07
R_5_13 n95 PAR_1_0_VDD075NNE 202.351072505
L_6_13 PAR_2_0_VDD075NNE n96 0.00505428670637
R_6_13 n96 PAR_1_0_VDD075NNE 2514.27858737
G0_14 PAR_2_0_VDD075NNE PAR_2_0_VSS PAR_2_0_VDD075NNE PAR_2_0_VSS -0.00822230689573
C0_14 PAR_2_0_VDD075NNE PAR_2_0_VSS 1.01336490872e-09
R_1_14 PAR_2_0_VDD075NNE n97 0.000244325490111
C_1_14 n97 PAR_2_0_VSS 5.19040840923e-08
R_2_14 PAR_2_0_VDD075NNE n98 0.000539886254275
C_2_14 n98 PAR_2_0_VSS 5.39284374003e-08
R_3_14 PAR_2_0_VDD075NNE n99 0.0545565491407
C_3_14 n99 PAR_2_0_VSS 1.10638742617e-09
R_4_14 PAR_2_0_VDD075NNE n100 4.58656043468
C_4_14 n100 PAR_2_0_VSS 8.1835775903e-11
R_5_14 PAR_2_0_VDD075NNE n101 15.5379305227
C_5_14 n101 PAR_2_0_VSS 9.19617248285e-11
L_6_14 PAR_2_0_VDD075NNE n102 1.3330386604e-06
R_6_14 n102 PAR_2_0_VSS 121.620319112
G0_15 PAR_2_0_VDD075NNE PAR_0_0_VSS PAR_2_0_VDD075NNE PAR_0_0_VSS -0.0259597126108
C0_15 PAR_2_0_VDD075NNE PAR_0_0_VSS 1.68340341558e-10
R_1_15 PAR_2_0_VDD075NNE n103 0.403107860473
C_1_15 n103 PAR_0_0_VSS 7.38860184016e-11
R_2_15 PAR_2_0_VDD075NNE n104 6.2635479708
C_2_15 n104 PAR_0_0_VSS 6.24134802987e-11
R_3_15 PAR_2_0_VDD075NNE n105 12.6005039709
C_3_15 n105 PAR_0_0_VSS 1.69907956876e-10
L_4_15 PAR_2_0_VDD075NNE n106 3.69582274918e-07
R_4_15 n106 PAR_0_0_VSS 38.5212229977
G0_16 PAR_3_0_VSS PAR_0_0_VDD075NNE PAR_3_0_VSS PAR_0_0_VDD075NNE -1.03087844606
C0_16 PAR_3_0_VSS PAR_0_0_VDD075NNE 2.47765365155e-10
R_1_16 PAR_3_0_VSS n107 0.0386551015824
C_1_16 n107 PAR_0_0_VDD075NNE 4.91504112891e-10
R_2_16 PAR_3_0_VSS n108 0.25326248063
C_2_16 n108 PAR_0_0_VDD075NNE 1.94920964382e-10
L_3_16 PAR_3_0_VSS n109 1.18696150457e-10
R_3_16 n109 PAR_0_0_VDD075NNE 0.970046468207
R_4_16 PAR_3_0_VSS n110 3.34919894431
C_4_16 n110 PAR_0_0_VDD075NNE 1.2032536471e-10
R_5_16 PAR_3_0_VSS n111 3.59130791768
C_5_16 n111 PAR_0_0_VDD075NNE 2.64312033408e-10
R_6_16 PAR_3_0_VSS n112 37.1760145234
C_6_16 n112 PAR_0_0_VDD075NNE 3.03583386347e-10
R0_17 PAR_3_0_VSS PAR_1_0_VSS 0.144667054321
C0_17 PAR_3_0_VSS PAR_1_0_VSS 2.48879199003e-10
R_1_17 PAR_3_0_VSS n113 0.0882435225141
C_1_17 n113 PAR_1_0_VSS 2.90578886522e-10
R_2_17 PAR_3_0_VSS n114 0.0982780379293
C_2_17 n114 PAR_1_0_VSS 9.80591767247e-10
R_3_17 PAR_3_0_VSS n115 0.46591920642
C_3_17 n115 PAR_1_0_VSS 6.3015103023e-10
R_4_17 PAR_3_0_VSS n116 0.4142244423
C_4_17 n116 PAR_1_0_VSS 1.81963415004e-09
R_5_17 PAR_3_0_VSS n117 0.193466099465
C_5_17 n117 PAR_1_0_VSS 1.89042040059e-08
R_6_17 PAR_3_0_VSS n118 0.403170676022
C_6_17 n118 PAR_1_0_VSS 2.5156857764e-08
G0_18 PAR_3_0_VSS PAR_1_0_VDD075NNE PAR_3_0_VSS PAR_1_0_VDD075NNE -0.546927021078
C0_18 PAR_3_0_VSS PAR_1_0_VDD075NNE 2.11815479442e-10
R_1_18 PAR_3_0_VSS n119 0.0465460971028
C_1_18 n119 PAR_1_0_VDD075NNE 3.40732187603e-10
R_2_18 PAR_3_0_VSS n120 0.235807052646
C_2_18 n120 PAR_1_0_VDD075NNE 2.00136899221e-10
L_3_18 PAR_3_0_VSS n121 2.27734372506e-10
R_3_18 n121 PAR_1_0_VDD075NNE 1.82839748852
R_4_18 PAR_3_0_VSS n122 3.12339367557
C_4_18 n122 PAR_1_0_VDD075NNE 1.39967371027e-10
R_5_18 PAR_3_0_VSS n123 4.39745800775
C_5_18 n123 PAR_1_0_VDD075NNE 2.34190148745e-10
R_6_18 PAR_3_0_VSS n124 33.7179624832
C_6_18 n124 PAR_1_0_VDD075NNE 2.97875148654e-10
R0_19 PAR_3_0_VSS PAR_2_0_VSS 0.00271375136643
L_1_19 PAR_3_0_VSS n125 1.63456971188e-13
R_1_19 n125 PAR_2_0_VSS 0.00667984748722
R_2_19 PAR_3_0_VSS n126 0.292087358214
C_2_19 n126 PAR_2_0_VSS 6.20626104683e-10
L_3_19 PAR_3_0_VSS n127 8.83573767794e-11
R_3_19 n127 PAR_2_0_VSS 0.222368260463
L_4_19 PAR_3_0_VSS n128 9.39903633912e-10
R_4_19 n128 PAR_2_0_VSS 0.574227868333
R_5_19 PAR_3_0_VSS n129 0.842590082739
C_5_19 n129 PAR_2_0_VSS 8.92370066471e-09
R_6_19 PAR_3_0_VSS n130 2.62136232093
C_6_19 n130 PAR_2_0_VSS 5.45402563217e-09
C0_20 PAR_3_0_VSS PAR_2_0_VDD075NNE 1.55245636237e-10
R_1_20 PAR_3_0_VSS n131 0.00402820562117
C_1_20 n131 PAR_2_0_VDD075NNE 3.2307516007e-09
R_2_20 PAR_3_0_VSS n132 0.00767951140059
C_2_20 n132 PAR_2_0_VDD075NNE 4.04265875791e-09
R_3_20 PAR_3_0_VSS n133 2.00522681014
C_3_20 n133 PAR_2_0_VDD075NNE 3.17536923741e-10
R_4_20 PAR_3_0_VSS n134 14.9306361473
C_4_20 n134 PAR_2_0_VDD075NNE 1.24393980206e-10
R_5_20 PAR_3_0_VSS n135 32.931965856
C_5_20 n135 PAR_2_0_VDD075NNE 3.17133217182e-10
R0_21 PAR_3_0_VSS PAR_0_0_VSS 1.1289722211
C0_21 PAR_3_0_VSS PAR_0_0_VSS 2.05162536744e-10
R_1_21 PAR_3_0_VSS n136 0.0981909960091
C_1_21 n136 PAR_0_0_VSS 6.11884231533e-10
R_2_21 PAR_3_0_VSS n137 0.0780110346836
C_2_21 n137 PAR_0_0_VSS 1.62472025923e-09
R_3_21 PAR_3_0_VSS n138 0.137907036574
C_3_21 n138 PAR_0_0_VSS 4.18914304872e-09
L_4_21 PAR_3_0_VSS n139 4.69019912345e-10
R_4_21 n139 PAR_0_0_VSS 0.519579587893
R_5_21 PAR_3_0_VSS n140 0.0699233414118
C_5_21 n140 PAR_0_0_VSS 4.58229324382e-08
R_6_21 PAR_3_0_VSS n141 0.250184728397
C_6_21 n141 PAR_0_0_VSS 3.95189675836e-08
G0_22 PAR_3_0_VDD075NNE PAR_0_0_VDD075NNE PAR_3_0_VDD075NNE PAR_0_0_VDD075NNE -6.00322865031
C0_22 PAR_3_0_VDD075NNE PAR_0_0_VDD075NNE 1.93231366157e-10
R_1_22 PAR_3_0_VDD075NNE n142 0.0607231899624
C_1_22 n142 PAR_0_0_VDD075NNE 1.00020822726e-10
L_2_22 PAR_3_0_VDD075NNE n143 7.77938379916e-12
R_2_22 n143 PAR_0_0_VDD075NNE 0.23810267162
L_3_22 PAR_3_0_VDD075NNE n144 3.66169646996e-11
R_3_22 n144 PAR_0_0_VDD075NNE 0.59060250699
L_4_22 PAR_3_0_VDD075NNE n145 3.34367541742e-09
R_4_22 n145 PAR_0_0_VDD075NNE 17.5737149396
L_5_22 PAR_3_0_VDD075NNE n146 1.12214946209e-08
R_5_22 n146 PAR_0_0_VDD075NNE 24.7973067311
L_6_22 PAR_3_0_VDD075NNE n147 1.00823699588e-07
R_6_22 n147 PAR_0_0_VDD075NNE 81.2831805347
L_7_22 PAR_3_0_VDD075NNE n148 7.76165387484e-06
R_7_22 n148 PAR_0_0_VDD075NNE 1426.22926879
G0_23 PAR_3_0_VDD075NNE PAR_1_0_VSS PAR_3_0_VDD075NNE PAR_1_0_VSS -0.00706653928367
C0_23 PAR_3_0_VDD075NNE PAR_1_0_VSS 2.31843563465e-10
R_1_23 PAR_3_0_VDD075NNE n149 0.124444384032
C_1_23 n149 PAR_1_0_VSS 1.69885473773e-10
R_2_23 PAR_3_0_VDD075NNE n150 3.68366668514
C_2_23 n150 PAR_1_0_VSS 1.40947745013e-10
L_3_23 PAR_3_0_VDD075NNE n151 6.90278290905e-06
R_3_23 n151 PAR_1_0_VSS 141.511908851
G0_24 PAR_3_0_VDD075NNE PAR_1_0_VDD075NNE PAR_3_0_VDD075NNE PAR_1_0_VDD075NNE -39.5797884622
C0_24 PAR_3_0_VDD075NNE PAR_1_0_VDD075NNE 1.49817120621e-10
R_1_24 PAR_3_0_VDD075NNE n152 0.0309177804883
C_1_24 n152 PAR_1_0_VDD075NNE 1.51431738723e-09
L_2_24 PAR_3_0_VDD075NNE n153 1.45605087947e-12
R_2_24 n153 PAR_1_0_VDD075NNE 0.026224862211
R_3_24 PAR_3_0_VDD075NNE n154 0.152695118815
C_3_24 n154 PAR_1_0_VDD075NNE 6.21910191828e-10
L_4_24 PAR_3_0_VDD075NNE n155 2.46347000263e-10
R_4_24 n155 PAR_1_0_VDD075NNE 0.839673889751
R_5_24 PAR_3_0_VDD075NNE n156 1.52406157083
C_5_24 n156 PAR_1_0_VDD075NNE 4.14107737483e-10
L_6_24 PAR_3_0_VDD075NNE n157 6.07026303662e-09
R_6_24 n157 PAR_1_0_VDD075NNE 3.96414228391
R_7_24 PAR_3_0_VDD075NNE n158 32.4665474427
C_7_24 n158 PAR_1_0_VDD075NNE 2.34211485382e-10
L_8_24 PAR_3_0_VDD075NNE n159 0.00114456087245
R_8_24 n159 PAR_1_0_VDD075NNE 204.683916338
G0_25 PAR_3_0_VDD075NNE PAR_2_0_VSS PAR_3_0_VDD075NNE PAR_2_0_VSS -0.0117413168942
C0_25 PAR_3_0_VDD075NNE PAR_2_0_VSS 1.63971815882e-10
R_1_25 PAR_3_0_VDD075NNE n160 0.015690637882
C_1_25 n160 PAR_2_0_VSS 1.04192653819e-09
R_2_25 PAR_3_0_VDD075NNE n161 0.0203285705968
C_2_25 n161 PAR_2_0_VSS 1.55502482786e-09
R_3_25 PAR_3_0_VDD075NNE n162 4.33251633348
C_3_25 n162 PAR_2_0_VSS 2.64043769885e-11
R_4_25 PAR_3_0_VDD075NNE n163 6.45492206113
C_4_25 n163 PAR_2_0_VSS 6.7461224899e-11
R_5_25 PAR_3_0_VDD075NNE n164 8.33160079777
C_5_25 n164 PAR_2_0_VSS 2.51074365244e-10
L_6_25 PAR_3_0_VDD075NNE n165 7.74558305466e-07
R_6_25 n165 PAR_2_0_VSS 85.1692968532
R0_26 PAR_3_0_VDD075NNE PAR_2_0_VDD075NNE 0.00369397455833
C0_26 PAR_3_0_VDD075NNE PAR_2_0_VDD075NNE 1.03260814407e-10
L_1_26 PAR_3_0_VDD075NNE n166 1.32421591374e-13
R_1_26 n166 PAR_2_0_VDD075NNE 0.00737142976822
L_2_26 PAR_3_0_VDD075NNE n167 5.63097197505e-13
R_2_26 n167 PAR_2_0_VDD075NNE 0.0166433089866
L_3_26 PAR_3_0_VDD075NNE n168 1.61529181816e-10
R_3_26 n168 PAR_2_0_VDD075NNE 1.80781348627
L_4_26 PAR_3_0_VDD075NNE n169 7.10381339237e-09
R_4_26 n169 PAR_2_0_VDD075NNE 19.9643935072
L_5_26 PAR_3_0_VDD075NNE n170 6.0221315203e-08
R_5_26 n170 PAR_2_0_VDD075NNE 58.0912644973
L_6_26 PAR_3_0_VDD075NNE n171 4.38196895002e-06
R_6_26 n171 PAR_2_0_VDD075NNE 1013.74814283
C0_27 PAR_3_0_VDD075NNE PAR_3_0_VSS 3.02644468619e-09
R_1_27 PAR_3_0_VDD075NNE n172 0.000204761246726
C_1_27 n172 PAR_3_0_VSS 7.93831287206e-08
R_2_27 PAR_3_0_VDD075NNE n173 0.000718219799106
C_2_27 n173 PAR_3_0_VSS 5.20120676543e-08
R_3_27 PAR_3_0_VDD075NNE n174 0.0739095005333
C_3_27 n174 PAR_3_0_VSS 1.75470549411e-09
R_4_27 PAR_3_0_VDD075NNE n175 0.105676729785
C_4_27 n175 PAR_3_0_VSS 3.00619188224e-09
R_5_27 PAR_3_0_VDD075NNE n176 0.662755581137
C_5_27 n176 PAR_3_0_VSS 1.51061624733e-09
R_6_27 PAR_3_0_VDD075NNE n177 4.69106973945
C_6_27 n177 PAR_3_0_VSS 1.14542411332e-09
G0_28 PAR_3_0_VDD075NNE PAR_0_0_VSS PAR_3_0_VDD075NNE PAR_0_0_VSS -0.049110519817
C0_28 PAR_3_0_VDD075NNE PAR_0_0_VSS 2.32597499794e-10
R_1_28 PAR_3_0_VDD075NNE n178 0.0801077118254
C_1_28 n178 PAR_0_0_VSS 3.66662409802e-10
R_2_28 PAR_3_0_VDD075NNE n179 2.93290464068
C_2_28 n179 PAR_0_0_VSS 1.45621951981e-10
L_3_28 PAR_3_0_VDD075NNE n180 1.18030551847e-07
R_3_28 n180 PAR_0_0_VSS 20.3622347661
G0_29 PAR_0_1_VSS PAR_0_0_VDD075NNE PAR_0_1_VSS PAR_0_0_VDD075NNE -0.533381970171
C0_29 PAR_0_1_VSS PAR_0_0_VDD075NNE 2.24738945944e-10
R_1_29 PAR_0_1_VSS n181 0.0274966551905
C_1_29 n181 PAR_0_0_VDD075NNE 8.78413673117e-10
R_2_29 PAR_0_1_VSS n182 0.10073260673
C_2_29 n182 PAR_0_0_VDD075NNE 4.66651947696e-10
L_3_29 PAR_0_1_VSS n183 8.32612716698e-10
R_3_29 n183 PAR_0_0_VDD075NNE 2.56939928512
L_4_29 PAR_0_1_VSS n184 7.12304621127e-09
R_4_29 n184 PAR_0_0_VDD075NNE 7.49352942527
L_5_29 PAR_0_1_VSS n185 3.92921498277e-07
R_5_29 n185 PAR_0_0_VDD075NNE 93.1317310987
R0_30 PAR_0_1_VSS PAR_1_0_VSS 0.152800586609
C0_30 PAR_0_1_VSS PAR_1_0_VSS 2.4119203537e-10
R_1_30 PAR_0_1_VSS n186 0.588714751349
C_1_30 n186 PAR_1_0_VSS 7.63393703029e-11
R_2_30 PAR_0_1_VSS n187 0.274628461196
C_2_30 n187 PAR_1_0_VSS 5.02200127863e-10
R_3_30 PAR_0_1_VSS n188 0.270013107752
C_3_30 n188 PAR_1_0_VSS 1.29999838279e-09
R_4_30 PAR_0_1_VSS n189 1.58381352968
C_4_30 n189 PAR_1_0_VSS 5.91967687644e-10
R_5_30 PAR_0_1_VSS n190 1.11471002326
C_5_30 n190 PAR_1_0_VSS 1.76354596514e-09
L_6_30 PAR_0_1_VSS n191 3.67205494803e-08
R_6_30 n191 PAR_1_0_VSS 3.88731161546
G0_31 PAR_0_1_VSS PAR_1_0_VDD075NNE PAR_0_1_VSS PAR_1_0_VDD075NNE -0.417738739382
C0_31 PAR_0_1_VSS PAR_1_0_VDD075NNE 2.05700214866e-10
R_1_31 PAR_0_1_VSS n192 0.247691148687
C_1_31 n192 PAR_1_0_VDD075NNE 9.5640617953e-11
R_2_31 PAR_0_1_VSS n193 3.92306565768
C_2_31 n193 PAR_1_0_VDD075NNE 2.12733365149e-11
L_3_31 PAR_0_1_VSS n194 1.28508291156e-09
R_3_31 n194 PAR_1_0_VDD075NNE 4.11319687422
L_4_31 PAR_0_1_VSS n195 5.3257763722e-09
R_4_31 n195 PAR_1_0_VDD075NNE 8.25806030328
L_5_31 PAR_0_1_VSS n196 2.92690096926e-08
R_5_31 n196 PAR_1_0_VDD075NNE 19.8572863497
L_6_31 PAR_0_1_VSS n197 2.65466362892e-06
R_6_31 n197 PAR_1_0_VDD075NNE 315.887312952
G0_32 PAR_0_1_VSS PAR_2_0_VSS PAR_0_1_VSS PAR_2_0_VSS -0.139187709397
C0_32 PAR_0_1_VSS PAR_2_0_VSS 2.0909871394e-10
R_1_32 PAR_0_1_VSS n198 0.626665150414
C_1_32 n198 PAR_2_0_VSS 4.71387550774e-11
R_2_32 PAR_0_1_VSS n199 0.907730790795
C_2_32 n199 PAR_2_0_VSS 1.66186263036e-10
R_3_32 PAR_0_1_VSS n200 0.365654479872
C_3_32 n200 PAR_2_0_VSS 1.0405313558e-09
R_4_32 PAR_0_1_VSS n201 2.32211452496
C_4_32 n201 PAR_2_0_VSS 4.06124319849e-10
R_5_32 PAR_0_1_VSS n202 2.31921427747
C_5_32 n202 PAR_2_0_VSS 8.08471345658e-10
L_6_32 PAR_0_1_VSS n203 6.75320713057e-08
R_6_32 n203 PAR_2_0_VSS 7.1845357843
G0_33 PAR_0_1_VSS PAR_2_0_VDD075NNE PAR_0_1_VSS PAR_2_0_VDD075NNE -0.429728099619
C0_33 PAR_0_1_VSS PAR_2_0_VDD075NNE 2.12697782205e-10
R_1_33 PAR_0_1_VSS n204 0.382034888517
C_1_33 n204 PAR_2_0_VDD075NNE 6.1140000625e-11
R_2_33 PAR_0_1_VSS n205 3.46384541192
C_2_33 n205 PAR_2_0_VDD075NNE 2.80809536507e-11
L_3_33 PAR_0_1_VSS n206 1.30982442368e-09
R_3_33 n206 PAR_2_0_VDD075NNE 4.13346680902
L_4_33 PAR_0_1_VSS n207 4.92505246303e-09
R_4_33 n207 PAR_2_0_VDD075NNE 7.71192943792
L_5_33 PAR_0_1_VSS n208 2.66010479439e-08
R_5_33 n208 PAR_2_0_VDD075NNE 18.2900151233
L_6_33 PAR_0_1_VSS n209 2.43364930071e-06
R_6_33 n209 PAR_2_0_VDD075NNE 289.305358294
R0_34 PAR_0_1_VSS PAR_3_0_VSS 83509.3238527
C0_34 PAR_0_1_VSS PAR_3_0_VSS 2.85184964107e-10
R_1_34 PAR_0_1_VSS n210 0.0716061532028
C_1_34 n210 PAR_3_0_VSS 5.87246050645e-10
R_2_34 PAR_0_1_VSS n211 0.0471117583716
C_2_34 n211 PAR_3_0_VSS 2.63361701995e-09
R_3_34 PAR_0_1_VSS n212 0.0697287881817
C_3_34 n212 PAR_3_0_VSS 3.61975441247e-09
R_4_34 PAR_0_1_VSS n213 0.148078313756
C_4_34 n213 PAR_3_0_VSS 3.48916624222e-09
R_5_34 PAR_0_1_VSS n214 0.328530447091
C_5_34 n214 PAR_3_0_VSS 3.42783493598e-09
R_6_34 PAR_0_1_VSS n215 2.20632466602
C_6_34 n215 PAR_3_0_VSS 4.43513080649e-09
G0_35 PAR_0_1_VSS PAR_3_0_VDD075NNE PAR_0_1_VSS PAR_3_0_VDD075NNE -1.24439317985
C0_35 PAR_0_1_VSS PAR_3_0_VDD075NNE 2.6952875632e-10
R_1_35 PAR_0_1_VSS n216 0.0618020119338
C_1_35 n216 PAR_3_0_VDD075NNE 2.84127033646e-10
R_2_35 PAR_0_1_VSS n217 0.251217178634
C_2_35 n217 PAR_3_0_VDD075NNE 1.84037562376e-10
L_3_35 PAR_0_1_VSS n218 4.80295885401e-10
R_3_35 n218 PAR_3_0_VDD075NNE 1.44019739435
L_4_35 PAR_0_1_VSS n219 1.40820317386e-09
R_4_35 n219 PAR_3_0_VDD075NNE 2.35893175895
L_5_35 PAR_0_1_VSS n220 1.19691772034e-08
R_5_35 n220 PAR_3_0_VDD075NNE 8.27352638422
L_6_35 PAR_0_1_VSS n221 1.40624169062e-06
R_6_35 n221 PAR_3_0_VDD075NNE 190.266867193
R0_36 PAR_0_1_VSS PAR_0_0_VSS 0.00825483243315
C0_36 PAR_0_1_VSS PAR_0_0_VSS 1.56907532394e-10
L_1_36 PAR_0_1_VSS n222 3.51158094893e-13
R_1_36 n222 PAR_0_0_VSS 0.0153623504424
L_2_36 PAR_0_1_VSS n223 3.48176184702e-12
R_2_36 n223 PAR_0_0_VSS 0.0777718669476
R_3_36 PAR_0_1_VSS n224 0.153162645413
C_3_36 n224 PAR_0_0_VSS 1.06327983191e-09
R_4_36 PAR_0_1_VSS n225 0.184466174847
C_4_36 n225 PAR_0_0_VSS 1.98885442745e-09
R_5_36 PAR_0_1_VSS n226 0.851504245225
C_5_36 n226 PAR_0_0_VSS 2.43020237604e-09
L_6_36 PAR_0_1_VSS n227 2.81639422228e-08
R_6_36 n227 PAR_0_0_VSS 2.91267624339
R0_37 PAR_0_1_VDD075NNE PAR_0_0_VDD075NNE 0.00774451837393
C0_37 PAR_0_1_VDD075NNE PAR_0_0_VDD075NNE 2.04711946647e-10
L_1_37 PAR_0_1_VDD075NNE n228 2.80147832888e-13
R_1_37 n228 PAR_0_0_VDD075NNE 0.0133817409811
L_2_37 PAR_0_1_VDD075NNE n229 1.37404117869e-12
R_2_37 n229 PAR_0_0_VDD075NNE 0.0337911414401
L_3_37 PAR_0_1_VDD075NNE n230 1.79858384436e-10
R_3_37 n230 PAR_0_0_VDD075NNE 1.99948107905
L_4_37 PAR_0_1_VDD075NNE n231 3.83425373235e-08
R_4_37 n231 PAR_0_0_VDD075NNE 70.9660791043
L_5_37 PAR_0_1_VDD075NNE n232 3.74663985914e-07
R_5_37 n232 PAR_0_0_VDD075NNE 208.748189424
L_6_37 PAR_0_1_VDD075NNE n233 0.00398388324455
R_6_37 n233 PAR_0_0_VDD075NNE 2356.82718441
G0_38 PAR_0_1_VDD075NNE PAR_1_0_VSS PAR_0_1_VDD075NNE PAR_1_0_VSS -0.348331820071
C0_38 PAR_0_1_VDD075NNE PAR_1_0_VSS 2.48421742758e-10
R_1_38 PAR_0_1_VDD075NNE n234 0.089964321464
C_1_38 n234 PAR_1_0_VSS 2.03016962351e-10
R_2_38 PAR_0_1_VDD075NNE n235 0.324599439048
C_2_38 n235 PAR_1_0_VSS 1.32238244585e-10
L_3_38 PAR_0_1_VDD075NNE n236 4.0528103131e-10
R_3_38 n236 PAR_1_0_VSS 3.09026434392
R_4_38 PAR_0_1_VDD075NNE n237 9.95565193571
C_4_38 n237 PAR_1_0_VSS 4.72271074747e-11
R_5_38 PAR_0_1_VDD075NNE n238 9.44688308122
C_5_38 n238 PAR_1_0_VSS 1.85185415471e-10
L_6_38 PAR_0_1_VDD075NNE n239 3.95587894048e-07
R_6_38 n239 PAR_1_0_VSS 40.4286865129
G0_39 PAR_0_1_VDD075NNE PAR_1_0_VDD075NNE PAR_0_1_VDD075NNE PAR_1_0_VDD075NNE -0.279947989014
C0_39 PAR_0_1_VDD075NNE PAR_1_0_VDD075NNE 1.65508110361e-10
L_1_39 PAR_0_1_VDD075NNE n240 4.98174341418e-12
R_1_39 n240 PAR_1_0_VDD075NNE 0.216353342919
L_2_39 PAR_0_1_VDD075NNE n241 1.57203305154e-11
R_2_39 n241 PAR_1_0_VDD075NNE 0.296125277978
R_3_39 PAR_0_1_VDD075NNE n242 3.79562674615
C_3_39 n242 PAR_1_0_VDD075NNE 3.81404694962e-11
L_4_39 PAR_0_1_VDD075NNE n243 7.81371036594e-09
R_4_39 n243 PAR_1_0_VDD075NNE 11.4235305811
R_5_39 PAR_0_1_VDD075NNE n244 60.654258995
C_5_39 n244 PAR_1_0_VDD075NNE 3.81444581215e-11
G0_40 PAR_0_1_VDD075NNE PAR_2_0_VSS PAR_0_1_VDD075NNE PAR_2_0_VSS -2.77133719841
C0_40 PAR_0_1_VDD075NNE PAR_2_0_VSS 1.73903414268e-10
R_1_40 PAR_0_1_VDD075NNE n245 0.404981002651
C_1_40 n245 PAR_2_0_VSS 3.93817941071e-11
L_2_40 PAR_0_1_VDD075NNE n246 1.16910725114e-11
R_2_40 n246 PAR_2_0_VSS 0.367341258785
R_3_40 PAR_0_1_VDD075NNE n247 6.43358777333
C_3_40 n247 PAR_2_0_VSS 1.89415036626e-11
R_4_40 PAR_0_1_VDD075NNE n248 66.9086544919
C_4_40 n248 PAR_2_0_VSS 6.14525010366e-12
R_5_40 PAR_0_1_VDD075NNE n249 7.59269423247
C_5_40 n249 PAR_2_0_VSS 1.74232116991e-10
L_6_40 PAR_0_1_VDD075NNE n250 6.03883063555e-08
R_6_40 n250 PAR_2_0_VSS 24.5170232958
L_7_40 PAR_0_1_VDD075NNE n251 1.11503871952e-06
R_7_40 n251 PAR_2_0_VSS 120.701488657
G0_41 PAR_0_1_VDD075NNE PAR_2_0_VDD075NNE PAR_0_1_VDD075NNE PAR_2_0_VDD075NNE -8.41986311652
C0_41 PAR_0_1_VDD075NNE PAR_2_0_VDD075NNE 1.44135172502e-10
R_1_41 PAR_0_1_VDD075NNE n252 0.155224632036
C_1_41 n252 PAR_2_0_VDD075NNE 9.95633685572e-11
L_2_41 PAR_0_1_VDD075NNE n253 5.05639852042e-12
R_2_41 n253 PAR_2_0_VDD075NNE 0.132361054552
R_3_41 PAR_0_1_VDD075NNE n254 0.590264925054
C_3_41 n254 PAR_2_0_VDD075NNE 1.36367588436e-10
L_4_41 PAR_0_1_VDD075NNE n255 2.25618245086e-10
R_4_41 n255 PAR_2_0_VDD075NNE 1.43809297293
R_5_41 PAR_0_1_VDD075NNE n256 4.54951020475
C_5_41 n256 PAR_2_0_VDD075NNE 9.22574711824e-11
L_6_41 PAR_0_1_VDD075NNE n257 5.96062155281e-09
R_6_41 n257 PAR_2_0_VDD075NNE 6.22904015179
R_7_41 PAR_0_1_VDD075NNE n258 15.7163032263
C_7_41 n258 PAR_2_0_VDD075NNE 1.17244283924e-10
L_8_41 PAR_0_1_VDD075NNE n259 1.04699792333e-06
R_8_41 n259 PAR_2_0_VDD075NNE 115.386386656
G0_42 PAR_0_1_VDD075NNE PAR_3_0_VSS PAR_0_1_VDD075NNE PAR_3_0_VSS -2.05136177052
C0_42 PAR_0_1_VDD075NNE PAR_3_0_VSS 3.0811417201e-10
R_1_42 PAR_0_1_VDD075NNE n260 0.0259560775931
C_1_42 n260 PAR_3_0_VSS 6.62211704642e-10
R_2_42 PAR_0_1_VDD075NNE n261 0.152543329185
C_2_42 n261 PAR_3_0_VSS 3.29444822083e-10
L_3_42 PAR_0_1_VDD075NNE n262 6.91689706545e-11
R_3_42 n262 PAR_3_0_VSS 0.487481053617
R_4_42 PAR_0_1_VDD075NNE n263 2.92688941773
C_4_42 n263 PAR_3_0_VSS 1.80357775963e-10
R_5_42 PAR_0_1_VDD075NNE n264 3.89261735184
C_5_42 n264 PAR_3_0_VSS 2.87318205766e-10
R_6_42 PAR_0_1_VDD075NNE n265 21.556059608
C_6_42 n265 PAR_3_0_VSS 4.52900345199e-10
G0_43 PAR_0_1_VDD075NNE PAR_3_0_VDD075NNE PAR_0_1_VDD075NNE PAR_3_0_VDD075NNE -8.13291799721
C0_43 PAR_0_1_VDD075NNE PAR_3_0_VDD075NNE 2.11301502887e-10
R_1_43 PAR_0_1_VDD075NNE n266 0.0222301710961
C_1_43 n266 PAR_3_0_VDD075NNE 1.82211899257e-10
L_2_43 PAR_0_1_VDD075NNE n267 5.56395609962e-12
R_2_43 n267 PAR_3_0_VDD075NNE 0.163513332608
L_3_43 PAR_0_1_VDD075NNE n268 3.59684238963e-11
R_3_43 n268 PAR_3_0_VDD075NNE 0.521085612348
L_4_43 PAR_0_1_VDD075NNE n269 3.87498270894e-09
R_4_43 n269 PAR_3_0_VDD075NNE 20.6231331214
L_5_43 PAR_0_1_VDD075NNE n270 1.40642110062e-08
R_5_43 n270 PAR_3_0_VDD075NNE 28.5941495188
L_6_43 PAR_0_1_VDD075NNE n271 9.21041590123e-08
R_6_43 n271 PAR_3_0_VDD075NNE 72.3615210171
L_7_43 PAR_0_1_VDD075NNE n272 6.00681025603e-06
R_7_43 n272 PAR_3_0_VDD075NNE 1058.39530327
G0_44 PAR_0_1_VDD075NNE PAR_0_1_VSS PAR_0_1_VDD075NNE PAR_0_1_VSS -0.192826358099
C0_44 PAR_0_1_VDD075NNE PAR_0_1_VSS 8.53076969449e-10
R_1_44 PAR_0_1_VDD075NNE n273 0.000416532984881
C_1_44 n273 PAR_0_1_VSS 3.16760686876e-08
R_2_44 PAR_0_1_VDD075NNE n274 0.000250174102863
C_2_44 n274 PAR_0_1_VSS 1.32413451779e-07
R_3_44 PAR_0_1_VDD075NNE n275 0.00226571825166
C_3_44 n275 PAR_0_1_VSS 2.17010908422e-08
R_4_44 PAR_0_1_VDD075NNE n276 0.142959811992
C_4_44 n276 PAR_0_1_VSS 1.06899154396e-09
L_5_44 PAR_0_1_VDD075NNE n277 4.91743509898e-09
R_5_44 n277 PAR_0_1_VSS 5.68857459434
L_6_44 PAR_0_1_VDD075NNE n278 2.18410437276e-07
R_6_44 n278 PAR_0_1_VSS 58.7012908365
G0_45 PAR_0_1_VDD075NNE PAR_0_0_VSS PAR_0_1_VDD075NNE PAR_0_0_VSS -0.0237441160563
C0_45 PAR_0_1_VDD075NNE PAR_0_0_VSS 2.30151267713e-10
R_1_45 PAR_0_1_VDD075NNE n279 0.00645262753473
C_1_45 n279 PAR_0_0_VSS 2.3590304234e-09
R_2_45 PAR_0_1_VDD075NNE n280 0.0143316234433
C_2_45 n280 PAR_0_0_VSS 2.6155030439e-09
R_3_45 PAR_0_1_VDD075NNE n281 7.15990037115
C_3_45 n281 PAR_0_0_VSS 1.99008130153e-10
L_4_45 PAR_0_1_VDD075NNE n282 5.19515739273e-07
R_4_45 n282 PAR_0_0_VSS 42.1156907653
G0_46 PAR_1_1_VSS PAR_0_0_VDD075NNE PAR_1_1_VSS PAR_0_0_VDD075NNE -0.639440985573
C0_46 PAR_1_1_VSS PAR_0_0_VDD075NNE 2.44930699299e-10
R_1_46 PAR_1_1_VSS n283 0.114362209545
C_1_46 n283 PAR_0_0_VDD075NNE 1.69352188264e-10
R_2_46 PAR_1_1_VSS n284 0.837071987633
C_2_46 n284 PAR_0_0_VDD075NNE 7.73358767736e-11
L_3_46 PAR_1_1_VSS n285 8.511774279e-10
R_3_46 n285 PAR_0_0_VDD075NNE 2.8196090167
L_4_46 PAR_1_1_VSS n286 2.89385118725e-09
R_4_46 n286 PAR_0_0_VDD075NNE 4.91282824488
L_5_46 PAR_1_1_VSS n287 1.881432597e-08
R_5_46 n287 PAR_0_0_VDD075NNE 13.0390364502
L_6_46 PAR_1_1_VSS n288 1.78953236925e-06
R_6_46 n288 PAR_0_0_VDD075NNE 220.246657696
R0_47 PAR_1_1_VSS PAR_1_0_VSS 0.00866772135584
C0_47 PAR_1_1_VSS PAR_1_0_VSS 1.31343871679e-10
L_1_47 PAR_1_1_VSS n289 4.1399737724e-13
R_1_47 n289 PAR_1_0_VSS 0.0151373425282
R_2_47 PAR_1_1_VSS n290 0.214014492132
C_2_47 n290 PAR_1_0_VSS 8.7551678651e-10
R_3_47 PAR_1_1_VSS n291 0.260835587633
C_3_47 n291 PAR_1_0_VSS 1.65245214855e-09
R_4_47 PAR_1_1_VSS n292 0.683541171631
C_4_47 n292 PAR_1_0_VSS 2.56736146728e-09
L_5_47 PAR_1_1_VSS n293 3.19562993602e-08
R_5_47 n293 PAR_1_0_VSS 3.27792264526
G0_48 PAR_1_1_VSS PAR_1_0_VDD075NNE PAR_1_1_VSS PAR_1_0_VDD075NNE -0.457202297276
C0_48 PAR_1_1_VSS PAR_1_0_VDD075NNE 2.14950601225e-10
R_1_48 PAR_1_1_VSS n294 0.0302843047442
C_1_48 n294 PAR_1_0_VDD075NNE 8.14353680817e-10
R_2_48 PAR_1_1_VSS n295 0.204336165065
C_2_48 n295 PAR_1_0_VDD075NNE 2.77524296904e-10
L_3_48 PAR_1_1_VSS n296 1.19007764554e-09
R_3_48 n296 PAR_1_0_VDD075NNE 2.95832599936
L_4_48 PAR_1_1_VSS n297 1.02441283992e-08
R_4_48 n297 PAR_1_0_VDD075NNE 8.87007587877
L_5_48 PAR_1_1_VSS n298 9.46201394288e-07
R_5_48 n298 PAR_1_0_VDD075NNE 155.407721282
R0_49 PAR_1_1_VSS PAR_2_0_VSS 0.204931888383
C0_49 PAR_1_1_VSS PAR_2_0_VSS 2.24107571487e-10
L_1_49 PAR_1_1_VSS n299 2.43291873477e-11
R_1_49 n299 PAR_2_0_VSS 0.618407148082
R_2_49 PAR_1_1_VSS n300 0.791881774288
C_2_49 n300 PAR_2_0_VSS 1.93198421449e-10
R_3_49 PAR_1_1_VSS n301 0.27856278457
C_3_49 n301 PAR_2_0_VSS 1.40177349424e-09
R_4_49 PAR_1_1_VSS n302 1.59742044504
C_4_49 n302 PAR_2_0_VSS 7.13357842828e-10
R_5_49 PAR_1_1_VSS n303 2.67141007907
C_5_49 n303 PAR_2_0_VSS 7.80344708762e-10
L_6_49 PAR_1_1_VSS n304 5.25881865545e-08
R_6_49 n304 PAR_2_0_VSS 5.64771550482
G0_50 PAR_1_1_VSS PAR_2_0_VDD075NNE PAR_1_1_VSS PAR_2_0_VDD075NNE -0.471644215821
C0_50 PAR_1_1_VSS PAR_2_0_VDD075NNE 2.27783243545e-10
R_1_50 PAR_1_1_VSS n305 0.181503682481
C_1_50 n305 PAR_2_0_VDD075NNE 1.29924179742e-10
R_2_50 PAR_1_1_VSS n306 0.885324274925
C_2_50 n306 PAR_2_0_VDD075NNE 8.70561936707e-11
L_3_50 PAR_1_1_VSS n307 1.20112765707e-09
R_3_50 n307 PAR_2_0_VDD075NNE 2.96520869686
L_4_50 PAR_1_1_VSS n308 8.8658647721e-09
R_4_50 n308 PAR_2_0_VDD075NNE 8.30893674272
L_5_50 PAR_1_1_VSS n309 2.43854665537e-07
R_5_50 n309 PAR_2_0_VDD075NNE 88.4158119003
L_6_50 PAR_1_1_VSS n310 3.87095478128e-06
R_6_50 n310 PAR_2_0_VDD075NNE 365.32447784
R0_51 PAR_1_1_VSS PAR_3_0_VSS 75177.2931405
C0_51 PAR_1_1_VSS PAR_3_0_VSS 2.77915181416e-10
R_1_51 PAR_1_1_VSS n311 0.0827439678436
C_1_51 n311 PAR_3_0_VSS 3.5524256544e-10
R_2_51 PAR_1_1_VSS n312 0.0355942760825
C_2_51 n312 PAR_3_0_VSS 3.71560407835e-09
R_3_51 PAR_1_1_VSS n313 0.0541647451769
C_3_51 n313 PAR_3_0_VSS 5.33460472259e-09
R_4_51 PAR_1_1_VSS n314 0.146433790972
C_4_51 n314 PAR_3_0_VSS 4.09655119633e-09
R_5_51 PAR_1_1_VSS n315 0.317151624367
C_5_51 n315 PAR_3_0_VSS 3.73026179647e-09
R_6_51 PAR_1_1_VSS n316 1.78057972402
C_6_51 n316 PAR_3_0_VSS 5.52106890602e-09
G0_52 PAR_1_1_VSS PAR_3_0_VDD075NNE PAR_1_1_VSS PAR_3_0_VDD075NNE -1.42847486096
C0_52 PAR_1_1_VSS PAR_3_0_VDD075NNE 2.80858823144e-10
R_1_52 PAR_1_1_VSS n317 0.0499267143113
C_1_52 n317 PAR_3_0_VDD075NNE 3.42877110551e-10
R_2_52 PAR_1_1_VSS n318 0.216865692593
C_2_52 n318 PAR_3_0_VDD075NNE 2.80037857302e-10
L_3_52 PAR_1_1_VSS n319 3.79350642688e-10
R_3_52 n319 PAR_3_0_VDD075NNE 0.930900076799
L_4_52 PAR_1_1_VSS n320 3.14429136486e-09
R_4_52 n320 PAR_3_0_VDD075NNE 3.51908454535
L_5_52 PAR_1_1_VSS n321 2.88070744207e-08
R_5_52 n321 PAR_3_0_VDD075NNE 15.2428721257
L_6_52 PAR_1_1_VSS n322 2.02871359096e-06
R_6_52 n322 PAR_3_0_VDD075NNE 223.390476754
R0_53 PAR_1_1_VSS PAR_0_1_VSS 0.00243187871218
L_1_53 PAR_1_1_VSS n323 1.82955449737e-13
R_1_53 n323 PAR_0_1_VSS 0.00524640610369
R_2_53 PAR_1_1_VSS n324 0.0281420844981
C_2_53 n324 PAR_0_1_VSS 5.92331769677e-09
L_3_53 PAR_1_1_VSS n325 7.7620162967e-12
R_3_53 n325 PAR_0_1_VSS 0.0290397249635
L_4_53 PAR_1_1_VSS n326 2.99997173114e-10
R_4_53 n326 PAR_0_1_VSS 0.341770570067
L_5_53 PAR_1_1_VSS n327 2.27697872444e-08
R_5_53 n327 PAR_0_1_VSS 5.27741805686
G0_54 PAR_1_1_VSS PAR_0_1_VDD075NNE PAR_1_1_VSS PAR_0_1_VDD075NNE -1.04456080414
C0_54 PAR_1_1_VSS PAR_0_1_VDD075NNE 4.31219670883e-10
R_1_54 PAR_1_1_VSS n328 0.00554439278238
C_1_54 n328 PAR_0_1_VDD075NNE 3.83741482434e-09
R_2_54 PAR_1_1_VSS n329 0.00507874933162
C_2_54 n329 PAR_0_1_VDD075NNE 7.71689324641e-09
L_3_54 PAR_1_1_VSS n330 2.05085484084e-10
R_3_54 n330 PAR_0_1_VDD075NNE 1.26725827207
L_4_54 PAR_1_1_VSS n331 3.61371702118e-09
R_4_54 n331 PAR_0_1_VDD075NNE 4.29439398617
L_5_54 PAR_1_1_VSS n332 1.59104234949e-07
R_5_54 n332 PAR_0_1_VDD075NNE 44.2596271249
R0_55 PAR_1_1_VSS PAR_0_0_VSS 0.159464780128
C0_55 PAR_1_1_VSS PAR_0_0_VSS 2.3057702093e-10
R_1_55 PAR_1_1_VSS n333 0.36133922657
C_1_55 n333 PAR_0_0_VSS 9.48974366723e-11
R_2_55 PAR_1_1_VSS n334 0.151842900279
C_2_55 n334 PAR_0_0_VSS 8.81497255605e-10
R_3_55 PAR_1_1_VSS n335 0.178406563718
C_3_55 n335 PAR_0_0_VSS 1.49982552762e-09
R_4_55 PAR_1_1_VSS n336 0.244616603042
C_4_55 n336 PAR_0_0_VSS 1.70420222287e-09
R_5_55 PAR_1_1_VSS n337 0.692016956409
C_5_55 n337 PAR_0_0_VSS 3.06605524814e-09
L_6_55 PAR_1_1_VSS n338 2.16355402086e-08
R_6_55 n338 PAR_0_0_VSS 2.27337486085
G0_56 PAR_1_1_VDD075NNE PAR_0_0_VDD075NNE PAR_1_1_VDD075NNE PAR_0_0_VDD075NNE -0.246684077222
C0_56 PAR_1_1_VDD075NNE PAR_0_0_VDD075NNE 1.71491315317e-10
L_1_56 PAR_1_1_VDD075NNE n339 4.90592424562e-12
R_1_56 n339 PAR_0_0_VDD075NNE 0.199264377994
L_2_56 PAR_1_1_VDD075NNE n340 1.84256337621e-11
R_2_56 n340 PAR_0_0_VDD075NNE 0.335585014242
R_3_56 PAR_1_1_VDD075NNE n341 4.38651643171
C_3_56 n341 PAR_0_0_VDD075NNE 3.89763130067e-11
L_4_56 PAR_1_1_VDD075NNE n342 7.06639749495e-09
R_4_56 n342 PAR_0_0_VDD075NNE 10.1415404584
R_5_56 PAR_1_1_VDD075NNE n343 53.4395175023
C_5_56 n343 PAR_0_0_VDD075NNE 4.44073192226e-11
G0_57 PAR_1_1_VDD075NNE PAR_1_0_VSS PAR_1_1_VDD075NNE PAR_1_0_VSS -0.0254649386428
C0_57 PAR_1_1_VDD075NNE PAR_1_0_VSS 2.63685771055e-10
R_1_57 PAR_1_1_VDD075NNE n344 0.00621566918241
C_1_57 n344 PAR_1_0_VSS 2.70622317362e-09
R_2_57 PAR_1_1_VDD075NNE n345 0.0222995314062
C_2_57 n345 PAR_1_0_VSS 1.77527954932e-09
R_3_57 PAR_1_1_VDD075NNE n346 10.9422101094
C_3_57 n346 PAR_1_0_VSS 5.72311103075e-11
R_4_57 PAR_1_1_VDD075NNE n347 12.4749634669
C_4_57 n347 PAR_1_0_VSS 1.63844453772e-10
L_5_57 PAR_1_1_VDD075NNE n348 3.53625179672e-07
R_5_57 n348 PAR_1_0_VSS 39.269675284
R0_58 PAR_1_1_VDD075NNE PAR_1_0_VDD075NNE 0.00889067253361
C0_58 PAR_1_1_VDD075NNE PAR_1_0_VDD075NNE 1.57755847252e-10
L_1_58 PAR_1_1_VDD075NNE n349 2.75836795705e-13
R_1_58 n349 PAR_1_0_VDD075NNE 0.0136589431083
L_2_58 PAR_1_1_VDD075NNE n350 1.94160438672e-12
R_2_58 n350 PAR_1_0_VDD075NNE 0.0475770214894
L_3_58 PAR_1_1_VDD075NNE n351 4.17247837138e-10
R_3_58 n351 PAR_1_0_VDD075NNE 4.0744631999
L_4_58 PAR_1_1_VDD075NNE n352 3.99078576045e-08
R_4_58 n352 PAR_1_0_VDD075NNE 79.7199090148
L_5_58 PAR_1_1_VDD075NNE n353 4.03743453718e-07
R_5_58 n353 PAR_1_0_VDD075NNE 234.887122156
L_6_58 PAR_1_1_VDD075NNE n354 0.00762611031432
R_6_58 n354 PAR_1_0_VDD075NNE 1432.66562806
G0_59 PAR_1_1_VDD075NNE PAR_2_0_VSS PAR_1_1_VDD075NNE PAR_2_0_VSS -0.0116029322875
C0_59 PAR_1_1_VDD075NNE PAR_2_0_VSS 1.77640482186e-10
R_1_59 PAR_1_1_VDD075NNE n355 0.646759587205
C_1_59 n355 PAR_2_0_VSS 6.4327591362e-11
R_2_59 PAR_1_1_VDD075NNE n356 10.3463167253
C_2_59 n356 PAR_2_0_VSS 3.98319132945e-11
R_3_59 PAR_1_1_VDD075NNE n357 18.3020142647
C_3_59 n357 PAR_2_0_VSS 8.36740393578e-11
L_4_59 PAR_1_1_VDD075NNE n358 8.62136139765e-07
R_4_59 n358 PAR_2_0_VSS 86.1850881468
G0_60 PAR_1_1_VDD075NNE PAR_2_0_VDD075NNE PAR_1_1_VDD075NNE PAR_2_0_VDD075NNE -0.213635064332
C0_60 PAR_1_1_VDD075NNE PAR_2_0_VDD075NNE 1.46980400884e-10
L_1_60 PAR_1_1_VDD075NNE n359 4.06788668974e-12
R_1_60 n359 PAR_2_0_VDD075NNE 0.196205670147
L_2_60 PAR_1_1_VDD075NNE n360 1.81699679452e-11
R_2_60 n360 PAR_2_0_VDD075NNE 0.345082765193
R_3_60 PAR_1_1_VDD075NNE n361 5.04150955513
C_3_60 n361 PAR_2_0_VDD075NNE 3.09288652671e-11
L_4_60 PAR_1_1_VDD075NNE n362 7.80622422854e-09
R_4_60 n362 PAR_2_0_VDD075NNE 11.7590139395
R_5_60 PAR_1_1_VDD075NNE n363 65.4374217053
C_5_60 n363 PAR_2_0_VDD075NNE 3.43304243687e-11
G0_61 PAR_1_1_VDD075NNE PAR_3_0_VSS PAR_1_1_VDD075NNE PAR_3_0_VSS -1.28738967479
C0_61 PAR_1_1_VDD075NNE PAR_3_0_VSS 2.65202438664e-10
R_1_61 PAR_1_1_VDD075NNE n364 0.029036436112
C_1_61 n364 PAR_3_0_VSS 5.39036756146e-10
R_2_61 PAR_1_1_VDD075NNE n365 0.173317914994
C_2_61 n365 PAR_3_0_VSS 2.78730452647e-10
L_3_61 PAR_1_1_VDD075NNE n366 1.09923796447e-10
R_3_61 n366 PAR_3_0_VSS 0.776765587108
R_4_61 PAR_1_1_VDD075NNE n367 3.22503665211
C_4_61 n367 PAR_3_0_VSS 1.68147543366e-10
R_5_61 PAR_1_1_VDD075NNE n368 4.45794903246
C_5_61 n368 PAR_3_0_VSS 2.53444958981e-10
R_6_61 PAR_1_1_VDD075NNE n369 24.0922269101
C_6_61 n369 PAR_3_0_VSS 4.05809977084e-10
G0_62 PAR_1_1_VDD075NNE PAR_3_0_VDD075NNE PAR_1_1_VDD075NNE PAR_3_0_VDD075NNE -7.61145324669
C0_62 PAR_1_1_VDD075NNE PAR_3_0_VDD075NNE 1.71522726923e-10
R_1_62 PAR_1_1_VDD075NNE n370 0.0202774230105
C_1_62 n370 PAR_3_0_VDD075NNE 1.73607041266e-10
L_2_62 PAR_1_1_VDD075NNE n371 5.45336554951e-12
R_2_62 n371 PAR_3_0_VDD075NNE 0.183379888838
L_3_62 PAR_1_1_VDD075NNE n372 3.13301834979e-11
R_3_62 n372 PAR_3_0_VDD075NNE 0.497199924409
L_4_62 PAR_1_1_VDD075NNE n373 1.68307094881e-09
R_4_62 n373 PAR_3_0_VDD075NNE 11.8082474319
L_5_62 PAR_1_1_VDD075NNE n374 9.30728724164e-09
R_5_62 n374 PAR_3_0_VDD075NNE 27.8486597881
L_6_62 PAR_1_1_VDD075NNE n375 3.82537401388e-08
R_6_62 n375 PAR_3_0_VDD075NNE 51.6313360967
L_7_62 PAR_1_1_VDD075NNE n376 2.4624299126e-07
R_7_62 n376 PAR_3_0_VDD075NNE 149.879769503
L_8_62 PAR_1_1_VDD075NNE n377 2.08117724893e-05
R_8_62 n377 PAR_3_0_VDD075NNE 2542.16472581
L_9_62 PAR_1_1_VDD075NNE n378 0.166442382011
R_9_62 n378 PAR_3_0_VDD075NNE 3310.89453983
G0_63 PAR_1_1_VDD075NNE PAR_0_1_VSS PAR_1_1_VDD075NNE PAR_0_1_VSS -0.773059227694
C0_63 PAR_1_1_VDD075NNE PAR_0_1_VSS 2.79556509872e-10
R_1_63 PAR_1_1_VDD075NNE n379 0.0233169272019
C_1_63 n379 PAR_0_1_VSS 1.03797978938e-09
R_2_63 PAR_1_1_VDD075NNE n380 0.012230367046
C_2_63 n380 PAR_0_1_VSS 3.29243114807e-09
L_3_63 PAR_1_1_VDD075NNE n381 2.40371150303e-10
R_3_63 n381 PAR_0_1_VSS 1.70416249893
L_4_63 PAR_1_1_VDD075NNE n382 4.87735949313e-09
R_4_63 n382 PAR_0_1_VSS 5.96142151165
L_5_63 PAR_1_1_VDD075NNE n383 1.79444861324e-07
R_5_63 n383 PAR_0_1_VSS 54.0087923957
R0_64 PAR_1_1_VDD075NNE PAR_0_1_VDD075NNE 0.00251333652937
C0_64 PAR_1_1_VDD075NNE PAR_0_1_VDD075NNE 1.35291655887e-10
L_1_64 PAR_1_1_VDD075NNE n384 2.49735962007e-13
R_1_64 n384 PAR_0_1_VDD075NNE 0.0141624469085
L_2_64 PAR_1_1_VDD075NNE n385 2.24688899483e-13
R_2_64 n385 PAR_0_1_VDD075NNE 0.00602993523829
L_3_64 PAR_1_1_VDD075NNE n386 4.86169227347e-11
R_3_64 n386 PAR_0_1_VDD075NNE 0.652485828915
L_4_64 PAR_1_1_VDD075NNE n387 3.63222692149e-08
R_4_64 n387 PAR_0_1_VDD075NNE 69.0471604938
L_5_64 PAR_1_1_VDD075NNE n388 3.4082475689e-07
R_5_64 n388 PAR_0_1_VDD075NNE 190.334176016
L_6_64 PAR_1_1_VDD075NNE n389 0.00430354581469
R_6_64 n389 PAR_0_1_VDD075NNE 1686.93330388
G0_65 PAR_1_1_VDD075NNE PAR_1_1_VSS PAR_1_1_VDD075NNE PAR_1_1_VSS -0.253644703238
C0_65 PAR_1_1_VDD075NNE PAR_1_1_VSS 1.262840947e-09
R_1_65 PAR_1_1_VDD075NNE n390 0.000391835068868
C_1_65 n390 PAR_1_1_VSS 3.56984280808e-08
R_2_65 PAR_1_1_VDD075NNE n391 0.000261361353173
C_2_65 n391 PAR_1_1_VSS 1.27973557616e-07
R_3_65 PAR_1_1_VDD075NNE n392 0.0094225756093
C_3_65 n392 PAR_1_1_VSS 6.04740244754e-09
R_4_65 PAR_1_1_VDD075NNE n393 0.300021275458
C_4_65 n393 PAR_1_1_VSS 5.0491986807e-10
L_5_65 PAR_1_1_VDD075NNE n394 3.40823165383e-09
R_5_65 n394 PAR_1_1_VSS 4.44201771947
L_6_65 PAR_1_1_VDD075NNE n395 1.03767267262e-07
R_6_65 n395 PAR_1_1_VSS 35.0609171225
G0_66 PAR_1_1_VDD075NNE PAR_0_0_VSS PAR_1_1_VDD075NNE PAR_0_0_VSS -0.244813891346
C0_66 PAR_1_1_VDD075NNE PAR_0_0_VSS 1.95778555909e-10
R_1_66 PAR_1_1_VDD075NNE n396 0.110513187529
C_1_66 n396 PAR_0_0_VSS 1.29638261799e-10
R_2_66 PAR_1_1_VDD075NNE n397 0.25998758292
C_2_66 n397 PAR_0_0_VSS 1.39438463531e-10
L_3_66 PAR_1_1_VDD075NNE n398 7.19394026323e-10
R_3_66 n398 PAR_0_0_VSS 4.70324338878
R_4_66 PAR_1_1_VDD075NNE n399 8.58975341046
C_4_66 n399 PAR_0_0_VSS 4.86917016882e-11
R_5_66 PAR_1_1_VDD075NNE n400 10.3128574594
C_5_66 n400 PAR_0_0_VSS 2.05432037153e-10
L_6_66 PAR_1_1_VDD075NNE n401 2.95920366121e-07
R_6_66 n401 PAR_0_0_VSS 31.0610502445
G0_67 PAR_2_1_VSS PAR_0_0_VDD075NNE PAR_2_1_VSS PAR_0_0_VDD075NNE -1.10040880983
C0_67 PAR_2_1_VSS PAR_0_0_VDD075NNE 2.12740920104e-10
R_1_67 PAR_2_1_VSS n402 0.112967961059
C_1_67 n402 PAR_0_0_VDD075NNE 1.43663510867e-10
L_2_67 PAR_2_1_VSS n403 1.22911830955e-10
R_2_67 n403 PAR_0_0_VDD075NNE 1.72580666328
R_3_67 PAR_2_1_VSS n404 1.55320945232
C_3_67 n404 PAR_0_0_VDD075NNE 8.88675988726e-11
L_4_67 PAR_2_1_VSS n405 1.09101045347e-09
R_4_67 n405 PAR_0_0_VDD075NNE 2.45916935473
L_5_67 PAR_2_1_VSS n406 1.1684052377e-08
R_5_67 n406 PAR_0_0_VDD075NNE 9.21070325868
L_6_67 PAR_2_1_VSS n407 1.23277141284e-06
R_6_67 n407 PAR_0_0_VDD075NNE 173.643772785
R0_68 PAR_2_1_VSS PAR_1_0_VSS 0.152687431263
C0_68 PAR_2_1_VSS PAR_1_0_VSS 2.29364456716e-10
R_1_68 PAR_2_1_VSS n408 0.368500385053
C_1_68 n408 PAR_1_0_VSS 9.59077410721e-11
R_2_68 PAR_2_1_VSS n409 0.616884228119
C_2_68 n409 PAR_1_0_VSS 2.29510880391e-10
R_3_68 PAR_2_1_VSS n410 0.172965703228
C_3_68 n410 PAR_1_0_VSS 2.01669609331e-09
R_4_68 PAR_2_1_VSS n411 1.18975131117
C_4_68 n411 PAR_1_0_VSS 7.3321038047e-10
R_5_68 PAR_2_1_VSS n412 0.822579974094
C_5_68 n412 PAR_1_0_VSS 2.3471623555e-09
L_6_68 PAR_2_1_VSS n413 2.9508647975e-08
R_6_68 n413 PAR_1_0_VSS 3.11116804767
G0_69 PAR_2_1_VSS PAR_1_0_VDD075NNE PAR_2_1_VSS PAR_1_0_VDD075NNE -0.448121487887
C0_69 PAR_2_1_VSS PAR_1_0_VDD075NNE 1.90885012332e-10
R_1_69 PAR_2_1_VSS n414 0.156291171252
C_1_69 n414 PAR_1_0_VDD075NNE 1.15048890322e-10
R_2_69 PAR_2_1_VSS n415 1.96616548562
C_2_69 n415 PAR_1_0_VDD075NNE 8.28155254005e-11
L_3_69 PAR_2_1_VSS n416 1.29439824609e-09
R_3_69 n416 PAR_1_0_VDD075NNE 2.98064492181
L_4_69 PAR_2_1_VSS n417 1.13161574972e-08
R_4_69 n417 PAR_1_0_VDD075NNE 9.34516014731
L_5_69 PAR_2_1_VSS n418 1.21849983825e-06
R_5_69 n418 PAR_1_0_VDD075NNE 178.05106625
R0_70 PAR_2_1_VSS PAR_2_0_VSS 0.0106959429064
C0_70 PAR_2_1_VSS PAR_2_0_VSS 1.6116549934e-10
L_1_70 PAR_2_1_VSS n419 3.81363550737e-13
R_1_70 n419 PAR_2_0_VSS 0.0171332931072
L_2_70 PAR_2_1_VSS n420 3.74395825776e-12
R_2_70 n420 PAR_2_0_VSS 0.0757375512977
R_3_70 PAR_2_1_VSS n421 0.242698427735
C_3_70 n421 PAR_2_0_VSS 1.65314068356e-09
R_4_70 PAR_2_1_VSS n422 1.10805119581
C_4_70 n422 PAR_2_0_VSS 1.36178042759e-09
L_5_70 PAR_2_1_VSS n423 6.55959708566e-08
R_5_70 n423 PAR_2_0_VSS 6.43573494746
G0_71 PAR_2_1_VSS PAR_2_0_VDD075NNE PAR_2_1_VSS PAR_2_0_VDD075NNE -0.442083542575
C0_71 PAR_2_1_VSS PAR_2_0_VDD075NNE 1.90374770477e-10
R_1_71 PAR_2_1_VSS n424 0.0346321120952
C_1_71 n424 PAR_2_0_VDD075NNE 6.49418052238e-10
R_2_71 PAR_2_1_VSS n425 0.11304264254
C_2_71 n425 PAR_2_0_VDD075NNE 3.96579774591e-10
R_3_71 PAR_2_1_VSS n426 1.5507238106
C_3_71 n426 PAR_2_0_VDD075NNE 9.80392623357e-11
L_4_71 PAR_2_1_VSS n427 1.38916572e-09
R_4_71 n427 PAR_2_0_VDD075NNE 2.99232881891
L_5_71 PAR_2_1_VSS n428 1.23753467909e-08
R_5_71 n428 PAR_2_0_VDD075NNE 9.74558393684
L_6_71 PAR_2_1_VSS n429 1.41626073577e-06
R_6_71 n429 PAR_2_0_VDD075NNE 189.211327843
R0_72 PAR_2_1_VSS PAR_3_0_VSS 0.149240573355
C0_72 PAR_2_1_VSS PAR_3_0_VSS 2.36141284545e-10
R_1_72 PAR_2_1_VSS n430 0.0613671510052
C_1_72 n430 PAR_3_0_VSS 7.38014297137e-10
R_2_72 PAR_2_1_VSS n431 0.0964463019228
C_2_72 n431 PAR_3_0_VSS 1.46630411914e-09
R_3_72 PAR_2_1_VSS n432 0.0424767636853
C_3_72 n432 PAR_3_0_VSS 6.8619743327e-09
R_4_72 PAR_2_1_VSS n433 0.136476286997
C_4_72 n433 PAR_3_0_VSS 4.46464458877e-09
R_5_72 PAR_2_1_VSS n434 0.316586204092
C_5_72 n434 PAR_3_0_VSS 3.77743840474e-09
R_6_72 PAR_2_1_VSS n435 1.7562133656
C_6_72 n435 PAR_3_0_VSS 5.60167231959e-09
G0_73 PAR_2_1_VSS PAR_3_0_VDD075NNE PAR_2_1_VSS PAR_3_0_VDD075NNE -1.46159685663
C0_73 PAR_2_1_VSS PAR_3_0_VDD075NNE 2.5113252457e-10
R_1_73 PAR_2_1_VSS n436 0.0498952068321
C_1_73 n436 PAR_3_0_VDD075NNE 3.76748513078e-10
R_2_73 PAR_2_1_VSS n437 0.36496420488
C_2_73 n437 PAR_3_0_VDD075NNE 1.16107842922e-10
R_3_73 PAR_2_1_VSS n438 0.748715065681
C_3_73 n438 PAR_3_0_VDD075NNE 2.34458048631e-10
L_4_73 PAR_2_1_VSS n439 3.68661881293e-10
R_4_73 n439 PAR_3_0_VDD075NNE 0.832766427016
L_5_73 PAR_2_1_VSS n440 4.78386621445e-09
R_5_73 n440 PAR_3_0_VDD075NNE 4.00909583461
L_6_73 PAR_2_1_VSS n441 4.86673611365e-07
R_6_73 n441 PAR_3_0_VDD075NNE 88.1277872207
G0_74 PAR_2_1_VSS PAR_0_1_VSS PAR_2_1_VSS PAR_0_1_VSS -9.80413987748
C0_74 PAR_2_1_VSS PAR_0_1_VSS 2.71446111869e-10
R_1_74 PAR_2_1_VSS n442 0.0923304983259
C_1_74 n442 PAR_0_1_VSS 3.63135785965e-10
R_2_74 PAR_2_1_VSS n443 0.0403498679463
C_2_74 n443 PAR_0_1_VSS 5.86997570019e-09
L_3_74 PAR_2_1_VSS n444 5.22172706626e-11
R_3_74 n444 PAR_0_1_VSS 0.125476320075
L_4_74 PAR_2_1_VSS n445 6.48095938752e-10
R_4_74 n445 PAR_0_1_VSS 0.556548302949
L_5_74 PAR_2_1_VSS n446 7.95981952e-08
R_5_74 n446 PAR_0_1_VSS 11.8849434451
G0_75 PAR_2_1_VSS PAR_0_1_VDD075NNE PAR_2_1_VSS PAR_0_1_VDD075NNE -1.00606523493
C0_75 PAR_2_1_VSS PAR_0_1_VDD075NNE 2.54335041004e-10
R_1_75 PAR_2_1_VSS n447 0.0559834082259
C_1_75 n447 PAR_0_1_VDD075NNE 2.12658627115e-10
R_2_75 PAR_2_1_VSS n448 1.85239512647
C_2_75 n448 PAR_0_1_VDD075NNE 9.22984321103e-11
L_3_75 PAR_2_1_VSS n449 3.6760382491e-10
R_3_75 n449 PAR_0_1_VDD075NNE 1.28092396734
L_4_75 PAR_2_1_VSS n450 4.53902527545e-09
R_4_75 n450 PAR_0_1_VDD075NNE 4.75371025137
L_5_75 PAR_2_1_VSS n451 3.12815929229e-07
R_5_75 n451 PAR_0_1_VDD075NNE 66.5921913862
R0_76 PAR_2_1_VSS PAR_1_1_VSS 0.00236819086842
C0_76 PAR_2_1_VSS PAR_1_1_VSS 7.3812807653e-12
L_1_76 PAR_2_1_VSS n452 1.62404597436e-13
R_1_76 n452 PAR_1_1_VSS 0.00512028666468
L_2_76 PAR_2_1_VSS n453 1.81327095893e-11
R_2_76 n453 PAR_1_1_VSS 0.213515297929
R_3_76 PAR_2_1_VSS n454 0.146565118376
C_3_76 n454 PAR_1_1_VSS 1.17552151091e-09
L_4_76 PAR_2_1_VSS n455 5.64743354412e-11
R_4_76 n455 PAR_1_1_VSS 0.118500853797
L_5_76 PAR_2_1_VSS n456 7.42241793115e-10
R_5_76 n456 PAR_1_1_VSS 0.568321275821
L_6_76 PAR_2_1_VSS n457 9.87662108924e-08
R_6_76 n457 PAR_1_1_VSS 12.3776596658
G0_77 PAR_2_1_VSS PAR_1_1_VDD075NNE PAR_2_1_VSS PAR_1_1_VDD075NNE -0.420604356511
C0_77 PAR_2_1_VSS PAR_1_1_VDD075NNE 2.27250566232e-10
R_1_77 PAR_2_1_VSS n458 0.0231509476069
C_1_77 n458 PAR_1_1_VDD075NNE 6.92036749781e-10
R_2_77 PAR_2_1_VSS n459 0.0108738266183
C_2_77 n459 PAR_1_1_VDD075NNE 3.37576823952e-09
R_3_77 PAR_2_1_VSS n460 1.50250693842
C_3_77 n460 PAR_1_1_VDD075NNE 9.57251327333e-11
L_4_77 PAR_2_1_VSS n461 1.55881078544e-09
R_4_77 n461 PAR_1_1_VDD075NNE 3.37550552478
L_5_77 PAR_2_1_VSS n462 1.06198230346e-08
R_5_77 n462 PAR_1_1_VDD075NNE 8.48324341556
L_6_77 PAR_2_1_VSS n463 1.15120161789e-06
R_6_77 n463 PAR_1_1_VDD075NNE 154.487989911
G0_78 PAR_2_1_VSS PAR_0_0_VSS PAR_2_1_VSS PAR_0_0_VSS -0.444473380376
C0_78 PAR_2_1_VSS PAR_0_0_VSS 2.06681851529e-10
R_1_78 PAR_2_1_VSS n464 0.129827177889
C_1_78 n464 PAR_0_0_VSS 2.93460323283e-10
R_2_78 PAR_2_1_VSS n465 0.631378128919
C_2_78 n465 PAR_0_0_VSS 1.98406939103e-10
R_3_78 PAR_2_1_VSS n466 0.134252698215
C_3_78 n466 PAR_0_0_VSS 2.08062080931e-09
R_4_78 PAR_2_1_VSS n467 0.245813474304
C_4_78 n467 PAR_0_0_VSS 1.74315825269e-09
R_5_78 PAR_2_1_VSS n468 0.677550716087
C_5_78 n468 PAR_0_0_VSS 3.14095688067e-09
L_6_78 PAR_2_1_VSS n469 2.13896929843e-08
R_6_78 n469 PAR_0_0_VSS 2.24982361541
G0_79 PAR_2_1_VDD075NNE PAR_0_0_VDD075NNE PAR_2_1_VDD075NNE PAR_0_0_VDD075NNE -7.54820025444
C0_79 PAR_2_1_VDD075NNE PAR_0_0_VDD075NNE 1.30962909421e-10
R_1_79 PAR_2_1_VDD075NNE n470 0.180320472727
C_1_79 n470 PAR_0_0_VDD075NNE 1.31301410581e-10
L_2_79 PAR_2_1_VDD075NNE n471 7.85537945514e-12
R_2_79 n471 PAR_0_0_VDD075NNE 0.150319814345
R_3_79 PAR_2_1_VDD075NNE n472 0.596372729344
C_3_79 n472 PAR_0_0_VDD075NNE 2.16605872899e-10
L_4_79 PAR_2_1_VDD075NNE n473 3.92587830823e-10
R_4_79 n473 PAR_0_0_VDD075NNE 1.30882474319
R_5_79 PAR_2_1_VDD075NNE n474 3.07231748274
C_5_79 n474 PAR_0_0_VDD075NNE 2.70090167039e-10
L_6_79 PAR_2_1_VDD075NNE n475 1.53976088641e-08
R_6_79 n475 PAR_0_0_VDD075NNE 7.56494985355
R_7_79 PAR_2_1_VDD075NNE n476 4398.36978277
C_7_79 n476 PAR_0_0_VDD075NNE 2.53302116814e-10
G0_80 PAR_2_1_VDD075NNE PAR_1_0_VSS PAR_2_1_VDD075NNE PAR_1_0_VSS -0.129938043888
C0_80 PAR_2_1_VDD075NNE PAR_1_0_VSS 2.28073258242e-10
R_1_80 PAR_2_1_VDD075NNE n477 0.0791856417884
C_1_80 n477 PAR_1_0_VSS 2.06539933101e-10
R_2_80 PAR_2_1_VDD075NNE n478 0.316530459863
C_2_80 n478 PAR_1_0_VSS 1.2741576863e-10
L_3_80 PAR_2_1_VDD075NNE n479 1.26042881362e-09
R_3_80 n479 PAR_1_0_VSS 9.42694382908
R_4_80 PAR_2_1_VDD075NNE n480 11.1205396224
C_4_80 n480 PAR_1_0_VSS 4.26718520982e-11
R_5_80 PAR_2_1_VDD075NNE n481 9.73209559448
C_5_80 n481 PAR_1_0_VSS 1.7937339892e-10
L_6_80 PAR_2_1_VDD075NNE n482 4.10741540531e-07
R_6_80 n482 PAR_1_0_VSS 41.9126752929
G0_81 PAR_2_1_VDD075NNE PAR_1_0_VDD075NNE PAR_2_1_VDD075NNE PAR_1_0_VDD075NNE -0.21668786075
C0_81 PAR_2_1_VDD075NNE PAR_1_0_VDD075NNE 1.53439360025e-10
L_1_81 PAR_2_1_VDD075NNE n483 4.34372204984e-12
R_1_81 n483 PAR_1_0_VDD075NNE 0.196354697956
L_2_81 PAR_2_1_VDD075NNE n484 1.88855695206e-11
R_2_81 n484 PAR_1_0_VDD075NNE 0.35463874283
R_3_81 PAR_2_1_VDD075NNE n485 5.04256787985
C_3_81 n485 PAR_1_0_VDD075NNE 3.31921885934e-11
L_4_81 PAR_2_1_VDD075NNE n486 7.40301183002e-09
R_4_81 n486 PAR_1_0_VDD075NNE 10.6831760769
R_5_81 PAR_2_1_VDD075NNE n487 54.4182085806
C_5_81 n487 PAR_1_0_VDD075NNE 4.26710845559e-11
G0_82 PAR_2_1_VDD075NNE PAR_2_0_VSS PAR_2_1_VDD075NNE PAR_2_0_VSS -0.0126964466272
C0_82 PAR_2_1_VDD075NNE PAR_2_0_VSS 2.47510994211e-10
R_1_82 PAR_2_1_VDD075NNE n488 0.00686488524998
C_1_82 n488 PAR_2_0_VSS 2.41694347154e-09
R_2_82 PAR_2_1_VDD075NNE n489 0.0197062661739
C_2_82 n489 PAR_2_0_VSS 1.94340140455e-09
R_3_82 PAR_2_1_VDD075NNE n490 0.791170576539
C_3_82 n490 PAR_2_0_VSS 9.85957460008e-11
R_4_82 PAR_2_1_VDD075NNE n491 10.0295202363
C_4_82 n491 PAR_2_0_VSS 4.18772979616e-11
R_5_82 PAR_2_1_VDD075NNE n492 17.3624164263
C_5_82 n492 PAR_2_0_VSS 9.023777555e-11
L_6_82 PAR_2_1_VDD075NNE n493 7.77037255e-07
R_6_82 n493 PAR_2_0_VSS 78.7621678282
R0_83 PAR_2_1_VDD075NNE PAR_2_0_VDD075NNE 0.00812339780322
C0_83 PAR_2_1_VDD075NNE PAR_2_0_VDD075NNE 1.69660630776e-10
L_1_83 PAR_2_1_VDD075NNE n494 2.59310925316e-13
R_1_83 n494 PAR_2_0_VDD075NNE 0.0128133338167
L_2_83 PAR_2_1_VDD075NNE n495 1.78039344811e-12
R_2_83 n495 PAR_2_0_VDD075NNE 0.0429147580647
L_3_83 PAR_2_1_VDD075NNE n496 4.21230264586e-10
R_3_83 n496 PAR_2_0_VDD075NNE 3.83261548904
L_4_83 PAR_2_1_VDD075NNE n497 3.04291638363e-08
R_4_83 n497 PAR_2_0_VDD075NNE 64.6677705308
L_5_83 PAR_2_1_VDD075NNE n498 3.24654769142e-07
R_5_83 n498 PAR_2_0_VDD075NNE 194.304756828
L_6_83 PAR_2_1_VDD075NNE n499 0.00655716940797
R_6_83 n499 PAR_2_0_VDD075NNE 1017.99037014
G0_84 PAR_2_1_VDD075NNE PAR_3_0_VSS PAR_2_1_VDD075NNE PAR_3_0_VSS -0.830216554798
C0_84 PAR_2_1_VDD075NNE PAR_3_0_VSS 2.83696689407e-10
R_1_84 PAR_2_1_VDD075NNE n500 0.021433058846
C_1_84 n500 PAR_3_0_VSS 7.78265535282e-10
R_2_84 PAR_2_1_VDD075NNE n501 0.121154212225
C_2_84 n501 PAR_3_0_VSS 3.73938188837e-10
L_3_84 PAR_2_1_VDD075NNE n502 1.91124627309e-10
R_3_84 n502 PAR_3_0_VSS 1.20450500121
R_4_84 PAR_2_1_VDD075NNE n503 3.20307417523
C_4_84 n503 PAR_3_0_VSS 1.80333301328e-10
R_5_84 PAR_2_1_VDD075NNE n504 4.4810947884
C_5_84 n504 PAR_3_0_VSS 2.57336407093e-10
R_6_84 PAR_2_1_VDD075NNE n505 22.4171763095
C_6_84 n505 PAR_3_0_VSS 4.37159105099e-10
G0_85 PAR_2_1_VDD075NNE PAR_3_0_VDD075NNE PAR_2_1_VDD075NNE PAR_3_0_VDD075NNE -4.15013168549
C0_85 PAR_2_1_VDD075NNE PAR_3_0_VDD075NNE 1.93438967944e-10
R_1_85 PAR_2_1_VDD075NNE n506 0.0225266027859
C_1_85 n506 PAR_3_0_VDD075NNE 1.78490019315e-10
L_2_85 PAR_2_1_VDD075NNE n507 3.133848976e-12
R_2_85 n507 PAR_3_0_VDD075NNE 0.106571076604
L_3_85 PAR_2_1_VDD075NNE n508 2.56865392985e-11
R_3_85 n508 PAR_3_0_VDD075NNE 0.425576377756
L_4_85 PAR_2_1_VDD075NNE n509 1.05589913249e-09
R_4_85 n509 PAR_3_0_VDD075NNE 7.48927847255
L_5_85 PAR_2_1_VDD075NNE n510 6.66756329546e-09
R_5_85 n510 PAR_3_0_VDD075NNE 21.8321699064
L_6_85 PAR_2_1_VDD075NNE n511 3.44448722688e-08
R_6_85 n511 PAR_3_0_VDD075NNE 48.2931514883
L_7_85 PAR_2_1_VDD075NNE n512 1.88443830515e-07
R_7_85 n512 PAR_3_0_VDD075NNE 117.041160573
R_8_85 PAR_2_1_VDD075NNE n513 2646.24034048
C_8_85 n513 PAR_3_0_VDD075NNE 3.04953075588e-12
G0_86 PAR_2_1_VDD075NNE PAR_0_1_VSS PAR_2_1_VDD075NNE PAR_0_1_VSS -0.870711811573
C0_86 PAR_2_1_VDD075NNE PAR_0_1_VSS 2.79287075932e-10
R_1_86 PAR_2_1_VDD075NNE n514 0.110871414915
C_1_86 n514 PAR_0_1_VSS 1.30454270857e-10
R_2_86 PAR_2_1_VDD075NNE n515 3.6839852843
C_2_86 n515 PAR_0_1_VSS 2.97418530543e-11
L_3_86 PAR_2_1_VDD075NNE n516 3.81283294949e-10
R_3_86 n516 PAR_0_1_VSS 1.42723614346
L_4_86 PAR_2_1_VDD075NNE n517 5.92090505931e-09
R_4_86 n517 PAR_0_1_VSS 6.34478155652
L_5_86 PAR_2_1_VDD075NNE n518 3.57175187716e-07
R_5_86 n518 PAR_0_1_VSS 80.3401565809
G0_87 PAR_2_1_VDD075NNE PAR_0_1_VDD075NNE PAR_2_1_VDD075NNE PAR_0_1_VDD075NNE -8.9525910855
C0_87 PAR_2_1_VDD075NNE PAR_0_1_VDD075NNE 1.6496656615e-10
R_1_87 PAR_2_1_VDD075NNE n519 0.16113164588
C_1_87 n519 PAR_0_1_VDD075NNE 1.55040880794e-10
L_2_87 PAR_2_1_VDD075NNE n520 7.41021725101e-12
R_2_87 n520 PAR_0_1_VDD075NNE 0.120636506323
R_3_87 PAR_2_1_VDD075NNE n521 0.414121106974
C_3_87 n521 PAR_0_1_VDD075NNE 2.86107841053e-10
L_4_87 PAR_2_1_VDD075NNE n522 9.34465845127e-10
R_4_87 n522 PAR_0_1_VDD075NNE 1.74515883157
R_5_87 PAR_2_1_VDD075NNE n523 3.01447253439
C_5_87 n523 PAR_0_1_VDD075NNE 4.10981051328e-10
L_6_87 PAR_2_1_VDD075NNE n524 6.36487067626e-08
R_6_87 n524 PAR_0_1_VDD075NNE 11.1862110491
G0_88 PAR_2_1_VDD075NNE PAR_1_1_VSS PAR_2_1_VDD075NNE PAR_1_1_VSS -0.505679854006
C0_88 PAR_2_1_VDD075NNE PAR_1_1_VSS 3.12480547148e-10
R_1_88 PAR_2_1_VDD075NNE n525 0.00533522130307
C_1_88 n525 PAR_1_1_VSS 2.71288316974e-09
R_2_88 PAR_2_1_VDD075NNE n526 0.00401122361203
C_2_88 n526 PAR_1_1_VSS 8.65502519236e-09
R_3_88 PAR_2_1_VDD075NNE n527 0.31397639071
C_3_88 n527 PAR_1_1_VSS 2.36468468581e-10
L_4_88 PAR_2_1_VDD075NNE n528 1.10211761781e-09
R_4_88 n528 PAR_1_1_VSS 2.88790177993
L_5_88 PAR_2_1_VDD075NNE n529 7.47406612476e-09
R_5_88 n529 PAR_1_1_VSS 6.64324271781
L_6_88 PAR_2_1_VDD075NNE n530 7.11692841889e-07
R_6_88 n530 PAR_1_1_VSS 112.627864295
R0_89 PAR_2_1_VDD075NNE PAR_1_1_VDD075NNE 0.0027319737967
C0_89 PAR_2_1_VDD075NNE PAR_1_1_VDD075NNE 1.04907273725e-10
L_1_89 PAR_2_1_VDD075NNE n531 1.41807642042e-13
R_1_89 n531 PAR_1_1_VDD075NNE 0.00851476642069
L_2_89 PAR_2_1_VDD075NNE n532 2.54847786103e-13
R_2_89 n532 PAR_1_1_VDD075NNE 0.0069712953694
L_3_89 PAR_2_1_VDD075NNE n533 1.73111864339e-10
R_3_89 n533 PAR_1_1_VDD075NNE 1.81809878596
L_4_89 PAR_2_1_VDD075NNE n534 2.57590785464e-08
R_4_89 n534 PAR_1_1_VDD075NNE 60.9700382156
L_5_89 PAR_2_1_VDD075NNE n535 2.45619761591e-07
R_5_89 n535 PAR_1_1_VDD075NNE 154.598073113
L_6_89 PAR_2_1_VDD075NNE n536 0.00493158645533
R_6_89 n536 PAR_1_1_VDD075NNE 927.881705499
G0_90 PAR_2_1_VDD075NNE PAR_2_1_VSS PAR_2_1_VDD075NNE PAR_2_1_VSS -0.236711296113
C0_90 PAR_2_1_VDD075NNE PAR_2_1_VSS 9.09410466304e-10
R_1_90 PAR_2_1_VDD075NNE n537 0.000436816359992
C_1_90 n537 PAR_2_1_VSS 3.00497757291e-08
R_2_90 PAR_2_1_VDD075NNE n538 0.000254904368398
C_2_90 n538 PAR_2_1_VSS 1.27793322595e-07
R_3_90 PAR_2_1_VDD075NNE n539 0.00418971260434
C_3_90 n539 PAR_2_1_VSS 1.21511827471e-08
R_4_90 PAR_2_1_VDD075NNE n540 0.409896106533
C_4_90 n540 PAR_2_1_VSS 4.82466528957e-10
L_5_90 PAR_2_1_VDD075NNE n541 4.10523111995e-09
R_5_90 n541 PAR_2_1_VSS 4.58248809972
L_6_90 PAR_2_1_VDD075NNE n542 2.16672799669e-07
R_6_90 n542 PAR_2_1_VSS 54.0855156832
G0_91 PAR_2_1_VDD075NNE PAR_0_0_VSS PAR_2_1_VDD075NNE PAR_0_0_VSS -0.0221966305129
C0_91 PAR_2_1_VDD075NNE PAR_0_0_VSS 2.09582487339e-10
R_1_91 PAR_2_1_VDD075NNE n543 0.120688697792
C_1_91 n543 PAR_0_0_VSS 1.43579729168e-10
R_2_91 PAR_2_1_VDD075NNE n544 7.29301605428
C_2_91 n544 PAR_0_0_VSS 2.08252077072e-10
L_3_91 PAR_2_1_VDD075NNE n545 1.27276740523e-06
R_3_91 n545 PAR_0_0_VSS 45.0518747916
G0_92 PAR_3_1_VSS PAR_0_0_VDD075NNE PAR_3_1_VSS PAR_0_0_VDD075NNE -0.789116954253
C0_92 PAR_3_1_VSS PAR_0_0_VDD075NNE 3.20437384634e-10
R_1_92 PAR_3_1_VSS n546 0.0266624582036
C_1_92 n546 PAR_0_0_VDD075NNE 8.13099251338e-10
L_2_92 PAR_3_1_VSS n547 1.78351956714e-10
R_2_92 n547 PAR_0_0_VDD075NNE 1.33494570402
L_3_92 PAR_3_1_VSS n548 8.90763515634e-08
R_3_92 n548 PAR_0_0_VDD075NNE 24.9857446546
R0_93 PAR_3_1_VSS PAR_1_0_VSS 10.1794038071
C0_93 PAR_3_1_VSS PAR_1_0_VSS 3.00552009455e-10
R_1_93 PAR_3_1_VSS n549 0.0531057031121
C_1_93 n549 PAR_1_0_VSS 5.46503135897e-10
R_2_93 PAR_3_1_VSS n550 0.0824323746149
C_2_93 n550 PAR_1_0_VSS 1.20476500053e-09
R_3_93 PAR_3_1_VSS n551 0.279025022282
C_3_93 n551 PAR_1_0_VSS 8.51680557461e-10
R_4_93 PAR_3_1_VSS n552 0.16881652273
C_4_93 n552 PAR_1_0_VSS 3.32689362343e-09
R_5_93 PAR_3_1_VSS n553 0.119233074555
C_5_93 n553 PAR_1_0_VSS 2.11865131361e-08
R_6_93 PAR_3_1_VSS n554 0.222642303722
C_6_93 n554 PAR_1_0_VSS 3.82230537087e-08
G0_94 PAR_3_1_VSS PAR_1_0_VDD075NNE PAR_3_1_VSS PAR_1_0_VDD075NNE -0.524867141847
C0_94 PAR_3_1_VSS PAR_1_0_VDD075NNE 2.31677825034e-10
R_1_94 PAR_3_1_VSS n555 0.0301823518949
C_1_94 n555 PAR_1_0_VDD075NNE 4.57571143101e-10
R_2_94 PAR_3_1_VSS n556 0.147955080033
C_2_94 n556 PAR_1_0_VDD075NNE 2.40876950931e-10
L_3_94 PAR_3_1_VSS n557 2.93606431566e-10
R_3_94 n557 PAR_1_0_VDD075NNE 2.34877315743
R_4_94 PAR_3_1_VSS n558 8.09671306423
C_4_94 n558 PAR_1_0_VDD075NNE 6.29066599421e-11
L_5_94 PAR_3_1_VSS n559 2.3310742748e-08
R_5_94 n559 PAR_1_0_VDD075NNE 10.089497697
R_6_94 PAR_3_1_VSS n560 29.7340751384
C_6_94 n560 PAR_1_0_VDD075NNE 2.93218898527e-10
R0_95 PAR_3_1_VSS PAR_2_0_VSS 0.144942557526
C0_95 PAR_3_1_VSS PAR_2_0_VSS 2.80698182873e-10
R_1_95 PAR_3_1_VSS n561 0.0659427133884
C_1_95 n561 PAR_2_0_VSS 2.84137556002e-10
R_2_95 PAR_3_1_VSS n562 0.295008755659
C_2_95 n562 PAR_2_0_VSS 4.01371255993e-10
R_3_95 PAR_3_1_VSS n563 0.268131098821
C_3_95 n563 PAR_2_0_VSS 1.77382309753e-09
R_4_95 PAR_3_1_VSS n564 0.506465976256
C_4_95 n564 PAR_2_0_VSS 1.67594448141e-09
R_5_95 PAR_3_1_VSS n565 0.203893369306
C_5_95 n565 PAR_2_0_VSS 1.19842308223e-08
R_6_95 PAR_3_1_VSS n566 0.384460721065
C_6_95 n566 PAR_2_0_VSS 2.2565627315e-08
G0_96 PAR_3_1_VSS PAR_2_0_VDD075NNE PAR_3_1_VSS PAR_2_0_VDD075NNE -0.030256187636
C0_96 PAR_3_1_VSS PAR_2_0_VDD075NNE 3.61240256384e-10
R_1_96 PAR_3_1_VSS n567 0.0414455031945
C_1_96 n567 PAR_2_0_VDD075NNE 6.41748545259e-10
R_2_96 PAR_3_1_VSS n568 11.7720385958
C_2_96 n568 PAR_2_0_VDD075NNE 4.30015365872e-11
L_3_96 PAR_3_1_VSS n569 1.46379998115e-07
R_3_96 n569 PAR_2_0_VDD075NNE 33.0510853596
R0_97 PAR_3_1_VSS PAR_3_0_VSS 0.0113160692565
C0_97 PAR_3_1_VSS PAR_3_0_VSS 2.77872348417e-10
L_1_97 PAR_3_1_VSS n570 1.22775168185e-13
R_1_97 n570 PAR_3_0_VSS 0.00774428647797
R_2_97 PAR_3_1_VSS n571 0.0145181990741
C_2_97 n571 PAR_3_0_VSS 7.2820762235e-09
R_3_97 PAR_3_1_VSS n572 0.0456007668458
C_3_97 n572 PAR_3_0_VSS 5.75706561358e-09
R_4_97 PAR_3_1_VSS n573 0.0555975346138
C_4_97 n573 PAR_3_0_VSS 1.30572498067e-08
R_5_97 PAR_3_1_VSS n574 0.0558394664783
C_5_97 n574 PAR_3_0_VSS 3.11565805362e-08
R_6_97 PAR_3_1_VSS n575 0.196028712731
C_6_97 n575 PAR_3_0_VSS 5.67715829254e-08
G0_98 PAR_3_1_VSS PAR_3_0_VDD075NNE PAR_3_1_VSS PAR_3_0_VDD075NNE -0.603407304343
C0_98 PAR_3_1_VSS PAR_3_0_VDD075NNE 4.46827357085e-10
R_1_98 PAR_3_1_VSS n576 0.0109100182297
C_1_98 n576 PAR_3_0_VDD075NNE 2.88874346388e-09
L_2_98 PAR_3_1_VSS n577 8.17076808638e-09
R_2_98 n577 PAR_3_0_VDD075NNE 19.0974268729
L_3_98 PAR_3_1_VSS n578 1.96670233836e-09
R_3_98 n578 PAR_3_0_VDD075NNE 1.81473634629
R0_99 PAR_3_1_VSS PAR_0_1_VSS 4320.69850391
C0_99 PAR_3_1_VSS PAR_0_1_VSS 4.42286958251e-10
R_1_99 PAR_3_1_VSS n579 0.0314582065141
C_1_99 n579 PAR_0_1_VSS 2.08010114462e-09
R_2_99 PAR_3_1_VSS n580 0.0242379745075
C_2_99 n580 PAR_0_1_VSS 8.98051581253e-09
R_3_99 PAR_3_1_VSS n581 3.42630193568
C_3_99 n581 PAR_0_1_VSS 8.11543231097e-10
G0_100 PAR_3_1_VSS PAR_0_1_VDD075NNE PAR_3_1_VSS PAR_0_1_VDD075NNE -2.09029575091
C0_100 PAR_3_1_VSS PAR_0_1_VDD075NNE 4.69512226132e-10
R_1_100 PAR_3_1_VSS n582 0.0210465734597
C_1_100 n582 PAR_0_1_VDD075NNE 1.10036190532e-09
L_2_100 PAR_3_1_VSS n583 7.65108355809e-11
R_2_100 n583 PAR_0_1_VDD075NNE 0.479219415229
L_3_100 PAR_3_1_VSS n584 1.30952978366e-05
R_3_100 n584 PAR_0_1_VDD075NNE 280.194471155
R0_101 PAR_3_1_VSS PAR_1_1_VSS 11.7483408668
C0_101 PAR_3_1_VSS PAR_1_1_VSS 4.85353463226e-10
R_1_101 PAR_3_1_VSS n585 0.0350989824917
C_1_101 n585 PAR_1_1_VSS 2.06229488121e-09
R_2_101 PAR_3_1_VSS n586 0.0189970485357
C_2_101 n586 PAR_1_1_VSS 1.17669157544e-08
R_3_101 PAR_3_1_VSS n587 3.52488210309
C_3_101 n587 PAR_1_1_VSS 1.04187699333e-09
G0_102 PAR_3_1_VSS PAR_1_1_VDD075NNE PAR_3_1_VSS PAR_1_1_VDD075NNE -1.22104628579
C0_102 PAR_3_1_VSS PAR_1_1_VDD075NNE 4.15857609046e-10
R_1_102 PAR_3_1_VSS n588 0.0248382309255
C_1_102 n588 PAR_1_1_VDD075NNE 8.97590116166e-10
L_2_102 PAR_3_1_VSS n589 1.38131303095e-10
R_2_102 n589 PAR_1_1_VDD075NNE 0.821728217054
L_3_102 PAR_3_1_VSS n590 8.61624150011e-06
R_3_102 n590 PAR_1_1_VDD075NNE 243.967235736
R0_103 PAR_3_1_VSS PAR_2_1_VSS 0.00213041546035
C0_103 PAR_3_1_VSS PAR_2_1_VSS 4.8667555647e-11
L_1_103 PAR_3_1_VSS n591 1.93336715515e-13
R_1_103 n591 PAR_2_1_VSS 0.00612930972231
R_2_103 PAR_3_1_VSS n592 0.056782055564
C_2_103 n592 PAR_2_1_VSS 3.61167894149e-09
R_3_103 PAR_3_1_VSS n593 0.0736975560292
C_3_103 n593 PAR_2_1_VSS 5.02613252506e-09
L_4_103 PAR_3_1_VSS n594 1.70401606479e-09
R_4_103 n594 PAR_2_1_VSS 0.614089975705
R_5_103 PAR_3_1_VSS n595 1.22759781566
C_5_103 n595 PAR_2_1_VSS 6.29595057487e-09
C0_104 PAR_3_1_VSS PAR_2_1_VDD075NNE 1.06787354519e-09
R_1_104 PAR_3_1_VSS n596 0.00291343790278
C_1_104 n596 PAR_2_1_VDD075NNE 1.1484773479e-08
R0_105 PAR_3_1_VSS PAR_0_0_VSS 23.3543448958
C0_105 PAR_3_1_VSS PAR_0_0_VSS 2.25633393776e-10
R_1_105 PAR_3_1_VSS n597 0.0583109273694
C_1_105 n597 PAR_0_0_VSS 8.44733762603e-10
R_2_105 PAR_3_1_VSS n598 0.0625429655929
C_2_105 n598 PAR_0_0_VSS 1.847020011e-09
R_3_105 PAR_3_1_VSS n599 0.143469081057
C_3_105 n599 PAR_0_0_VSS 1.7448728889e-09
R_4_105 PAR_3_1_VSS n600 0.0923373051095
C_4_105 n600 PAR_0_0_VSS 6.10227107754e-09
R_5_105 PAR_3_1_VSS n601 0.104756840108
C_5_105 n601 PAR_0_0_VSS 2.64814063198e-08
R_6_105 PAR_3_1_VSS n602 0.172570298334
C_6_105 n602 PAR_0_0_VSS 4.93260987031e-08
G0_106 PAR_3_1_VDD075NNE PAR_0_0_VDD075NNE PAR_3_1_VDD075NNE PAR_0_0_VDD075NNE -8.75313032572
C0_106 PAR_3_1_VDD075NNE PAR_0_0_VDD075NNE 1.5158171148e-10
R_1_106 PAR_3_1_VDD075NNE n603 0.0179202323523
C_1_106 n603 PAR_0_0_VDD075NNE 1.49073710556e-10
L_2_106 PAR_3_1_VDD075NNE n604 3.83794756911e-12
R_2_106 n604 PAR_0_0_VDD075NNE 0.136245890747
L_3_106 PAR_3_1_VDD075NNE n605 3.6554902141e-11
R_3_106 n605 PAR_0_0_VDD075NNE 0.737321983667
L_4_106 PAR_3_1_VDD075NNE n606 4.37136433473e-09
R_4_106 n606 PAR_0_0_VDD075NNE 32.6022698861
L_5_106 PAR_3_1_VDD075NNE n607 2.25563020032e-08
R_5_106 n607 PAR_0_0_VDD075NNE 63.9039628285
L_6_106 PAR_3_1_VDD075NNE n608 1.11844467367e-07
R_6_106 n608 PAR_0_0_VDD075NNE 139.175788652
L_7_106 PAR_3_1_VDD075NNE n609 4.63764392438e-07
R_7_106 n609 PAR_0_0_VDD075NNE 284.793875969
G0_107 PAR_3_1_VDD075NNE PAR_1_0_VSS PAR_3_1_VDD075NNE PAR_1_0_VSS -0.945772909985
C0_107 PAR_3_1_VDD075NNE PAR_1_0_VSS 2.0432634531e-10
R_1_107 PAR_3_1_VDD075NNE n610 0.0526760386646
C_1_107 n610 PAR_1_0_VSS 1.43216372276e-10
L_2_107 PAR_3_1_VDD075NNE n611 1.11925484695e-10
R_2_107 n611 PAR_1_0_VSS 1.33477713244
L_3_107 PAR_3_1_VDD075NNE n612 1.02550805009e-09
R_3_107 n612 PAR_1_0_VSS 5.83082036014
R_4_107 PAR_3_1_VDD075NNE n613 8.59886849549
C_4_107 n613 PAR_1_0_VSS 4.10049938513e-11
R_5_107 PAR_3_1_VDD075NNE n614 11.2421008421
C_5_107 n614 PAR_1_0_VSS 1.45168815883e-10
L_6_107 PAR_3_1_VDD075NNE n615 3.81222579823e-07
R_6_107 n615 PAR_1_0_VSS 39.8696771718
G0_108 PAR_3_1_VDD075NNE PAR_1_0_VDD075NNE PAR_3_1_VDD075NNE PAR_1_0_VDD075NNE -8.98505765148
C0_108 PAR_3_1_VDD075NNE PAR_1_0_VDD075NNE 1.29369341128e-10
R_1_108 PAR_3_1_VDD075NNE n616 0.165908486623
C_1_108 n616 PAR_1_0_VDD075NNE 1.71854491337e-10
L_2_108 PAR_3_1_VDD075NNE n617 8.01794675361e-12
R_2_108 n617 PAR_1_0_VDD075NNE 0.138257300617
R_3_108 PAR_3_1_VDD075NNE n618 0.505467211762
C_3_108 n618 PAR_1_0_VDD075NNE 3.16309457935e-10
L_4_108 PAR_3_1_VDD075NNE n619 3.05707446424e-10
R_4_108 n619 PAR_1_0_VDD075NNE 0.77459906086
R_5_108 PAR_3_1_VDD075NNE n620 1.05796268711
C_5_108 n620 PAR_1_0_VDD075NNE 8.79644942854e-10
L_6_108 PAR_3_1_VDD075NNE n621 3.92773565083e-09
R_6_108 n621 PAR_1_0_VDD075NNE 2.16771875173
R_7_108 PAR_3_1_VDD075NNE n622 29.3618249138
C_7_108 n622 PAR_1_0_VDD075NNE 3.12318461428e-10
G0_109 PAR_3_1_VDD075NNE PAR_2_0_VSS PAR_3_1_VDD075NNE PAR_2_0_VSS -0.00203223556673
C0_109 PAR_3_1_VDD075NNE PAR_2_0_VSS 2.30202413921e-10
R_1_109 PAR_3_1_VDD075NNE n623 0.613430890044
C_1_109 n623 PAR_2_0_VSS 4.95613421576e-11
R_2_109 PAR_3_1_VDD075NNE n624 8.85729628809
C_2_109 n624 PAR_2_0_VSS 6.39597320479e-11
L_3_109 PAR_3_1_VDD075NNE n625 8.19570180592e-05
R_3_109 n625 PAR_2_0_VSS 492.06818571
G0_110 PAR_3_1_VDD075NNE PAR_2_0_VDD075NNE PAR_3_1_VDD075NNE PAR_2_0_VDD075NNE -0.528533363668
C0_110 PAR_3_1_VDD075NNE PAR_2_0_VDD075NNE 1.9370819442e-10
L_1_110 PAR_3_1_VDD075NNE n626 5.50952126891e-12
R_1_110 n626 PAR_2_0_VDD075NNE 0.191751227896
L_2_110 PAR_3_1_VDD075NNE n627 2.17442242533e-11
R_2_110 n627 PAR_2_0_VDD075NNE 0.36016521471
R_3_110 PAR_3_1_VDD075NNE n628 2.32641290211
C_3_110 n628 PAR_2_0_VDD075NNE 8.11111324503e-11
L_4_110 PAR_3_1_VDD075NNE n629 1.91484113458e-09
R_4_110 n629 PAR_2_0_VDD075NNE 3.78760750172
R_5_110 PAR_3_1_VDD075NNE n630 10.1330413288
C_5_110 n630 PAR_2_0_VDD075NNE 1.27349563962e-10
L_6_110 PAR_3_1_VDD075NNE n631 3.36346291106e-07
R_6_110 n631 PAR_2_0_VDD075NNE 42.0534276916
G0_111 PAR_3_1_VDD075NNE PAR_3_0_VSS PAR_3_1_VDD075NNE PAR_3_0_VSS -2.2068282617
C0_111 PAR_3_1_VDD075NNE PAR_3_0_VSS 2.78863186149e-10
R_1_111 PAR_3_1_VDD075NNE n632 0.00494414994289
C_1_111 n632 PAR_3_0_VSS 3.37093745705e-09
R_2_111 PAR_3_1_VDD075NNE n633 0.0142406665179
C_2_111 n633 PAR_3_0_VSS 2.66180243198e-09
L_3_111 PAR_3_1_VDD075NNE n634 6.00466329581e-11
R_3_111 n634 PAR_3_0_VSS 0.453139020955
R_4_111 PAR_3_1_VDD075NNE n635 4.1962644843
C_4_111 n635 PAR_3_0_VSS 1.07143704233e-10
R_5_111 PAR_3_1_VDD075NNE n636 4.02819305843
C_5_111 n636 PAR_3_0_VSS 2.32676543771e-10
R_6_111 PAR_3_1_VDD075NNE n637 25.803504804
C_6_111 n637 PAR_3_0_VSS 3.85624470589e-10
R0_112 PAR_3_1_VDD075NNE PAR_3_0_VDD075NNE 0.00773794848576
C0_112 PAR_3_1_VDD075NNE PAR_3_0_VDD075NNE 2.66753018034e-10
L_1_112 PAR_3_1_VDD075NNE n638 3.70772703267e-13
R_1_112 n638 PAR_3_0_VDD075NNE 0.013748387564
L_2_112 PAR_3_1_VDD075NNE n639 4.1313728745e-12
R_2_112 n639 PAR_3_0_VDD075NNE 0.0788739226751
L_3_112 PAR_3_1_VDD075NNE n640 3.83886164674e-09
R_3_112 n640 PAR_3_0_VDD075NNE 14.9992466869
L_4_112 PAR_3_1_VDD075NNE n641 2.11022303227e-08
R_4_112 n641 PAR_3_0_VDD075NNE 31.3084839185
L_5_112 PAR_3_1_VDD075NNE n642 4.27301810144e-07
R_5_112 n642 PAR_3_0_VDD075NNE 204.391600882
L_6_112 PAR_3_1_VDD075NNE n643 0.00191092986457
R_6_112 n643 PAR_3_0_VDD075NNE 4725.51960665
G0_113 PAR_3_1_VDD075NNE PAR_0_1_VSS PAR_3_1_VDD075NNE PAR_0_1_VSS -2.32098636481
C0_113 PAR_3_1_VDD075NNE PAR_0_1_VSS 2.87849869804e-10
R_1_113 PAR_3_1_VDD075NNE n644 0.0503768457225
C_1_113 n644 PAR_0_1_VSS 3.08703375882e-10
L_2_113 PAR_3_1_VDD075NNE n645 7.21272023842e-11
R_2_113 n645 PAR_0_1_VSS 0.989133360886
L_3_113 PAR_3_1_VDD075NNE n646 2.26749571343e-10
R_3_113 n646 PAR_0_1_VSS 1.11896738407
L_4_113 PAR_3_1_VDD075NNE n647 1.43874675686e-09
R_4_113 n647 PAR_0_1_VSS 3.15939466345
L_5_113 PAR_3_1_VDD075NNE n648 1.30110520094e-08
R_5_113 n648 PAR_0_1_VSS 10.546359643
L_6_113 PAR_3_1_VDD075NNE n649 1.57708654524e-06
R_6_113 n649 PAR_0_1_VSS 200.663244148
G0_114 PAR_3_1_VDD075NNE PAR_0_1_VDD075NNE PAR_3_1_VDD075NNE PAR_0_1_VDD075NNE -8.70269052223
C0_114 PAR_3_1_VDD075NNE PAR_0_1_VDD075NNE 1.56164914724e-10
R_1_114 PAR_3_1_VDD075NNE n650 0.136940636879
C_1_114 n650 PAR_0_1_VDD075NNE 2.84894658713e-10
L_2_114 PAR_3_1_VDD075NNE n651 9.17038709411e-12
R_2_114 n651 PAR_0_1_VDD075NNE 0.130133370268
R_3_114 PAR_3_1_VDD075NNE n652 0.779576023789
C_3_114 n652 PAR_0_1_VDD075NNE 8.07484076063e-10
L_4_114 PAR_3_1_VDD075NNE n653 1.44216843594e-09
R_4_114 n653 PAR_0_1_VDD075NNE 0.981620538363
R_5_114 PAR_3_1_VDD075NNE n654 8.5100793002
C_5_114 n654 PAR_0_1_VDD075NNE 1.05879569863e-09
G0_115 PAR_3_1_VDD075NNE PAR_1_1_VSS PAR_3_1_VDD075NNE PAR_1_1_VSS -1.69537460268
C0_115 PAR_3_1_VDD075NNE PAR_1_1_VSS 2.89835307251e-10
R_1_115 PAR_3_1_VDD075NNE n655 0.0392808458546
C_1_115 n655 PAR_1_1_VSS 3.44580083659e-10
R_2_115 PAR_3_1_VDD075NNE n656 1.77134099541
C_2_115 n656 PAR_1_1_VSS 2.84572428832e-11
L_3_115 PAR_3_1_VDD075NNE n657 1.77575906857e-10
R_3_115 n657 PAR_1_1_VSS 0.961617931235
L_4_115 PAR_3_1_VDD075NNE n658 7.95557433368e-10
R_4_115 n658 PAR_1_1_VSS 1.96132036609
L_5_115 PAR_3_1_VDD075NNE n659 8.34880374201e-09
R_5_115 n659 PAR_1_1_VSS 7.2154424571
L_6_115 PAR_3_1_VDD075NNE n660 1.03544103179e-06
R_6_115 n660 PAR_1_1_VSS 142.68788917
G0_116 PAR_3_1_VDD075NNE PAR_1_1_VDD075NNE PAR_3_1_VDD075NNE PAR_1_1_VDD075NNE -8.59048777684
C0_116 PAR_3_1_VDD075NNE PAR_1_1_VDD075NNE 1.57821580377e-10
R_1_116 PAR_3_1_VDD075NNE n661 0.170385342611
C_1_116 n661 PAR_1_1_VDD075NNE 1.77366188832e-10
L_2_116 PAR_3_1_VDD075NNE n662 1.01864027252e-11
R_2_116 n662 PAR_1_1_VDD075NNE 0.147773140231
R_3_116 PAR_3_1_VDD075NNE n663 0.516543995757
C_3_116 n663 PAR_1_1_VDD075NNE 5.32786466934e-10
L_4_116 PAR_3_1_VDD075NNE n664 4.01735050506e-10
R_4_116 n664 PAR_1_1_VDD075NNE 0.59411759564
R_5_116 PAR_3_1_VDD075NNE n665 1.2730828745
C_5_116 n665 PAR_1_1_VDD075NNE 1.15393348716e-09
L_6_116 PAR_3_1_VDD075NNE n666 6.25189287195e-08
R_6_116 n666 PAR_1_1_VDD075NNE 7.16537906397
G0_117 PAR_3_1_VDD075NNE PAR_2_1_VSS PAR_3_1_VDD075NNE PAR_2_1_VSS -0.730187844224
C0_117 PAR_3_1_VDD075NNE PAR_2_1_VSS 2.36410632561e-10
R_1_117 PAR_3_1_VDD075NNE n667 0.0254416328402
C_1_117 n667 PAR_2_1_VSS 5.60950484631e-10
R_2_117 PAR_3_1_VDD075NNE n668 0.00962651471811
C_2_117 n668 PAR_2_1_VSS 3.85062727762e-09
R_3_117 PAR_3_1_VDD075NNE n669 2.18278026663
C_3_117 n669 PAR_2_1_VSS 6.25422756549e-11
L_4_117 PAR_3_1_VDD075NNE n670 6.941794282e-10
R_4_117 n670 PAR_2_1_VSS 1.74776430965
L_5_117 PAR_3_1_VDD075NNE n671 7.50904433017e-09
R_5_117 n671 PAR_2_1_VSS 6.64257494265
L_6_117 PAR_3_1_VDD075NNE n672 9.34265249724e-07
R_6_117 n672 PAR_2_1_VSS 133.613196264
R0_118 PAR_3_1_VDD075NNE PAR_2_1_VDD075NNE 0.00265920312619
C0_118 PAR_3_1_VDD075NNE PAR_2_1_VDD075NNE 1.55477058627e-10
L_1_118 PAR_3_1_VDD075NNE n673 2.98229106397e-13
R_1_118 n673 PAR_2_1_VDD075NNE 0.0137377665846
L_2_118 PAR_3_1_VDD075NNE n674 2.43816539475e-13
R_2_118 n674 PAR_2_1_VDD075NNE 0.00642451558774
L_3_118 PAR_3_1_VDD075NNE n675 1.03285088594e-10
R_3_118 n675 PAR_2_1_VDD075NNE 1.22255582694
L_4_118 PAR_3_1_VDD075NNE n676 1.82596572896e-08
R_4_118 n676 PAR_2_1_VDD075NNE 52.0960631203
L_5_118 PAR_3_1_VDD075NNE n677 1.23734296108e-07
R_5_118 n677 PAR_2_1_VDD075NNE 104.998212329
L_6_118 PAR_3_1_VDD075NNE n678 3.25394824791e-05
R_6_118 n678 PAR_2_1_VDD075NNE 2282.95056792
C0_119 PAR_3_1_VDD075NNE PAR_3_1_VSS 2.34959910533e-09
R_1_119 PAR_3_1_VDD075NNE n679 0.000328608821424
C_1_119 n679 PAR_3_1_VSS 5.6730924912e-08
R_2_119 PAR_3_1_VDD075NNE n680 0.000314125708188
C_2_119 n680 PAR_3_1_VSS 1.16417102973e-07
R_3_119 PAR_3_1_VDD075NNE n681 0.0863080106704
C_3_119 n681 PAR_3_1_VSS 1.35324400698e-09
R_4_119 PAR_3_1_VDD075NNE n682 0.665391716273
C_4_119 n682 PAR_3_1_VSS 5.81090385864e-10
R_5_119 PAR_3_1_VDD075NNE n683 26.9285319695
C_5_119 n683 PAR_3_1_VSS 4.37396596267e-10
G0_120 PAR_3_1_VDD075NNE PAR_0_0_VSS PAR_3_1_VDD075NNE PAR_0_0_VSS -0.988036366738
C0_120 PAR_3_1_VDD075NNE PAR_0_0_VSS 2.20900603745e-10
R_1_120 PAR_3_1_VDD075NNE n684 0.062838073768
C_1_120 n684 PAR_0_0_VSS 2.8209881287e-10
L_2_120 PAR_3_1_VDD075NNE n685 1.13423898683e-10
R_2_120 n685 PAR_0_0_VSS 1.05485546504
R_3_120 PAR_3_1_VDD075NNE n686 18.4601233761
C_3_120 n686 PAR_0_0_VSS 2.29808577505e-11
R_4_120 PAR_3_1_VDD075NNE n687 12.3068142802
C_4_120 n687 PAR_0_0_VSS 1.88068473246e-10
L_5_120 PAR_3_1_VDD075NNE n688 2.19935555509e-07
R_5_120 n688 PAR_0_0_VSS 24.9755268047
.ENDS
