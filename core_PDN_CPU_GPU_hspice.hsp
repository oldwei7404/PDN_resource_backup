* Top level spice file

.option post=1
*.chkanode type=gate dv=0.5*pvdd report=active
.option parhier = local
.option measform = 1
.option lis_new
.option post probe

*************************************** User defined functions ****************
.param V_meas(node, ref) = 'v(node) - v(ref)'

*************************************** Input Models**************************
	***** define load current source model used in die model *****

	*.inc ./hspice_inc/out_curr_profile_CPU_55ns_13A_1000ns_cnst_500ns_9_13_rand_55ns_rampDown_noClk.txt

	*.inc ./hspice_inc/out_curr_profile_CPU_72ns_13A_1000ns_cnst_500ns_9_13_rand_72ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_CPU_144ns_13A_1000ns_cnst_500ns_9_13_rand_144ns_rampDown_noClk.txt

	*.inc ./hspice_inc/out_curr_profile_CPU_55ns_11A_1000ns_cnst_500ns_9_13_rand_55ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_CPU_55ns_9A_1000ns_cnst_500ns_6_9_rand_55ns_rampDown_noClk.txt

	* .inc ./hspice_inc/out_curr_profile_CPU_55ns_17A_2000ns_cnst_1000ns_12_17_rand_55ns_rampDown_noClk.txt
* .param pwl_file_cpu = str('./hspice_inc/out_curr_profile_CPU_55ns_17A_2000ns_cnst_1000ns_12_17_rand_55ns_rampDown_noClk.csv')		*** 9us

* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p5GHz_v2.txt.csv') 			*** NOTE: 10/10 current profile 	, length 1us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p5GHz_v3.txt.csv') 			*** NOTE: 10/10 current profile , length 7us
*.param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p0GHz_v2p2.txt.csv') 			*** NOTE: 10/10 current profile , length 1us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p0GHz_v3p2.txt.csv') 			*** NOTE: 10/10 current profile , length 8us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231018_2p5GHz_1us.txt.csv') 			*** NOTE: 10/18 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231018_2p5GHz_L3_6p5us.txt.csv') 			*** NOTE: 10/18 current profile

* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_1027.txt.csv') 			*** NOTE: 10/27 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_231106.txt.csv') 			*** NOTE: 11/06 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p0G_231108.txt.csv') 			*** NOTE: 11/08 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_240105.txt.csv') 			*** NOTE: 24/01/04 current profile, 3us
.param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_240105_timeX10.txt.csv') 			*** NOTE: 24/01/04 current profile, time slow down by 10x, 14us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_dtX14_240105.txt.csv') 			*** NOTE: 24/01/04 current profile, time slow down by 14x, 14us

	*** GPU profile
* .inc ./hspice_inc/out_curr_profile_GPU_20ns_2p5A_5000ns_cnst_noClk.txt
.param pwl_file_gpu = str('./hspice_inc/out_curr_profile_GPU_20ns_2p5A_5000ns_cnst_noClk.csv')

	***** define die model *****
* .inc ./hspice_inc/model_die_CPU.inc
* .inc ./hspice_inc/model_die_GPU.inc

.subckt model_die_typ
+ pin_bump ref_gnd C_die=100n R_die_1=1.25m R_die_2=RESMIN R_leak=0.84	pwl_file_in = str('./currSrc.csv')

R_die_1_ 	pin_bump	2	R_die_1
R_die_2_	2		3	R_die_2
C_die_		3		ref_gnd	C_die
R_leak_		pin_bump	ref_gnd	R_leak
IcurrSrc	pin_bump	ref_gnd	PWL pwlfile = str(pwl_file_in)
.ends

	***** define pkg model *****
	*.inc ./hspice_inc/C_v1_forCPU_wBF_wDSU_wGPU_RmLF_1e4Hz_IdEM.cir
	*.param pkg_model = str('C_v1_forCPU_wBF_wDSU_wGPU_RmLF_1e4Hz_IdEM')

.inc ./hspice_inc/Mam_MCM_Andes_0724_cpugpu_cut3_run2_IdEM.cir
.param pkg_model = str('Mam_MCM_Andes_0724_cpugpu_cut3_run2_IdEM')

	***** define PCB model *****
	*.inc ./hspice_inc/ACM2_PT00547399_A_01_cut_CPU_PSI_RmLF_manip_IdEM0p5.cir
	*.param PCB_model = str('ACM2_PT00547399_A_01_cut_CPU_PSI_RmLF_manip_IdEM0p5')

	*.inc ./hspice_inc/ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmDC_mani_IdEM_0p5.cir		*** 0626 Cadera improvement
	*.param PCB_model = str('ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmDC_mani_IdEM_0p5')

	*.inc ./hspice_inc/ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmL5L10_RmDC_mani_IdEM0p5.cir 	*** 0626, but remove L5, L10 pwr shape
	*.param PCB_model = str('ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmL5L10_RmDC_mani_IdEM0p5')

	*.inc ./hspice_inc/MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_IdEM_0p5.cir
	*.param PCB_model = str('MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_IdEM_0p5')

	*.inc ./hspice_inc/MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_rmDC_manip_IdEM_0p5.cir
	*.param PCB_model = str('MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_rmDC_manip_IdEM_0p5')

	* .inc ./hspice_inc/MAMMOTH_PCB_230803_CPU_GPU_merge_discrt_DCrm_manip_IdEM.cir			*** POR
	* .param PCB_model = str('MAMMOTH_PCB_230803_CPU_GPU_merge_discrt_DCrm_manip_IdEM')

	* .inc ./hspice_inc/MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_DCrm_manip_IdEM.cir					***0927, CPU PMIC at south of SoC
	* .param PCB_model = str('MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_DCrm_manip_IdEM')

	* .inc ./hspice_inc/MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_RmPwrL4L9_DCrm_manip_IdEM.cir		***0927, CPU PMIC at south of SoC, L4/9 pwr cut off
	* .param PCB_model = str('MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_RmPwrL4L9_DCrm_manip_IdEM')

	* .inc ./hspice_inc/MAMMOTH_PCB_231013_CPU_GPU_merge_ORIG_cutL10L14_rmLF_manip_IdEM.cir					*** 1018, PMIC at south of SoC, PTH power vias
	* .param PCB_model = str('MAMMOTH_PCB_231013_CPU_GPU_merge_ORIG_cutL10L14_rmLF_manip_IdEM')
	* .inc ./hspice_inc/MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_jgwei_rmLF_manip_IdEM.cir				*** 1025, PMIC at west of SoC, PTH power vias
	* .param PCB_model = str('MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_jgwei_rmLF_manip_IdEM')

	.inc ./hspice_inc/MAMMOTH_PCB_231023_1_CPU_GPU_merge_stk1025_jgwei_rmLF_manip_IdEM.cir				*** 1025, PMIC at south of SoC, PTH power vias, 1025 new PCB stackup,
	.param PCB_model = str('MAMMOTH_PCB_231023_1_CPU_GPU_merge_stk1025_jgwei_rmLF_manip_IdEM')
	* .inc ./hspice_inc/MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_stk1025_jgwei_rmLF_manip_IdEM.cir		*** 1025, PMIC at west of SoC, PTH power vias, 1025 new PCB stackup,
	* .param PCB_model = str('MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_stk1025_jgwei_rmLF_manip_IdEM')

			* .inc ./hspice_inc/ACM3_122323_nne_cut_manip_IdEM_s377p.cir					*** 231221 ACM3 PCB NNE, this is just a test

*************************************** Input params **************************
.param Vdd 	= 0.775

.param CPU_die = str('model_die_lumped_cpu')
.param GPU_die = str('model_die_lumped_gpu')

.param Cdie_cpu	 = '276.n'
.param Rdie_cpu	 = '0.452m'
.param Rleak_cpu = 0.232

.param Cdie_gpu  = '268.n'
.param Rdie_gpu  = '0.465m'
.param Rleak_gpu = 1.27

	*** exp. to turn off GPU die model
	*.param Cdie_gpu	= '0.n'
	*.param Rdie_gpu	= '1.e9m'
	*.param Rleak_gpu= 1.e9
*************************************** cap model *****************************
.inc ../models_cap/GCM155D70E106ME36_DC0V_125degC_0402_10uF.mod
.inc ../models_cap/GCM155D70G475ME36_DC0V_125degC_0402_4p7uF.mod
.inc ../models_cap/GCM155C71A105KE38_DC0V_125degC_0402_1uF.mod
.inc ../models_cap/GCM31CD70G476ME02_DC0V_125degC_1206_47uF.mod
.inc ../models_cap/GCM32ED70E107ME36_DC0V_125degC_1210_100uF.mod
.inc ../models_cap/GCM033D70E105ME36_DC0V_125degC_0201_1uF.mod
.inc ../models_cap/NFM15HC105D0G3_feedthrough_DC0V_85degC_3T_0402_1uF.mod
.inc ../models_cap/LLC152D70G105ME01_DC0V_125degC_0204_1uF.mod
.inc ../models_cap/LLL153C70G104ME01_DC0V_125degC_0204_0.1uF.mod
.inc ../models_cap/GRT033R70J103KE01_DC0V_125degC_0201_0p01uF.mod
.inc ../models_cap/GCM155R71C104KA55_DC0V_125degC_0402_0.1uF.mod
.inc ../models_cap/GCM21BD70G226ME36_DC0V_125degC_0805_22uF.mod
.inc ../models_cap/GCM155R71E153KA55_DC0V_125degC_0402_0.015uF.mod
.inc ../models_cap/GRT033C70J104KE01_DC0V_125degC_0201_0p1uF.mod
.inc ../models_cap/GCM32EM8EA227ME08_DC0V_125degC_1210_220uF.mod
.inc ../models_cap/GCM033C70J104KE02_DC0V_125degC_0p1uF_0201.mod
.inc ../models_cap/mlcc_470uF_mockup_T598D477M2R5ATE009.mod
.inc ../models_cap/open_circuit.mod

.inc ../models_cap/EC1001.mod
.inc ../models_cap/EC1002.mod
.inc ../models_cap/EC1100_200nF.mod

	***** define cap model strings for better ref ****
.param mlcc_1uF_0402 		= str('GCM155C71A105KE38_DC0V_125degC_0402_1uF')
.param mlcc_1uF_0204 		= str('LLC152D70G105ME01_DC0V_125degC_0204_1uF')
.param mlcc_1uF_0201 		= str('GCM033D70E105ME36_DC0V_125degC_0201_1uF')
.param mlcc_1uF_0402_3T_ft		= str('NFM15HC105D0G3_feedthrough_DC0V_85degC_3T_0402_1uF')
.param mlcc_4p7uF_0402 		= str('GCM155D70G475ME36_DC0V_125degC_0402_4p7uF')
.param mlcc_10uF_0402 		= str('GCM155D70E106ME36_DC0V_125degC_0402_10uF')
.param mlcc_47uF_1206		= str('GCM31CD70G476ME02_DC0V_125degC_1206_47uF')
.param mlcc_100uF_1210		= str('GCM32ED70E107ME36_DC0V_125degC_1210_100uF')
.param mlcc_0p1uF_0402		= str('GCM155R71C104KA55_DC0V_125degC')
.param mlcc_0p1uF_0201		= str('GRT033C70J104KE01_DC0V_125degC')
.param mlcc_0p1uF_0204 		= str('LLL153C70G104ME01_DC0V_125degC')
.param mlcc_0p015uF_0402	= str('GCM155R71E153KA55_DC0V_125degC')
.param mlcc_0p01uF_0201		= str('GRT033R70J103KE01_DC0V_125degC')
.param mlcc_22uF_0805		= str('GCM21BD70G226ME36_DC0V_125degC_0805_22uF')
.param mlcc_220uF_1210		= str('GCM32EM8EA227ME08_DC0V_125degC')
.param mlcc_470uF_mockup	= str('mlcc_470uF_mockup_T598D477M2R5ATE009')

.param siCap_empwr_EC1001 = str('EC1001')
.param siCap_empwr_EC1002 = str('EC1002')
.param siCap_empwr_EC1100_200nF = str('EC1100_200nF')

*************************************** PMIC **********************************
.subckt PMIC_model
+ pin_out ref_gnd vdd_pmic = 0.75
	VshortPMIC	pin_out	ref_gnd	vdd_pmic
.ends

Vref_gnd 	ref_gnd		0	0.				*** opt 1/2 ideal PMIC w/o remote sense feedback
	*E_fdbk	ref_gnd	0	VCVS DELAY pmic_pwr pkg_bump_1_0  td=50.n	*** opt 2/2 VCVS to model feedback

*VshortPMIC	pmic_pwr	ref_gnd	Vdd		*** can be switched to PMIC model
xblk_PMIC pmic_pwr ref_gnd PMIC_model vdd_pmic = 'Vdd'

*************************************** Socket ********************************
Rskt	bga_pcb		bga_pkg		0.				*** can add socket model

*************************************** PCB ***********************************

.if ( 1 )	*** PCB 1018, 1025 (PMIC south or left, multiple pcb same set of ports) Andes mockup, PTH via, 1030 jgwei cap enhancement
	Xblk_PCB
	+ pmic_pwr 					 	*** use L501 and L511 as PMIC port
	+ pmic_pwr
	+ bga_pcb
    + pcbCap_C501
    + pcbCap_C502
    + pcbCap_C503
    + pcbCap_C504
    + pcbCap_C505
    + pcbCap_C511
    + pcbCap_C512
    + pcbCap_C513
    + pcbCap_C514
    + pcbCap_C515
    + pcbCap_C516
    + pcbCap_C517
    + pcbCap_C700
    + pcbCap_C701
    + pcbCap_C4009
    + pcbCap_C4010
    + pcbCap_C4016
    + pcbCap_C4017
    + pcbCap_C4018
    + pcbCap_C4019
    + pcbCap_C4020
    + pcbCap_C4021
    + pcbCap_C5001
    + pcbCap_C5002
    + pcbCap_C5003
    + pcbCap_C5004
    + pcbCap_C5005
    + pcbCap_C5006
    + pcbCap_C5007
    + pcbCap_C5008
    + pcbCap_C5009
    + pcbCap_C5010
    + pcbCap_C5011
    + pcbCap_C5012
    + pcbCap_C5013
    + pcbCap_C5014
    + pcbCap_C5015
    + pcbCap_C5016
    + pcbCap_C5017
    + pcbCap_C5018
    + pcbCap_C5019
    + pcbCap_C5020
    + pcbCap_C5021
    + pcbCap_C5022
    + pcbCap_C5023
    + pcbCap_C5024
    + pcbCap_C5025
    + pcbCap_C5026
    + pcbCap_C5027
    + pcbCap_C5028
    + pcbCap_C5029
    + pcbCap_C5030
    + pcbCap_C5031
    + pcbCap_C5032
    + pcbCap_C5033
    + pcbCap_C5034
    + pcbCap_C5035
    + pcbCap_C5036
    + pcbCap_C5037
    + pcbCap_C5038
    + pcbCap_C5039
    + pcbCap_C5040
    + pcbCap_C5041
    + pcbCap_C5042
    + pcbCap_C5043
    + pcbCap_C5044
    + pcbCap_C5045
    + pcbCap_C5046
    + pcbCap_C5047
    + pcbCap_C5048
    + pcbCap_C5049
    + pcbCap_C5050
    + pcbCap_C5051
    + pcbCap_C5052
    + pcbCap_C5053
    + pcbCap_C5054
    + pcbCap_C5055
    + pcbCap_C5056
    + pcbCap_C5057
    + pcbCap_C5058
    + pcbCap_C5059
    + pcbCap_C5060
    + pcbCap_C5061
	+ ref_gnd
	+ str(PCB_model)

	*** start of PMIC bulk
	XpcbCap_C504   pcbCap_C504	   ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C505   pcbCap_C505     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C514   pcbCap_C514     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C515   pcbCap_C515     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C501   pcbCap_C501     ref_gnd  str(mlcc_220uF_1210)
	XpcbCap_C502   pcbCap_C502     ref_gnd  str(mlcc_220uF_1210)
	XpcbCap_C503   pcbCap_C503     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C511   pcbCap_C511     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C512   pcbCap_C512     ref_gnd  str(mlcc_220uF_1210)
	XpcbCap_C513   pcbCap_C513     ref_gnd	str(mlcc_220uF_1210)
	*** end of PMIC bulk

	*** CPU/GPU PCB bulk cap outside die shadow
	XpcbCap_C700   pcbCap_C700     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C701   pcbCap_C701     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C516   pcbCap_C516     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C517   pcbCap_C517     ref_gnd	str(mlcc_220uF_1210)
		*** jgwei experiment to
	XpcbCap_C5052	 pcbCap_C5052	ref_gnd   str(mlcc_100uF_1210)
	XpcbCap_C4018	 pcbCap_C4018	ref_gnd   str(mlcc_100uF_1210)

	*** CPU/GPU PCB bulk cap outside die shadow

	*** start of CPU caps under PCB die shadow
	XpcbCap_C5001	 pcbCap_C5001	ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5002    pcbCap_C5002   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5003    pcbCap_C5003   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5004    pcbCap_C5004   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5005    pcbCap_C5005   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5006    pcbCap_C5006   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5007    pcbCap_C5007   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5008    pcbCap_C5008   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5009    pcbCap_C5009   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5010    pcbCap_C5010   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5011    pcbCap_C5011   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5012    pcbCap_C5012   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5013    pcbCap_C5013   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5014    pcbCap_C5014   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5015    pcbCap_C5015   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5016    pcbCap_C5016   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5017    pcbCap_C5017   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5018    pcbCap_C5018   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5019    pcbCap_C5019   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5020    pcbCap_C5020   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5021    pcbCap_C5021   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5022    pcbCap_C5022   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5023    pcbCap_C5023   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5024    pcbCap_C5024   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5025    pcbCap_C5025   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5026    pcbCap_C5026   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5027    pcbCap_C5027   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5028    pcbCap_C5028   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5029    pcbCap_C5029   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5030    pcbCap_C5030   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5031    pcbCap_C5031   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5032    pcbCap_C5032   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5033    pcbCap_C5033   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5034    pcbCap_C5034   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5035    pcbCap_C5035   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5036    pcbCap_C5036   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5037    pcbCap_C5037   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5038    pcbCap_C5038   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5039    pcbCap_C5039   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5040    pcbCap_C5040   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5041    pcbCap_C5041   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5042    pcbCap_C5042   ref_gnd   str(mlcc_10uF_0402)
	*** end of CPU caps under PCB die shadow

.endif	*** end of PCB 1018 Andes mockup, 1030 jgwei cap enhancement

.if ( 0 )	*** PCB 1018, 1025 (PMIC south or left, multiple pcb same set of ports) Andes mockup, PTH via
	Xblk_PCB
	+ pmic_pwr 					 	*** use L501 and L511 as PMIC port
	+ pmic_pwr
	+ bga_pcb
    + pcbCap_C501
    + pcbCap_C502
    + pcbCap_C503
    + pcbCap_C504
    + pcbCap_C505
    + pcbCap_C511
    + pcbCap_C512
    + pcbCap_C513
    + pcbCap_C514
    + pcbCap_C515
    + pcbCap_C516
    + pcbCap_C517
    + pcbCap_C700
    + pcbCap_C701
    + pcbCap_C4009
    + pcbCap_C4010
    + pcbCap_C4016
    + pcbCap_C4017
    + pcbCap_C4018
    + pcbCap_C4019
    + pcbCap_C4020
    + pcbCap_C4021
    + pcbCap_C5001
    + pcbCap_C5002
    + pcbCap_C5003
    + pcbCap_C5004
    + pcbCap_C5005
    + pcbCap_C5006
    + pcbCap_C5007
    + pcbCap_C5008
    + pcbCap_C5009
    + pcbCap_C5010
    + pcbCap_C5011
    + pcbCap_C5012
    + pcbCap_C5013
    + pcbCap_C5014
    + pcbCap_C5015
    + pcbCap_C5016
    + pcbCap_C5017
    + pcbCap_C5018
    + pcbCap_C5019
    + pcbCap_C5020
    + pcbCap_C5021
    + pcbCap_C5022
    + pcbCap_C5023
    + pcbCap_C5024
    + pcbCap_C5025
    + pcbCap_C5026
    + pcbCap_C5027
    + pcbCap_C5028
    + pcbCap_C5029
    + pcbCap_C5030
    + pcbCap_C5031
    + pcbCap_C5032
    + pcbCap_C5033
    + pcbCap_C5034
    + pcbCap_C5035
    + pcbCap_C5036
    + pcbCap_C5037
    + pcbCap_C5038
    + pcbCap_C5039
    + pcbCap_C5040
    + pcbCap_C5041
    + pcbCap_C5042
    + pcbCap_C5043
    + pcbCap_C5044
    + pcbCap_C5045
    + pcbCap_C5046
    + pcbCap_C5047
    + pcbCap_C5048
    + pcbCap_C5049
    + pcbCap_C5050
    + pcbCap_C5051
    + pcbCap_C5052
    + pcbCap_C5053
    + pcbCap_C5054
    + pcbCap_C5055
    + pcbCap_C5056
    + pcbCap_C5057
    + pcbCap_C5058
    + pcbCap_C5059
    + pcbCap_C5060
    + pcbCap_C5061
	+ ref_gnd
	+ str(PCB_model)

	*** start of PMIC bulk
	* XpcbCap_C504   pcbCap_C504	   ref_gnd	str(mlcc_220uF_1210)
	* XpcbCap_C505   pcbCap_C505     ref_gnd	str(mlcc_220uF_1210)
	* XpcbCap_C514   pcbCap_C514     ref_gnd	str(mlcc_220uF_1210)
	* XpcbCap_C515   pcbCap_C515     ref_gnd	str(mlcc_220uF_1210)
	* XpcbCap_C501   pcbCap_C501     ref_gnd  str(mlcc_220uF_1210)
	* XpcbCap_C502   pcbCap_C502     ref_gnd  str(mlcc_220uF_1210)
	* XpcbCap_C503   pcbCap_C503     ref_gnd	str(mlcc_220uF_1210)
	* XpcbCap_C511   pcbCap_C511     ref_gnd	str(mlcc_220uF_1210)
	* XpcbCap_C512   pcbCap_C512     ref_gnd  str(mlcc_220uF_1210)
	* XpcbCap_C513   pcbCap_C513     ref_gnd	str(mlcc_220uF_1210)
	*** end of PMIC bulk

	*** CPU PCB bulk cap outside die shadow
	XpcbCap_C700   pcbCap_C700     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C701   pcbCap_C701     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C516   pcbCap_C516     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C517   pcbCap_C517     ref_gnd	str(mlcc_220uF_1210)

	* XpcbCap_C700   pcbCap_C700     ref_gnd	str(mlcc_100uF_1210)
	* XpcbCap_C701   pcbCap_C701     ref_gnd	str(mlcc_100uF_1210)
	* XpcbCap_C516   pcbCap_C516     ref_gnd	str(mlcc_100uF_1210)
	* XpcbCap_C517   pcbCap_C517     ref_gnd	str(mlcc_100uF_1210)

	.if ( 0 )	*** exp used to suppress resonoance near 0.2MHz
		XpcbCap_C506_2  pcbCap_C506     ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C507_2  pcbCap_C507     ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C516_2  pcbCap_C516     ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C517_2  pcbCap_C517     ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C5034_2  pcbCap_C5034    ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C5035_2  pcbCap_C5035    ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C5036_2  pcbCap_C5036    ref_gnd  	str(mlcc_47uF_1206)
		XpcbCap_C5037_2  pcbCap_C5037    ref_gnd  	str(mlcc_47uF_1206)
		XpcbCap_C5038_2  pcbCap_C5038    ref_gnd  	str(mlcc_47uF_1206)
	.endif

	.if ( 0 )	*** exp to suppress low freq noise
		XpcbCap_C5002_2  pcbCap_C5002    ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C5026_2  pcbCap_C5026    ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C5012_2  pcbCap_C5012    ref_gnd	str(mlcc_47uF_1206)
		XpcbCap_C5048_2  pcbCap_C5048    ref_gnd	str(mlcc_47uF_1206)
	.endif
	*** CPU PCB bulk cap outside die shadow

	*** start of CPU caps under PCB die shadow
	XpcbCap_C5002  pcbCap_C5002    ref_gnd	str(mlcc_1uF_0402)
	XpcbCap_C5003  pcbCap_C5003    ref_gnd	str(mlcc_1uF_0402)
	XpcbCap_C5004  pcbCap_C5004    ref_gnd	str(mlcc_1uF_0402)
	XpcbCap_C5005  pcbCap_C5005    ref_gnd	str(mlcc_1uF_0402)
	XpcbCap_C5006  pcbCap_C5006    ref_gnd	str(mlcc_1uF_0402)
	XpcbCap_C5007  pcbCap_C5007    ref_gnd	str(mlcc_1uF_0402)
	XpcbCap_C5009  pcbCap_C5009    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5010  pcbCap_C5010    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5011  pcbCap_C5011    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5012  pcbCap_C5012    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5013  pcbCap_C5013    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5014  pcbCap_C5014    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5016  pcbCap_C5016    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5017  pcbCap_C5017    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5018  pcbCap_C5018    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5019  pcbCap_C5019    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5020  pcbCap_C5020    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5021  pcbCap_C5021    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5022  pcbCap_C5022    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5023  pcbCap_C5023    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5024  pcbCap_C5024    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5025  pcbCap_C5025    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5026  pcbCap_C5026    ref_gnd	str(mlcc_4p7uF_0402)
	XpcbCap_C5027  pcbCap_C5027    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5028  pcbCap_C5028    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5029  pcbCap_C5029    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5030  pcbCap_C5030    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5031  pcbCap_C5031    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5032  pcbCap_C5032    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5033  pcbCap_C5033    ref_gnd	str(mlcc_10uF_0402)
	*** end of CPU caps under PCB die shadow

	*** start of CPU caps outside PCB die shadow
	XpcbCap_C5034  pcbCap_C5034    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5035  pcbCap_C5035    ref_gnd	str(mlcc_10uF_0402)
	XpcbCap_C5036  pcbCap_C5036    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5037  pcbCap_C5037    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5038  pcbCap_C5038    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5039  pcbCap_C5039    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5040  pcbCap_C5040    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5041  pcbCap_C5041    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5042  pcbCap_C5042    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5043  pcbCap_C5043    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5044  pcbCap_C5044    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5045  pcbCap_C5045    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5046  pcbCap_C5046    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5047  pcbCap_C5047    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5048  pcbCap_C5048    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5049  pcbCap_C5049    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5050  pcbCap_C5050    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5051  pcbCap_C5051    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5052  pcbCap_C5052    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5053  pcbCap_C5053    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5054  pcbCap_C5054    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5055  pcbCap_C5055    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5056  pcbCap_C5056    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5057  pcbCap_C5057    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5058  pcbCap_C5058    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5059  pcbCap_C5059    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5060  pcbCap_C5060    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5061  pcbCap_C5061    ref_gnd  str(mlcc_10uF_0402)

	*** end of CPU caps outside PCB die shadow

	*** start of GPU PCB caps
	XpcbCap_C4009  pcbCap_C4009    ref_gnd	str(mlcc_1uF_0402)
	XpcbCap_C4010  pcbCap_C4010    ref_gnd  str(mlcc_1uF_0402)
	XpcbCap_C4016  pcbCap_C4016    ref_gnd  str(mlcc_1uF_0402)
	XpcbCap_C4017  pcbCap_C4017    ref_gnd  str(mlcc_1uF_0402)
	XpcbCap_C4018  pcbCap_C4018    ref_gnd  str(mlcc_1uF_0402)
	XpcbCap_C4019  pcbCap_C4019    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C4020  pcbCap_C4020    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C4021  pcbCap_C4021    ref_gnd  str(mlcc_10uF_0402)
	XpcbCap_C5001  pcbCap_C5001    ref_gnd  str(mlcc_4p7uF_0402)
	XpcbCap_C5008  pcbCap_C5008    ref_gnd  str(mlcc_4p7uF_0402)
	XpcbCap_C5015  pcbCap_C5015    ref_gnd	str(mlcc_4p7uF_0402)
	*** end of GPU PCB caps

.endif	*** end of PCB 1018 Andes mockup

					.if ( 0 )	*** 231221 ACM3 PCB for NNE, this is just a test
						Xblk_PCB
						+ bga_pcb
						+ pmic_pwr
						+ pmic_pwr
						+ pmic_pwr
						+ pmic_pwr
						+ pcbCap_C86
						+ pcbCap_C87
						+ pcbCap_C88
						+ pcbCap_C89
						+ pcbCap_C91
						+ pcbCap_C93
						+ pcbCap_C94
						+ pcbCap_C95
						+ pcbCap_C96
						+ pcbCap_C97
						+ pcbCap_C503
						+ pcbCap_C504
						+ pcbCap_C505
						+ pcbCap_C506
						+ pcbCap_C507
						+ pcbCap_C508
						+ pcbCap_C509
						+ pcbCap_C510
						+ pcbCap_C511
						+ pcbCap_C512
						+ pcbCap_C523
						+ pcbCap_C524
						+ pcbCap_C525
						+ pcbCap_C526
						+ pcbCap_C527
						+ pcbCap_C528
						+ pcbCap_C529
						+ pcbCap_C530
						+ pcbCap_C531
						+ pcbCap_C532
						+ pcbCap_C543
						+ pcbCap_C544
						+ pcbCap_C545
						+ pcbCap_C546
						+ pcbCap_C547
						+ pcbCap_C548
						+ pcbCap_C549
						+ pcbCap_C550
						+ pcbCap_C551
						+ pcbCap_C552
						+ pcbCap_C563
						+ pcbCap_C564
						+ pcbCap_C565
						+ pcbCap_C566
						+ pcbCap_C567
						+ pcbCap_C568
						+ pcbCap_C569
						+ pcbCap_C570
						+ pcbCap_C571
						+ pcbCap_C572
						+ pcbCap_C583
						+ pcbCap_C584
						+ pcbCap_C585
						+ pcbCap_C586
						+ pcbCap_C587
						+ pcbCap_C588
						+ pcbCap_C589
						+ pcbCap_C590
						+ pcbCap_C591
						+ pcbCap_C592
						+ pcbCap_C603
						+ pcbCap_C604
						+ pcbCap_C605
						+ pcbCap_C606
						+ pcbCap_C607
						+ pcbCap_C608
						+ pcbCap_C609
						+ pcbCap_C610
						+ pcbCap_C611
						+ pcbCap_C612
						+ pcbCap_C623
						+ pcbCap_C624
						+ pcbCap_C625
						+ pcbCap_C626
						+ pcbCap_C627
						+ pcbCap_C628
						+ pcbCap_C629
						+ pcbCap_C630
						+ pcbCap_C631
						+ pcbCap_C632
						+ pcbCap_C643
						+ pcbCap_C644
						+ pcbCap_C645
						+ pcbCap_C646
						+ pcbCap_C647
						+ pcbCap_C648
						+ pcbCap_C649
						+ pcbCap_C650
						+ pcbCap_C651
						+ pcbCap_C652
						+ pcbCap_C663
						+ pcbCap_C664
						+ pcbCap_C665
						+ pcbCap_C666
						+ pcbCap_C667
						+ pcbCap_C668
						+ pcbCap_C669
						+ pcbCap_C670
						+ pcbCap_C671
						+ pcbCap_C672
						+ pcbCap_C683
						+ pcbCap_C684
						+ pcbCap_C685
						+ pcbCap_C686
						+ pcbCap_C687
						+ pcbCap_C688
						+ pcbCap_C689
						+ pcbCap_C690
						+ pcbCap_C691
						+ pcbCap_C692
						+ pcbCap_C696
						+ pcbCap_C697
						+ pcbCap_C698
						+ pcbCap_C699
						+ pcbCap_C700
						+ pcbCap_C701
						+ pcbCap_C702
						+ pcbCap_C703
						+ pcbCap_C704
						+ pcbCap_C705
						+ pcbCap_C706
						+ pcbCap_C707
						+ pcbCap_C708
						+ pcbCap_C709
						+ pcbCap_C710
						+ pcbCap_C711
						+ pcbCap_C712
						+ pcbCap_C713
						+ pcbCap_C714
						+ pcbCap_C715
						+ pcbCap_C728
						+ pcbCap_C729
						+ pcbCap_C730
						+ pcbCap_C731
						+ pcbCap_C732
						+ pcbCap_C733
						+ pcbCap_C734
						+ pcbCap_C735
						+ pcbCap_C736
						+ pcbCap_C737
						+ pcbCap_C748
						+ pcbCap_C749
						+ pcbCap_C750
						+ pcbCap_C751
						+ pcbCap_C752
						+ pcbCap_C753
						+ pcbCap_C754
						+ pcbCap_C755
						+ pcbCap_C756
						+ pcbCap_C757
						+ pcbCap_C768
						+ pcbCap_C769
						+ pcbCap_C770
						+ pcbCap_C771
						+ pcbCap_C772
						+ pcbCap_C773
						+ pcbCap_C774
						+ pcbCap_C775
						+ pcbCap_C776
						+ pcbCap_C777
						+ pcbCap_C788
						+ pcbCap_C789
						+ pcbCap_C790
						+ pcbCap_C791
						+ pcbCap_C792
						+ pcbCap_C793
						+ pcbCap_C794
						+ pcbCap_C795
						+ pcbCap_C796
						+ pcbCap_C797
						+ pcbCap_C1042
						+ pcbCap_C1043
						+ pcbCap_C1044
						+ pcbCap_C1134
						+ pcbCap_C1135
						+ pcbCap_C1136
						+ pcbCap_C1137
						+ pcbCap_C1138
						+ pcbCap_C1139
						+ pcbCap_C1140
						+ pcbCap_C1141
						+ pcbCap_C1142
						+ pcbCap_C1143
						+ pcbCap_C1144
						+ pcbCap_C1145
						+ pcbCap_C1146
						+ pcbCap_C1147
						+ pcbCap_C1148
						+ pcbCap_C1149
						+ pcbCap_C1150
						+ pcbCap_C1151
						+ pcbCap_C1152
						+ pcbCap_C1153
						+ pcbCap_C1154
						+ pcbCap_C1155
						+ pcbCap_C1156
						+ pcbCap_C1157
						+ pcbCap_C1158
						+ pcbCap_C1159
						+ pcbCap_C1160
						+ pcbCap_C1161
						+ pcbCap_C1162
						+ pcbCap_C1163
						+ pcbCap_C1164
						+ pcbCap_C1165
						+ pcbCap_C1166
						+ pcbCap_C1167
						+ pcbCap_C1168
						+ pcbCap_C1169
						+ pcbCap_C1170
						+ pcbCap_C1171
						+ pcbCap_C1172
						+ pcbCap_C1173
						+ pcbCap_C1174
						+ pcbCap_C1175
						+ pcbCap_C1176
						+ pcbCap_C1177
						+ pcbCap_C1178
						+ pcbCap_C1179
						+ pcbCap_C1180
						+ pcbCap_C1181
						+ pcbCap_C1182
						+ pcbCap_C1183
						+ pcbCap_C1184
						+ pcbCap_C1185
						+ pcbCap_C1186
						+ pcbCap_C1187
						+ pcbCap_C1188
						+ pcbCap_C1189
						+ pcbCap_C1190
						+ pcbCap_C1191
						+ pcbCap_C1192
						+ pcbCap_C1193
						+ pcbCap_C1194
						+ pcbCap_C1195
						+ pcbCap_C1196
						+ pcbCap_C1197
						+ pcbCap_C1198
						+ pcbCap_C1199
						+ pcbCap_C1200
						+ pcbCap_C1201
						+ pcbCap_C1202
						+ pcbCap_C1203
						+ pcbCap_C1204
						+ pcbCap_C1205
						+ pcbCap_C1206
						+ pcbCap_C1207
						+ pcbCap_C1208
						+ pcbCap_C1209
						+ pcbCap_C1210
						+ pcbCap_C1211
						+ pcbCap_C1212
						+ pcbCap_C1213
						+ pcbCap_C1214
						+ pcbCap_C1215
						+ pcbCap_C1216
						+ pcbCap_C1217
						+ pcbCap_C1218
						+ pcbCap_C1219
						+ pcbCap_C1220
						+ pcbCap_C1221
						+ pcbCap_C1222
						+ pcbCap_C1223
						+ pcbCap_C1224
						+ pcbCap_C1225
						+ pcbCap_C1226
						+ pcbCap_C1227
						+ pcbCap_C1228
						+ pcbCap_C1229
						+ pcbCap_C1230
						+ pcbCap_C1231
						+ pcbCap_C1232
						+ pcbCap_C1233
						+ pcbCap_C1234
						+ pcbCap_C1235
						+ pcbCap_C1236
						+ pcbCap_C1237
						+ pcbCap_C1238
						+ pcbCap_C1239
						+ pcbCap_C1240
						+ pcbCap_C1241
						+ pcbCap_C1242
						+ pcbCap_C1243
						+ pcbCap_C1244
						+ pcbCap_C1245
						+ pcbCap_C1246
						+ pcbCap_C1247
						+ pcbCap_C1248
						+ pcbCap_C1249
						+ pcbCap_C1250
						+ pcbCap_C1251
						+ pcbCap_C1252
						+ pcbCap_C1253
						+ pcbCap_C1254
						+ pcbCap_C1255
						+ pcbCap_C1256
						+ pcbCap_C1257
						+ pcbCap_C1258
						+ pcbCap_C1259
						+ pcbCap_C1260
						+ pcbCap_C1261
						+ pcbCap_C1262
						+ pcbCap_C1263
						+ pcbCap_C1264
						+ pcbCap_C1265
						+ pcbCap_C1266
						+ pcbCap_C1267
						+ pcbCap_C1268
						+ pcbCap_C1269
						+ pcbCap_C1270
						+ pcbCap_C1271
						+ pcbCap_C1272
						+ pcbCap_C1273
						+ pcbCap_C1274
						+ pcbCap_C1275
						+ pcbCap_C1276
						+ pcbCap_C1277
						+ pcbCap_C1278
						+ pcbCap_C1279
						+ pcbCap_C1280
						+ pcbCap_C1281
						+ pcbCap_C1282
						+ pcbCap_C1283
						+ pcbCap_C1284
						+ pcbCap_C1285
						+ pcbCap_C1286
						+ pcbCap_C1287
						+ pcbCap_C1288
						+ pcbCap_C1289
						+ pcbCap_C1290
						+ pcbCap_C1291
						+ pcbCap_C1292
						+ pcbCap_C1293
						+ pcbCap_C1294
						+ pcbCap_C1295
						+ pcbCap_C1296
						+ pcbCap_C1309
						+ pcbCap_C1310
						+ pcbCap_C1311
						+ pcbCap_C1312
						+ pcbCap_C1313
						+ pcbCap_C1314
						+ pcbCap_C1315
						+ pcbCap_C1316
						+ pcbCap_C1317
						+ pcbCap_C1318
						+ pcbCap_C1319
						+ pcbCap_C1320
						+ pcbCap_C1321
						+ pcbCap_C1322
						+ pcbCap_C1323
						+ pcbCap_C1324
						+ pcbCap_C1325
						+ pcbCap_C1326
						+ pcbCap_C1327
						+ pcbCap_C1328
						+ pcbCap_C1329
						+ pcbCap_C1330
						+ pcbCap_C1331
						+ pcbCap_C1332
						+ pcbCap_C1333
						+ pcbCap_C1334
						+ pcbCap_C1335
						+ pcbCap_C1336
						+ pcbCap_C1337
						+ pcbCap_C1338
						+ pcbCap_C1339
						+ pcbCap_C1340
						+ pcbCap_C1341
						+ pcbCap_C1342
						+ pcbCap_C1343
						+ pcbCap_C1344
						+ ref_gnd
						+ ACM3_122323_nne_cut_manip_IdEM_s377p

						*** PCB cap ***
							*** under PCB, under IP shadow
						XpcbCap_C503 	pcbCap_C503     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C504 	pcbCap_C504     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C505 	pcbCap_C505     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C506 	pcbCap_C506     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C507 	pcbCap_C507     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C508 	pcbCap_C508     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C509 	pcbCap_C509     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C510 	pcbCap_C510     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C511 	pcbCap_C511     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C512 	pcbCap_C512     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C523 	pcbCap_C523     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C524 	pcbCap_C524     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C525 	pcbCap_C525     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C526 	pcbCap_C526     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C527 	pcbCap_C527     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C528 	pcbCap_C528     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C529 	pcbCap_C529     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C530 	pcbCap_C530     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C531 	pcbCap_C531     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C532 	pcbCap_C532     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C552 	pcbCap_C552     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C583 	pcbCap_C583     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C584 	pcbCap_C584     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C585 	pcbCap_C585     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C586 	pcbCap_C586     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C587 	pcbCap_C587     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C588 	pcbCap_C588     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C589 	pcbCap_C589     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C590 	pcbCap_C590     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C591 	pcbCap_C591     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C592 	pcbCap_C592     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C603 	pcbCap_C603     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C604 	pcbCap_C604     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C605 	pcbCap_C605     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C606 	pcbCap_C606     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C607 	pcbCap_C607     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C608 	pcbCap_C608     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C609 	pcbCap_C609     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C610 	pcbCap_C610     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C611 	pcbCap_C611     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C612 	pcbCap_C612     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C631 	pcbCap_C631     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C632 	pcbCap_C632     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C706 	pcbCap_C706     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C707 	pcbCap_C707     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C708 	pcbCap_C708     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C709 	pcbCap_C709     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C710 	pcbCap_C710     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C711 	pcbCap_C711     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C712 	pcbCap_C712     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C713 	pcbCap_C713     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C714 	pcbCap_C714     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C715 	pcbCap_C715     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C728 	pcbCap_C728     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C729 	pcbCap_C729     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C730 	pcbCap_C730     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C731 	pcbCap_C731     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C732 	pcbCap_C732     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C733 	pcbCap_C733     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C734 	pcbCap_C734     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C735 	pcbCap_C735     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C736 	pcbCap_C736     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C737 	pcbCap_C737     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C777 	pcbCap_C777     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C797 	pcbCap_C797     ref_gnd		str(mlcc_10uF_0402)
						XpcbCap_C1238	pcbCap_C1238    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1244	pcbCap_C1244    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1245	pcbCap_C1245    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1246	pcbCap_C1246    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1247	pcbCap_C1247    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1248	pcbCap_C1248    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1276	pcbCap_C1276    ref_gnd 	str(mlcc_10uF_0402)

						*** under PCB, outside IP shadow
						XpcbCap_C543 	pcbCap_C543     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C544 	pcbCap_C544     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C545 	pcbCap_C545     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C546 	pcbCap_C546     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C547 	pcbCap_C547     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C548 	pcbCap_C548     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C549 	pcbCap_C549     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C550 	pcbCap_C550     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C551 	pcbCap_C551     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C563 	pcbCap_C563     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C564 	pcbCap_C564     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C565 	pcbCap_C565     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C566 	pcbCap_C566     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C567 	pcbCap_C567     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C568 	pcbCap_C568     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C569 	pcbCap_C569     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C570 	pcbCap_C570     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C571 	pcbCap_C571     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C572 	pcbCap_C572     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C623 	pcbCap_C623     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C624 	pcbCap_C624     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C625 	pcbCap_C625     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C626 	pcbCap_C626     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C627 	pcbCap_C627     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C628 	pcbCap_C628     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C629 	pcbCap_C629     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C630 	pcbCap_C630     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C643 	pcbCap_C643     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C644 	pcbCap_C644     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C645 	pcbCap_C645     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C646 	pcbCap_C646     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C647 	pcbCap_C647     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C648 	pcbCap_C648     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C649 	pcbCap_C649     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C650 	pcbCap_C650     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C651 	pcbCap_C651     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C652 	pcbCap_C652     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C663 	pcbCap_C663     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C664 	pcbCap_C664     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C665 	pcbCap_C665     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C666 	pcbCap_C666     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C667 	pcbCap_C667     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C668 	pcbCap_C668     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C669 	pcbCap_C669     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C670 	pcbCap_C670     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C671 	pcbCap_C671     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C672 	pcbCap_C672     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C683 	pcbCap_C683     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C684 	pcbCap_C684     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C685 	pcbCap_C685     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C686 	pcbCap_C686     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C687 	pcbCap_C687     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C688 	pcbCap_C688     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C689 	pcbCap_C689     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C690 	pcbCap_C690     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C691 	pcbCap_C691     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C692 	pcbCap_C692     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C696 	pcbCap_C696     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C697 	pcbCap_C697     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C698 	pcbCap_C698     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C699 	pcbCap_C699     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C700 	pcbCap_C700     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C701 	pcbCap_C701     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C702 	pcbCap_C702     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C703 	pcbCap_C703     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C704 	pcbCap_C704     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C705 	pcbCap_C705     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C748 	pcbCap_C748     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C749 	pcbCap_C749     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C755 	pcbCap_C755     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C756 	pcbCap_C756     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C757 	pcbCap_C757     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C768 	pcbCap_C768     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C769 	pcbCap_C769     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C771 	pcbCap_C771     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C772 	pcbCap_C772     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C773 	pcbCap_C773     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C774 	pcbCap_C774     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C775 	pcbCap_C775     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C776 	pcbCap_C776     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C788 	pcbCap_C788     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C789 	pcbCap_C789     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C790 	pcbCap_C790     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C791 	pcbCap_C791     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C792 	pcbCap_C792     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C793 	pcbCap_C793     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C794 	pcbCap_C794     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C795 	pcbCap_C795     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C796 	pcbCap_C796     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1138	pcbCap_C1138    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1139	pcbCap_C1139    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1140	pcbCap_C1140    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1145	pcbCap_C1145    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1146	pcbCap_C1146    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1147	pcbCap_C1147    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1148	pcbCap_C1148    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1149	pcbCap_C1149    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1150	pcbCap_C1150    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1151	pcbCap_C1151    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1152	pcbCap_C1152    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1153	pcbCap_C1153    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1154	pcbCap_C1154    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1155	pcbCap_C1155    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1156	pcbCap_C1156    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1157	pcbCap_C1157    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1158	pcbCap_C1158    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1159	pcbCap_C1159    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1160	pcbCap_C1160    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1161	pcbCap_C1161    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1162	pcbCap_C1162    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1163	pcbCap_C1163    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1166	pcbCap_C1166    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1168	pcbCap_C1168    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1169	pcbCap_C1169    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1170	pcbCap_C1170    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1171	pcbCap_C1171    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1174	pcbCap_C1174    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1175	pcbCap_C1175    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1176	pcbCap_C1176    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1177	pcbCap_C1177    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1178	pcbCap_C1178    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1179	pcbCap_C1179    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1180	pcbCap_C1180    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1181	pcbCap_C1181    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1182	pcbCap_C1182    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1183	pcbCap_C1183    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1184	pcbCap_C1184    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1185	pcbCap_C1185    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1186	pcbCap_C1186    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1187	pcbCap_C1187    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1188	pcbCap_C1188    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1189	pcbCap_C1189    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1190	pcbCap_C1190    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1191	pcbCap_C1191    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1192	pcbCap_C1192    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1193	pcbCap_C1193    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1194	pcbCap_C1194    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1195	pcbCap_C1195    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1196	pcbCap_C1196    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1197	pcbCap_C1197    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1198	pcbCap_C1198    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1199	pcbCap_C1199    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1200	pcbCap_C1200    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1201	pcbCap_C1201    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1202	pcbCap_C1202    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1203	pcbCap_C1203    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1204	pcbCap_C1204    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1205	pcbCap_C1205    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1206	pcbCap_C1206    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1207	pcbCap_C1207    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1208	pcbCap_C1208    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1209	pcbCap_C1209    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1210	pcbCap_C1210    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1211	pcbCap_C1211    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1212	pcbCap_C1212    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1213	pcbCap_C1213    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1214	pcbCap_C1214    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1215	pcbCap_C1215    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1216	pcbCap_C1216    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1217	pcbCap_C1217    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1218	pcbCap_C1218    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1219	pcbCap_C1219    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1220	pcbCap_C1220    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1221	pcbCap_C1221    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1222	pcbCap_C1222    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1223	pcbCap_C1223    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1224	pcbCap_C1224    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1225	pcbCap_C1225    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1226	pcbCap_C1226    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1227	pcbCap_C1227    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1228	pcbCap_C1228    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1229	pcbCap_C1229    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1230	pcbCap_C1230    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1231	pcbCap_C1231    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1232	pcbCap_C1232    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1233	pcbCap_C1233    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1234	pcbCap_C1234    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1235	pcbCap_C1235    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1236	pcbCap_C1236    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1239	pcbCap_C1239    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1240	pcbCap_C1240    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1241	pcbCap_C1241    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1242	pcbCap_C1242    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1243	pcbCap_C1243    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1249	pcbCap_C1249    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1250	pcbCap_C1250    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1251	pcbCap_C1251    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1252	pcbCap_C1252    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1253	pcbCap_C1253    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1254	pcbCap_C1254    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1255	pcbCap_C1255    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1256	pcbCap_C1256    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1257	pcbCap_C1257    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1258	pcbCap_C1258    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1259	pcbCap_C1259    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1260	pcbCap_C1260    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1261	pcbCap_C1261    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1262	pcbCap_C1262    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1263	pcbCap_C1263    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1264	pcbCap_C1264    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1265	pcbCap_C1265    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1266	pcbCap_C1266    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1267	pcbCap_C1267    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1268	pcbCap_C1268    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1269	pcbCap_C1269    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1270	pcbCap_C1270    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1271	pcbCap_C1271    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1272	pcbCap_C1272    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1273	pcbCap_C1273    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1274	pcbCap_C1274    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1275	pcbCap_C1275    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1277	pcbCap_C1277    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1278	pcbCap_C1278    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1279	pcbCap_C1279    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1280	pcbCap_C1280    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1281	pcbCap_C1281    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1282	pcbCap_C1282    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1283	pcbCap_C1283    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1284	pcbCap_C1284    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1285	pcbCap_C1285    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1286	pcbCap_C1286    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1287	pcbCap_C1287    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1288	pcbCap_C1288    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1289	pcbCap_C1289    ref_gnd     str(mlcc_10uF_0402)

						*** same side caps btw SoC and PMIC
						XpcbCap_C1342	pcbCap_C1342    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1340	pcbCap_C1340    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1334	pcbCap_C1334    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1337	pcbCap_C1337    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1336	pcbCap_C1336    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1343	pcbCap_C1343    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1341	pcbCap_C1341    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1331	pcbCap_C1331    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C752 	pcbCap_C752     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1167	pcbCap_C1167    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1339	pcbCap_C1339    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1172	pcbCap_C1172    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C750 	pcbCap_C750     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C754 	pcbCap_C754     ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1164	pcbCap_C1164    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1142	pcbCap_C1142    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1134	pcbCap_C1134    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1135	pcbCap_C1135    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1173	pcbCap_C1173    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1137	pcbCap_C1137    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1141	pcbCap_C1141    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1143	pcbCap_C1143    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1237	pcbCap_C1237    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1136	pcbCap_C1136    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1144	pcbCap_C1144    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C751 	pcbCap_C751     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1322	pcbCap_C1322    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1309	pcbCap_C1309    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1165	pcbCap_C1165    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1321	pcbCap_C1321    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1325	pcbCap_C1325    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1324	pcbCap_C1324    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1310	pcbCap_C1310    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1316	pcbCap_C1316    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1315	pcbCap_C1315    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1318	pcbCap_C1318    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1317	pcbCap_C1317    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1311	pcbCap_C1311    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1312	pcbCap_C1312    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1313	pcbCap_C1313    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1314	pcbCap_C1314    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1323	pcbCap_C1323    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C753 	pcbCap_C753     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C770 	pcbCap_C770     ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1319	pcbCap_C1319    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1320	pcbCap_C1320    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1326	pcbCap_C1326    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1327	pcbCap_C1327    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1328	pcbCap_C1328    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1330	pcbCap_C1330    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1344	pcbCap_C1344    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1332	pcbCap_C1332    ref_gnd 	str(mlcc_10uF_0402)
						XpcbCap_C1333	pcbCap_C1333    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1329	pcbCap_C1329    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1335	pcbCap_C1335    ref_gnd     str(mlcc_10uF_0402)
						XpcbCap_C1338	pcbCap_C1338    ref_gnd 	str(mlcc_10uF_0402)

						*** bulk caps under PMIC
						* XpcbCap_C1295	pcbCap_C1295    ref_gnd 	str(mlcc_100uF_1210)
						* XpcbCap_C95  	pcbCap_C95      ref_gnd 	str(mlcc_100uF_1210)
						* XpcbCap_C88  	pcbCap_C88      ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C89  	pcbCap_C89      ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C91  	pcbCap_C91      ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C94  	pcbCap_C94      ref_gnd 	str(mlcc_100uF_1210)
						* XpcbCap_C96  	pcbCap_C96      ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C1293	pcbCap_C1293    ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C1042	pcbCap_C1042    ref_gnd 	str(mlcc_100uF_1210)
						* XpcbCap_C1291	pcbCap_C1291    ref_gnd     str(mlcc_100uF_1210)

						*** bulk caps same side as PMIC             str(mlcc_100uF_1210)
						* XpcbCap_C87  	pcbCap_C87      ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C86  	pcbCap_C86  	ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C1044	pcbCap_C1044    ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C1290	pcbCap_C1290    ref_gnd 	str(mlcc_100uF_1210)
						* XpcbCap_C1294	pcbCap_C1294    ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C93  	pcbCap_C93      ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C1043	pcbCap_C1043    ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C97  	pcbCap_C97      ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C1296	pcbCap_C1296    ref_gnd     str(mlcc_100uF_1210)
						* XpcbCap_C1292	pcbCap_C1292    ref_gnd 	str(mlcc_100uF_1210)

					.endif 	*** end of 231221 ACM3 PCB, this is a test

*************************************** Pkg ***********************************
.if ( 1 )	*** pkg mock up Andes 0724, 1004
	Xblk_pkg
	 + pkgCap_C142  ref_gnd
	 + pkgCap_C143  ref_gnd
	 + pkgCap_C144  ref_gnd
	 + pkgCap_C145  ref_gnd
	 + pkgCap_C146  ref_gnd
	 + pkgCap_C147  ref_gnd
	 + pkgCap_C148  ref_gnd
	 + pkgCap_C149  ref_gnd
	 + pkgCap_C150  ref_gnd
	 + pkgCap_C151  ref_gnd
	 + pkgCap_C200  ref_gnd
	 + pkgCap_C201  ref_gnd
	 + pkgCap_C202  ref_gnd
	 + pkgCap_C203  ref_gnd
	 + pkgCap_C204  ref_gnd
	 + pkgCap_C205  ref_gnd
	 + pkgCap_C206  ref_gnd
	 + pkgCap_C207  ref_gnd
	 + pkgCap_C79   ref_gnd
	 + pkgCap_C82   ref_gnd
	 + pkgCap_C83   ref_gnd
	 + pkgCap_C84   ref_gnd
	 + pkg_bump_gpu ref_gnd 	*** GPU
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd		*** DSU
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + bga_pkg		ref_gnd
	 + bga_pkg		ref_gnd
	 + str(pkg_model)

	*** Pkg cap ***
					*** commented out due to size 1108
					* XpkgCap_C147  pkgCap_C147	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C148  pkgCap_C148	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C149  pkgCap_C149	ref_gnd		str(mlcc_1uF_0204)
					* XpkgCap_C150  pkgCap_C150	ref_gnd		str(mlcc_1uF_0204)
					* XpkgCap_C151  pkgCap_C151	ref_gnd		str(mlcc_1uF_0204)
					* XpkgCap_C142  pkgCap_C142	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C143  pkgCap_C143	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C144  pkgCap_C144	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C145  pkgCap_C145	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C146  pkgCap_C146	ref_gnd		str(mlcc_0p1uF_0204)

	XpkgCap_C147  pkgCap_C147	ref_gnd		str(mlcc_0p1uF_0201)
	XpkgCap_C148  pkgCap_C148	ref_gnd		str(mlcc_0p1uF_0201)
	XpkgCap_C149  pkgCap_C149	ref_gnd		str(mlcc_0p01uF_0201)
	XpkgCap_C150  pkgCap_C150	ref_gnd		str(mlcc_0p01uF_0201)
	XpkgCap_C151  pkgCap_C151	ref_gnd		str(mlcc_0p01uF_0201)
	XpkgCap_C142  pkgCap_C142	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C143  pkgCap_C143	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C144  pkgCap_C144	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C145  pkgCap_C145	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C146  pkgCap_C146	ref_gnd		str(mlcc_1uF_0201)

	XpkgCap_C200  pkgCap_C200	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C201  pkgCap_C201	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C202  pkgCap_C202	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C203  pkgCap_C203	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C204  pkgCap_C204	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C205  pkgCap_C205	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C206  pkgCap_C206	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C207  pkgCap_C207	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C79   pkgCap_C79	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C82   pkgCap_C82	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C83   pkgCap_C83	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C84   pkgCap_C84	ref_gnd		str(mlcc_10uF_0402)

.endif  	*** end of pkg mock up Andes 0724

*************************************** Die ***********************************
* Xblk_die 		pkg_bump	ref_gnd str(CPU_die) C_die= 'Cdie_cpu'	R_die_1= 'Rdie_cpu' R_die_2= 1.e-6	R_leak= 'Rleak_cpu'
* Xblk_die_gpu 	pkg_bump_gpu	ref_gnd str(GPU_die) C_die= 'Cdie_gpu'	R_die_1= 'Rdie_gpu' R_die_2= 1.e-6	R_leak= 'Rleak_gpu'

Xblk_die 		pkg_bump		ref_gnd model_die_typ C_die= 'Cdie_cpu'	R_die_1= 'Rdie_cpu' R_die_2= 1.e-6	R_leak= 'Rleak_cpu'	pwl_file_in = str(pwl_file_cpu)
Xblk_die_gpu 	pkg_bump_gpu	ref_gnd model_die_typ C_die= 'Cdie_gpu'	R_die_1= 'Rdie_gpu' R_die_2= 1.e-6	R_leak= 'Rleak_gpu'	pwl_file_in = str(pwl_file_gpu)

.param is_ac_run = 0
*************************************** Analysis I: AC simulation *************
.if ( is_ac_run == 1 )
	.if ( 1 )
		*** NOTE: DO not include port def if tran analysis later
		P1 pkg_bump	ref_gnd	port=1	z0 = 0.1
		P2 pkg_bump_gpu	ref_gnd	port=2	z0 = 0.1

		.lin 	sparcalc=1 	filename=impedance_plot	noisecalc=0 	gdcalc=0	format=touchstone 	dataformat=MA
		*.probe  ac s11(db) s11(p) s21(db) s21(p)
		.probe ac zin(1)(m) zin(1)(p) zin(2)(m) zin(2)(p)
	.endif

	.ac 	dec 50 1. 1.G
	*I_pkg_bump_1_0 		pkg_bump_1_0	ref_gnd		AC=1
	*.probe AC v(pkg_bump_1_0)

.endif

*************************************** Analysis II: Transient simulation *****
.if ( is_ac_run != 1 )
	.param tStep	= 10.p
	.param tStop	= 14.u
	.tran tStep tSTOP

	.probe tran v(pkg_bump) 	v(pkg_bump_gpu) 	v(bga_pkg)
	.probe x(Xblk_die.pin_bump)
	.probe x(Xblk_PCB.a_3)
	.probe x(xblk_PCB.a_1)  	x(xblk_PCB.a_2)
	.probe x(xblk_PMIC.pin_out)

	.param vdd_meas_start = 0.n
	.param vdd_meas_end   = 14.u
	.meas tran pkg_bump_cpu_p2p 		PP	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'
	.meas tran pkg_bump_cpu_vmax	MAX	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'
	.meas tran pkg_bump_cpu_vmin	MIN	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'
	.meas tran pkg_bump_cpu_vmax_t	WHEN	V(pkg_bump) = 'pkg_bump_cpu_vmax' 	from='vdd_meas_start' to='vdd_meas_end'
	.meas tran pkg_bump_cpu_vmin_t	WHEN	V(pkg_bump) = 'pkg_bump_cpu_vmin' 	from='vdd_meas_start' to='vdd_meas_end'
	.meas tran pkg_bump_p2p 		PP	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'

	*.probe i(L_comp)	i(L_comp_gpu)
	*.probe i(*)
	*.probe x(*)

.endif
