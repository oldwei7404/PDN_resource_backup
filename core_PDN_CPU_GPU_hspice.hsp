* Top level spice file

.option post=1
*.chkanode type=gate dv=0.5*pvdd report=active
.option parhier = local
.option measform = 1
.option lis_new
.option post probe

*************************************** User defined functions ****************
.param V_meas(node, ref) = 'v(node) - v(ref)'

*************************************** Input Models**************************
	***** define load current source model used in die model *****

	*.inc ./hspice_inc/out_curr_profile_CPU_55ns_13A_1000ns_cnst_500ns_9_13_rand_55ns_rampDown_noClk.txt

	*.inc ./hspice_inc/out_curr_profile_CPU_72ns_13A_1000ns_cnst_500ns_9_13_rand_72ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_CPU_144ns_13A_1000ns_cnst_500ns_9_13_rand_144ns_rampDown_noClk.txt

	*.inc ./hspice_inc/out_curr_profile_CPU_55ns_11A_1000ns_cnst_500ns_9_13_rand_55ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_CPU_55ns_9A_1000ns_cnst_500ns_6_9_rand_55ns_rampDown_noClk.txt

	* .inc ./hspice_inc/out_curr_profile_CPU_55ns_17A_2000ns_cnst_1000ns_12_17_rand_55ns_rampDown_noClk.txt
* .param pwl_file_cpu = str('./hspice_inc/out_curr_profile_CPU_55ns_17A_2000ns_cnst_1000ns_12_17_rand_55ns_rampDown_noClk.csv')		*** 9us

* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p5GHz_v2.txt.csv') 			*** NOTE: 10/10 current profile 	, length 1us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p5GHz_v3.txt.csv') 			*** NOTE: 10/10 current profile , length 7us
*.param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p0GHz_v2p2.txt.csv') 			*** NOTE: 10/10 current profile , length 1us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231010_2p0GHz_v3p2.txt.csv') 			*** NOTE: 10/10 current profile , length 8us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231018_2p5GHz_1us.txt.csv') 			*** NOTE: 10/18 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_cpu_20231018_2p5GHz_L3_6p5us.txt.csv') 			*** NOTE: 10/18 current profile

* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_1027.txt.csv') 			*** NOTE: 10/27 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_231106.txt.csv') 			*** NOTE: 11/06 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p0G_231108.txt.csv') 			*** NOTE: 11/08 current profile
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_240105.txt.csv') 			*** NOTE: 24/01/04 current profile, 3us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_240105_timeX10.txt.csv') 			*** NOTE: 24/01/04 current profile, time slow down by 10x, 14us
* .param pwl_file_cpu = str('./hspice_inc/curr_profile_CPU_2p5G_dtX14_240105.txt.csv') 			*** NOTE: 24/01/04 current profile, time slow down by 14x, 14us

* .param pwl_file_cpugpuAll = str('./hspice_inc/curr_profile_CPU_2p5G_240105_0p822V_UpDown_x7.txt.csv') 			*** NOTE: 240131 current profile, time slow down by 7x for up/down only, 5us
.param pwl_file_cpugpuAll = str('./hspice_inc/curr_profile_CPU_2p5G_240105_0p822V_UpDown_x7_v2.txt.csv')			*** NOTE: 2400206 current profile, time slow down by 7x for up/down only, extend mid 5 times, 8us
*.param pwl_file_cpugpuAll = str('./hspice_inc/curr_profile_CPU_2p5G_240105_0p822V_UpDown_x3p5.txt.csv') 			*** NOTE: 240205 current profile, time slow down by 3.5x for up/down only, 5us

	*** GPU profile
* .inc ./hspice_inc/out_curr_profile_GPU_20ns_2p5A_5000ns_cnst_noClk.txt
.param pwl_file_gpu = str('./hspice_inc/out_curr_profile_GPU_20ns_2p5A_5000ns_cnst_noClk.csv')

	***** define die model *****
* .inc ./hspice_inc/model_die_CPU.inc
* .inc ./hspice_inc/model_die_GPU.inc

.subckt model_die_typ
+ pin_bump ref_gnd C_die=100n R_die_1=1.25m R_die_2=RESMIN R_leak=0.84	pwl_file_in = str('./currSrc.csv')

R_die_1_ 	pin_bump	2	R_die_1
R_die_2_	2		3	R_die_2
C_die_		3		ref_gnd	C_die
R_leak_		pin_bump	ref_gnd	R_leak
IcurrSrc	pin_bump	ref_gnd	PWL pwlfile = str(pwl_file_in)
.ends

	***** define pkg model *****
	*.inc ./hspice_inc/C_v1_forCPU_wBF_wDSU_wGPU_RmLF_1e4Hz_IdEM.cir
	*.param pkg_model = str('C_v1_forCPU_wBF_wDSU_wGPU_RmLF_1e4Hz_IdEM')

.inc ./hspice_inc/Mam_MCM_Andes_0724_cpugpu_cut3_run2_IdEM.cir
.param pkg_model = str('Mam_MCM_Andes_0724_cpugpu_cut3_run2_IdEM')

	.inc ./hspice_inc/Mam_MCM_L12_231215c_mod48_CPU_GPU_02_IdEM_s25p.cir

	.inc ./hspice_inc/cpu_0206_2_IdEM.cir		***  Zijie mock up 240207 w/  3x embedded ecap EC2047

	***** define PCB model *****
	*.inc ./hspice_inc/ACM2_PT00547399_A_01_cut_CPU_PSI_RmLF_manip_IdEM0p5.cir
	*.param PCB_model = str('ACM2_PT00547399_A_01_cut_CPU_PSI_RmLF_manip_IdEM0p5')

	*.inc ./hspice_inc/ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmDC_mani_IdEM_0p5.cir		*** 0626 Cadera improvement
	*.param PCB_model = str('ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmDC_mani_IdEM_0p5')

	*.inc ./hspice_inc/ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmL5L10_RmDC_mani_IdEM0p5.cir 	*** 0626, but remove L5, L10 pwr shape
	*.param PCB_model = str('ACM2_PT00547399_A_01_Layout_Study_20230626_cut_CPU_RmL5L10_RmDC_mani_IdEM0p5')

	*.inc ./hspice_inc/MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_IdEM_0p5.cir
	*.param PCB_model = str('MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_IdEM_0p5')

	*.inc ./hspice_inc/MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_rmDC_manip_IdEM_0p5.cir
	*.param PCB_model = str('MAMMOTH_PCB_230721_CPU_GPU_merge_discrete_rmDC_manip_IdEM_0p5')

	* .inc ./hspice_inc/MAMMOTH_PCB_230803_CPU_GPU_merge_discrt_DCrm_manip_IdEM.cir			*** POR
	* .param PCB_model = str('MAMMOTH_PCB_230803_CPU_GPU_merge_discrt_DCrm_manip_IdEM')

	* .inc ./hspice_inc/MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_DCrm_manip_IdEM.cir					***0927, CPU PMIC at south of SoC
	* .param PCB_model = str('MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_DCrm_manip_IdEM')

	* .inc ./hspice_inc/MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_RmPwrL4L9_DCrm_manip_IdEM.cir		***0927, CPU PMIC at south of SoC, L4/9 pwr cut off
	* .param PCB_model = str('MAMMOTH_PCB_230925_CPU_GPU_merge_0927_jgwei_RmPwrL4L9_DCrm_manip_IdEM')

	* .inc ./hspice_inc/MAMMOTH_PCB_231013_CPU_GPU_merge_ORIG_cutL10L14_rmLF_manip_IdEM.cir					*** 1018, PMIC at south of SoC, PTH power vias
	* .param PCB_model = str('MAMMOTH_PCB_231013_CPU_GPU_merge_ORIG_cutL10L14_rmLF_manip_IdEM')
	* .inc ./hspice_inc/MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_jgwei_rmLF_manip_IdEM.cir				*** 1025, PMIC at west of SoC, PTH power vias
	* .param PCB_model = str('MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_jgwei_rmLF_manip_IdEM')

	.inc ./hspice_inc/MAMMOTH_PCB_231023_1_CPU_GPU_merge_stk1025_jgwei_rmLF_manip_IdEM.cir				*** 1025, PMIC at south of SoC, PTH power vias, 1025 new PCB stackup,
	.param PCB_model = str('MAMMOTH_PCB_231023_1_CPU_GPU_merge_stk1025_jgwei_rmLF_manip_IdEM')
	* .inc ./hspice_inc/MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_stk1025_jgwei_rmLF_manip_IdEM.cir		*** 1025, PMIC at west of SoC, PTH power vias, 1025 new PCB stackup,
	* .param PCB_model = str('MAMMOTH_PCB_231023_2_CPU_GPU_merge_pmic_left_stk1025_jgwei_rmLF_manip_IdEM')

			.inc ./hspice_inc/ACM3_122323_nne_cut_reduce_v2_manip_s5p.cir				*** 231221 ACM3 PCB, reduced to 5 ports, just for test

*************************************** Input params **************************
.param Vdd 	= 0.822

.param CPU_die = str('model_die_lumped_cpu')
.param GPU_die = str('model_die_lumped_gpu')

.param Cdie_cpu	 = '292.n' 				* '276.n'
.param Rdie_cpu	 = '0.086m'				* '0.452m'
.param Rleak_cpu = 0.232

.param Cdie_gpu  = '283.n'				* '268.n'
.param Rdie_gpu  = '0.088m'				* '0.465m'
.param Rleak_gpu = 1.27

.param is_use_ecap_ebed = 0		*** value: 0 or 1

	*** exp. to turn off GPU die model
	*.param Cdie_gpu	= '0.n'
	*.param Rdie_gpu	= '1.e9m'
	*.param Rleak_gpu= 1.e9
*************************************** cap model *****************************
.inc /data/home/jiangongwei/work/cap_models.hsp

*************************************** PMIC **********************************
.subckt PMIC_model
+ pin_out ref_gnd vdd_pmic = 0.75
	VshortPMIC	pin_out	ref_gnd	vdd_pmic
.ends

Vref_gnd 	ref_gnd		0	0.				*** opt 1/2 ideal PMIC w/o remote sense feedback
	*E_fdbk	ref_gnd	0	VCVS DELAY pmic_pwr pkg_bump_1_0  td=50.n	*** opt 2/2 VCVS to model feedback

*VshortPMIC	pmic_pwr	ref_gnd	Vdd		*** can be switched to PMIC model
xblk_PMIC pmic_pwr ref_gnd PMIC_model vdd_pmic = 'Vdd'

*************************************** Socket ********************************
Rskt	bga_pcb		bga_pkg		0.				*** can add socket model

*************************************** PCB ***********************************

.if ( 1 )	*** PCB 1018, 1025 (PMIC south or left, multiple pcb same set of ports) Andes mockup, PTH via, 1030 jgwei cap enhancement
	Xblk_PCB
	+ pmic_pwr 					 	*** use L501 and L511 as PMIC port
	+ pmic_pwr
	+ bga_pcb
    + pcbCap_C501
    + pcbCap_C502
    + pcbCap_C503
    + pcbCap_C504
    + pcbCap_C505
    + pcbCap_C511
    + pcbCap_C512
    + pcbCap_C513
    + pcbCap_C514
    + pcbCap_C515
    + pcbCap_C516
    + pcbCap_C517
    + pcbCap_C700
    + pcbCap_C701
    + pcbCap_C4009
    + pcbCap_C4010
    + pcbCap_C4016
    + pcbCap_C4017
    + pcbCap_C4018
    + pcbCap_C4019
    + pcbCap_C4020
    + pcbCap_C4021
    + pcbCap_C5001
    + pcbCap_C5002
    + pcbCap_C5003
    + pcbCap_C5004
    + pcbCap_C5005
    + pcbCap_C5006
    + pcbCap_C5007
    + pcbCap_C5008
    + pcbCap_C5009
    + pcbCap_C5010
    + pcbCap_C5011
    + pcbCap_C5012
    + pcbCap_C5013
    + pcbCap_C5014
    + pcbCap_C5015
    + pcbCap_C5016
    + pcbCap_C5017
    + pcbCap_C5018
    + pcbCap_C5019
    + pcbCap_C5020
    + pcbCap_C5021
    + pcbCap_C5022
    + pcbCap_C5023
    + pcbCap_C5024
    + pcbCap_C5025
    + pcbCap_C5026
    + pcbCap_C5027
    + pcbCap_C5028
    + pcbCap_C5029
    + pcbCap_C5030
    + pcbCap_C5031
    + pcbCap_C5032
    + pcbCap_C5033
    + pcbCap_C5034
    + pcbCap_C5035
    + pcbCap_C5036
    + pcbCap_C5037
    + pcbCap_C5038
    + pcbCap_C5039
    + pcbCap_C5040
    + pcbCap_C5041
    + pcbCap_C5042
    + pcbCap_C5043
    + pcbCap_C5044
    + pcbCap_C5045
    + pcbCap_C5046
    + pcbCap_C5047
    + pcbCap_C5048
    + pcbCap_C5049
    + pcbCap_C5050
    + pcbCap_C5051
    + pcbCap_C5052
    + pcbCap_C5053
    + pcbCap_C5054
    + pcbCap_C5055
    + pcbCap_C5056
    + pcbCap_C5057
    + pcbCap_C5058
    + pcbCap_C5059
    + pcbCap_C5060
    + pcbCap_C5061
	+ ref_gnd
	+ str(PCB_model)

	*** start of PMIC bulk
	XpcbCap_C504   pcbCap_C504	   ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C505   pcbCap_C505     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C514   pcbCap_C514     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C515   pcbCap_C515     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C501   pcbCap_C501     ref_gnd  str(mlcc_220uF_1210)
	XpcbCap_C502   pcbCap_C502     ref_gnd  str(mlcc_220uF_1210)
	XpcbCap_C503   pcbCap_C503     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C511   pcbCap_C511     ref_gnd	str(mlcc_220uF_1210)
	XpcbCap_C512   pcbCap_C512     ref_gnd  str(mlcc_220uF_1210)
	XpcbCap_C513   pcbCap_C513     ref_gnd	str(mlcc_220uF_1210)
	*** end of PMIC bulk

	*** CPU/GPU PCB bulk cap outside die shadow
	.if ( 1 )
		XpcbCap_C700   pcbCap_C700     ref_gnd	str(mlcc_220uF_1210)
		XpcbCap_C701   pcbCap_C701     ref_gnd	str(mlcc_220uF_1210)
		XpcbCap_C516   pcbCap_C516     ref_gnd	str(mlcc_220uF_1210)
		XpcbCap_C517   pcbCap_C517     ref_gnd	str(mlcc_220uF_1210)
			*** jgwei experiment to
		XpcbCap_C5052	 pcbCap_C5052	ref_gnd   str(mlcc_100uF_1210)
		XpcbCap_C4018	 pcbCap_C4018	ref_gnd   str(mlcc_100uF_1210)
	.endif
	*** CPU/GPU PCB bulk cap outside die shadow

	*** start of CPU caps under PCB die shadow
	XpcbCap_C5001	 pcbCap_C5001	ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5002    pcbCap_C5002   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5003    pcbCap_C5003   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5004    pcbCap_C5004   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5005    pcbCap_C5005   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5006    pcbCap_C5006   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5007    pcbCap_C5007   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5008    pcbCap_C5008   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5009    pcbCap_C5009   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5010    pcbCap_C5010   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5011    pcbCap_C5011   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5012    pcbCap_C5012   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5013    pcbCap_C5013   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5014    pcbCap_C5014   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5015    pcbCap_C5015   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5016    pcbCap_C5016   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5017    pcbCap_C5017   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5018    pcbCap_C5018   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5019    pcbCap_C5019   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5020    pcbCap_C5020   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5021    pcbCap_C5021   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5022    pcbCap_C5022   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5023    pcbCap_C5023   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5024    pcbCap_C5024   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5025    pcbCap_C5025   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5026    pcbCap_C5026   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5027    pcbCap_C5027   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5028    pcbCap_C5028   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5029    pcbCap_C5029   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5030    pcbCap_C5030   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5031    pcbCap_C5031   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5032    pcbCap_C5032   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5033    pcbCap_C5033   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5034    pcbCap_C5034   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5035    pcbCap_C5035   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5036    pcbCap_C5036   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5037    pcbCap_C5037   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5038    pcbCap_C5038   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5039    pcbCap_C5039   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5040    pcbCap_C5040   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5041    pcbCap_C5041   ref_gnd   str(mlcc_10uF_0402)
	XpcbCap_C5042    pcbCap_C5042   ref_gnd   str(mlcc_10uF_0402)
	*** end of CPU caps under PCB die shadow

.endif	*** end of PCB 1018 Andes mockup, 1030 jgwei cap enhancement

					.if ( 0 )		*** just a test,  231221 ACM3 PCB for NNE , reduced to 5 ports
						Xblk_PCB
						+ bga_pcb
						+ pmic_pwr
						+ pmic_pwr
						+ pmic_pwr
						+ pmic_pwr
						+ ref_gnd
						+ ACM3_122323_nne_cut_reduce_v2_manip_s5p

					.endif 		*** end of 231221 ACM3 PCB for NNE , reduced to 5 ports

*************************************** Pkg ***********************************
.if ( 0 )	*** pkg mock up Andes 0724, 1004
	Xblk_pkg
	 + pkgCap_C142  ref_gnd
	 + pkgCap_C143  ref_gnd
	 + pkgCap_C144  ref_gnd
	 + pkgCap_C145  ref_gnd
	 + pkgCap_C146  ref_gnd
	 + pkgCap_C147  ref_gnd
	 + pkgCap_C148  ref_gnd
	 + pkgCap_C149  ref_gnd
	 + pkgCap_C150  ref_gnd
	 + pkgCap_C151  ref_gnd
	 + pkgCap_C200  ref_gnd
	 + pkgCap_C201  ref_gnd
	 + pkgCap_C202  ref_gnd
	 + pkgCap_C203  ref_gnd
	 + pkgCap_C204  ref_gnd
	 + pkgCap_C205  ref_gnd
	 + pkgCap_C206  ref_gnd
	 + pkgCap_C207  ref_gnd
	 + pkgCap_C79   ref_gnd
	 + pkgCap_C82   ref_gnd
	 + pkgCap_C83   ref_gnd
	 + pkgCap_C84   ref_gnd
	 + pkg_bump_gpu ref_gnd 	*** GPU
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd		*** DSU
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + pkg_bump ref_gnd
	 + bga_pkg		ref_gnd
	 + bga_pkg		ref_gnd
	 + str(pkg_model)

	*** Pkg cap ***
					*** commented out due to size 1108
					* XpkgCap_C147  pkgCap_C147	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C148  pkgCap_C148	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C149  pkgCap_C149	ref_gnd		str(mlcc_1uF_0204)
					* XpkgCap_C150  pkgCap_C150	ref_gnd		str(mlcc_1uF_0204)
					* XpkgCap_C151  pkgCap_C151	ref_gnd		str(mlcc_1uF_0204)
					* XpkgCap_C142  pkgCap_C142	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C143  pkgCap_C143	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C144  pkgCap_C144	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C145  pkgCap_C145	ref_gnd		str(mlcc_0p1uF_0204)
					* XpkgCap_C146  pkgCap_C146	ref_gnd		str(mlcc_0p1uF_0204)

	XpkgCap_C147  pkgCap_C147	ref_gnd		str(mlcc_0p1uF_0201)
	XpkgCap_C148  pkgCap_C148	ref_gnd		str(mlcc_0p1uF_0201)
	XpkgCap_C149  pkgCap_C149	ref_gnd		str(mlcc_0p01uF_0201)
	XpkgCap_C150  pkgCap_C150	ref_gnd		str(mlcc_0p01uF_0201)
	XpkgCap_C151  pkgCap_C151	ref_gnd		str(mlcc_0p01uF_0201)
	XpkgCap_C142  pkgCap_C142	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C143  pkgCap_C143	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C144  pkgCap_C144	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C145  pkgCap_C145	ref_gnd		str(mlcc_1uF_0201)
	XpkgCap_C146  pkgCap_C146	ref_gnd		str(mlcc_1uF_0201)

	XpkgCap_C200  pkgCap_C200	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C201  pkgCap_C201	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C202  pkgCap_C202	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C203  pkgCap_C203	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C204  pkgCap_C204	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C205  pkgCap_C205	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C206  pkgCap_C206	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C207  pkgCap_C207	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C79   pkgCap_C79	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C82   pkgCap_C82	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C83   pkgCap_C83	ref_gnd		str(mlcc_10uF_0402)
	XpkgCap_C84   pkgCap_C84	ref_gnd		str(mlcc_10uF_0402)

.endif  	*** end of pkg mock up Andes 0724

.if ( 0 )	*** pkg mock up Andes 240117
	Xblk_pkg
	+ bga_pkg
	+ pkgCap_C1
	+ pkgCap_C2
	+ pkgCap_C3
	+ pkgCap_C4
	+ pkgCap_C5
	+ pkgCap_C6
	+ pkgCap_C7
	+ pkgCap_C8
	+ pkgCap_C9
	+ pkgCap_C10
	+ pkgCap_C3_1
	+ pkgCap_C3_2
	+ pkgCap_C3_3
	+ pkgCap_C3_4
	+ pkgCap_C3_5
	+ pkgCap_C3_6
	+ pkgCap_C3_7
	+ pkgCap_C3_8
	+ pkgCap_C4_1
	+ pkgCap_C4_2
	+ pkgCap_C4_3
	+ pkgCap_C4_4
	+ pkg_bump_gpu
	+ pkg_bump
	+ ref_gnd
	+ Mam_MCM_L12_231215c_mod48_CPU_GPU_02_IdEM_s25p

	XpkgCap_C1   		 pkgCap_C1     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)
	XpkgCap_C2           pkgCap_C2     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)
	XpkgCap_C3           pkgCap_C3     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)
	XpkgCap_C4           pkgCap_C4     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)

	XpkgCap_C5           pkgCap_C5     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)
	XpkgCap_C6           pkgCap_C6     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)
	XpkgCap_C7           pkgCap_C7     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)
	XpkgCap_C8           pkgCap_C8     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)

	XpkgCap_C3_1         pkgCap_C3_1   ref_gnd    pkgCap_C3_1   ref_gnd str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C3_2         pkgCap_C3_2   ref_gnd    pkgCap_C3_2   ref_gnd str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C3_3         pkgCap_C3_3   ref_gnd    pkgCap_C3_3   ref_gnd str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C3_4         pkgCap_C3_4   ref_gnd    pkgCap_C3_4   ref_gnd str(mlcc_1uF_0402_3T_ft)

	XpkgCap_C3_5         pkgCap_C3_5   ref_gnd   str(mlcc_1uF_0204)
	XpkgCap_C3_6         pkgCap_C3_6   ref_gnd   str(mlcc_1uF_0204)
	XpkgCap_C3_7         pkgCap_C3_7   ref_gnd   str(mlcc_1uF_0204)
	XpkgCap_C3_8         pkgCap_C3_8   ref_gnd   str(mlcc_1uF_0204)

	XpkgCap_C4_1         pkgCap_C4_1   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_2         pkgCap_C4_2   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_3         pkgCap_C4_3   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_4         pkgCap_C4_4   ref_gnd   str(mlcc_10uF_0402)
	*** add more 10uF caps
	XpkgCap_C4_1_2         pkgCap_C4_1   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_2_2         pkgCap_C4_2   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_3_2         pkgCap_C4_3   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_4_2         pkgCap_C4_4   ref_gnd   str(mlcc_10uF_0402)

	.if ( 0 )  *** test to connect Ecap to bump
		XeCap_1
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ str(siCap_empwr_EC2047_4p8uF)

		XeCap_2
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ str(siCap_empwr_EC2047_4p8uF)

		XeCap_3
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one	pkg_bump_one
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ str(siCap_empwr_EC2047_4p8uF)

	.endif

.endif 		*** pkg mock up Andes 240117 end

.if ( 1 )	*** Zijie mock up 240207 w/  3x embedded ecap EC2047
	Xblk_pkg
	+ pkg_bump
	+ pkg_bump_gpu
	+ bga_pkg
	+ pkgCap_C4_1
	+ pkgCap_C4_2
	+ pkgCap_C4_3
	+ pkgCap_C4_4
	+ pkgCap_C1
	+ pkgCap_C2
	+ pkgCap_C3
	+ pkgCap_C4
	+ pkgCap_C5
	+ pkgCap_C6
	+ pkgCap_C7
	+ pkgCap_C8
	+ pkgCap_C9
	+ pkgCap_C10
	+ pkgCap_C3_1
	+ pkgCap_C3_2
	+ pkgCap_C3_3
	+ pkgCap_C3_4
	+ pkgCap_C3_5
	+ pkgCap_C3_6
	+ pkgCap_C3_7
	+ pkgCap_C3_8
	+ pkgCap_eCap_EC1_A1
	+ pkgCap_eCap_EC1_A2
	+ pkgCap_eCap_EC1_A3
	+ pkgCap_eCap_EC1_A4
	+ pkgCap_eCap_EC1_A5
	+ pkgCap_eCap_EC1_A6
	+ pkgCap_eCap_EC1_C1
	+ pkgCap_eCap_EC1_C2
	+ pkgCap_eCap_EC1_C3
	+ pkgCap_eCap_EC1_C4
	+ pkgCap_eCap_EC1_C5
	+ pkgCap_eCap_EC1_C6
	+ pkgCap_eCap_EC1_E1
	+ pkgCap_eCap_EC1_E2
	+ pkgCap_eCap_EC1_E3
	+ pkgCap_eCap_EC1_E4
	+ pkgCap_eCap_EC1_E5
	+ pkgCap_eCap_EC1_E6
	+ pkgCap_eCap_EC2_A1
	+ pkgCap_eCap_EC2_A2
	+ pkgCap_eCap_EC2_A3
	+ pkgCap_eCap_EC2_A4
	+ pkgCap_eCap_EC2_A5
	+ pkgCap_eCap_EC2_A6
	+ pkgCap_eCap_EC2_C1
	+ pkgCap_eCap_EC2_C2
	+ pkgCap_eCap_EC2_C3
	+ pkgCap_eCap_EC2_C4
	+ pkgCap_eCap_EC2_C5
	+ pkgCap_eCap_EC2_C6
	+ pkgCap_eCap_EC2_E1
	+ pkgCap_eCap_EC2_E2
	+ pkgCap_eCap_EC2_E3
	+ pkgCap_eCap_EC2_E4
	+ pkgCap_eCap_EC2_E5
	+ pkgCap_eCap_EC2_E6
	+ pkgCap_eCap_EC3_A1
	+ pkgCap_eCap_EC3_A2
	+ pkgCap_eCap_EC3_A3
	+ pkgCap_eCap_EC3_A4
	+ pkgCap_eCap_EC3_A5
	+ pkgCap_eCap_EC3_A6
	+ pkgCap_eCap_EC3_C1
	+ pkgCap_eCap_EC3_C2
	+ pkgCap_eCap_EC3_C3
	+ pkgCap_eCap_EC3_C4
	+ pkgCap_eCap_EC3_C5
	+ pkgCap_eCap_EC3_C6
	+ pkgCap_eCap_EC3_E1
	+ pkgCap_eCap_EC3_E2
	+ pkgCap_eCap_EC3_E3
	+ pkgCap_eCap_EC3_E4
	+ pkgCap_eCap_EC3_E5
	+ pkgCap_eCap_EC3_E6
	+ ref_gnd
	+ cpu_0206_2_IdEM

	*** pkg MLCC DSC
	XpkgCap_C1   		 pkgCap_C1     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)
	XpkgCap_C2           pkgCap_C2     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)
	XpkgCap_C3           pkgCap_C3     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)
	XpkgCap_C4           pkgCap_C4     ref_gnd    ref_gnd  str(mlcc_0p1uF_0204_TDK)

	XpkgCap_C5           pkgCap_C5     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)
	XpkgCap_C6           pkgCap_C6     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)
	XpkgCap_C7           pkgCap_C7     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)
	XpkgCap_C8           pkgCap_C8     ref_gnd    ref_gnd  str(mlcc_0p047uF_0204_TDK)

	XpkgCap_C3_1         pkgCap_C3_1   ref_gnd    pkgCap_C3_1   ref_gnd str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C3_2         pkgCap_C3_2   ref_gnd    pkgCap_C3_2   ref_gnd str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C3_3         pkgCap_C3_3   ref_gnd    pkgCap_C3_3   ref_gnd str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C3_4         pkgCap_C3_4   ref_gnd    pkgCap_C3_4   ref_gnd str(mlcc_1uF_0402_3T_ft)

	XpkgCap_C3_5         pkgCap_C3_5   ref_gnd   str(mlcc_1uF_0204)
	XpkgCap_C3_6         pkgCap_C3_6   ref_gnd   str(mlcc_1uF_0204)
	XpkgCap_C3_7         pkgCap_C3_7   ref_gnd   str(mlcc_1uF_0204)
	XpkgCap_C3_8         pkgCap_C3_8   ref_gnd   str(mlcc_1uF_0204)

	XpkgCap_C4_1         pkgCap_C4_1   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_2         pkgCap_C4_2   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_3         pkgCap_C4_3   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_4         pkgCap_C4_4   ref_gnd   str(mlcc_10uF_0402)
	*** add more 10uF caps
	XpkgCap_C4_1_2         pkgCap_C4_1   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_2_2         pkgCap_C4_2   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_3_2         pkgCap_C4_3   ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C4_4_2         pkgCap_C4_4   ref_gnd   str(mlcc_10uF_0402)

	*** embedded Ecap
	.if (is_use_ecap_ebed == 1)
		X_pkgEcap_1
		+ pkgCap_eCap_EC1_A1
		+ pkgCap_eCap_EC1_A2
		+ pkgCap_eCap_EC1_A3
		+ pkgCap_eCap_EC1_A4
		+ pkgCap_eCap_EC1_A5
		+ pkgCap_eCap_EC1_A6
		+ pkgCap_eCap_EC1_C1
		+ pkgCap_eCap_EC1_C2
		+ pkgCap_eCap_EC1_C3
		+ pkgCap_eCap_EC1_C4
		+ pkgCap_eCap_EC1_C5
		+ pkgCap_eCap_EC1_C6
		+ pkgCap_eCap_EC1_E1
		+ pkgCap_eCap_EC1_E2
		+ pkgCap_eCap_EC1_E3
		+ pkgCap_eCap_EC1_E4
		+ pkgCap_eCap_EC1_E5
		+ pkgCap_eCap_EC1_E6
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ str(siCap_empwr_EC2047_4p8uF)

		X_pkgEcap_2
		+ pkgCap_eCap_EC2_A1
		+ pkgCap_eCap_EC2_A2
		+ pkgCap_eCap_EC2_A3
		+ pkgCap_eCap_EC2_A4
		+ pkgCap_eCap_EC2_A5
		+ pkgCap_eCap_EC2_A6
		+ pkgCap_eCap_EC2_C1
		+ pkgCap_eCap_EC2_C2
		+ pkgCap_eCap_EC2_C3
		+ pkgCap_eCap_EC2_C4
		+ pkgCap_eCap_EC2_C5
		+ pkgCap_eCap_EC2_C6
		+ pkgCap_eCap_EC2_E1
		+ pkgCap_eCap_EC2_E2
		+ pkgCap_eCap_EC2_E3
		+ pkgCap_eCap_EC2_E4
		+ pkgCap_eCap_EC2_E5
		+ pkgCap_eCap_EC2_E6
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ str(siCap_empwr_EC2047_4p8uF)

		X_pkgEcap_3
		+ pkgCap_eCap_EC3_A1
		+ pkgCap_eCap_EC3_A2
		+ pkgCap_eCap_EC3_A3
		+ pkgCap_eCap_EC3_A4
		+ pkgCap_eCap_EC3_A5
		+ pkgCap_eCap_EC3_A6
		+ pkgCap_eCap_EC3_C1
		+ pkgCap_eCap_EC3_C2
		+ pkgCap_eCap_EC3_C3
		+ pkgCap_eCap_EC3_C4
		+ pkgCap_eCap_EC3_C5
		+ pkgCap_eCap_EC3_C6
		+ pkgCap_eCap_EC3_E1
		+ pkgCap_eCap_EC3_E2
		+ pkgCap_eCap_EC3_E3
		+ pkgCap_eCap_EC3_E4
		+ pkgCap_eCap_EC3_E5
		+ pkgCap_eCap_EC3_E6
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ ref_gnd 	ref_gnd		ref_gnd		ref_gnd 	ref_gnd		ref_gnd
		+ str(siCap_empwr_EC2047_4p8uF)

	.endif

.endif 		*** Zijie mock up 240207 w/  3x embedded ecap EC2047 end

*************************************** Die ***********************************
*** approach 1: multi grp modeling
* Xblk_die 		pkg_bump		ref_gnd model_die_typ C_die= 'Cdie_cpu'	R_die_1= 'Rdie_cpu' R_die_2= 1.e-6	R_leak= 'Rleak_cpu'	pwl_file_in = str(pwl_file_cpu)
* Xblk_die_gpu 	pkg_bump_gpu	ref_gnd model_die_typ C_die= 'Cdie_gpu'	R_die_1= 'Rdie_gpu' R_die_2= 1.e-6	R_leak= 'Rleak_gpu'	pwl_file_in = str(pwl_file_gpu)

*** approach 2: single grp modeling
	*** all bump grps connected to single die model
	R_bump_merge_0 pkg_bump_one	pkg_bump		1.n
	R_bump_merge_1 pkg_bump_one	pkg_bump_gpu	1.n

	Xblk_die 		pkg_bump_one	ref_gnd model_die_typ C_die=  575.n	R_die_1= 0.043m  R_die_2= 1.n	R_leak= 'Rleak_cpu'	pwl_file_in = str(pwl_file_cpugpuAll)
	* Xblk_die 		pkg_bump_one	ref_gnd model_die_typ C_die= 2092.n	R_die_1= 0.043m  R_die_2= 1.n	R_leak= 'Rleak_cpu'	pwl_file_in = str(pwl_file_cpugpuAll)	*** MIM, + 50 * 43.33 * 0.7

.param is_ac_run = 0
*************************************** Analysis I: AC simulation *************
.if ( is_ac_run == 1 )
	.if ( 1 )
		*** NOTE: DO not include port def if tran analysis later
		P1 pkg_bump	ref_gnd	port=1	z0 = 0.1
		P2 pkg_bump_gpu	ref_gnd	port=2	z0 = 0.1

		.lin 	sparcalc=1 	filename=impedance_plot	noisecalc=0 	gdcalc=0	format=touchstone 	dataformat=MA
		*.probe  ac s11(db) s11(p) s21(db) s21(p)
		.probe ac zin(1)(m) zin(1)(p) zin(2)(m) zin(2)(p)
	.endif

	.ac 	dec 50 1. 1.G
	*I_pkg_bump_1_0 		pkg_bump_1_0	ref_gnd		AC=1
	*.probe AC v(pkg_bump_1_0)

.endif

*************************************** Analysis II: Transient simulation *****
.if ( is_ac_run != 1 )
	.param tStep	= 10.p
	.param tStop	= 8.u
	.tran tStep tSTOP

	.probe tran v(pkg_bump) 	v(pkg_bump_gpu) 	v(bga_pkg)
	.probe x(Xblk_die.pin_bump)
	.probe x(Xblk_PCB.a_3)
	.probe x(xblk_PCB.a_1)  	x(xblk_PCB.a_2)
	.probe x(xblk_PMIC.pin_out)

	* .param vdd_meas_start = 0.n
	* .param vdd_meas_end   = 5.u
	* .meas tran pkg_bump_cpu_p2p 		PP	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_cpu_vmax	MAX	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_cpu_vmin	MIN	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_cpu_vmax_t	WHEN	V(pkg_bump) = 'pkg_bump_cpu_vmax' 	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_cpu_vmin_t	WHEN	V(pkg_bump) = 'pkg_bump_cpu_vmin' 	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_p2p 		PP	V(pkg_bump)	from='vdd_meas_start' to='vdd_meas_end'

	*.probe i(L_comp)	i(L_comp_gpu)
	*.probe i(*)
	*.probe x(*)

.endif
