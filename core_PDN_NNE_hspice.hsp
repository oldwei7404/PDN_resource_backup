* Top level spice file

.option post=1
*.chkanode type=gate dv=0.5*pvdd report=active
.option parhier = local
.option measform = 1
.option lis_new
.option post probe
.param pi = 3.141592653

*************************************** User defined functions ****************
.param V_meas(node, ref) = 'v(node) - v(ref)'

*************************************** Input Models**************************
	***** define load current source model used in die model *****
* .param pwl_file_in_PA = str('./hspice_inc/out_curr_profile_NNE_4x2grp_PA_test4_act_0p3_0p2_0518_200clk_0scale_continue_idle_clk_51703_0925.inc.csv')
* .param pwl_file_in_MA = str('./hspice_inc/out_curr_profile_NNE_4x2grp_MA_test4_act_0p3_0p2_0518_200clk_0scale_continue_idle_clk_51703_0925.inc.csv')

		* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_shortened.txt.csv')		*** PMIC vendor test, 11us
		* .param pwl_file_in_MA = str('./hspice_inc/curr_profile_NNE_4x2_MA_shortened.txt.csv')

		* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_1031_500MHz.txt.csv')		*** PMIC vendor test,  11us, POR
		* .param pwl_file_in_MA = str('./hspice_inc/curr_profile_NNE_4x2_MA_1031_500MHz.txt.csv')

		* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_noRampFr0515_1116.csv')		*** PMIC vendor test, no ramp ,  11us
		* .param pwl_file_in_MA = str('./hspice_inc/curr_profile_NNE_4x2_MA_noRampFr0515_1116.csv')

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_240117.txt.csv')				*** ramp 16clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp32clk.txt.csv')			*** ramp 32clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp64clk.txt.csv')			*** ramp 64clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp128clk.txt.csv')			*** ramp 128clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp256clk.txt.csv')			*** ramp 256clk,  18us (3us w/ up/down)

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp16clk_80W.txt.csv')		*** ramp 16clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp32clk_80W.txt.csv')		*** ramp 32clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp64clk_80W.txt.csv')		*** ramp 64clk,  18us (2.5us w/ up/down)

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp16clk_105W.txt.csv')		*** ramp 16clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp32clk_105W.txt.csv')		*** ramp 32clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp64clk_105W.txt.csv')		*** ramp 64clk,  18us (2.5us w/ up/down)

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_x0p25_traceFrPD_240215.txt.csv')		*** *** 240215 Puru trace x 0.25, 3us

				* .param pwl_file_in_MA = str('./hspice_inc/curr_idle_0A.csv')	*** MA current NA as of 2024/1/17

				.param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_ramped_trace_scaled_240306.txt.csv')		*** 1/4 of PA, Rahul 240313, 8us
				.param pwl_file_in_MA = str('./hspice_inc/curr_profile_NNE_4x2_GMT_ramped_trace_scaled_240306.txt.csv')		*** 1/4 of PA, Rahul 240313, 8us

						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp16clk_80W.txt.csv')	*** single current profile for whole NNE PA
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp32clk_80W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp64clk_80W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp128clk_80W.txt.csv')

						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp16clk_80W_30W.txt.csv')	*** single current profile for whole NNE PA, 240202
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp32clk_80W_30W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp64clk_80W_30W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp128clk_80W_30W.txt.csv')

						*.param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_traceFrPD_240207.txt.csv')			*** 240207 Puru trace, 1us
						*.param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_traceFrPD_x0p762_240207.txt.csv')	*** 240207 Puru trace x 0.762 to simulate 80W, 1us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_traceFrPD_240215.txt.csv')			*** 240215 Puru trace, 3us

						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_fullAlign_240222.txt.csv')		*** 240222  trace, PA + GMEM 3us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_stagger_240222.txt.csv')			*** 240222  trace, PA + GMEM 3us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_fullAlign_scale_240222.txt.csv')	*** 240222  trace, PA + GMEM 3us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_stagger_scale_240222.txt.csv')	*** 240222  trace, PA + GMEM 3us

						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_240301.txt.csv')		*** 240301  trace, PA + GMEM 4us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_sacled_240301.txt.csv')		*** 240301  trace, PA + GMEM 4us
						.param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_240306.txt.csv')		*** 240306  trace, PA + GMEM 4us

		*** idle current
		.param pwl_file_quiet = str('./hspice_inc/curr_quiet_30us.txt.csv')

		***  step up current (only one def allowed)
	*.inc ./hspice_inc/out_curr_profile_NNE_100ns_12A_10000ns_cnst_100ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_NNE_300nsRamp_100ns_12A_10000ns_cnst_100ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_NNE_300nsRamp_100ns_12A_10000ns_cnst_100ns_rampDown_Clk0p7floor.txt

	***** define die model *****
.subckt model_die_lumped_nne_tile
	+ pin_bump ref_gnd C_die=100n R_die_1=1.25m R_die_2=RESMIN R_leak=0.84	pwl_file_in = str(pwl_file_quiet) delay = 0.

	R_die_1_ 	pin_bump	2	R_die_1
	R_die_2_	2		3	R_die_2
	C_die_		3		ref_gnd	C_die
	R_leak_		pin_bump	ref_gnd	R_leak
	IcurrSrc	pin_bump	ref_gnd	PWL pwlfile = str(pwl_file_in) td = delay    *** add 'R' if repeat
.ends

.inc ./hspice_inc/cpm_nne_4x2_240313.sp 	*** Andes 4x2 CPM model 240313

	***** define pkg model *****
	* .inc ./hspice_inc/nne_pkg_230329_FCBGA_L12_mammoth_20230525ate_a_IdEM.cir	***  0526 Andes pkg w/ 28 + 35 DSC
* .inc ./hspice_inc/Mam_MCM_L12_231215_mod40_jgwei_s72_IdEM.cir				*** 231220 Andes pkg, POR
	* .inc ./hspice_inc/ipd_partial_w_Ports_manip_IdEM_0p0001_wt0p5.cir		*** 240109 Zijie pkg w/ IPD
	*.inc ./hspice_inc/ecap_diff_dist_manip_order8_fixDC_s249p.cir			*** 240110 Zijie pkg w/ 3x diff Ecap + 1x embeded Ecap
	* .inc  ./hspice_inc/dsc_lsc_0111_2_manip_order8_0p5wt.cir				*** 240112 Zijie pkg w/ LSC, DSC, L&R DSC
    * .inc  ./hspice_inc/Mam_MCM_L12_231215c_mod48_NNE_02_IdEM.cir			*** 240118 Andes pkg
	.inc  ./hspice_inc/nne_ecap_dsc_IdEM.cir								*** 240131 Zijie pkg mockup w/ DSC and embedded Ecap
	.inc  ./hspice_inc/NNE_pkg_redu_240131_ZijiePkg_Ecap_Disabled_s2p_IdEM.cir	*** reduced model of "240131 Zijie pkg mockup w/ DSC and embedded Ecap"
	.inc  ./hspice_inc/NNE_pkg_redu_240131_ZijiePkg_Ecap_Enabled_s2p_IdEM.cir	*** reduced model of "240131 Zijie pkg mockup w/ DSC and embedded Ecap", with Ecap enabled
	.inc  ./hspice_inc/Mam_MCM_L12_BH9_Ballv0p83_BPIv0071_20240124_3_20240216ate_b_IdEM.cir  	*** 240222 Andes pkg 140um pitch
	.inc  ./hspice_inc/nne_6x_ecap_0307_2__w_ecap_redu_1e_4_order18_IdEM_s2p.cir	*** 240311 Zijie pkg w/ 6x EC2047 cap model, 140um pitch, reduced model
	.inc  ./hspice_inc/nne_6x_ecap_0307_2__w_12xFeC2072ecap_redu_IdEM_s2p.cir		*** 240311 Zijie pkg w/ 12x Fec2072 cap model, 140um pitch, reduced model

	.inc ./hspice_inc/nne_4x2_Andes_redu_IdEM.cir 		*** Andes 140um 4x2 + bga model, MLCC only
	.inc ./hspice_inc/nne_4x2_6xEC2047_redu_IdEM.cir 	*** 240311 Zijie pkg w/ 6x EC2047 cap model, 140um pitch, 4x2 + bga model

	***** define PCB model *****
		* .inc ./hspice_inc/MAMMOTH_PCB_231031_3_NNE_LFmanip_IdEM.cir					*** 1101, version, SoC bulk caps added vias
		*.inc ./hspice_inc/ACM3_122323_nne_cut_manip_IdEM_s377p.cir					*** 231221 ACM3 PCB,   240126, accuracy not good btw 1~40MHz,  DO NOT USE
	.inc ./hspice_inc/ACM3_122323_nne_cut_reduce_v2_manip_s5p.cir				*** 231221 ACM3 PCB, reduced to 5 ports
		* .inc ./hspice_inc/ACM3_NEWLAYOUT_01_30_4_3uF_4Phase_half10uFCAPSrev3_manip_IdEM.cir		*** 240131 ACM3 PCB, Kavoos provided reduced PCB model, w/ 10uF, and 1uF caps; do NOT use due to LF noise near 500kHz
	.inc ./hspice_inc/ACM3_notoplayer_10_100uF_10_220uF_IdEM.cir				*** Kavoos 240216 ACM3, 10uF, w/ 20x bulk caps
	.inc ./hspice_inc/ACM3_notoplayer_no_10_100uF_10_220uF_IdEM.cir				*** Kavoos 240216 ACM3, 10uF, w/o 20x bulk caps
	.inc ./hspice_inc/ACM3_bulk_top_and_centerbottom_caps_IdEM.cir				*** Kavoos 240221 ACM3, only top side caps, bulk caps, 66 back side caps
    .inc ./hspice_inc/acm3_nne_pcb_240314_105C_IdEM.cir							*** jgwei 240314 ACM3, 105C, all 100uF
	.inc ./hspice_inc/ACM3_105C_3_14_24_IdEM.cir

	****** define reduced model *****
	* .inc ./hspice_inc/Z_NNE_all_reducedModel_240202_manip_IdEM.cir
	* .inc ./hspice_inc/NNE_pkg_PCB_ACM3Kavoos_w_bulk_redu_240216_s5p_IdEM.cir		*** low accuracy, do not use
	* .inc ./hspice_inc/NNE_pkg_PCB_ACM3Kavoos_wo_bulk_redu_240216_s5p_IdEM.cir		*** low accuracy, do not use

*************************************** Input params **************************
.param Vdd 	= 0.75

.para Cdie_coeff = 1.0				*** ONLY multi grp controlling, use 1.0 if no Cdie scaling, use 3.62 for NNE if MIM cap is added,
.para Rdie_coeff = 1.0				*** Rdie is constant 1. , rather than scaled by '1./Cdie_coeff'

*** Cdie Rdie based on MAM-242, tau = 24.26 (excluding MIM)
.param Cdie_PA 	= '130.3n * Cdie_coeff'
.param Cdie_MA 	= '101.7n * Cdie_coeff'
.param Rdie_PA 	= '0.186m * Rdie_coeff'
.param Rdie_MA 	= '0.239m * Rdie_coeff'
.param Rleak 	= 0.84

.param is_use_3T_cap_ft = 1		*** value: 0 or 1, note: this could be baked in pkg model

.param is_use_ecap_ebed = 0		*** value: 0 or 1, note: this could be baked in pkg model
.param is_MIM 		= 0

.param die_model_sig = 0		*** value: 0 if multi grp model, 1 if single die grp model

		* .param r_grid = 52e6.m			*** only applied when multi grp model, i.e. die_model_sig = 0

.param is_ac_run = 1		*** 1 if impedance, 0 if transient

.param tStep	= 10.p
.param tStop	= 8.u     ** 35.u

.param td_delay = 0.n

*************************************** End of User Input params **************

*************************************** cap model *****************************
.inc ../models_cap/GCM155D70E106ME36_DC0V_125degC_0402_10uF.mod
.inc ../models_cap/GCM155D70G475ME36_DC0V_125degC_0402_4p7uF.mod
.inc ../models_cap/GCM155C71A105KE38_DC0V_125degC_0402_1uF.mod
.inc ../models_cap/GCM31CD70G476ME02_DC0V_125degC_1206_47uF.mod
.inc ../models_cap/GCM32ED70E107ME36_DC0V_125degC_1210_100uF.mod
.inc ../models_cap/GCM033D70E105ME36_DC0V_125degC_0201_1uF.mod
.inc ../models_cap/NFM15HC105D0G3_feedthrough_DC0V_85degC_3T_0402_1uF.mod
.inc ../models_cap/LLC152D70G105ME01_DC0V_125degC_0204_1uF.mod
.inc ../models_cap/LLL153C70G104ME01_DC0V_125degC_0204_0.1uF.mod
.inc ../models_cap/GRT033R70J103KE01_DC0V_125degC_0201_0p01uF.mod
.inc ../models_cap/GCM155R71C104KA55_DC0V_125degC_0402_0.1uF.mod
.inc ../models_cap/GCM21BD70G226ME36_DC0V_125degC_0805_22uF.mod
.inc ../models_cap/GCM32EM8EA227ME08_DC0V_125degC_1210_220uF.mod
.inc ../models_cap/GCM155R71E153KA55_DC0V_125degC_0402_0.015uF.mod
.inc ../models_cap/GRT033C70J104KE01_DC0V_125degC_0201_0p1uF.mod
.inc ../models_cap/GCM033C70J104KE02_DC0V_125degC_0p1uF_0201.mod
.inc ../models_cap/mlcc_470uF_mockup_T598D477M2R5ATE009.mod
.inc ../models_cap/open_circuit.mod
.inc ../models_cap/cgaea1x7r1h473m030bc_47nF_100pH_ACL_0204_IdEM.cir
.inc ../models_cap/cgaew1x7t0g104m020bc_100nF_90pH_ACL_0204_IdEM.cir
.inc ../models_cap/GCM033R71A103KA03_DC0V_125degC_0201_0.01uF.mod

.inc ../models_cap/EC1001.mod
.inc ../models_cap/EC1002.mod
.inc ../models_cap/EC1100_200nF.mod
.inc ../models_cap/ECAP_16600nF_12x10array.mod

	***** define cap model strings for better ref ****
.param mlcc_1uF_0402 		= str('GCM155C71A105KE38_DC0V_125degC_0402_1uF')
.param mlcc_1uF_0204 		= str('LLC152D70G105ME01_DC0V_125degC_0204_1uF')
.param mlcc_1uF_0201 		= str('GCM033D70E105ME36_DC0V_125degC_0201_1uF')
.param mlcc_1uF_0402_3T_ft		= str('NFM15HC105D0G3_feedthrough_DC0V_85degC_3T_0402_1uF')
.param mlcc_4p7uF_0402 		= str('GCM155D70G475ME36_DC0V_125degC_0402_4p7uF')
.param mlcc_10uF_0402 		= str('GCM155D70E106ME36_DC0V_125degC_0402_10uF')
.param mlcc_47uF_1206		= str('GCM31CD70G476ME02_DC0V_125degC_1206_47uF')
.param mlcc_100uF_1210		= str('GCM32ED70E107ME36_DC0V_125degC_1210_100uF')
.param mlcc_0p1uF_0402		= str('GCM155R71C104KA55_DC0V_125degC')
.param mlcc_0p1uF_0201		= str('GRT033C70J104KE01_DC0V_125degC')
.param mlcc_0p1uF_0204 		= str('LLL153C70G104ME01_DC0V_125degC')
.param mlcc_0p015uF_0402	= str('GCM155R71E153KA55_DC0V_125degC')
.param mlcc_0p01uF_0201		= str('GRT033R70J103KE01_DC0V_125degC')
.param mlcc_0p01uF_0201_II  = str('GCM033R71A103KA03_DC0V_125degC')

.param mlcc_22uF_0805		= str('GCM21BD70G226ME36_DC0V_125degC_0805_22uF')
.param mlcc_220uF_1210		= str('GCM32EM8EA227ME08_DC0V_125degC')
.param mlcc_0p047uF_0204_TDK= str('cgaea1x7r1h473m030bc_47nF_100pH_ACL_0204_IdEM')
.param mlcc_0p1uF_0204_TDK  = str('cgaew1x7t0g104m020bc_100nF_90pH_ACL_0204_IdEM')

.param mlcc_470uF_mockup	= str('mlcc_470uF_mockup_T598D477M2R5ATE009')

.param siCap_empwr_EC1001 = str('EC1001')
.param siCap_empwr_EC1002 = str('EC1002')
.param siCap_empwr_EC1100_200nF = str('EC1100_200nF')
.param siCap_empwr_EC1005_16600nF = str('ECAP_16600nF_12x10array')

*************************************** PMIC **********************************

Vref_gnd 	ref_gnd		0	0.
	*E_fdbk	ref_gnd	0	VCVS DELAY pmic_pwr pkg_bump_1_0  td=50.n	*** opt 2/2 VCVS to model feedback

.subckt PMIC_model
+ pin_out ref_gnd vdd_pmic = 0.75
	VshortPMIC	pin_out	ref_gnd	vdd_pmic
.ends

*** opt 1 ideal PMIC w/o remote sense feedback
.if ( 1 )
	*VshortPMIC	pmic_pwr	ref_gnd	Vdd		*** can be switched to PMIC model
	xblk_PMIC pmic_pwr ref_gnd PMIC_model  vdd_pmic = 'Vdd'
.endif
*** opt 2 EMpower simplified IVR equivalent model 	(remember to disable PMIC bulk caps on PCB)
.if ( 0 )
	VempowerVS	pmicEMpwrNode1	ref_gnd	Vdd		*** can be switched to PMIC model
	LempowerVS1  pmicEMpwrNode1  pmicEMpwrNode2  	'0.027778n * 0.9091'
	RempowerVS1  pmicEMpwrNode2  pmic_pwr			50.u
.endif
*************************************** Socket ********************************
Rskt	bga_pcb		bga_pkg		1.u				*** can add socket model

																									.if ( 0 )  	***  test reduced PCB+pkg for SIMPLIS  ==> low accuracy, do NOT use
																										Xblk_PCB
																										+ pkg_bump_one
																										+ pmic_pwr
																										+ pmic_pwr
																										+ pmic_pwr
																										+ pmic_pwr
																										+ ref_gnd
																										+ NNE_pkg_PCB_ACM3Kavoos_w_bulk_redu_240216_s5p_IdEM
																									.endif 		***  test reduced PCB+pkg for SIMPLIS end

*************************************** PCB ***********************************
.if ( 1 )		***  ACM3 PCB, reduced to 5 ports, POR 240216
					Xblk_PCB
					+ bga_pcb
					+ pmic_pwr
					+ pmic_pwr
					+ pmic_pwr
					+ pmic_pwr
					+ ref_gnd
					+ ACM3_notoplayer_10_100uF_10_220uF_IdEM
					* + ACM3_notoplayer_no_10_100uF_10_220uF_IdEM
					* + ACM3_122323_nne_cut_reduce_v2_manip_s5p
					* + ACM3_bulk_top_and_centerbottom_caps_IdEM

	* Xblk_PCB
	* + pmic_pwr
	* + pmic_pwr
	* + pmic_pwr
	* + pmic_pwr
	* + bga_pcb
	* + ref_gnd
	* + acm3_nne_pcb_240314_105C_IdEM
	* * + ACM3_105C_3_14_24_IdEM

.endif 		*** end of ACM3 PCB, reduced to 5 ports

					* .if ( 0 )
						* Xblk_PCB
						* + pmic_pwr
						* + bga_pcb
						* + ref_gnd
						* + ACM3_NEWLAYOUT_01_30_4_3uF_4Phase_half10uFCAPSrev3_manip_IdEM
					* .endif

*************************************** Pkg ***********************************
									.if ( 0 ) 	*** single grp reduced model
										Xblk_pkg
										+ pkg_bump_one
										+ bga_pkg
										+ ref_gnd
										+ nne_6x_ecap_0307_2__w_ecap_redu_1e_4_order18_IdEM_s2p
												* + NNE_pkg_redu_240131_ZijiePkg_Ecap_Disabled_s2p_IdEM
												* + NNE_pkg_redu_240131_ZijiePkg_Ecap_Enabled_s2p_IdEM
												* + nne_6x_ecap_0307_2__w_12xFeC2072ecap_redu_IdEM_s2p
									.endif 		*** reduced model end

.if ( 1 ) 	*** 4x2 reduced model

	.if ( is_use_ecap_ebed == 1)
		Xblk_pkg
		+ pkg_bump_0_0
		+ pkg_bump_0_1
		+ pkg_bump_0_2
		+ pkg_bump_0_3
		+ pkg_bump_1_0
		+ pkg_bump_1_1
		+ pkg_bump_1_2
		+ pkg_bump_1_3
		+ bga_pkg
		+ ref_gnd
		+ nne_4x2_6xEC2047_redu_IdEM
	.endif

	.if ( is_use_ecap_ebed != 1)
		Xblk_pkg
		+ pkg_bump_0_0
		+ pkg_bump_0_1
		+ pkg_bump_0_2
		+ pkg_bump_0_3
		+ pkg_bump_1_0
		+ pkg_bump_1_1
		+ pkg_bump_1_2
		+ pkg_bump_1_3
		+ bga_pkg
		+ ref_gnd
		+ nne_4x2_Andes_redu_IdEM
	.endif

.endif

.if ( 0 )   *** 240222 Andes pkg 140um bump pitch
	Xblk_pkg
	+ bga_pkg
	+ pkgCap_C1
	+ pkgCap_C2
	+ pkgCap_C3
	+ pkgCap_C4
	+ pkgCap_C5
	+ pkgCap_C6
	+ pkgCap_C7
	+ pkgCap_C8
	+ pkgCap_C9
	+ pkgCap_C10
	+ pkgCap_C11
	+ pkgCap_C12
	+ pkgCap_C13
	+ pkgCap_C14
	+ pkgCap_C15
	+ pkgCap_C16
	+ pkgCap_C17
	+ pkgCap_C18
	+ pkgCap_C19
	+ pkgCap_C20
	+ pkgCap_C21
	+ pkgCap_C22
	+ pkgCap_C23
	+ pkgCap_C24
	+ pkgCap_C25
	+ pkgCap_C26
	+ pkgCap_C27
	+ pkgCap_C28
	+ pkgCap_C29
	+ pkgCap_C30
	+ pkgCap_C31
	+ pkgCap_C32
	+ pkgCap_C33
	+ pkgCap_C34
	+ pkgCap_C35
	+ pkgCap_C36
	+ pkgCap_C37
	+ pkgCap_C38
	+ pkgCap_C39
	+ pkgCap_C40
	+ pkgCap_C41
	+ pkgCap_C42
	+ pkgCap_C43
	+ pkgCap_C44
	+ pkgCap_C45
	+ pkgCap_C46
	+ pkgCap_C47
	+ pkgCap_C48
	+ pkgCap_C49
	+ pkgCap_C50
	+ pkgCap_C51
	+ pkgCap_C52
	+ pkgCap_C53
	+ pkgCap_C54
	+ pkgCap_C55
	+ pkgCap_C56
	+ pkgCap_C57
	+ pkgCap_C58
	+ pkgCap_C59
	+ pkgCap_C60
	+ pkg_bump_0_0
	+ pkg_bump_0_1
	+ pkg_bump_0_2
	+ pkg_bump_0_3
	+ pkg_bump_1_0
	+ pkg_bump_1_1
	+ pkg_bump_1_2
	+ pkg_bump_1_3
	+ ref_gnd
	+ Mam_MCM_L12_BH9_Ballv0p83_BPIv0071_20240124_3_20240216ate_b_IdEM

	*** DSC
	XpkgCap_C1		pkgCap_C1  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C2		pkgCap_C2  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C3		pkgCap_C3  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C4		pkgCap_C4  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C5		pkgCap_C5  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C6		pkgCap_C6  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C7		pkgCap_C7  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C8		pkgCap_C8  ref_gnd   str(mlcc_0p1uF_0201)

	XpkgCap_C9    pkgCap_C9   ref_gnd  pkgCap_C9   ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C10   pkgCap_C10  ref_gnd  pkgCap_C10  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C11   pkgCap_C11  ref_gnd  pkgCap_C11  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C12   pkgCap_C12  ref_gnd  pkgCap_C12  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C13   pkgCap_C13  ref_gnd  pkgCap_C13  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C14   pkgCap_C14  ref_gnd  pkgCap_C14  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C15   pkgCap_C15  ref_gnd  pkgCap_C15  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C16   pkgCap_C16  ref_gnd  pkgCap_C16  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C17   pkgCap_C17  ref_gnd  pkgCap_C17  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C18   pkgCap_C18  ref_gnd  pkgCap_C18  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C19   pkgCap_C19  ref_gnd  pkgCap_C19  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C20   pkgCap_C20  ref_gnd  pkgCap_C20  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C21   pkgCap_C21  ref_gnd  pkgCap_C21  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C22   pkgCap_C22  ref_gnd  pkgCap_C22  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C23   pkgCap_C23  ref_gnd  pkgCap_C23  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C24   pkgCap_C24  ref_gnd  pkgCap_C24  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C25   pkgCap_C25  ref_gnd  pkgCap_C25  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C26   pkgCap_C26  ref_gnd  pkgCap_C26  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C27   pkgCap_C27  ref_gnd  pkgCap_C27  ref_gnd   str(mlcc_1uF_0402_3T_ft)

	XpkgCap_C28   pkgCap_C28  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C29   pkgCap_C29  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C30   pkgCap_C30  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C31   pkgCap_C31  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C32   pkgCap_C32  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C33   pkgCap_C33  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C34   pkgCap_C34  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C35   pkgCap_C35  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C36   pkgCap_C36  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C37   pkgCap_C37  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C38   pkgCap_C38  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C39   pkgCap_C39  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C40   pkgCap_C40  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C41   pkgCap_C41  ref_gnd  str(mlcc_0p015uF_0402)

	XpkgCap_C42    pkgCap_C42  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C43    pkgCap_C43  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C44    pkgCap_C44  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C45    pkgCap_C45  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C46    pkgCap_C46  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C47    pkgCap_C47  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C48    pkgCap_C48  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C49    pkgCap_C49  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C50    pkgCap_C50  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C51    pkgCap_C51   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C52    pkgCap_C52   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C53    pkgCap_C53   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C54    pkgCap_C54   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C55    pkgCap_C55   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C56    pkgCap_C56   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C57    pkgCap_C57   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C58    pkgCap_C58   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C59    pkgCap_C59   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C60    pkgCap_C60   ref_gnd  str(mlcc_10uF_0402)

.endif 		*** 240222 Andes pkg 140um bump pitch end

.if ( 0 )   *** 240131 Zijie pkg w/ DSC + embedded 1xEC1005, POR240216
	Xblk_pkg
	+ pkg_bump_0_0
	+ pkg_bump_0_1
	+ pkg_bump_0_2
	+ pkg_bump_0_3
	+ pkg_bump_1_0
	+ pkg_bump_1_1
	+ pkg_bump_1_2
	+ pkg_bump_1_3
	+ bga_pkg
	+ pkgCap_C152_2
	+ pkgCap_C153_2
	+ pkgCap_C154_2
	+ pkgCap_C155_2
	+ pkgCap_C156_2
	+ pkgCap_C157_2
	+ pkgCap_C158_2
	+ pkgCap_C159_2
	+ pkgCap_C210_1
	+ pkgCap_C211_1
	+ pkgCap_C212_1
	+ pkgCap_C213_1
	+ pkgCap_C214_1
	+ pkgCap_C215_1
	+ pkgCap_C216_1
	+ pkgCap_C217_1
	+ pkgCap_C218_1
	+ pkgCap_C219_1
	+ pkgCap_C220_1
	+ pkgCap_C221_1
	+ pkgCap_C222_1
	+ pkgCap_C223_1
	+ pkgCap_C224_1
	+ pkgCap_C225_1
	+ pkgCap_C226_1
	+ pkgCap_C227_1
	+ pkgCap_C228_1
	+ pkgCap_C229_1
	+ pkgCap_C841_1
	+ pkgCap_C842_2
	+ pkgCap_C843_1
	+ pkgCap_C844_1
	+ pkgCap_C845_1
	+ pkgCap_C846_2
	+ pkgCap_C847_1
	+ pkgCap_C848_2
	+ pkgCap_C849_1
	+ pkgCap_C850_2
	+ pkgCap_C851_1
	+ pkgCap_C852_2
	+ pkgCap_C853_1
	+ pkgCap_C854_2
	+ pkgCap_C855_1
	+ pkgCap_C856_2
	+ pkgCap_C857_1
	+ pkgCap_C858_2
	+ pkgCap_C859_1
	+ pkgCap_C860_2
	+ pkgCap_C861_2
	+ pkgCap_C862_1
	+ pkgCap_C863_2
	+ pkgCap_C864_1
	+ pkgCap_C865_2
	+ pkgCap_C866_1
	+ pkgCap_C867_2
	+ pkgCap_C868_1
	+ pkgCap_C869_2
	+ pkgCap_C870_1
	+ pkgCap_C871_2
	+ pkgCap_C872_1
	+ pkgCap_C873_2
	+ pkgCap_C874_1
	+ pkgCap_C875_2
	+ pkgCap_Ecap_core_1_A1
	+ pkgCap_Ecap_core_1_A3
	+ pkgCap_Ecap_core_1_A5
	+ pkgCap_Ecap_core_1_A7
	+ pkgCap_Ecap_core_1_A9
	+ pkgCap_Ecap_core_1_A11
	+ pkgCap_Ecap_core_1_B2
	+ pkgCap_Ecap_core_1_B4
	+ pkgCap_Ecap_core_1_B6
	+ pkgCap_Ecap_core_1_B8
	+ pkgCap_Ecap_core_1_B10
	+ pkgCap_Ecap_core_1_B12
	+ pkgCap_Ecap_core_1_C1
	+ pkgCap_Ecap_core_1_C3
	+ pkgCap_Ecap_core_1_C5
	+ pkgCap_Ecap_core_1_C7
	+ pkgCap_Ecap_core_1_C9
	+ pkgCap_Ecap_core_1_C11
	+ pkgCap_Ecap_core_1_D2
	+ pkgCap_Ecap_core_1_D4
	+ pkgCap_Ecap_core_1_D6
	+ pkgCap_Ecap_core_1_D8
	+ pkgCap_Ecap_core_1_D10
	+ pkgCap_Ecap_core_1_D12
	+ pkgCap_Ecap_core_1_E1
	+ pkgCap_Ecap_core_1_E3
	+ pkgCap_Ecap_core_1_E5
	+ pkgCap_Ecap_core_1_E7
	+ pkgCap_Ecap_core_1_E9
	+ pkgCap_Ecap_core_1_E11
	+ pkgCap_Ecap_core_1_F2
	+ pkgCap_Ecap_core_1_F4
	+ pkgCap_Ecap_core_1_F6
	+ pkgCap_Ecap_core_1_F8
	+ pkgCap_Ecap_core_1_F10
	+ pkgCap_Ecap_core_1_F12
	+ pkgCap_Ecap_core_1_G1
	+ pkgCap_Ecap_core_1_G3
	+ pkgCap_Ecap_core_1_G5
	+ pkgCap_Ecap_core_1_G7
	+ pkgCap_Ecap_core_1_G9
	+ pkgCap_Ecap_core_1_G11
	+ pkgCap_Ecap_core_1_H2
	+ pkgCap_Ecap_core_1_H4
	+ pkgCap_Ecap_core_1_H6
	+ pkgCap_Ecap_core_1_H8
	+ pkgCap_Ecap_core_1_H10
	+ pkgCap_Ecap_core_1_H12
	+ pkgCap_Ecap_core_1_J1
	+ pkgCap_Ecap_core_1_J3
	+ pkgCap_Ecap_core_1_J5
	+ pkgCap_Ecap_core_1_J7
	+ pkgCap_Ecap_core_1_J9
	+ pkgCap_Ecap_core_1_J11
	+ pkgCap_Ecap_core_1_K2
	+ pkgCap_Ecap_core_1_K4
	+ pkgCap_Ecap_core_1_K6
	+ pkgCap_Ecap_core_1_K8
	+ pkgCap_Ecap_core_1_K10
	+ pkgCap_Ecap_core_1_K12
	+ ref_gnd
	+ nne_ecap_dsc_IdEM

		*** DSC

		.if ( is_use_3T_cap_ft != 1 )  *** No 3T caps
			XpkgCap_C152_2 pkgCap_C152_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C153_2 pkgCap_C153_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C154_2 pkgCap_C154_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C155_2 pkgCap_C155_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C156_2 pkgCap_C156_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C157_2 pkgCap_C157_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C158_2 pkgCap_C158_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C159_2 pkgCap_C159_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C210_1 pkgCap_C210_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C211_1 pkgCap_C211_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C212_1 pkgCap_C212_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C213_1 pkgCap_C213_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C214_1 pkgCap_C214_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C215_1 pkgCap_C215_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C216_1 pkgCap_C216_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C217_1 pkgCap_C217_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C218_1 pkgCap_C218_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C219_1 pkgCap_C219_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C220_1 pkgCap_C220_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C221_1 pkgCap_C221_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C222_1 pkgCap_C222_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C223_1 pkgCap_C223_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C224_1 pkgCap_C224_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C225_1 pkgCap_C225_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C226_1 pkgCap_C226_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
		.endif

		.if ( is_use_3T_cap_ft == 1 )  *** Use  3T caps
			XpkgCap_C152_2 pkgCap_C152_2    ref_gnd  pkgCap_C152_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C154_2 pkgCap_C154_2    ref_gnd  pkgCap_C154_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C156_2 pkgCap_C156_2    ref_gnd  pkgCap_C156_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C158_2 pkgCap_C158_2    ref_gnd  pkgCap_C158_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C210_1 pkgCap_C210_1    ref_gnd  pkgCap_C210_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C211_1 pkgCap_C211_1    ref_gnd  pkgCap_C211_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C212_1 pkgCap_C212_1    ref_gnd  pkgCap_C212_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C213_1 pkgCap_C213_1    ref_gnd  pkgCap_C213_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C214_1 pkgCap_C214_1    ref_gnd  pkgCap_C214_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C215_1 pkgCap_C215_1    ref_gnd  pkgCap_C215_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C216_1 pkgCap_C216_1    ref_gnd  pkgCap_C216_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C220_1 pkgCap_C220_1    ref_gnd  pkgCap_C220_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C221_1 pkgCap_C221_1    ref_gnd  pkgCap_C221_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C222_1 pkgCap_C222_1    ref_gnd  pkgCap_C222_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C223_1 pkgCap_C223_1    ref_gnd  pkgCap_C223_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C224_1 pkgCap_C224_1    ref_gnd  pkgCap_C224_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C225_1 pkgCap_C225_1    ref_gnd  pkgCap_C225_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C226_1 pkgCap_C226_1    ref_gnd  pkgCap_C226_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
		.endif

		XpkgCap_C227_1 pkgCap_C227_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
		XpkgCap_C228_1 pkgCap_C228_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
		XpkgCap_C229_1 pkgCap_C229_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)

		XpkgCap_C841_1 pkgCap_C841_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C842_2 pkgCap_C842_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C843_1 pkgCap_C843_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C844_1 pkgCap_C844_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C845_1 pkgCap_C845_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C846_2 pkgCap_C846_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C847_1 pkgCap_C847_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C848_2 pkgCap_C848_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C849_1 pkgCap_C849_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C850_2 pkgCap_C850_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C851_1 pkgCap_C851_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C852_2 pkgCap_C852_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C853_1 pkgCap_C853_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C854_2 pkgCap_C854_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C855_1 pkgCap_C855_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C856_2 pkgCap_C856_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C857_1 pkgCap_C857_1    ref_gnd str(mlcc_0p015uF_0402)

		XpkgCap_C858_2 pkgCap_C858_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C859_1 pkgCap_C859_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C860_2 pkgCap_C860_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C861_2 pkgCap_C861_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C862_1 pkgCap_C862_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C863_2 pkgCap_C863_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C864_1 pkgCap_C864_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C865_2 pkgCap_C865_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C866_1 pkgCap_C866_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C867_2 pkgCap_C867_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C868_1 pkgCap_C868_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C869_2 pkgCap_C869_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C870_1 pkgCap_C870_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C871_2 pkgCap_C871_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C872_1 pkgCap_C872_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C873_2 pkgCap_C873_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C874_1 pkgCap_C874_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C875_2 pkgCap_C875_2    ref_gnd str(mlcc_10uF_0402)

		*** Ecap embedded
		.if ( is_use_ecap_ebed == 1 )  *** use ecap embed
			xECAP_16600nF_core_2
			+ pkgCap_Ecap_core_1_A1
			+ pkgCap_Ecap_core_1_A3
			+ pkgCap_Ecap_core_1_A5
			+ pkgCap_Ecap_core_1_A7
			+ pkgCap_Ecap_core_1_A9
			+ pkgCap_Ecap_core_1_A11
			+ pkgCap_Ecap_core_1_B2
			+ pkgCap_Ecap_core_1_B4
			+ pkgCap_Ecap_core_1_B6
			+ pkgCap_Ecap_core_1_B8
			+ pkgCap_Ecap_core_1_B10
			+ pkgCap_Ecap_core_1_B12
			+ pkgCap_Ecap_core_1_C1
			+ pkgCap_Ecap_core_1_C3
			+ pkgCap_Ecap_core_1_C5
			+ pkgCap_Ecap_core_1_C7
			+ pkgCap_Ecap_core_1_C9
			+ pkgCap_Ecap_core_1_C11
			+ pkgCap_Ecap_core_1_D2
			+ pkgCap_Ecap_core_1_D4
			+ pkgCap_Ecap_core_1_D6
			+ pkgCap_Ecap_core_1_D8
			+ pkgCap_Ecap_core_1_D10
			+ pkgCap_Ecap_core_1_D12
			+ pkgCap_Ecap_core_1_E1
			+ pkgCap_Ecap_core_1_E3
			+ pkgCap_Ecap_core_1_E5
			+ pkgCap_Ecap_core_1_E7
			+ pkgCap_Ecap_core_1_E9
			+ pkgCap_Ecap_core_1_E11
			+ pkgCap_Ecap_core_1_F2
			+ pkgCap_Ecap_core_1_F4
			+ pkgCap_Ecap_core_1_F6
			+ pkgCap_Ecap_core_1_F8
			+ pkgCap_Ecap_core_1_F10
			+ pkgCap_Ecap_core_1_F12
			+ pkgCap_Ecap_core_1_G1
			+ pkgCap_Ecap_core_1_G3
			+ pkgCap_Ecap_core_1_G5
			+ pkgCap_Ecap_core_1_G7
			+ pkgCap_Ecap_core_1_G9
			+ pkgCap_Ecap_core_1_G11
			+ pkgCap_Ecap_core_1_H2
			+ pkgCap_Ecap_core_1_H4
			+ pkgCap_Ecap_core_1_H6
			+ pkgCap_Ecap_core_1_H8
			+ pkgCap_Ecap_core_1_H10
			+ pkgCap_Ecap_core_1_H12
			+ pkgCap_Ecap_core_1_J1
			+ pkgCap_Ecap_core_1_J3
			+ pkgCap_Ecap_core_1_J5
			+ pkgCap_Ecap_core_1_J7
			+ pkgCap_Ecap_core_1_J9
			+ pkgCap_Ecap_core_1_J11
			+ pkgCap_Ecap_core_1_K2
			+ pkgCap_Ecap_core_1_K4
			+ pkgCap_Ecap_core_1_K6
			+ pkgCap_Ecap_core_1_K8
			+ pkgCap_Ecap_core_1_K10
			+ pkgCap_Ecap_core_1_K12
			+ ref_gnd
			+ str(siCap_empwr_EC1005_16600nF)
		.endif

.endif 		*** 240131 Zijie pkg w/ DSC + embedded Ecap END

*************************************** Die ***********************************
*** approach 1: multi grp modeling
.if (die_model_sig != 1 )

	xblk_die
	+         pkg_bump_0_3
	+ ref_gnd pkg_bump_0_2
	+ ref_gnd pkg_bump_0_1
	+ ref_gnd pkg_bump_0_0
	+ ref_gnd pkg_bump_1_3
	+ ref_gnd pkg_bump_1_2
	+ ref_gnd pkg_bump_1_1
	+ ref_gnd pkg_bump_1_0
	+ ref_gnd
	+ adsPowerModel

	IcurrSrc_0_0	pkg_bump_0_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= td_delay    *** add 'R' if repeat
	IcurrSrc_0_1	pkg_bump_0_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= td_delay
	IcurrSrc_0_2	pkg_bump_0_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= td_delay
	IcurrSrc_0_3	pkg_bump_0_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= td_delay

	IcurrSrc_1_0	pkg_bump_1_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay
	IcurrSrc_1_1	pkg_bump_1_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay
	IcurrSrc_1_2	pkg_bump_1_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay
	IcurrSrc_1_3	pkg_bump_1_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay

	.if (is_MIM == 1)
		C_MIM_bump_0_0 pkg_bump_0_0	ref_gnd	335.3n
		C_MIM_bump_0_1 pkg_bump_0_1	ref_gnd	335.3n
		C_MIM_bump_0_2 pkg_bump_0_2	ref_gnd	335.3n
		C_MIM_bump_0_3 pkg_bump_0_3	ref_gnd	335.3n

		C_MIM_bump_1_0 pkg_bump_1_0	ref_gnd	444.45n
		C_MIM_bump_1_1 pkg_bump_1_1	ref_gnd	444.45n
		C_MIM_bump_1_2 pkg_bump_1_2	ref_gnd	444.45n
		C_MIM_bump_1_3 pkg_bump_1_3	ref_gnd	444.45n
	.endif

* Xblk_die_0_0	pkg_bump_0_0	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
* Xblk_die_0_1	pkg_bump_0_1	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
* Xblk_die_0_2	pkg_bump_0_2	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
* Xblk_die_0_3	pkg_bump_0_3	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
* Xblk_die_1_0	pkg_bump_1_0	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 1500.p
* Xblk_die_1_1	pkg_bump_1_1	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 1000.p
* Xblk_die_1_2	pkg_bump_1_2	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 500.p
* Xblk_die_1_3	pkg_bump_1_3	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p

	* *** test to add coupling RL btw two grps

	* R_ma_0_1 pkg_bump_0_0	pkg_bump_0_1	r_grid
	* R_ma_1_2 pkg_bump_0_1	pkg_bump_0_2	r_grid
	* R_ma_2_3 pkg_bump_0_2	pkg_bump_0_3	r_grid
	* R_pa_0_1 pkg_bump_1_0	pkg_bump_1_1	r_grid
	* R_pa_1_2 pkg_bump_1_1	pkg_bump_1_2	r_grid
	* R_pa_2_3 pkg_bump_1_2	pkg_bump_1_3	r_grid
	* R_mpa_0	 pkg_bump_0_0	pkg_bump_1_0	r_grid
	* R_mpa_1	 pkg_bump_0_1	pkg_bump_1_1	r_grid
	* R_mpa_2	 pkg_bump_0_2	pkg_bump_1_2	r_grid
	* R_mpa_3	 pkg_bump_0_3	pkg_bump_1_3	r_grid

	* * R_0_bump_merge pkg_bump_one	pkg_bump_0_0	1.n
	* * R_1_bump_merge pkg_bump_one	pkg_bump_0_1	1.n
	* * R_2_bump_merge pkg_bump_one	pkg_bump_1_0	1.n
	* * R_3_bump_merge pkg_bump_one	pkg_bump_1_1	1.n

	* * R_4_bump_merge pkg_bump_two	pkg_bump_0_2	1.n
	* * R_5_bump_merge pkg_bump_two	pkg_bump_0_3	1.n
	* * R_6_bump_merge pkg_bump_two	pkg_bump_1_2	1.n
	* * R_7_bump_merge pkg_bump_two	pkg_bump_1_3	1.n

	* * R_cpl_01 	pkg_bump_one		pkg_bump_cpl_01  	0.8m
	* * L_cpl_01	pkg_bump_cpl_01		pkg_bump_two 		2.p
.endif
*** approach 1: multi grp modeling END

*** approach 2: single grp modeling
.if (die_model_sig == 1 )
	*** all bump grps connected to single die model
	R_0_bump_merge pkg_bump_one	pkg_bump_0_0	1.n
	R_1_bump_merge pkg_bump_one	pkg_bump_0_1	1.n
	R_2_bump_merge pkg_bump_one	pkg_bump_0_2	1.n
	R_3_bump_merge pkg_bump_one	pkg_bump_0_3	1.n
	R_4_bump_merge pkg_bump_one	pkg_bump_1_0	1.n
	R_5_bump_merge pkg_bump_one	pkg_bump_1_1	1.n
	R_6_bump_merge pkg_bump_one	pkg_bump_1_2	1.n
	R_7_bump_merge pkg_bump_one	pkg_bump_1_3	1.n

    .if (is_MIM == 1)
		Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 3359.n	R_die_1= 0.027m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)		*** w/ MIM
	.endif
	.if (is_MIM != 1 )
	  Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 928.n	R_die_1= 0.027m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)
	* Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 1074.6n	R_die_1= 0.023m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)     *** add diffusion 1um
	* Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 1118.n	R_die_1= 0.022m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)		*** merge with SoC
	* Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 4047.n	R_die_1= 0.022m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)		*** merge with SoC * MIM
	.endif

.endif
*** approach 2: single grp modeling	END

*************************************** Analysis I: AC simulation *************
.if ( is_ac_run == 1 )
	.if ( 1 )
		*** NOTE: DO not include port def if tran analysis later
		P1 pkg_bump_0_0	ref_gnd	port=1	z0 = 0.1
		P2 pkg_bump_0_1	ref_gnd	port=2	z0 = 0.1
		P3 pkg_bump_0_2	ref_gnd	port=3	z0 = 0.1
		P4 pkg_bump_0_3	ref_gnd	port=4	z0 = 0.1
		P5 pkg_bump_1_0	ref_gnd	port=5	z0 = 0.1
		P6 pkg_bump_1_1	ref_gnd	port=6	z0 = 0.1
		P7 pkg_bump_1_2	ref_gnd	port=7	z0 = 0.1
		P8 pkg_bump_1_3	ref_gnd	port=8	z0 = 0.1

		.lin 	sparcalc=1 	filename=impedance_plot	noisecalc=0 	gdcalc=0	format=touchstone 	dataformat=MA
		**.probe  ac s11(db) s11(p) s21(db) s21(p)
		.probe ac zin(1)(m) zin(1)(p) zin(5)(m) zin(5)(p) zin(8)(m) zin(8)(p)

		.ac 	dec 50 1. 1.G

	.endif

	.if ( 0 )
		*i_ac_pkg_bump_0_0 pkg_bump_0_0 ref_gnd dc=0 ac=-1.
		* .probe ac v(pkg_bump_0_0)

		i_ac_pkg_bump_1_0 pkg_bump_1_0 ref_gnd dc=0 ac=-1.
		.probe ac v(pkg_bump_1_0)	vi(pkg_bump_1_0)	vr(pkg_bump_1_0)

		.ac 	dec 50 1. 1.G

		* .param v_imag = vi(pkg_bump_1_0)
		* .param acl = 'v_imag / 2./pi '
		* .print 'vi(pkg_bump_1_0) / 2. '		*** works
				* .print 'vi(pkg_bump_1_0) / pi '						*** NOT work
				* .measure ac ACL param = 'vi(pkg_bump_1_0) / 2.'		*** NOT work

		.param pfreq = 100.e6
		.param dfreq = 10.e6
		.measure ac zval_1   find vi(pkg_bump_1_0)	at = 'pfreq - dfreq '
		.measure ac zval_2   find vi(pkg_bump_1_0)	at = 'pfreq + dfreq '
		.measure ac acl      param='(zval_2 - zval_1)/2./pi/(dfreq+dfreq)'

	.endif

.endif

*************************************** Analysis II: Transient simulation *****
.if ( is_ac_run != 1 )
	.tran tStep tSTOP

	.probe tran v(pkg_bump_1_0) v(pkg_bump_1_3) v(pkg_bump_0_0) v(pkg_bump_0_3)  v(bga_pkg)
	* .probe tran v(pkg_bump_1_1) v(pkg_bump_1_2)
	.probe x(Xblk_die_1_0.pin_bump)	x(Xblk_PCB.a_1)	x(Xblk_pkg.a_1)
	.probe x(Xblk_pkg.a_9)
	.probe x(xblk_PMIC.pin_out)

	* .param vdd_meas_start = 0.u
	* .param vdd_meas_end   = 3.u      ** 50.u
	* .meas tran pkg_bump_1_0_p2p 		PP	V(pkg_bump_1_0)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmax	MAX	V(pkg_bump_1_0)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmin	MIN	V(pkg_bump_1_0)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmax_t	WHEN	V(pkg_bump_1_0) = 'pkg_bump_1_0_cpu_vmax' 	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmin_t	WHEN	V(pkg_bump_1_0) = 'pkg_bump_1_0_cpu_vmin' 	from='vdd_meas_start' to='vdd_meas_end'

	*.probe i(*)
	*.probe x(*)

.endif
