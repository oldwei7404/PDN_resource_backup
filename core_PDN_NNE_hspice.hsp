* Top level spice file

.option post=1
*.chkanode type=gate dv=0.5*pvdd report=active
.option parhier = local
.option measform = 1
.option lis_new
.option post probe
.param pi = 3.141592653

*************************************** User defined functions ****************
.param V_meas(node, ref) = 'v(node) - v(ref)'

*************************************** Input Models**************************
	***** define load current source model used in die model *****
* .param pwl_file_in_PA = str('./hspice_inc/out_curr_profile_NNE_4x2grp_PA_test4_act_0p3_0p2_0518_200clk_0scale_continue_idle_clk_51703_0925.inc.csv')
* .param pwl_file_in_MA = str('./hspice_inc/out_curr_profile_NNE_4x2grp_MA_test4_act_0p3_0p2_0518_200clk_0scale_continue_idle_clk_51703_0925.inc.csv')

		* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_shortened.txt.csv')		*** PMIC vendor test, 11us
		* .param pwl_file_in_MA = str('./hspice_inc/curr_profile_NNE_4x2_MA_shortened.txt.csv')

		* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_1031_500MHz.txt.csv')		*** PMIC vendor test,  11us, POR
		* .param pwl_file_in_MA = str('./hspice_inc/curr_profile_NNE_4x2_MA_1031_500MHz.txt.csv')

		* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_noRampFr0515_1116.csv')		*** PMIC vendor test, no ramp ,  11us
		* .param pwl_file_in_MA = str('./hspice_inc/curr_profile_NNE_4x2_MA_noRampFr0515_1116.csv')

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_240117.txt.csv')				*** ramp 16clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp32clk.txt.csv')			*** ramp 32clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp64clk.txt.csv')			*** ramp 64clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp128clk.txt.csv')			*** ramp 128clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_4x2_PA_Ramp256clk.txt.csv')			*** ramp 256clk,  18us (3us w/ up/down)

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp16clk_80W.txt.csv')		*** ramp 16clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp32clk_80W.txt.csv')		*** ramp 32clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp64clk_80W.txt.csv')		*** ramp 64clk,  18us (2.5us w/ up/down)

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp16clk_105W.txt.csv')		*** ramp 16clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp32clk_105W.txt.csv')		*** ramp 32clk,  18us (2.5us w/ up/down)
				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_4x2_Ramp64clk_105W.txt.csv')		*** ramp 64clk,  18us (2.5us w/ up/down)

				* .param pwl_file_in_PA = str('./hspice_inc/curr_profile_NNE_PA_x0p25_traceFrPD_240215.txt.csv')		*** *** 240215 Puru trace x 0.25, 3us

				* .param pwl_file_in_MA = str('./hspice_inc/curr_idle_0A.csv')	*** MA current NA as of 2024/1/17

						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp16clk_80W.txt.csv')	*** single current profile for whole NNE PA
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp32clk_80W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp64clk_80W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp128clk_80W.txt.csv')

						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp16clk_80W_30W.txt.csv')	*** single current profile for whole NNE PA, 240202
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp32clk_80W_30W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp64clk_80W_30W.txt.csv')
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_Ramp128clk_80W_30W.txt.csv')

						*.param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_traceFrPD_240207.txt.csv')			*** 240207 Puru trace, 1us
						*.param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_traceFrPD_x0p762_240207.txt.csv')	*** 240207 Puru trace x 0.762 to simulate 80W, 1us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_PA_all_traceFrPD_240215.txt.csv')			*** 240215 Puru trace, 3us

						.param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_fullAlign_240222.txt.csv')		*** 240222  trace, PA + GMEM 3us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_stagger_240222.txt.csv')			*** 240222  trace, PA + GMEM 3us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_fullAlign_scale_240222.txt.csv')	*** 240222  trace, PA + GMEM 3us
						* .param  pwl_file_All = str('./hspice_inc/curr_profile_NNE_all_traceFrPD_stagger_scale_240222.txt.csv')	*** 240222  trace, PA + GMEM 3us

		*** idle current
		.param pwl_file_quiet = str('./hspice_inc/curr_quiet_30us.txt.csv')

		***  step up current (only one def allowed)
	*.inc ./hspice_inc/out_curr_profile_NNE_100ns_12A_10000ns_cnst_100ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_NNE_300nsRamp_100ns_12A_10000ns_cnst_100ns_rampDown_noClk.txt
	*.inc ./hspice_inc/out_curr_profile_NNE_300nsRamp_100ns_12A_10000ns_cnst_100ns_rampDown_Clk0p7floor.txt

	***** define die model *****
.subckt model_die_lumped_nne_tile
	+ pin_bump ref_gnd C_die=100n R_die_1=1.25m R_die_2=RESMIN R_leak=0.84	pwl_file_in = str(pwl_file_quiet) delay = 0.

	R_die_1_ 	pin_bump	2	R_die_1
	R_die_2_	2		3	R_die_2
	C_die_		3		ref_gnd	C_die
	R_leak_		pin_bump	ref_gnd	R_leak
	IcurrSrc	pin_bump	ref_gnd	PWL pwlfile = str(pwl_file_in) td = delay    *** add 'R' if repeat
.ends

	***** define pkg model *****
	* .inc ./hspice_inc/nne_pkg_230329_FCBGA_L12_mammoth_20230525ate_a_IdEM.cir	***  0526 Andes pkg w/ 28 + 35 DSC
* .inc ./hspice_inc/Mam_MCM_L12_231215_mod40_jgwei_s72_IdEM.cir				*** 231220 Andes pkg, POR
	* .inc ./hspice_inc/ipd_partial_w_Ports_manip_IdEM_0p0001_wt0p5.cir		*** 240109 Zijie pkg w/ IPD
	*.inc ./hspice_inc/ecap_diff_dist_manip_order8_fixDC_s249p.cir			*** 240110 Zijie pkg w/ 3x diff Ecap + 1x embeded Ecap
	* .inc  ./hspice_inc/dsc_lsc_0111_2_manip_order8_0p5wt.cir				*** 240112 Zijie pkg w/ LSC, DSC, L&R DSC
    * .inc  ./hspice_inc/Mam_MCM_L12_231215c_mod48_NNE_02_IdEM.cir			*** 240118 Andes pkg
	.inc  ./hspice_inc/nne_ecap_dsc_IdEM.cir								*** 240131 Zijie pkg mockup w/ DSC and embedded Ecap
	.inc  ./hspice_inc/NNE_pkg_redu_240131_ZijiePkg_Ecap_Disabled_s2p_IdEM.cir	*** reduced model of "240131 Zijie pkg mockup w/ DSC and embedded Ecap"
	.inc  ./hspice_inc/NNE_pkg_redu_240131_ZijiePkg_Ecap_Enabled_s2p_IdEM.cir	*** reduced model of "240131 Zijie pkg mockup w/ DSC and embedded Ecap", with Ecap enabled
	.inc  ./hspice_inc/Mam_MCM_L12_BH9_Ballv0p83_BPIv0071_20240124_3_20240216ate_b_IdEM.cir  	*** 240222 Andes pkg 140um pitch

	***** define PCB model *****
		* .inc ./hspice_inc/MAMMOTH_PCB_231031_3_NNE_LFmanip_IdEM.cir					*** 1101, version, SoC bulk caps added vias
		*.inc ./hspice_inc/ACM3_122323_nne_cut_manip_IdEM_s377p.cir					*** 231221 ACM3 PCB,   240126, accuracy not good btw 1~40MHz,  DO NOT USE
	.inc ./hspice_inc/ACM3_122323_nne_cut_reduce_v2_manip_s5p.cir				*** 231221 ACM3 PCB, reduced to 5 ports
		* .inc ./hspice_inc/ACM3_NEWLAYOUT_01_30_4_3uF_4Phase_half10uFCAPSrev3_manip_IdEM.cir		*** 240131 ACM3 PCB, Kavoos provided reduced PCB model, w/ 10uF, and 1uF caps; do NOT use due to LF noise near 500kHz
	.inc ./hspice_inc/ACM3_notoplayer_10_100uF_10_220uF_IdEM.cir				*** Kavoos 240216 ACM3, 10uF, w/ 20x bulk caps
	.inc ./hspice_inc/ACM3_notoplayer_no_10_100uF_10_220uF_IdEM.cir				*** Kavoos 240216 ACM3, 10uF, w/o 20x bulk caps
	.inc ./hspice_inc/ACM3_bulk_top_and_centerbottom_caps_IdEM.cir				*** Kavoos 240221 ACM3, only top side caps, bulk caps, 66 back side caps

	****** define reduced model *****
	* .inc ./hspice_inc/Z_NNE_all_reducedModel_240202_manip_IdEM.cir
	* .inc ./hspice_inc/NNE_pkg_PCB_ACM3Kavoos_w_bulk_redu_240216_s5p_IdEM.cir		*** low accuracy, do not use
	* .inc ./hspice_inc/NNE_pkg_PCB_ACM3Kavoos_wo_bulk_redu_240216_s5p_IdEM.cir		*** low accuracy, do not use

*************************************** Input params **************************
.param Vdd 	= 0.75

.para Cdie_coeff = 1.0				*** ONLY multi grp controlling, use 1.0 if no Cdie scaling, use 3.62 for NNE if MIM cap is added,
.para Rdie_coeff = 1.0				*** Rdie is constant 1. , rather than scaled by '1./Cdie_coeff'

*** Cdie Rdie based on MAM-242, tau = 24.26 (excluding MIM)
.param Cdie_PA 	= '130.3n * Cdie_coeff'
.param Cdie_MA 	= '101.7n * Cdie_coeff'
.param Rdie_PA 	= '0.186m * Rdie_coeff'
.param Rdie_MA 	= '0.239m * Rdie_coeff'
.param Rleak 	= 0.84

.param is_use_3T_cap_ft = 1		*** value: 0 or 1

.param is_use_ecap_ebed = 0		*** value: 0 or 1
.param is_MIM = 0

.param die_model_sig = 1		*** value: 0 if multi grp model, 1 if single die grp model
.param r_grid = 52e6.m			*** only applied when multi grp model, i.e. die_model_sig = 0

.param is_ac_run = 0		*** 1 if impedance, 0 if transient

*************************************** End of User Input params **************

*************************************** cap model *****************************
.inc ../models_cap/GCM155D70E106ME36_DC0V_125degC_0402_10uF.mod
.inc ../models_cap/GCM155D70G475ME36_DC0V_125degC_0402_4p7uF.mod
.inc ../models_cap/GCM155C71A105KE38_DC0V_125degC_0402_1uF.mod
.inc ../models_cap/GCM31CD70G476ME02_DC0V_125degC_1206_47uF.mod
.inc ../models_cap/GCM32ED70E107ME36_DC0V_125degC_1210_100uF.mod
.inc ../models_cap/GCM033D70E105ME36_DC0V_125degC_0201_1uF.mod
.inc ../models_cap/NFM15HC105D0G3_feedthrough_DC0V_85degC_3T_0402_1uF.mod
.inc ../models_cap/LLC152D70G105ME01_DC0V_125degC_0204_1uF.mod
.inc ../models_cap/LLL153C70G104ME01_DC0V_125degC_0204_0.1uF.mod
.inc ../models_cap/GRT033R70J103KE01_DC0V_125degC_0201_0p01uF.mod
.inc ../models_cap/GCM155R71C104KA55_DC0V_125degC_0402_0.1uF.mod
.inc ../models_cap/GCM21BD70G226ME36_DC0V_125degC_0805_22uF.mod
.inc ../models_cap/GCM32EM8EA227ME08_DC0V_125degC_1210_220uF.mod
.inc ../models_cap/GCM155R71E153KA55_DC0V_125degC_0402_0.015uF.mod
.inc ../models_cap/GRT033C70J104KE01_DC0V_125degC_0201_0p1uF.mod
.inc ../models_cap/GCM033C70J104KE02_DC0V_125degC_0p1uF_0201.mod
.inc ../models_cap/mlcc_470uF_mockup_T598D477M2R5ATE009.mod
.inc ../models_cap/open_circuit.mod
.inc ../models_cap/cgaea1x7r1h473m030bc_47nF_100pH_ACL_0204_IdEM.cir
.inc ../models_cap/cgaew1x7t0g104m020bc_100nF_90pH_ACL_0204_IdEM.cir
.inc ../models_cap/GCM033R71A103KA03_DC0V_125degC_0201_0.01uF.mod

.inc ../models_cap/EC1001.mod
.inc ../models_cap/EC1002.mod
.inc ../models_cap/EC1100_200nF.mod
.inc ../models_cap/ECAP_16600nF_12x10array.mod

	***** define cap model strings for better ref ****
.param mlcc_1uF_0402 		= str('GCM155C71A105KE38_DC0V_125degC_0402_1uF')
.param mlcc_1uF_0204 		= str('LLC152D70G105ME01_DC0V_125degC_0204_1uF')
.param mlcc_1uF_0201 		= str('GCM033D70E105ME36_DC0V_125degC_0201_1uF')
.param mlcc_1uF_0402_3T_ft		= str('NFM15HC105D0G3_feedthrough_DC0V_85degC_3T_0402_1uF')
.param mlcc_4p7uF_0402 		= str('GCM155D70G475ME36_DC0V_125degC_0402_4p7uF')
.param mlcc_10uF_0402 		= str('GCM155D70E106ME36_DC0V_125degC_0402_10uF')
.param mlcc_47uF_1206		= str('GCM31CD70G476ME02_DC0V_125degC_1206_47uF')
.param mlcc_100uF_1210		= str('GCM32ED70E107ME36_DC0V_125degC_1210_100uF')
.param mlcc_0p1uF_0402		= str('GCM155R71C104KA55_DC0V_125degC')
.param mlcc_0p1uF_0201		= str('GRT033C70J104KE01_DC0V_125degC')
.param mlcc_0p1uF_0204 		= str('LLL153C70G104ME01_DC0V_125degC')
.param mlcc_0p015uF_0402	= str('GCM155R71E153KA55_DC0V_125degC')
.param mlcc_0p01uF_0201		= str('GRT033R70J103KE01_DC0V_125degC')
.param mlcc_0p01uF_0201_II  = str('GCM033R71A103KA03_DC0V_125degC')

.param mlcc_22uF_0805		= str('GCM21BD70G226ME36_DC0V_125degC_0805_22uF')
.param mlcc_220uF_1210		= str('GCM32EM8EA227ME08_DC0V_125degC')
.param mlcc_0p047uF_0204_TDK= str('cgaea1x7r1h473m030bc_47nF_100pH_ACL_0204_IdEM')
.param mlcc_0p1uF_0204_TDK  = str('cgaew1x7t0g104m020bc_100nF_90pH_ACL_0204_IdEM')

.param mlcc_470uF_mockup	= str('mlcc_470uF_mockup_T598D477M2R5ATE009')

.param siCap_empwr_EC1001 = str('EC1001')
.param siCap_empwr_EC1002 = str('EC1002')
.param siCap_empwr_EC1100_200nF = str('EC1100_200nF')
.param siCap_empwr_EC1005_16600nF = str('ECAP_16600nF_12x10array')

*************************************** PMIC **********************************

Vref_gnd 	ref_gnd		0	0.
	*E_fdbk	ref_gnd	0	VCVS DELAY pmic_pwr pkg_bump_1_0  td=50.n	*** opt 2/2 VCVS to model feedback

.subckt PMIC_model
+ pin_out ref_gnd vdd_pmic = 0.75
	VshortPMIC	pin_out	ref_gnd	vdd_pmic
.ends

*** opt 1 ideal PMIC w/o remote sense feedback
.if ( 1 )
	*VshortPMIC	pmic_pwr	ref_gnd	Vdd		*** can be switched to PMIC model
	xblk_PMIC pmic_pwr ref_gnd PMIC_model  vdd_pmic = 'Vdd'
.endif
*** opt 2 EMpower simplified IVR equivalent model 	(remember to disable PMIC bulk caps on PCB)
.if ( 0 )
	VempowerVS	pmicEMpwrNode1	ref_gnd	Vdd		*** can be switched to PMIC model
	LempowerVS1  pmicEMpwrNode1  pmicEMpwrNode2  	'0.027778n * 0.9091'
	RempowerVS1  pmicEMpwrNode2  pmic_pwr			50.u
.endif
*************************************** Socket ********************************
Rskt	bga_pcb		bga_pkg		1.u				*** can add socket model

																									.if ( 0 )  	***  test reduced PCB+pkg for SIMPLIS  ==> low accuracy, do NOT use
																										Xblk_PCB
																										+ pkg_bump_one
																										+ pmic_pwr
																										+ pmic_pwr
																										+ pmic_pwr
																										+ pmic_pwr
																										+ ref_gnd
																										+ NNE_pkg_PCB_ACM3Kavoos_w_bulk_redu_240216_s5p_IdEM
																									.endif 		***  test reduced PCB+pkg for SIMPLIS end

*************************************** PCB ***********************************
.if ( 1 )		*** 231221 ACM3 PCB, reduced to 5 ports, POR 240216
	Xblk_PCB
	+ bga_pcb
	+ pmic_pwr
	+ pmic_pwr
	+ pmic_pwr
	+ pmic_pwr
	+ ref_gnd
	+ ACM3_notoplayer_10_100uF_10_220uF_IdEM
	* + ACM3_notoplayer_no_10_100uF_10_220uF_IdEM
	* + ACM3_122323_nne_cut_reduce_v2_manip_s5p
	* + ACM3_bulk_top_and_centerbottom_caps_IdEM
.endif 		*** end of 231221 ACM3 PCB, reduced to 5 ports

.if ( 0 )	*** 231221 ACM3 PCB
	Xblk_PCB
	+ bga_pcb
	+ pmic_pwr
	+ pmic_pwr
	+ pmic_pwr
	+ pmic_pwr
	+ pcbCap_C86
	+ pcbCap_C87
	+ pcbCap_C88
	+ pcbCap_C89
	+ pcbCap_C91
	+ pcbCap_C93
	+ pcbCap_C94
	+ pcbCap_C95
	+ pcbCap_C96
	+ pcbCap_C97
	+ pcbCap_C503
	+ pcbCap_C504
	+ pcbCap_C505
	+ pcbCap_C506
	+ pcbCap_C507
	+ pcbCap_C508
	+ pcbCap_C509
	+ pcbCap_C510
	+ pcbCap_C511
	+ pcbCap_C512
	+ pcbCap_C523
	+ pcbCap_C524
	+ pcbCap_C525
	+ pcbCap_C526
	+ pcbCap_C527
	+ pcbCap_C528
	+ pcbCap_C529
	+ pcbCap_C530
	+ pcbCap_C531
	+ pcbCap_C532
	+ pcbCap_C543
	+ pcbCap_C544
	+ pcbCap_C545
	+ pcbCap_C546
	+ pcbCap_C547
	+ pcbCap_C548
	+ pcbCap_C549
	+ pcbCap_C550
	+ pcbCap_C551
	+ pcbCap_C552
	+ pcbCap_C563
	+ pcbCap_C564
	+ pcbCap_C565
	+ pcbCap_C566
	+ pcbCap_C567
	+ pcbCap_C568
	+ pcbCap_C569
	+ pcbCap_C570
	+ pcbCap_C571
	+ pcbCap_C572
	+ pcbCap_C583
	+ pcbCap_C584
	+ pcbCap_C585
	+ pcbCap_C586
	+ pcbCap_C587
	+ pcbCap_C588
	+ pcbCap_C589
	+ pcbCap_C590
	+ pcbCap_C591
	+ pcbCap_C592
	+ pcbCap_C603
	+ pcbCap_C604
	+ pcbCap_C605
	+ pcbCap_C606
	+ pcbCap_C607
	+ pcbCap_C608
	+ pcbCap_C609
	+ pcbCap_C610
	+ pcbCap_C611
	+ pcbCap_C612
	+ pcbCap_C623
	+ pcbCap_C624
	+ pcbCap_C625
	+ pcbCap_C626
	+ pcbCap_C627
	+ pcbCap_C628
	+ pcbCap_C629
	+ pcbCap_C630
	+ pcbCap_C631
	+ pcbCap_C632
	+ pcbCap_C643
	+ pcbCap_C644
	+ pcbCap_C645
	+ pcbCap_C646
	+ pcbCap_C647
	+ pcbCap_C648
	+ pcbCap_C649
	+ pcbCap_C650
	+ pcbCap_C651
	+ pcbCap_C652
	+ pcbCap_C663
	+ pcbCap_C664
	+ pcbCap_C665
	+ pcbCap_C666
	+ pcbCap_C667
	+ pcbCap_C668
	+ pcbCap_C669
	+ pcbCap_C670
	+ pcbCap_C671
	+ pcbCap_C672
	+ pcbCap_C683
	+ pcbCap_C684
	+ pcbCap_C685
	+ pcbCap_C686
	+ pcbCap_C687
	+ pcbCap_C688
	+ pcbCap_C689
	+ pcbCap_C690
	+ pcbCap_C691
	+ pcbCap_C692
	+ pcbCap_C696
	+ pcbCap_C697
	+ pcbCap_C698
	+ pcbCap_C699
	+ pcbCap_C700
	+ pcbCap_C701
	+ pcbCap_C702
	+ pcbCap_C703
	+ pcbCap_C704
	+ pcbCap_C705
	+ pcbCap_C706
	+ pcbCap_C707
	+ pcbCap_C708
	+ pcbCap_C709
	+ pcbCap_C710
	+ pcbCap_C711
	+ pcbCap_C712
	+ pcbCap_C713
	+ pcbCap_C714
	+ pcbCap_C715
	+ pcbCap_C728
	+ pcbCap_C729
	+ pcbCap_C730
	+ pcbCap_C731
	+ pcbCap_C732
	+ pcbCap_C733
	+ pcbCap_C734
	+ pcbCap_C735
	+ pcbCap_C736
	+ pcbCap_C737
	+ pcbCap_C748
	+ pcbCap_C749
	+ pcbCap_C750
	+ pcbCap_C751
	+ pcbCap_C752
	+ pcbCap_C753
	+ pcbCap_C754
	+ pcbCap_C755
	+ pcbCap_C756
	+ pcbCap_C757
	+ pcbCap_C768
	+ pcbCap_C769
	+ pcbCap_C770
	+ pcbCap_C771
	+ pcbCap_C772
	+ pcbCap_C773
	+ pcbCap_C774
	+ pcbCap_C775
	+ pcbCap_C776
	+ pcbCap_C777
	+ pcbCap_C788
	+ pcbCap_C789
	+ pcbCap_C790
	+ pcbCap_C791
	+ pcbCap_C792
	+ pcbCap_C793
	+ pcbCap_C794
	+ pcbCap_C795
	+ pcbCap_C796
	+ pcbCap_C797
	+ pcbCap_C1042
	+ pcbCap_C1043
	+ pcbCap_C1044
	+ pcbCap_C1134
	+ pcbCap_C1135
	+ pcbCap_C1136
	+ pcbCap_C1137
	+ pcbCap_C1138
	+ pcbCap_C1139
	+ pcbCap_C1140
	+ pcbCap_C1141
	+ pcbCap_C1142
	+ pcbCap_C1143
	+ pcbCap_C1144
	+ pcbCap_C1145
	+ pcbCap_C1146
	+ pcbCap_C1147
	+ pcbCap_C1148
	+ pcbCap_C1149
	+ pcbCap_C1150
	+ pcbCap_C1151
	+ pcbCap_C1152
	+ pcbCap_C1153
	+ pcbCap_C1154
	+ pcbCap_C1155
	+ pcbCap_C1156
	+ pcbCap_C1157
	+ pcbCap_C1158
	+ pcbCap_C1159
	+ pcbCap_C1160
	+ pcbCap_C1161
	+ pcbCap_C1162
	+ pcbCap_C1163
	+ pcbCap_C1164
	+ pcbCap_C1165
	+ pcbCap_C1166
	+ pcbCap_C1167
	+ pcbCap_C1168
	+ pcbCap_C1169
	+ pcbCap_C1170
	+ pcbCap_C1171
	+ pcbCap_C1172
	+ pcbCap_C1173
	+ pcbCap_C1174
	+ pcbCap_C1175
	+ pcbCap_C1176
	+ pcbCap_C1177
	+ pcbCap_C1178
	+ pcbCap_C1179
	+ pcbCap_C1180
	+ pcbCap_C1181
	+ pcbCap_C1182
	+ pcbCap_C1183
	+ pcbCap_C1184
	+ pcbCap_C1185
	+ pcbCap_C1186
	+ pcbCap_C1187
	+ pcbCap_C1188
	+ pcbCap_C1189
	+ pcbCap_C1190
	+ pcbCap_C1191
	+ pcbCap_C1192
	+ pcbCap_C1193
	+ pcbCap_C1194
	+ pcbCap_C1195
	+ pcbCap_C1196
	+ pcbCap_C1197
	+ pcbCap_C1198
	+ pcbCap_C1199
	+ pcbCap_C1200
	+ pcbCap_C1201
	+ pcbCap_C1202
	+ pcbCap_C1203
	+ pcbCap_C1204
	+ pcbCap_C1205
	+ pcbCap_C1206
	+ pcbCap_C1207
	+ pcbCap_C1208
	+ pcbCap_C1209
	+ pcbCap_C1210
	+ pcbCap_C1211
	+ pcbCap_C1212
	+ pcbCap_C1213
	+ pcbCap_C1214
	+ pcbCap_C1215
	+ pcbCap_C1216
	+ pcbCap_C1217
	+ pcbCap_C1218
	+ pcbCap_C1219
	+ pcbCap_C1220
	+ pcbCap_C1221
	+ pcbCap_C1222
	+ pcbCap_C1223
	+ pcbCap_C1224
	+ pcbCap_C1225
	+ pcbCap_C1226
	+ pcbCap_C1227
	+ pcbCap_C1228
	+ pcbCap_C1229
	+ pcbCap_C1230
	+ pcbCap_C1231
	+ pcbCap_C1232
	+ pcbCap_C1233
	+ pcbCap_C1234
	+ pcbCap_C1235
	+ pcbCap_C1236
	+ pcbCap_C1237
	+ pcbCap_C1238
	+ pcbCap_C1239
	+ pcbCap_C1240
	+ pcbCap_C1241
	+ pcbCap_C1242
	+ pcbCap_C1243
	+ pcbCap_C1244
	+ pcbCap_C1245
	+ pcbCap_C1246
	+ pcbCap_C1247
	+ pcbCap_C1248
	+ pcbCap_C1249
	+ pcbCap_C1250
	+ pcbCap_C1251
	+ pcbCap_C1252
	+ pcbCap_C1253
	+ pcbCap_C1254
	+ pcbCap_C1255
	+ pcbCap_C1256
	+ pcbCap_C1257
	+ pcbCap_C1258
	+ pcbCap_C1259
	+ pcbCap_C1260
	+ pcbCap_C1261
	+ pcbCap_C1262
	+ pcbCap_C1263
	+ pcbCap_C1264
	+ pcbCap_C1265
	+ pcbCap_C1266
	+ pcbCap_C1267
	+ pcbCap_C1268
	+ pcbCap_C1269
	+ pcbCap_C1270
	+ pcbCap_C1271
	+ pcbCap_C1272
	+ pcbCap_C1273
	+ pcbCap_C1274
	+ pcbCap_C1275
	+ pcbCap_C1276
	+ pcbCap_C1277
	+ pcbCap_C1278
	+ pcbCap_C1279
	+ pcbCap_C1280
	+ pcbCap_C1281
	+ pcbCap_C1282
	+ pcbCap_C1283
	+ pcbCap_C1284
	+ pcbCap_C1285
	+ pcbCap_C1286
	+ pcbCap_C1287
	+ pcbCap_C1288
	+ pcbCap_C1289
	+ pcbCap_C1290
	+ pcbCap_C1291
	+ pcbCap_C1292
	+ pcbCap_C1293
	+ pcbCap_C1294
	+ pcbCap_C1295
	+ pcbCap_C1296
	+ pcbCap_C1309
	+ pcbCap_C1310
	+ pcbCap_C1311
	+ pcbCap_C1312
	+ pcbCap_C1313
	+ pcbCap_C1314
	+ pcbCap_C1315
	+ pcbCap_C1316
	+ pcbCap_C1317
	+ pcbCap_C1318
	+ pcbCap_C1319
	+ pcbCap_C1320
	+ pcbCap_C1321
	+ pcbCap_C1322
	+ pcbCap_C1323
	+ pcbCap_C1324
	+ pcbCap_C1325
	+ pcbCap_C1326
	+ pcbCap_C1327
	+ pcbCap_C1328
	+ pcbCap_C1329
	+ pcbCap_C1330
	+ pcbCap_C1331
	+ pcbCap_C1332
	+ pcbCap_C1333
	+ pcbCap_C1334
	+ pcbCap_C1335
	+ pcbCap_C1336
	+ pcbCap_C1337
	+ pcbCap_C1338
	+ pcbCap_C1339
	+ pcbCap_C1340
	+ pcbCap_C1341
	+ pcbCap_C1342
	+ pcbCap_C1343
	+ pcbCap_C1344
	+ ref_gnd
	+ ACM3_122323_nne_cut_manip_IdEM_s377p

	*** PCB cap ***
		*** under PCB, under IP shadow
	XpcbCap_C503 	pcbCap_C503     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C504 	pcbCap_C504     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C505 	pcbCap_C505     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C506 	pcbCap_C506     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C507 	pcbCap_C507     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C508 	pcbCap_C508     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C509 	pcbCap_C509     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C510 	pcbCap_C510     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C511 	pcbCap_C511     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C512 	pcbCap_C512     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C523 	pcbCap_C523     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C524 	pcbCap_C524     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C525 	pcbCap_C525     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C526 	pcbCap_C526     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C527 	pcbCap_C527     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C528 	pcbCap_C528     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C529 	pcbCap_C529     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C530 	pcbCap_C530     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C531 	pcbCap_C531     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C532 	pcbCap_C532     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C552 	pcbCap_C552     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C583 	pcbCap_C583     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C584 	pcbCap_C584     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C585 	pcbCap_C585     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C586 	pcbCap_C586     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C587 	pcbCap_C587     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C588 	pcbCap_C588     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C589 	pcbCap_C589     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C590 	pcbCap_C590     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C591 	pcbCap_C591     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C592 	pcbCap_C592     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C603 	pcbCap_C603     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C604 	pcbCap_C604     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C605 	pcbCap_C605     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C606 	pcbCap_C606     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C607 	pcbCap_C607     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C608 	pcbCap_C608     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C609 	pcbCap_C609     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C610 	pcbCap_C610     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C611 	pcbCap_C611     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C612 	pcbCap_C612     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C631 	pcbCap_C631     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C632 	pcbCap_C632     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C706 	pcbCap_C706     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C707 	pcbCap_C707     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C708 	pcbCap_C708     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C709 	pcbCap_C709     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C710 	pcbCap_C710     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C711 	pcbCap_C711     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C712 	pcbCap_C712     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C713 	pcbCap_C713     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C714 	pcbCap_C714     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C715 	pcbCap_C715     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C728 	pcbCap_C728     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C729 	pcbCap_C729     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C730 	pcbCap_C730     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C731 	pcbCap_C731     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C732 	pcbCap_C732     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C733 	pcbCap_C733     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C734 	pcbCap_C734     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C735 	pcbCap_C735     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C736 	pcbCap_C736     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C737 	pcbCap_C737     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C777 	pcbCap_C777     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C797 	pcbCap_C797     ref_gnd		str(mlcc_10uF_0402)
	XpcbCap_C1238	pcbCap_C1238    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1244	pcbCap_C1244    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1245	pcbCap_C1245    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1246	pcbCap_C1246    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1247	pcbCap_C1247    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1248	pcbCap_C1248    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1276	pcbCap_C1276    ref_gnd 	str(mlcc_10uF_0402)

	*** under PCB, outside IP shadow
	XpcbCap_C543 	pcbCap_C543     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C544 	pcbCap_C544     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C545 	pcbCap_C545     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C546 	pcbCap_C546     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C547 	pcbCap_C547     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C548 	pcbCap_C548     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C549 	pcbCap_C549     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C550 	pcbCap_C550     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C551 	pcbCap_C551     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C563 	pcbCap_C563     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C564 	pcbCap_C564     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C565 	pcbCap_C565     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C566 	pcbCap_C566     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C567 	pcbCap_C567     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C568 	pcbCap_C568     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C569 	pcbCap_C569     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C570 	pcbCap_C570     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C571 	pcbCap_C571     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C572 	pcbCap_C572     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C623 	pcbCap_C623     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C624 	pcbCap_C624     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C625 	pcbCap_C625     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C626 	pcbCap_C626     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C627 	pcbCap_C627     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C628 	pcbCap_C628     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C629 	pcbCap_C629     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C630 	pcbCap_C630     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C643 	pcbCap_C643     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C644 	pcbCap_C644     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C645 	pcbCap_C645     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C646 	pcbCap_C646     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C647 	pcbCap_C647     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C648 	pcbCap_C648     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C649 	pcbCap_C649     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C650 	pcbCap_C650     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C651 	pcbCap_C651     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C652 	pcbCap_C652     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C663 	pcbCap_C663     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C664 	pcbCap_C664     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C665 	pcbCap_C665     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C666 	pcbCap_C666     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C667 	pcbCap_C667     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C668 	pcbCap_C668     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C669 	pcbCap_C669     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C670 	pcbCap_C670     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C671 	pcbCap_C671     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C672 	pcbCap_C672     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C683 	pcbCap_C683     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C684 	pcbCap_C684     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C685 	pcbCap_C685     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C686 	pcbCap_C686     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C687 	pcbCap_C687     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C688 	pcbCap_C688     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C689 	pcbCap_C689     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C690 	pcbCap_C690     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C691 	pcbCap_C691     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C692 	pcbCap_C692     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C696 	pcbCap_C696     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C697 	pcbCap_C697     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C698 	pcbCap_C698     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C699 	pcbCap_C699     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C700 	pcbCap_C700     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C701 	pcbCap_C701     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C702 	pcbCap_C702     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C703 	pcbCap_C703     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C704 	pcbCap_C704     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C705 	pcbCap_C705     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C748 	pcbCap_C748     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C749 	pcbCap_C749     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C755 	pcbCap_C755     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C756 	pcbCap_C756     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C757 	pcbCap_C757     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C768 	pcbCap_C768     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C769 	pcbCap_C769     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C771 	pcbCap_C771     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C772 	pcbCap_C772     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C773 	pcbCap_C773     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C774 	pcbCap_C774     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C775 	pcbCap_C775     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C776 	pcbCap_C776     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C788 	pcbCap_C788     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C789 	pcbCap_C789     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C790 	pcbCap_C790     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C791 	pcbCap_C791     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C792 	pcbCap_C792     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C793 	pcbCap_C793     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C794 	pcbCap_C794     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C795 	pcbCap_C795     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C796 	pcbCap_C796     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1138	pcbCap_C1138    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1139	pcbCap_C1139    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1140	pcbCap_C1140    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1145	pcbCap_C1145    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1146	pcbCap_C1146    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1147	pcbCap_C1147    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1148	pcbCap_C1148    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1149	pcbCap_C1149    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1150	pcbCap_C1150    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1151	pcbCap_C1151    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1152	pcbCap_C1152    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1153	pcbCap_C1153    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1154	pcbCap_C1154    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1155	pcbCap_C1155    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1156	pcbCap_C1156    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1157	pcbCap_C1157    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1158	pcbCap_C1158    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1159	pcbCap_C1159    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1160	pcbCap_C1160    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1161	pcbCap_C1161    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1162	pcbCap_C1162    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1163	pcbCap_C1163    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1166	pcbCap_C1166    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1168	pcbCap_C1168    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1169	pcbCap_C1169    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1170	pcbCap_C1170    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1171	pcbCap_C1171    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1174	pcbCap_C1174    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1175	pcbCap_C1175    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1176	pcbCap_C1176    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1177	pcbCap_C1177    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1178	pcbCap_C1178    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1179	pcbCap_C1179    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1180	pcbCap_C1180    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1181	pcbCap_C1181    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1182	pcbCap_C1182    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1183	pcbCap_C1183    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1184	pcbCap_C1184    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1185	pcbCap_C1185    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1186	pcbCap_C1186    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1187	pcbCap_C1187    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1188	pcbCap_C1188    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1189	pcbCap_C1189    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1190	pcbCap_C1190    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1191	pcbCap_C1191    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1192	pcbCap_C1192    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1193	pcbCap_C1193    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1194	pcbCap_C1194    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1195	pcbCap_C1195    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1196	pcbCap_C1196    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1197	pcbCap_C1197    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1198	pcbCap_C1198    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1199	pcbCap_C1199    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1200	pcbCap_C1200    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1201	pcbCap_C1201    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1202	pcbCap_C1202    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1203	pcbCap_C1203    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1204	pcbCap_C1204    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1205	pcbCap_C1205    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1206	pcbCap_C1206    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1207	pcbCap_C1207    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1208	pcbCap_C1208    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1209	pcbCap_C1209    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1210	pcbCap_C1210    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1211	pcbCap_C1211    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1212	pcbCap_C1212    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1213	pcbCap_C1213    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1214	pcbCap_C1214    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1215	pcbCap_C1215    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1216	pcbCap_C1216    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1217	pcbCap_C1217    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1218	pcbCap_C1218    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1219	pcbCap_C1219    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1220	pcbCap_C1220    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1221	pcbCap_C1221    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1222	pcbCap_C1222    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1223	pcbCap_C1223    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1224	pcbCap_C1224    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1225	pcbCap_C1225    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1226	pcbCap_C1226    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1227	pcbCap_C1227    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1228	pcbCap_C1228    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1229	pcbCap_C1229    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1230	pcbCap_C1230    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1231	pcbCap_C1231    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1232	pcbCap_C1232    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1233	pcbCap_C1233    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1234	pcbCap_C1234    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1235	pcbCap_C1235    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1236	pcbCap_C1236    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1239	pcbCap_C1239    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1240	pcbCap_C1240    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1241	pcbCap_C1241    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1242	pcbCap_C1242    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1243	pcbCap_C1243    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1249	pcbCap_C1249    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1250	pcbCap_C1250    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1251	pcbCap_C1251    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1252	pcbCap_C1252    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1253	pcbCap_C1253    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1254	pcbCap_C1254    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1255	pcbCap_C1255    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1256	pcbCap_C1256    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1257	pcbCap_C1257    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1258	pcbCap_C1258    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1259	pcbCap_C1259    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1260	pcbCap_C1260    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1261	pcbCap_C1261    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1262	pcbCap_C1262    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1263	pcbCap_C1263    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1264	pcbCap_C1264    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1265	pcbCap_C1265    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1266	pcbCap_C1266    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1267	pcbCap_C1267    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1268	pcbCap_C1268    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1269	pcbCap_C1269    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1270	pcbCap_C1270    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1271	pcbCap_C1271    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1272	pcbCap_C1272    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1273	pcbCap_C1273    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1274	pcbCap_C1274    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1275	pcbCap_C1275    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1277	pcbCap_C1277    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1278	pcbCap_C1278    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1279	pcbCap_C1279    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1280	pcbCap_C1280    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1281	pcbCap_C1281    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1282	pcbCap_C1282    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1283	pcbCap_C1283    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1284	pcbCap_C1284    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1285	pcbCap_C1285    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1286	pcbCap_C1286    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1287	pcbCap_C1287    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1288	pcbCap_C1288    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1289	pcbCap_C1289    ref_gnd     str(mlcc_10uF_0402)

	*** same side caps btw SoC and PMIC
	XpcbCap_C1342	pcbCap_C1342    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1340	pcbCap_C1340    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1334	pcbCap_C1334    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1337	pcbCap_C1337    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1336	pcbCap_C1336    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1343	pcbCap_C1343    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1341	pcbCap_C1341    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1331	pcbCap_C1331    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C752 	pcbCap_C752     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1167	pcbCap_C1167    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1339	pcbCap_C1339    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1172	pcbCap_C1172    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C750 	pcbCap_C750     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C754 	pcbCap_C754     ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1164	pcbCap_C1164    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1142	pcbCap_C1142    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1134	pcbCap_C1134    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1135	pcbCap_C1135    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1173	pcbCap_C1173    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1137	pcbCap_C1137    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1141	pcbCap_C1141    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1143	pcbCap_C1143    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1237	pcbCap_C1237    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1136	pcbCap_C1136    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1144	pcbCap_C1144    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C751 	pcbCap_C751     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1322	pcbCap_C1322    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1309	pcbCap_C1309    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1165	pcbCap_C1165    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1321	pcbCap_C1321    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1325	pcbCap_C1325    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1324	pcbCap_C1324    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1310	pcbCap_C1310    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1316	pcbCap_C1316    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1315	pcbCap_C1315    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1318	pcbCap_C1318    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1317	pcbCap_C1317    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1311	pcbCap_C1311    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1312	pcbCap_C1312    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1313	pcbCap_C1313    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1314	pcbCap_C1314    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1323	pcbCap_C1323    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C753 	pcbCap_C753     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C770 	pcbCap_C770     ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1319	pcbCap_C1319    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1320	pcbCap_C1320    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1326	pcbCap_C1326    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1327	pcbCap_C1327    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1328	pcbCap_C1328    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1330	pcbCap_C1330    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1344	pcbCap_C1344    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1332	pcbCap_C1332    ref_gnd 	str(mlcc_10uF_0402)
	XpcbCap_C1333	pcbCap_C1333    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1329	pcbCap_C1329    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1335	pcbCap_C1335    ref_gnd     str(mlcc_10uF_0402)
	XpcbCap_C1338	pcbCap_C1338    ref_gnd 	str(mlcc_10uF_0402)

	*** bulk caps under PMIC
	* XpcbCap_C1295	pcbCap_C1295    ref_gnd 	str(mlcc_100uF_1210)
	* XpcbCap_C95  	pcbCap_C95      ref_gnd 	str(mlcc_100uF_1210)
	* XpcbCap_C88  	pcbCap_C88      ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C89  	pcbCap_C89      ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C91  	pcbCap_C91      ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C94  	pcbCap_C94      ref_gnd 	str(mlcc_100uF_1210)
	* XpcbCap_C96  	pcbCap_C96      ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C1293	pcbCap_C1293    ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C1042	pcbCap_C1042    ref_gnd 	str(mlcc_100uF_1210)
	* XpcbCap_C1291	pcbCap_C1291    ref_gnd     str(mlcc_100uF_1210)

	*** bulk caps same side as PMIC             str(mlcc_100uF_1210)
	* XpcbCap_C87  	pcbCap_C87      ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C86  	pcbCap_C86  	ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C1044	pcbCap_C1044    ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C1290	pcbCap_C1290    ref_gnd 	str(mlcc_100uF_1210)
	* XpcbCap_C1294	pcbCap_C1294    ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C93  	pcbCap_C93      ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C1043	pcbCap_C1043    ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C97  	pcbCap_C97      ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C1296	pcbCap_C1296    ref_gnd     str(mlcc_100uF_1210)
	* XpcbCap_C1292	pcbCap_C1292    ref_gnd 	str(mlcc_100uF_1210)

.endif 	*** end of 231221 ACM3 PCB

					* .if ( 0 )
						* Xblk_PCB
						* + pmic_pwr
						* + bga_pcb
						* + ref_gnd
						* + ACM3_NEWLAYOUT_01_30_4_3uF_4Phase_half10uFCAPSrev3_manip_IdEM
					* .endif

*************************************** Pkg ***********************************
					.if ( 0 ) 	*** 240217 reduced model test of " Zijie pkg w/ DSC + embedded Ecap"
						Xblk_pkg
						+ pkg_bump_1_0
						+ bga_pkg
						+ ref_gnd
						+ NNE_pkg_redu_240131_ZijiePkg_Ecap_Disabled_s2p_IdEM
						* + NNE_pkg_redu_240131_ZijiePkg_Ecap_Enabled_s2p_IdEM
					.endif 		*** *** 240217 reduced model test of " Zijie pkg w/ DSC + embedded Ecap", end

.if ( 0 )   *** 240222 Andes pkg 140um bump pitch
	Xblk_pkg
	+ bga_pkg
	+ pkgCap_C1
	+ pkgCap_C2
	+ pkgCap_C3
	+ pkgCap_C4
	+ pkgCap_C5
	+ pkgCap_C6
	+ pkgCap_C7
	+ pkgCap_C8
	+ pkgCap_C9
	+ pkgCap_C10
	+ pkgCap_C11
	+ pkgCap_C12
	+ pkgCap_C13
	+ pkgCap_C14
	+ pkgCap_C15
	+ pkgCap_C16
	+ pkgCap_C17
	+ pkgCap_C18
	+ pkgCap_C19
	+ pkgCap_C20
	+ pkgCap_C21
	+ pkgCap_C22
	+ pkgCap_C23
	+ pkgCap_C24
	+ pkgCap_C25
	+ pkgCap_C26
	+ pkgCap_C27
	+ pkgCap_C28
	+ pkgCap_C29
	+ pkgCap_C30
	+ pkgCap_C31
	+ pkgCap_C32
	+ pkgCap_C33
	+ pkgCap_C34
	+ pkgCap_C35
	+ pkgCap_C36
	+ pkgCap_C37
	+ pkgCap_C38
	+ pkgCap_C39
	+ pkgCap_C40
	+ pkgCap_C41
	+ pkgCap_C42
	+ pkgCap_C43
	+ pkgCap_C44
	+ pkgCap_C45
	+ pkgCap_C46
	+ pkgCap_C47
	+ pkgCap_C48
	+ pkgCap_C49
	+ pkgCap_C50
	+ pkgCap_C51
	+ pkgCap_C52
	+ pkgCap_C53
	+ pkgCap_C54
	+ pkgCap_C55
	+ pkgCap_C56
	+ pkgCap_C57
	+ pkgCap_C58
	+ pkgCap_C59
	+ pkgCap_C60
	+ pkg_bump_0_0
	+ pkg_bump_0_1
	+ pkg_bump_0_2
	+ pkg_bump_0_3
	+ pkg_bump_1_0
	+ pkg_bump_1_1
	+ pkg_bump_1_2
	+ pkg_bump_1_3
	+ ref_gnd
	+ Mam_MCM_L12_BH9_Ballv0p83_BPIv0071_20240124_3_20240216ate_b_IdEM

	*** DSC
	XpkgCap_C1		pkgCap_C1  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C2		pkgCap_C2  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C3		pkgCap_C3  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C4		pkgCap_C4  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C5		pkgCap_C5  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C6		pkgCap_C6  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C7		pkgCap_C7  ref_gnd   str(mlcc_0p1uF_0201)
	XpkgCap_C8		pkgCap_C8  ref_gnd   str(mlcc_0p1uF_0201)

	XpkgCap_C9    pkgCap_C9   ref_gnd  pkgCap_C9   ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C10   pkgCap_C10  ref_gnd  pkgCap_C10  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C11   pkgCap_C11  ref_gnd  pkgCap_C11  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C12   pkgCap_C12  ref_gnd  pkgCap_C12  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C13   pkgCap_C13  ref_gnd  pkgCap_C13  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C14   pkgCap_C14  ref_gnd  pkgCap_C14  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C15   pkgCap_C15  ref_gnd  pkgCap_C15  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C16   pkgCap_C16  ref_gnd  pkgCap_C16  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C17   pkgCap_C17  ref_gnd  pkgCap_C17  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C18   pkgCap_C18  ref_gnd  pkgCap_C18  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C19   pkgCap_C19  ref_gnd  pkgCap_C19  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C20   pkgCap_C20  ref_gnd  pkgCap_C20  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C21   pkgCap_C21  ref_gnd  pkgCap_C21  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C22   pkgCap_C22  ref_gnd  pkgCap_C22  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C23   pkgCap_C23  ref_gnd  pkgCap_C23  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C24   pkgCap_C24  ref_gnd  pkgCap_C24  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C25   pkgCap_C25  ref_gnd  pkgCap_C25  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C26   pkgCap_C26  ref_gnd  pkgCap_C26  ref_gnd   str(mlcc_1uF_0402_3T_ft)
	XpkgCap_C27   pkgCap_C27  ref_gnd  pkgCap_C27  ref_gnd   str(mlcc_1uF_0402_3T_ft)

	XpkgCap_C28   pkgCap_C28  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C29   pkgCap_C29  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C30   pkgCap_C30  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C31   pkgCap_C31  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C32   pkgCap_C32  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C33   pkgCap_C33  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C34   pkgCap_C34  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C35   pkgCap_C35  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C36   pkgCap_C36  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C37   pkgCap_C37  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C38   pkgCap_C38  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C39   pkgCap_C39  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C40   pkgCap_C40  ref_gnd  str(mlcc_0p015uF_0402)
	XpkgCap_C41   pkgCap_C41  ref_gnd  str(mlcc_0p015uF_0402)

	XpkgCap_C42    pkgCap_C42  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C43    pkgCap_C43  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C44    pkgCap_C44  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C45    pkgCap_C45  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C46    pkgCap_C46  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C47    pkgCap_C47  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C48    pkgCap_C48  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C49    pkgCap_C49  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C50    pkgCap_C50  ref_gnd   str(mlcc_10uF_0402)
	XpkgCap_C51    pkgCap_C51   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C52    pkgCap_C52   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C53    pkgCap_C53   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C54    pkgCap_C54   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C55    pkgCap_C55   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C56    pkgCap_C56   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C57    pkgCap_C57   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C58    pkgCap_C58   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C59    pkgCap_C59   ref_gnd  str(mlcc_10uF_0402)
	XpkgCap_C60    pkgCap_C60   ref_gnd  str(mlcc_10uF_0402)

.endif 		*** 240222 Andes pkg 140um bump pitch end

.if ( 1 )   *** 240131 Zijie pkg w/ DSC + embedded Ecap, POR240216
	Xblk_pkg
	+ pkg_bump_0_0
	+ pkg_bump_0_1
	+ pkg_bump_0_2
	+ pkg_bump_0_3
	+ pkg_bump_1_0
	+ pkg_bump_1_1
	+ pkg_bump_1_2
	+ pkg_bump_1_3
	+ bga_pkg
	+ pkgCap_C152_2
	+ pkgCap_C153_2
	+ pkgCap_C154_2
	+ pkgCap_C155_2
	+ pkgCap_C156_2
	+ pkgCap_C157_2
	+ pkgCap_C158_2
	+ pkgCap_C159_2
	+ pkgCap_C210_1
	+ pkgCap_C211_1
	+ pkgCap_C212_1
	+ pkgCap_C213_1
	+ pkgCap_C214_1
	+ pkgCap_C215_1
	+ pkgCap_C216_1
	+ pkgCap_C217_1
	+ pkgCap_C218_1
	+ pkgCap_C219_1
	+ pkgCap_C220_1
	+ pkgCap_C221_1
	+ pkgCap_C222_1
	+ pkgCap_C223_1
	+ pkgCap_C224_1
	+ pkgCap_C225_1
	+ pkgCap_C226_1
	+ pkgCap_C227_1
	+ pkgCap_C228_1
	+ pkgCap_C229_1
	+ pkgCap_C841_1
	+ pkgCap_C842_2
	+ pkgCap_C843_1
	+ pkgCap_C844_1
	+ pkgCap_C845_1
	+ pkgCap_C846_2
	+ pkgCap_C847_1
	+ pkgCap_C848_2
	+ pkgCap_C849_1
	+ pkgCap_C850_2
	+ pkgCap_C851_1
	+ pkgCap_C852_2
	+ pkgCap_C853_1
	+ pkgCap_C854_2
	+ pkgCap_C855_1
	+ pkgCap_C856_2
	+ pkgCap_C857_1
	+ pkgCap_C858_2
	+ pkgCap_C859_1
	+ pkgCap_C860_2
	+ pkgCap_C861_2
	+ pkgCap_C862_1
	+ pkgCap_C863_2
	+ pkgCap_C864_1
	+ pkgCap_C865_2
	+ pkgCap_C866_1
	+ pkgCap_C867_2
	+ pkgCap_C868_1
	+ pkgCap_C869_2
	+ pkgCap_C870_1
	+ pkgCap_C871_2
	+ pkgCap_C872_1
	+ pkgCap_C873_2
	+ pkgCap_C874_1
	+ pkgCap_C875_2
	+ pkgCap_Ecap_core_1_A1
	+ pkgCap_Ecap_core_1_A3
	+ pkgCap_Ecap_core_1_A5
	+ pkgCap_Ecap_core_1_A7
	+ pkgCap_Ecap_core_1_A9
	+ pkgCap_Ecap_core_1_A11
	+ pkgCap_Ecap_core_1_B2
	+ pkgCap_Ecap_core_1_B4
	+ pkgCap_Ecap_core_1_B6
	+ pkgCap_Ecap_core_1_B8
	+ pkgCap_Ecap_core_1_B10
	+ pkgCap_Ecap_core_1_B12
	+ pkgCap_Ecap_core_1_C1
	+ pkgCap_Ecap_core_1_C3
	+ pkgCap_Ecap_core_1_C5
	+ pkgCap_Ecap_core_1_C7
	+ pkgCap_Ecap_core_1_C9
	+ pkgCap_Ecap_core_1_C11
	+ pkgCap_Ecap_core_1_D2
	+ pkgCap_Ecap_core_1_D4
	+ pkgCap_Ecap_core_1_D6
	+ pkgCap_Ecap_core_1_D8
	+ pkgCap_Ecap_core_1_D10
	+ pkgCap_Ecap_core_1_D12
	+ pkgCap_Ecap_core_1_E1
	+ pkgCap_Ecap_core_1_E3
	+ pkgCap_Ecap_core_1_E5
	+ pkgCap_Ecap_core_1_E7
	+ pkgCap_Ecap_core_1_E9
	+ pkgCap_Ecap_core_1_E11
	+ pkgCap_Ecap_core_1_F2
	+ pkgCap_Ecap_core_1_F4
	+ pkgCap_Ecap_core_1_F6
	+ pkgCap_Ecap_core_1_F8
	+ pkgCap_Ecap_core_1_F10
	+ pkgCap_Ecap_core_1_F12
	+ pkgCap_Ecap_core_1_G1
	+ pkgCap_Ecap_core_1_G3
	+ pkgCap_Ecap_core_1_G5
	+ pkgCap_Ecap_core_1_G7
	+ pkgCap_Ecap_core_1_G9
	+ pkgCap_Ecap_core_1_G11
	+ pkgCap_Ecap_core_1_H2
	+ pkgCap_Ecap_core_1_H4
	+ pkgCap_Ecap_core_1_H6
	+ pkgCap_Ecap_core_1_H8
	+ pkgCap_Ecap_core_1_H10
	+ pkgCap_Ecap_core_1_H12
	+ pkgCap_Ecap_core_1_J1
	+ pkgCap_Ecap_core_1_J3
	+ pkgCap_Ecap_core_1_J5
	+ pkgCap_Ecap_core_1_J7
	+ pkgCap_Ecap_core_1_J9
	+ pkgCap_Ecap_core_1_J11
	+ pkgCap_Ecap_core_1_K2
	+ pkgCap_Ecap_core_1_K4
	+ pkgCap_Ecap_core_1_K6
	+ pkgCap_Ecap_core_1_K8
	+ pkgCap_Ecap_core_1_K10
	+ pkgCap_Ecap_core_1_K12
	+ ref_gnd
	+ nne_ecap_dsc_IdEM

		*** DSC

		.if ( is_use_3T_cap_ft != 1 )  *** No 3T caps
			XpkgCap_C152_2 pkgCap_C152_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C153_2 pkgCap_C153_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C154_2 pkgCap_C154_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C155_2 pkgCap_C155_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C156_2 pkgCap_C156_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C157_2 pkgCap_C157_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C158_2 pkgCap_C158_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C159_2 pkgCap_C159_2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C210_1 pkgCap_C210_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C211_1 pkgCap_C211_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C212_1 pkgCap_C212_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C213_1 pkgCap_C213_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C214_1 pkgCap_C214_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C215_1 pkgCap_C215_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C216_1 pkgCap_C216_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C217_1 pkgCap_C217_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C218_1 pkgCap_C218_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C219_1 pkgCap_C219_1    ref_gnd  ref_gnd  str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C220_1 pkgCap_C220_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C221_1 pkgCap_C221_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C222_1 pkgCap_C222_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C223_1 pkgCap_C223_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C224_1 pkgCap_C224_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C225_1 pkgCap_C225_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C226_1 pkgCap_C226_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
		.endif

		.if ( is_use_3T_cap_ft == 1 )  *** Use  3T caps
			XpkgCap_C152_2 pkgCap_C152_2    ref_gnd  pkgCap_C152_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C154_2 pkgCap_C154_2    ref_gnd  pkgCap_C154_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C156_2 pkgCap_C156_2    ref_gnd  pkgCap_C156_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C158_2 pkgCap_C158_2    ref_gnd  pkgCap_C158_2    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C210_1 pkgCap_C210_1    ref_gnd  pkgCap_C210_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C211_1 pkgCap_C211_1    ref_gnd  pkgCap_C211_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C212_1 pkgCap_C212_1    ref_gnd  pkgCap_C212_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C213_1 pkgCap_C213_1    ref_gnd  pkgCap_C213_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C214_1 pkgCap_C214_1    ref_gnd  pkgCap_C214_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C215_1 pkgCap_C215_1    ref_gnd  pkgCap_C215_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C216_1 pkgCap_C216_1    ref_gnd  pkgCap_C216_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C220_1 pkgCap_C220_1    ref_gnd  pkgCap_C220_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C221_1 pkgCap_C221_1    ref_gnd  pkgCap_C221_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C222_1 pkgCap_C222_1    ref_gnd  pkgCap_C222_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C223_1 pkgCap_C223_1    ref_gnd  pkgCap_C223_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C224_1 pkgCap_C224_1    ref_gnd  pkgCap_C224_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C225_1 pkgCap_C225_1    ref_gnd  pkgCap_C225_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C226_1 pkgCap_C226_1    ref_gnd  pkgCap_C226_1    ref_gnd  str(mlcc_1uF_0402_3T_ft)
		.endif

		XpkgCap_C227_1 pkgCap_C227_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
		XpkgCap_C228_1 pkgCap_C228_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)
		XpkgCap_C229_1 pkgCap_C229_1    ref_gnd  ref_gnd  str(mlcc_0p1uF_0204_TDK)

		XpkgCap_C841_1 pkgCap_C841_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C842_2 pkgCap_C842_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C843_1 pkgCap_C843_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C844_1 pkgCap_C844_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C845_1 pkgCap_C845_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C846_2 pkgCap_C846_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C847_1 pkgCap_C847_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C848_2 pkgCap_C848_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C849_1 pkgCap_C849_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C850_2 pkgCap_C850_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C851_1 pkgCap_C851_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C852_2 pkgCap_C852_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C853_1 pkgCap_C853_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C854_2 pkgCap_C854_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C855_1 pkgCap_C855_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C856_2 pkgCap_C856_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C857_1 pkgCap_C857_1    ref_gnd str(mlcc_0p015uF_0402)

		XpkgCap_C858_2 pkgCap_C858_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C859_1 pkgCap_C859_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C860_2 pkgCap_C860_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C861_2 pkgCap_C861_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C862_1 pkgCap_C862_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C863_2 pkgCap_C863_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C864_1 pkgCap_C864_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C865_2 pkgCap_C865_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C866_1 pkgCap_C866_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C867_2 pkgCap_C867_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C868_1 pkgCap_C868_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C869_2 pkgCap_C869_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C870_1 pkgCap_C870_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C871_2 pkgCap_C871_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C872_1 pkgCap_C872_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C873_2 pkgCap_C873_2    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C874_1 pkgCap_C874_1    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C875_2 pkgCap_C875_2    ref_gnd str(mlcc_10uF_0402)

		*** Ecap embedded
		.if ( is_use_ecap_ebed == 1 )  *** use ecap embed
			xECAP_16600nF_core_2
			+ pkgCap_Ecap_core_1_A1
			+ pkgCap_Ecap_core_1_A3
			+ pkgCap_Ecap_core_1_A5
			+ pkgCap_Ecap_core_1_A7
			+ pkgCap_Ecap_core_1_A9
			+ pkgCap_Ecap_core_1_A11
			+ pkgCap_Ecap_core_1_B2
			+ pkgCap_Ecap_core_1_B4
			+ pkgCap_Ecap_core_1_B6
			+ pkgCap_Ecap_core_1_B8
			+ pkgCap_Ecap_core_1_B10
			+ pkgCap_Ecap_core_1_B12
			+ pkgCap_Ecap_core_1_C1
			+ pkgCap_Ecap_core_1_C3
			+ pkgCap_Ecap_core_1_C5
			+ pkgCap_Ecap_core_1_C7
			+ pkgCap_Ecap_core_1_C9
			+ pkgCap_Ecap_core_1_C11
			+ pkgCap_Ecap_core_1_D2
			+ pkgCap_Ecap_core_1_D4
			+ pkgCap_Ecap_core_1_D6
			+ pkgCap_Ecap_core_1_D8
			+ pkgCap_Ecap_core_1_D10
			+ pkgCap_Ecap_core_1_D12
			+ pkgCap_Ecap_core_1_E1
			+ pkgCap_Ecap_core_1_E3
			+ pkgCap_Ecap_core_1_E5
			+ pkgCap_Ecap_core_1_E7
			+ pkgCap_Ecap_core_1_E9
			+ pkgCap_Ecap_core_1_E11
			+ pkgCap_Ecap_core_1_F2
			+ pkgCap_Ecap_core_1_F4
			+ pkgCap_Ecap_core_1_F6
			+ pkgCap_Ecap_core_1_F8
			+ pkgCap_Ecap_core_1_F10
			+ pkgCap_Ecap_core_1_F12
			+ pkgCap_Ecap_core_1_G1
			+ pkgCap_Ecap_core_1_G3
			+ pkgCap_Ecap_core_1_G5
			+ pkgCap_Ecap_core_1_G7
			+ pkgCap_Ecap_core_1_G9
			+ pkgCap_Ecap_core_1_G11
			+ pkgCap_Ecap_core_1_H2
			+ pkgCap_Ecap_core_1_H4
			+ pkgCap_Ecap_core_1_H6
			+ pkgCap_Ecap_core_1_H8
			+ pkgCap_Ecap_core_1_H10
			+ pkgCap_Ecap_core_1_H12
			+ pkgCap_Ecap_core_1_J1
			+ pkgCap_Ecap_core_1_J3
			+ pkgCap_Ecap_core_1_J5
			+ pkgCap_Ecap_core_1_J7
			+ pkgCap_Ecap_core_1_J9
			+ pkgCap_Ecap_core_1_J11
			+ pkgCap_Ecap_core_1_K2
			+ pkgCap_Ecap_core_1_K4
			+ pkgCap_Ecap_core_1_K6
			+ pkgCap_Ecap_core_1_K8
			+ pkgCap_Ecap_core_1_K10
			+ pkgCap_Ecap_core_1_K12
			+ ref_gnd
			+ str(siCap_empwr_EC1005_16600nF)
		.endif

.endif 		*** 240131 Zijie pkg w/ DSC + embedded Ecap END

.if ( 0 )   *** 240117 Andes pkg, jgwei cap
	Xblk_pkg
	+ bga_pkg
    + pkg_bump_1_3
    + pkg_bump_1_2
    + pkg_bump_0_0
	+ pkg_bump_0_1
	+ pkg_bump_0_2
	+ pkg_bump_1_0
	+ pkg_bump_0_3
    + pkg_bump_1_1
    + pkgCap_C1
	+ pkgCap_C2
	+ pkgCap_C3
	+ pkgCap_C4
	+ pkgCap_C5
	+ pkgCap_C6
	+ pkgCap_C7
	+ pkgCap_C8
	+ pkgCap_C9
	+ pkgCap_C10
	+ pkgCap_C11
	+ pkgCap_C12
	+ pkgCap_C13
	+ pkgCap_C14
	+ pkgCap_C15
	+ pkgCap_C16
	+ pkgCap_C17
	+ pkgCap_C18
	+ pkgCap_C19
	+ pkgCap_C20
	+ pkgCap_C21
	+ pkgCap_C22
	+ pkgCap_C23
	+ pkgCap_C24
	+ pkgCap_C25
	+ pkgCap_C26
	+ pkgCap_C27
	+ pkgCap_C28
    + pkgCap_C4_1
	+ pkgCap_C4_2
	+ pkgCap_C4_3
	+ pkgCap_C4_4
	+ pkgCap_C4_5
	+ pkgCap_C4_6
	+ pkgCap_C4_7
	+ pkgCap_C4_8
	+ pkgCap_C4_9
	+ pkgCap_C4_10
	+ pkgCap_C4_11
	+ pkgCap_C4_12
	+ pkgCap_C4_13
	+ pkgCap_C4_14
	+ pkgCap_C4_15
    + pkgCap_C5_1
	+ pkgCap_C5_2
	+ pkgCap_C5_3
	+ pkgCap_C5_4
	+ pkgCap_C5_5
	+ pkgCap_C5_6
	+ pkgCap_C5_7
	+ pkgCap_C5_8
	+ pkgCap_C5_9
	+ pkgCap_C5_10
	+ pkgCap_C5_11
	+ pkgCap_C5_12
	+ pkgCap_C5_13
	+ pkgCap_C5_14
	+ pkgCap_C5_15
	+ pkgCap_C5_16
	+ pkgCap_C5_17
	+ pkgCap_C5_18
	+ pkgCap_C5_19
	+ ref_gnd
	+ Mam_MCM_L12_231215c_mod48_NNE_02_IdEM

		*** DSC
		.param is_use_3T_cap_ft = 0		*** use 0 or 1

		.if ( is_use_3T_cap_ft != 1 )  *** No 3T caps
			XpkgCap_C1		pkgCap_C1    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C2		pkgCap_C2    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C3		pkgCap_C3    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C4		pkgCap_C4    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C5		pkgCap_C5    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C6		pkgCap_C6    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C7		pkgCap_C7    ref_gnd str(mlcc_0p01uF_0201_II)
			XpkgCap_C8		pkgCap_C8    ref_gnd str(mlcc_0p01uF_0201_II)

			XpkgCap_C9 		pkgCap_C9     ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C10		pkgCap_C10    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C11		pkgCap_C11    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C12		pkgCap_C12    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C13		pkgCap_C13    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C14		pkgCap_C14    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C15		pkgCap_C15    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C16		pkgCap_C16    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C17		pkgCap_C17    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)
			XpkgCap_C18		pkgCap_C18    ref_gnd  ref_gnd str(mlcc_0p047uF_0204_TDK)

			XpkgCap_C19		pkgCap_C19    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C20		pkgCap_C20    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C21		pkgCap_C21    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C22		pkgCap_C22    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C23		pkgCap_C23    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C24		pkgCap_C24    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C25		pkgCap_C25    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C26		pkgCap_C26    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C27		pkgCap_C27    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
			XpkgCap_C28		pkgCap_C28    ref_gnd  ref_gnd str(mlcc_0p1uF_0204_TDK)
		.endif

		.if ( is_use_3T_cap_ft == 1 )  *** Use 3T caps
			XpkgCap_C1		pkgCap_C1    ref_gnd pkgCap_C1    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C3		pkgCap_C3    ref_gnd pkgCap_C3    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C5		pkgCap_C5    ref_gnd pkgCap_C5    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C7		pkgCap_C7    ref_gnd pkgCap_C7    ref_gnd str(mlcc_1uF_0402_3T_ft)

			XpkgCap_C9 		pkgCap_C9     ref_gnd pkgCap_C9     ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C10		pkgCap_C10    ref_gnd pkgCap_C10    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C11		pkgCap_C11    ref_gnd pkgCap_C11    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C12		pkgCap_C12    ref_gnd pkgCap_C12    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C13		pkgCap_C13    ref_gnd pkgCap_C13    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C14		pkgCap_C14    ref_gnd pkgCap_C14    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C15		pkgCap_C15    ref_gnd pkgCap_C15    ref_gnd str(mlcc_1uF_0402_3T_ft)

			XpkgCap_C19		pkgCap_C19    ref_gnd pkgCap_C19    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C20		pkgCap_C20    ref_gnd pkgCap_C20    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C21		pkgCap_C21    ref_gnd pkgCap_C21    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C22		pkgCap_C22    ref_gnd pkgCap_C22    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C23		pkgCap_C23    ref_gnd pkgCap_C23    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C24		pkgCap_C24    ref_gnd pkgCap_C24    ref_gnd str(mlcc_1uF_0402_3T_ft)
			XpkgCap_C25		pkgCap_C25    ref_gnd pkgCap_C25    ref_gnd str(mlcc_1uF_0402_3T_ft)

		.endif

		XpkgCap_C4_1  pkgCap_C4_1    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_2  pkgCap_C4_2    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_3  pkgCap_C4_3    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_4  pkgCap_C4_4    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_5  pkgCap_C4_5    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_6  pkgCap_C4_6    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_7  pkgCap_C4_7    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_8  pkgCap_C4_8    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_9  pkgCap_C4_9    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_10 pkgCap_C4_10    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_11 pkgCap_C4_11    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_12 pkgCap_C4_12    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_13 pkgCap_C4_13    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_14 pkgCap_C4_14    ref_gnd str(mlcc_0p015uF_0402)
		XpkgCap_C4_15 pkgCap_C4_15    ref_gnd str(mlcc_0p015uF_0402)

		XpkgCap_C5_1 ppkgCap_C5_1    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_2 ppkgCap_C5_2    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_3 ppkgCap_C5_3    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_4 ppkgCap_C5_4    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_5 ppkgCap_C5_5    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_6 ppkgCap_C5_6    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_7 ppkgCap_C5_7    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_8 ppkgCap_C5_8    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_9 ppkgCap_C5_9    ref_gnd str(mlcc_0p1uF_0402)
		XpkgCap_C5_10 pkgCap_C5_10    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_11 pkgCap_C5_11    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_12 pkgCap_C5_12    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_13 pkgCap_C5_13    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_14 pkgCap_C5_14    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_15 pkgCap_C5_15    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_16 pkgCap_C5_16    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_17 pkgCap_C5_17    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_18 pkgCap_C5_18    ref_gnd str(mlcc_10uF_0402)
		XpkgCap_C5_19 pkgCap_C5_19    ref_gnd str(mlcc_10uF_0402)

.endif 		*** 240117 Andes pkg, jgwei cap end

*************************************** Die ***********************************
*** approach 1: multi grp modeling
.if (die_model_sig != 1 )
Xblk_die_0_0	pkg_bump_0_0	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
Xblk_die_0_1	pkg_bump_0_1	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
Xblk_die_0_2	pkg_bump_0_2	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
Xblk_die_0_3	pkg_bump_0_3	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
Xblk_die_1_0	pkg_bump_1_0	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 1500.p
Xblk_die_1_1	pkg_bump_1_1	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 1000.p
Xblk_die_1_2	pkg_bump_1_2	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 500.p
Xblk_die_1_3	pkg_bump_1_3	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p

	*** test to add coupling RL btw two grps

	R_ma_0_1 pkg_bump_0_0	pkg_bump_0_1	r_grid
	R_ma_1_2 pkg_bump_0_1	pkg_bump_0_2	r_grid
	R_ma_2_3 pkg_bump_0_2	pkg_bump_0_3	r_grid
	R_pa_0_1 pkg_bump_1_0	pkg_bump_1_1	r_grid
	R_pa_1_2 pkg_bump_1_1	pkg_bump_1_2	r_grid
	R_pa_2_3 pkg_bump_1_2	pkg_bump_1_3	r_grid
	R_mpa_0	 pkg_bump_0_0	pkg_bump_1_0	r_grid
	R_mpa_1	 pkg_bump_0_1	pkg_bump_1_1	r_grid
	R_mpa_2	 pkg_bump_0_2	pkg_bump_1_2	r_grid
	R_mpa_3	 pkg_bump_0_3	pkg_bump_1_3	r_grid

	* R_0_bump_merge pkg_bump_one	pkg_bump_0_0	1.n
	* R_1_bump_merge pkg_bump_one	pkg_bump_0_1	1.n
	* R_2_bump_merge pkg_bump_one	pkg_bump_1_0	1.n
	* R_3_bump_merge pkg_bump_one	pkg_bump_1_1	1.n

	* R_4_bump_merge pkg_bump_two	pkg_bump_0_2	1.n
	* R_5_bump_merge pkg_bump_two	pkg_bump_0_3	1.n
	* R_6_bump_merge pkg_bump_two	pkg_bump_1_2	1.n
	* R_7_bump_merge pkg_bump_two	pkg_bump_1_3	1.n

	* R_cpl_01 	pkg_bump_one		pkg_bump_cpl_01  	0.8m
	* L_cpl_01	pkg_bump_cpl_01		pkg_bump_two 		2.p
.endif
*** approach 1: multi grp modeling END

*** approach 2: single grp modeling
.if (die_model_sig == 1 )
	*** all bump grps connected to single die model
	R_0_bump_merge pkg_bump_one	pkg_bump_0_0	1.n
	R_1_bump_merge pkg_bump_one	pkg_bump_0_1	1.n
	R_2_bump_merge pkg_bump_one	pkg_bump_0_2	1.n
	R_3_bump_merge pkg_bump_one	pkg_bump_0_3	1.n
	R_4_bump_merge pkg_bump_one	pkg_bump_1_0	1.n
	R_5_bump_merge pkg_bump_one	pkg_bump_1_1	1.n
	R_6_bump_merge pkg_bump_one	pkg_bump_1_2	1.n
	R_7_bump_merge pkg_bump_one	pkg_bump_1_3	1.n

    .if (is_MIM == 1)
		Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 3359.n	R_die_1= 0.027m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)		*** w/ MIM
	.endif
	.if (is_MIM != 1 )
	  Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 928.n	R_die_1= 0.027m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)
	* Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 1074.6n	R_die_1= 0.023m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)     *** add diffusion 1um
	* Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 1118.n	R_die_1= 0.022m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)		*** merge with SoC
	* Xblk_die_0_0	pkg_bump_one	ref_gnd	model_die_lumped_nne_tile	C_die= 4047.n	R_die_1= 0.022m R_die_2= 1.n	R_leak= 0.1		pwl_file_in = str(pwl_file_All)		*** merge with SoC * MIM
	.endif

.endif
*** approach 2: single grp modeling	END

*************************************** Analysis I: AC simulation *************
.if ( is_ac_run == 1 )
	.if ( 1 )
		*** NOTE: DO not include port def if tran analysis later
		P1 pkg_bump_0_0	ref_gnd	port=1	z0 = 0.1
		P2 pkg_bump_0_1	ref_gnd	port=2	z0 = 0.1
		P3 pkg_bump_0_2	ref_gnd	port=3	z0 = 0.1
		P4 pkg_bump_0_3	ref_gnd	port=4	z0 = 0.1
		P5 pkg_bump_1_0	ref_gnd	port=5	z0 = 0.1
		P6 pkg_bump_1_1	ref_gnd	port=6	z0 = 0.1
		P7 pkg_bump_1_2	ref_gnd	port=7	z0 = 0.1
		P8 pkg_bump_1_3	ref_gnd	port=8	z0 = 0.1

		.lin 	sparcalc=1 	filename=impedance_plot	noisecalc=0 	gdcalc=0	format=touchstone 	dataformat=MA
		**.probe  ac s11(db) s11(p) s21(db) s21(p)
		.probe ac zin(1)(m) zin(1)(p) zin(5)(m) zin(5)(p) zin(8)(m) zin(8)(p)

		.ac 	dec 50 1. 1.G

	.endif

	.if ( 0 )
		*i_ac_pkg_bump_0_0 pkg_bump_0_0 ref_gnd dc=0 ac=-1.
		* .probe ac v(pkg_bump_0_0)

		i_ac_pkg_bump_1_0 pkg_bump_1_0 ref_gnd dc=0 ac=-1.
		.probe ac v(pkg_bump_1_0)	vi(pkg_bump_1_0)	vr(pkg_bump_1_0)

		.ac 	dec 50 1. 1.G

		* .param v_imag = vi(pkg_bump_1_0)
		* .param acl = 'v_imag / 2./pi '
		* .print 'vi(pkg_bump_1_0) / 2. '		*** works
				* .print 'vi(pkg_bump_1_0) / pi '						*** NOT work
				* .measure ac ACL param = 'vi(pkg_bump_1_0) / 2.'		*** NOT work

		.param pfreq = 100.e6
		.param dfreq = 10.e6
		.measure ac zval_1   find vi(pkg_bump_1_0)	at = 'pfreq - dfreq '
		.measure ac zval_2   find vi(pkg_bump_1_0)	at = 'pfreq + dfreq '
		.measure ac acl      param='(zval_2 - zval_1)/2./pi/(dfreq+dfreq)'

	.endif

.endif

*************************************** Analysis II: Transient simulation *****
.if ( is_ac_run != 1 )
	.param tStep	= 10.p
	.param tStop	= 3.u     ** 35.u
	.tran tStep tSTOP

	.probe tran v(pkg_bump_1_0) v(pkg_bump_1_3) v(pkg_bump_0_0) v(pkg_bump_0_3)  v(bga_pkg)
	* .probe tran v(pkg_bump_1_1) v(pkg_bump_1_2)
	.probe x(Xblk_die_1_0.pin_bump)	x(Xblk_PCB.a_1)	x(Xblk_pkg.a_1)
	.probe x(Xblk_pkg.a_9)
	.probe x(xblk_PMIC.pin_out)

	* .param vdd_meas_start = 0.u
	* .param vdd_meas_end   = 3.u      ** 50.u
	* .meas tran pkg_bump_1_0_p2p 		PP	V(pkg_bump_1_0)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmax	MAX	V(pkg_bump_1_0)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmin	MIN	V(pkg_bump_1_0)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmax_t	WHEN	V(pkg_bump_1_0) = 'pkg_bump_1_0_cpu_vmax' 	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmin_t	WHEN	V(pkg_bump_1_0) = 'pkg_bump_1_0_cpu_vmin' 	from='vdd_meas_start' to='vdd_meas_end'

	*.probe i(*)
	*.probe x(*)

.endif
