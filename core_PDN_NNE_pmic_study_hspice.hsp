* Top level spice file

.option post=1
*.chkanode type=gate dv=0.5*pvdd report=active
.option parhier = local
.option measform = 1
.option lis_new
.option post probe
.param pi = 3.141592653

*************************************** User defined functions ****************
.param V_meas(node, ref) = 'v(node) - v(ref)'

*************************************** Input Models**************************
	***** define load current source model used in die model *****

	.param pwl_file_in_PA = str('./hspice_inc/curr_idle_0A.csv')	*** PA current NA, might need to add "R" at end of src
	.param pwl_file_in_MA = str('./hspice_inc/curr_idle_0A.csv')	*** MA current NA, might need to add "R" at end of src
*** idle current
		.param pwl_file_quiet = str('./hspice_inc/curr_quiet_30us.txt.csv')

*** filter for measurement
.subckt meas_filter
+ pin_in  ref_gnd 	hf  lf

E_meas pin_meas ref_gnd  pin_in ref_gnd	1.0

C_hf pin_meas	hf  	160.p
R_hf hf         ref_gnd 1k

R_lf pin_meas	lf		1k
C_lf lf 		ref_gnd	160.p
.ends meas_filter

	***** define die model *****
.subckt model_die_lumped_nne_tile
	+ pin_bump ref_gnd C_die=100n R_die_1=1.25m R_die_2=RESMIN R_leak=0.84	pwl_file_in = str(pwl_file_quiet) delay = 0.

	R_die_1_ 	pin_bump	2	R_die_1
	R_die_2_	2		3	R_die_2
	C_die_		3		ref_gnd	C_die
	R_leak_		pin_bump	ref_gnd	R_leak
	IcurrSrc	pin_bump	ref_gnd	PWL pwlfile = str(pwl_file_in) td = delay    *** add 'R' if repeat
.ends

.inc ./hspice_inc/cpm_nne_240724_modelOnly.sp		*** 4x8 parition
.inc ./hspice_inc/cpm_nne_240523_modelOnly.spice
* .inc ./hspice_inc/cpm_nne_4x2_240313.sp 			*** Andes 4x2 CPM model 240313
* .inc ./hspice_inc/cpm_nne_240426_Redu_IdEM.cir		*** 240426 CPM reduced model
* .inc ./hspice_inc/cpm_maual_appx_nne_4x2_240317.sp	*** jgwei 4x2 CPM manual mockup based on CPM

	***** define pkg model *****
	* .inc ./hspice_inc/nne_pkg_230329_FCBGA_L12_mammoth_20230525ate_a_IdEM.cir	***  0526 Andes pkg w/ 28 + 35 DSC
* .inc ./hspice_inc/Mam_MCM_L12_231215_mod40_jgwei_s72_IdEM.cir				*** 231220 Andes pkg, POR
	* .inc ./hspice_inc/ipd_partial_w_Ports_manip_IdEM_0p0001_wt0p5.cir		*** 240109 Zijie pkg w/ IPD
	*.inc ./hspice_inc/ecap_diff_dist_manip_order8_fixDC_s249p.cir			*** 240110 Zijie pkg w/ 3x diff Ecap + 1x embeded Ecap
	* .inc  ./hspice_inc/dsc_lsc_0111_2_manip_order8_0p5wt.cir				*** 240112 Zijie pkg w/ LSC, DSC, L&R DSC
    * .inc  ./hspice_inc/Mam_MCM_L12_231215c_mod48_NNE_02_IdEM.cir			*** 240118 Andes pkg
	.inc  ./hspice_inc/nne_ecap_dsc_IdEM.cir								*** 240131 Zijie pkg mockup w/ DSC and embedded Ecap
	.inc  ./hspice_inc/NNE_pkg_redu_240131_ZijiePkg_Ecap_Disabled_s2p_IdEM.cir	*** reduced model of "240131 Zijie pkg mockup w/ DSC and embedded Ecap"
	.inc  ./hspice_inc/NNE_pkg_redu_240131_ZijiePkg_Ecap_Enabled_s2p_IdEM.cir	*** reduced model of "240131 Zijie pkg mockup w/ DSC and embedded Ecap", with Ecap enabled
	.inc  ./hspice_inc/Mam_MCM_L12_BH9_Ballv0p83_BPIv0071_20240124_3_20240216ate_b_IdEM.cir  	*** 240222 Andes pkg 140um pitch
	.inc  ./hspice_inc/nne_6x_ecap_0307_2__w_ecap_redu_1e_4_order18_IdEM_s2p.cir	*** 240311 Zijie pkg w/ 6x EC2047 cap model, 140um pitch, reduced model
	.inc  ./hspice_inc/nne_6x_ecap_0307_2__w_12xFeC2072ecap_redu_IdEM_s2p.cir		*** 240311 Zijie pkg w/ 12x Fec2072 cap model, 140um pitch, reduced model

	.inc ./hspice_inc/nne_4x2_Andes_redu_IdEM.cir 		*** Andes 140um 4x2 + bga model, MLCC only
	.inc ./hspice_inc/nne_4x2_6xEC2047_redu_IdEM.cir 	*** 240311 Zijie pkg w/ 6x EC2047 cap model, 140um pitch, 4x2 + bga model
	.inc ./hspice_inc/nne0415_cut_IdEM.cir 				*** 240416 Andes new pkg, total system DCR 0.215mOhm
	.inc ./hspice_inc/nne0415_cut_Redu_IdEM_s9p_v2.cir		*** 240416 Andes new pkg reduced (for comparison with simplis)
	.inc ./hspice_inc/nne0415_cut_Redu_2BgaGrp_IdEM.cir		*** 240506 Andes 240415 pkg, 2 ports for BGA
	.inc ./hspice_inc/nne0415_cut_BGAgrpX6_v2_IdEM.cir		*** 240510 Andes 240415 pkg, 6 ports for BGA
	.inc ./hspice_inc/nne0415_cut_Redu_6BGAGrpTo1BGAGrp_IdEM.cir	*** 240510 Andes 240415 pkg, 6 ports for BGA ==> merge to 1 BGA
	.inc ./hspice_inc/NNE_pkg_240522_DSC_tdk_3t_reduModel_IdEM.cir	*** 240522 Andes pkg, reduced model
	.inc ./hspice_inc/NNE_pkg_240725_reduModel_IdEM.cir		*** 240725 for the new 4x8 CPM, create this reduced model with 8+4 ports for NNE
	.inc ./hspice_inc/Z_plot_NNE_pkg_ReduceModel_4x8_to_4x2_240821_IdEM.cir		*** 240821 Andes 4x8 pkg cir, jgwei reduced model

	***** define PCB model *****
		* .inc ./hspice_inc/MAMMOTH_PCB_231031_3_NNE_LFmanip_IdEM.cir					*** 1101, version, SoC bulk caps added vias
		*.inc ./hspice_inc/ACM3_122323_nne_cut_manip_IdEM_s377p.cir					*** 231221 ACM3 PCB,   240126, accuracy not good btw 1~40MHz,  DO NOT USE
	.inc ./hspice_inc/ACM3_122323_nne_cut_reduce_v2_manip_s5p.cir				*** 231221 ACM3 PCB, reduced to 5 ports
		* .inc ./hspice_inc/ACM3_NEWLAYOUT_01_30_4_3uF_4Phase_half10uFCAPSrev3_manip_IdEM.cir		*** 240131 ACM3 PCB, Kavoos provided reduced PCB model, w/ 10uF, and 1uF caps; do NOT use due to LF noise near 500kHz
	.inc ./hspice_inc/ACM3_notoplayer_10_100uF_10_220uF_IdEM.cir				*** Kavoos 240216 ACM3, 10uF, w/ 20x bulk caps
	.inc ./hspice_inc/ACM3_notoplayer_no_10_100uF_10_220uF_IdEM.cir				*** Kavoos 240216 ACM3, 10uF, w/o 20x bulk caps
	.inc ./hspice_inc/ACM3_bulk_top_and_centerbottom_caps_IdEM.cir				*** Kavoos 240221 ACM3, only top side caps, bulk caps, 66 back side caps
	.inc ./hspice_inc/acm3_nne_240320_discrt_105C_IdEM.cir						*** jgwei 240314 ACM3, 105C,
	.inc ./hspice_inc/acm3_nne_240320_discrt_105C_No100uF_IdEM.cir				*** jgwei 240314 ACM3, 105C, no 100uF
		.inc ./hspice_inc/ACM3_105C_3_14_24_IdEM.cir								*** Kavoos 240314 ACM3 105C pcb
	.inc ./hspice_inc/acm3_nne_240320_discrt_105C_vf_no100uF_341x10uF_w_IVRports_manip_IdEM.cir	*** 240324 ACM3 105C, no 100uF, vertical feeding, 341x10uF caps
	.inc ./hspice_inc/ACM3_04172024_NNE_PDN_220uF_IdEM.cir						*** ACM3 240417, 10x220uF, 105C
	.inc ./hspice_inc/ACM3_05032024_NNE_PDN_jgwei_noBulk_Bga2Grp_s6p_IdEM.cir				*** ACM3 240503, only 10uF and 22uF, no bulkCap, originally for SIMPLIS sim, 2 BGA grps
	.inc ./hspice_inc/ACM3_05032024_NNE_PDN_jgwei_noBulk_Bga3Grp_IdEM.cir					*** ACM3 240503, only 10uF and 22uF, no bulkCap, originally for SIMPLIS sim, 3 BGA grps
	.inc ./hspice_inc/ACM3_05032024_NNE_PDN_BGAgrpX6_IdEM.cir								*** ACM3 240503, only 10uF and 22uF, no bulkCap, originally for SIMPLIS sim, 6 BGA grps
	.inc ./hspice_inc/ACM3_05032024_NNE_PDN_BGAgrpX6_trunc_25MHz_0x100uF_manip_IdEM.cir
	.inc ./hspice_inc/ACM3_05032024_NNE_PDN_BGAgrpX6_trunc_25MHz_0x100uF_0x22uF_manip_IdEM.cir

					***

	****** define reduced model *****
	* .inc ./hspice_inc/Z_NNE_all_reducedModel_240202_manip_IdEM.cir

*************************************** Input params **************************
.param Vdd 	= 0.775

.param is_use_ecap_ebed = 0		*** value: 0 or 1, note: this could be baked in pkg model
.param is_MIM 			= 0

.param die_model_sig 	= 0		*** value: 0 if multi grp model, 1 if single die grp model
.param single_bga_grp 	= 0		*** value: 0 if use multiple BGA grps, 1 if use single BGA grp

.param is_use_3T_cap_ft = 1		*** value: 0 or 1, note: this could be baked in pkg model

.param induct_eqvlnt_r =  0.m   *** DCR of inductor of ALL phases, use 0.0m if PMIC_opt ==3, use 0.07m if run ideal voltage src
.param PMIC_opt = 3				*** 1: ideal voltage src; 2:ideal voltage src w/ VCVS feedback; 3: voltage src using pwl
*** NOTE: ONLY applicable if PMIC_opt == 3
.param volt_src = str('./hspice_inc/volt_profile_adi_240327_25us.txt.csv')		*** for PMIC delay test only

* .param volt_src = str('./hspice_inc/vout_simplis_2mS_6xBGA_pkg240521.csv')
* .param volt_src = str('./hspice_inc/volt_src_Unit_s_V_nne_2mS_6xBGA_240519_fr_simplis.csv')
* .param volt_src = str('./hspice_inc/volt_src_Unit_s_V_nne_2mS_Ecap_240517_fr_simplis.csv')
* .param volt_src = str('./hspice_inc/volt_src_Unit_s_V_nne_2mS_240517_fr_simplis.csv')
* .param volt_src = str('./hspice_inc/volt_src_Unit_s_V_nne_240518_fr_simplis.csv')
.param Vdd_shift_fr_pwl = 0.0

	*** not used when CPM is enabled
	.para Cdie_coeff = 1.0				*** ONLY multi grp controlling, use 1.0 if no Cdie scaling, use 3.62 for NNE if MIM cap is added,
	.para Rdie_coeff = 1.0				*** Rdie is constant 1. , rather than scaled by '1./Cdie_coeff'

	*** Cdie Rdie based on MAM-242, tau = 24.26 (excluding MIM)
	.param Cdie_PA 	= '130.3n * Cdie_coeff'
	.param Cdie_MA 	= '101.7n * Cdie_coeff'
	.param Rdie_PA 	= '0.186m * Rdie_coeff'
	.param Rdie_MA 	= '0.239m * Rdie_coeff'
	.param Rleak 	= 0.84

		* .param r_grid = 52e6.m			*** only applied when multi grp model, i.e. die_model_sig = 0

.param is_ac_run = 0		*** 1 if impedance, 0 if transient

.param tStep	= 10.p
.param tStop	= 25.u  * 400.u

.param td_delay = 0.n

*************************************** End of User Input params **************

*************************************** cap model *****************************
.inc /data/home/jiangongwei/work/cap_models.hsp

*************************************** PMIC **********************************
*** ref_gnd def.
Vref_gnd 	ref_gnd		0	0.										*** normal gnd

.subckt PMIC_model
+ pin_out ref_gnd fdbk_node opt = 1 vdd_pmic = 0.75 Vdd_shift= 0.0 t_delay = 0.n pwl_volt_in = str(volt_src)
	*** opt 1/3 ideal voltage src
		.if (opt == 1)
			VshortPMIC	pin_out	ref_gnd	vdd_pmic
		.endif
	*** opt 2/3, add feedback
		.if (opt == 2)
			VshortPMIC_ref	pin_out_tmp	0 	vdd_pmic	*** ref contant voltage src

			VshortPMIC	pin_out	pin_tmp	vdd_pmic
			E_fdbk	    pin_tmp	ref_gnd VCVS DELAY pin_out_tmp fdbk_node  TD=0.n			*** VCVS to model feedback using low freq signal
		.endif
	*** opt 3/3 voltage src waveform w/ shift
		.if (opt == 3)
			Vpmic_wf     pin_out  pin_tmp  Vdd_shift					*** NOTE: shift waveform by constant voltage in V., use 0.0 if no shift
			Vpmic_wf_pwl pin_tmp  ref_gnd PWL pwlfile = str(pwl_volt_in)   td = t_delay
		.endif
	***
.ends

*** opt 1 ideal PMIC w/o remote sense feedback
.if ( 1 )
	xblk_PMIC pmic_pwr_raw ref_gnd pkg_bump_PA_ns_3_lf PMIC_model
	+ opt = 'PMIC_opt'  vdd_pmic = 'Vdd' 	Vdd_shift = 'Vdd_shift_fr_pwl'		t_delay = 0.u 	pwl_volt_in = str(volt_src)
.endif
*** opt 2 EMpower simplified IVR equivalent model 	(remember to disable PMIC bulk caps on PCB)
.if ( 0 )
	VempowerVS	pmicEMpwrNode1	ref_gnd	Vdd		*** can be switched to PMIC model
	LempowerVS1  pmicEMpwrNode1  pmicEMpwrNode2  	'0.027778n * 0.9091'
	RempowerVS1  pmicEMpwrNode2  pmic_pwr_raw			50.u
.endif

*** add inductor btw ideal volt src and PDN
* .param per_ind_L	= 32.n
* .param per_ind_R	= 0.28m

.param per_ind_L	= 17.n
.param per_ind_R	= 0.3m

r_ind_pmic_0 pmic_pwr_raw pmic_pwr_0_tmp 	per_ind_R
L_ind_pmic_0 pmic_pwr_0_tmp pmic_pwr_0  	per_ind_L
r_ind_pmic_1 pmic_pwr_raw pmic_pwr_1_tmp 	per_ind_R
L_ind_pmic_1 pmic_pwr_1_tmp pmic_pwr_1  	per_ind_L
r_ind_pmic_2 pmic_pwr_raw pmic_pwr_2_tmp 	per_ind_R
L_ind_pmic_2 pmic_pwr_2_tmp pmic_pwr_2  	per_ind_L
r_ind_pmic_3 pmic_pwr_raw pmic_pwr_3_tmp 	per_ind_R
L_ind_pmic_3 pmic_pwr_3_tmp pmic_pwr_3  	per_ind_L

*************************************** Socket ********************************
Rskt	bga_pcb		bga_pkg		1.n				*** can add socket model

																									.if ( 0 )  	***  test reduced PCB+pkg for SIMPLIS  ==> low accuracy, do NOT use
																										Xblk_PCB
																										+ pkg_bump_one
																										+ pmic_pwr
																										+ pmic_pwr
																										+ pmic_pwr
																										+ pmic_pwr
																										+ ref_gnd
																										+ NNE_pkg_PCB_ACM3Kavoos_w_bulk_redu_240216_s5p_IdEM
																									.endif 		***  test reduced PCB+pkg for SIMPLIS end

*************************************** PCB ***********************************
					*** debug to skip PCB
					* R_short_pcb bga_pcb 	pmic_pwr	1.n

.if ( 1 )		***  ACM3 PCB, reduced to 5 ports
	*** 6 BGA ports
	.if (single_bga_grp != 1)
		Xblk_PCB
		+ bga_pcb_0
		+ pmic_pwr_0
		+ pmic_pwr_1
		+ pmic_pwr_2
		+ pmic_pwr_3
		+ bga_pcb_1
		+ bga_pcb_2
		+ bga_pcb_3
		+ bga_pcb_4
		+ bga_pcb_5
		+ ref_gnd
		+ ACM3_05032024_NNE_PDN_BGAgrpX6_IdEM
		* + ACM3_05032024_NNE_PDN_BGAgrpX6_trunc_25MHz_0x100uF_manip_IdEM		***
		* + ACM3_05032024_NNE_PDN_BGAgrpX6_trunc_25MHz_0x100uF_0x22uF_manip_IdEM ***
	.endif

				* *** S-para (only for AC sim)
				* .model pcb_spara_model S
				* + TSTONEFILE = '/data/home/jiangongwei/work/PDN_core/hspice_inc/ACM3_05032024_NNE_PDN_BGAgrpX6.s10p'
				* + FMAX= 1G

				* S_blk_PCB
				* + bga_pcb_0
				* + pmic_pwr
				* + pmic_pwr
				* + pmic_pwr
				* + pmic_pwr
				* + bga_pcb_1
				* + bga_pcb_2
				* + bga_pcb_3
				* + bga_pcb_4
				* + bga_pcb_5
				* + ref_gnd
				* + mname = pcb_spara_model
				* ***

.endif 		*** end of ACM3 PCB, reduced to 5 ports

*************************************** Pkg ***********************************
.if ( 1 ) 	*** 240522 Andes pkg DSC, reduced model in ADS , PA west MA east
	.if (single_bga_grp != 1)
		Xblk_pkg
		+ pkg_bump_MA_ns_0
		+ pkg_bump_MA_ns_1
		+ pkg_bump_MA_ns_2
		+ pkg_bump_MA_ns_3
		+ pkg_bump_PA_ns_0
		+ pkg_bump_PA_ns_1
		+ pkg_bump_PA_ns_2
		+ pkg_bump_PA_ns_3
		+ bga_pcb_0
		+ bga_pcb_1
		+ bga_pcb_2
		+ bga_pcb_3
		+ bga_pcb_4
		+ bga_pcb_5
		+ ref_gnd
		* + NNE_pkg_240522_DSC_tdk_3t_reduModel_IdEM
		+ Z_plot_NNE_pkg_ReduceModel_4x8_to_4x2_240821_IdEM

								* Xblk_pkg	*** 8+4 NNE grp
								* + pkg_bump_MA_ns_0
								* + pkg_bump_MA_ns_1
								* + pkg_bump_MA_ns_2
								* + pkg_bump_MA_ns_3
								* + pkg_bump_PA_ns_0
								* + pkg_bump_PA_ns_1
								* + pkg_bump_PA_ns_2
								* + pkg_bump_PA_ns_3
								* + bga_pcb_0
								* + bga_pcb_1
								* + bga_pcb_2
								* + bga_pcb_3
								* + bga_pcb_4
								* + bga_pcb_5
								* + pkg_bump_PA_ns_0_edge
								* + pkg_bump_PA_ns_1_edge
								* + pkg_bump_PA_ns_2_edge
								* + pkg_bump_PA_ns_3_edge
								* + ref_gnd
								* + NNE_pkg_240725_reduModel_IdEM
	.endif

	*** Ecap embedded, NOTE: this is just mock up, NOT real connection, connected on bumps, Optimistic !!
		.if ( is_use_ecap_ebed == 1 )  *** use ecap embed
			xECAP_16600nF_core_2
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_3_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ pkg_bump_PA_ns_2_
			+ ref_gnd
			+ str(siCap_empwr_EC1005_16600nF)

			*** NOTE:  mouting L and R based on 24/1/31 Zijie layout w/ Ecap
			r_ecap_EC1005_half_2 	pkg_bump_PA_ns_2_		pkg_bump_PA_ns_2_tmp	6.u
			l_ecap_EC1005_half_2    pkg_bump_PA_ns_2_tmp	pkg_bump_PA_ns_2		4.p
			r_ecap_EC1005_half_3 	pkg_bump_PA_ns_3_		pkg_bump_PA_ns_3_tmp	6.u
			l_ecap_EC1005_half_3    pkg_bump_PA_ns_3_tmp	pkg_bump_PA_ns_3		4.p

		.endif

.endif

*************************************** Die ***********************************
*** approach 1: multi grp modeling
.if (die_model_sig != 1 )

	* xblk_die
	* +         pkg_bump_MA_ns_0
	* + ref_gnd pkg_bump_MA_ns_1
	* + ref_gnd pkg_bump_MA_ns_2
	* + ref_gnd pkg_bump_MA_ns_3
	* + ref_gnd pkg_bump_PA_ns_0
	* + ref_gnd pkg_bump_PA_ns_1
	* + ref_gnd pkg_bump_PA_ns_2
	* + ref_gnd pkg_bump_PA_ns_3
	* + ref_gnd
	* * + adsPowerModel
	* + adsPowerModel_nne_240523

	* IcurrSrc_0_0	pkg_bump_MA_ns_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R 	*** add 'R' if repeat
	* IcurrSrc_0_1	pkg_bump_MA_ns_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R
	* IcurrSrc_0_2	pkg_bump_MA_ns_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R
	* IcurrSrc_0_3	pkg_bump_MA_ns_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R

	* IcurrSrc_1_0	pkg_bump_PA_ns_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay   R
	* IcurrSrc_1_1	pkg_bump_PA_ns_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay   R
	* IcurrSrc_1_2	pkg_bump_PA_ns_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay   R
	* IcurrSrc_1_3	pkg_bump_PA_ns_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= td_delay   R

						* xblk_die		*** reduced CPM, to correlate with SIMPLIS, good accuracy confirmed
						* + pkg_bump_PA_ns_3
						* + pkg_bump_PA_ns_2
						* + pkg_bump_PA_ns_1
						* + pkg_bump_PA_ns_0
						* + pkg_bump_MA_ns_3
						* + pkg_bump_MA_ns_2
						* + pkg_bump_MA_ns_1
						* + pkg_bump_MA_ns_0
						* + ref_gnd
						* + cpm_nne_240426_Redu_IdEM

							* xblk_die 	*** 8+4 NNE grp
							* +         pkg_bump_MA_ns_0
							* + ref_gnd pkg_bump_MA_ns_1
							* + ref_gnd pkg_bump_MA_ns_2
							* + ref_gnd pkg_bump_MA_ns_3
							* + ref_gnd pkg_bump_MA_ns_0
							* + ref_gnd pkg_bump_MA_ns_1
							* + ref_gnd pkg_bump_MA_ns_2
							* + ref_gnd pkg_bump_MA_ns_3
							* + ref_gnd pkg_bump_MA_ns_0
							* + ref_gnd pkg_bump_MA_ns_1
							* + ref_gnd pkg_bump_MA_ns_2
							* + ref_gnd pkg_bump_MA_ns_3
							* + ref_gnd pkg_bump_MA_ns_0
							* + ref_gnd pkg_bump_MA_ns_1
							* + ref_gnd pkg_bump_MA_ns_2
							* + ref_gnd pkg_bump_MA_ns_3
							* + ref_gnd pkg_bump_PA_ns_0
							* + ref_gnd pkg_bump_PA_ns_1
							* + ref_gnd pkg_bump_PA_ns_2
							* + ref_gnd pkg_bump_PA_ns_3
							* + ref_gnd pkg_bump_PA_ns_0
							* + ref_gnd pkg_bump_PA_ns_1
							* + ref_gnd pkg_bump_PA_ns_2
							* + ref_gnd pkg_bump_PA_ns_3
							* + ref_gnd pkg_bump_PA_ns_0
							* + ref_gnd pkg_bump_PA_ns_1
							* + ref_gnd pkg_bump_PA_ns_2
							* + ref_gnd pkg_bump_PA_ns_3
							* + ref_gnd pkg_bump_PA_ns_0_edge
							* + ref_gnd pkg_bump_PA_ns_1_edge
							* + ref_gnd pkg_bump_PA_ns_2_edge
							* + ref_gnd pkg_bump_PA_ns_3_edge
							* + ref_gnd
							* + adsPowerModel_nne_240724

							* IcurrSrc_0_0	pkg_bump_MA_ns_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R 	*** add 'R' if repeat
							* IcurrSrc_0_1	pkg_bump_MA_ns_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R
							* IcurrSrc_0_2	pkg_bump_MA_ns_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R
							* IcurrSrc_0_3	pkg_bump_MA_ns_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R

							* IcurrSrc_1_0	pkg_bump_PA_ns_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_nonEdge)  td= td_delay   R
							* IcurrSrc_1_1	pkg_bump_PA_ns_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_nonEdge)  td= td_delay   R
							* IcurrSrc_1_2	pkg_bump_PA_ns_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_nonEdge)  td= td_delay   R
							* IcurrSrc_1_3	pkg_bump_PA_ns_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_nonEdge)  td= td_delay   R

							* IcurrSrc_2_0	pkg_bump_PA_ns_3_edge	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_Edge)  td= td_delay   R
							* IcurrSrc_2_1	pkg_bump_PA_ns_2_edge	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_Edge)  td= td_delay   R
							* IcurrSrc_2_2	pkg_bump_PA_ns_1_edge	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_Edge)  td= td_delay   R
							* IcurrSrc_2_3	pkg_bump_PA_ns_0_edge	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA_Edge)  td= td_delay   R

	xblk_die 	*** 8+4 NNE grp, 240821 sign off
	+         pkg_bump_MA_ns_0
	+ ref_gnd pkg_bump_MA_ns_1
	+ ref_gnd pkg_bump_MA_ns_2
	+ ref_gnd pkg_bump_MA_ns_3
	+ ref_gnd pkg_bump_MA_ns_0
	+ ref_gnd pkg_bump_MA_ns_1
	+ ref_gnd pkg_bump_MA_ns_2
	+ ref_gnd pkg_bump_MA_ns_3
	+ ref_gnd pkg_bump_MA_ns_0
	+ ref_gnd pkg_bump_MA_ns_1
	+ ref_gnd pkg_bump_MA_ns_2
	+ ref_gnd pkg_bump_MA_ns_3
	+ ref_gnd pkg_bump_MA_ns_0
	+ ref_gnd pkg_bump_MA_ns_1
	+ ref_gnd pkg_bump_MA_ns_2
	+ ref_gnd pkg_bump_MA_ns_3
	+ ref_gnd pkg_bump_PA_ns_0
	+ ref_gnd pkg_bump_PA_ns_1
	+ ref_gnd pkg_bump_PA_ns_2
	+ ref_gnd pkg_bump_PA_ns_3
	+ ref_gnd pkg_bump_PA_ns_0
	+ ref_gnd pkg_bump_PA_ns_1
	+ ref_gnd pkg_bump_PA_ns_2
	+ ref_gnd pkg_bump_PA_ns_3
	+ ref_gnd pkg_bump_PA_ns_0
	+ ref_gnd pkg_bump_PA_ns_1
	+ ref_gnd pkg_bump_PA_ns_2
	+ ref_gnd pkg_bump_PA_ns_3
	+ ref_gnd pkg_bump_PA_ns_0
	+ ref_gnd pkg_bump_PA_ns_1
	+ ref_gnd pkg_bump_PA_ns_2
	+ ref_gnd pkg_bump_PA_ns_3
	+ ref_gnd
	+ adsPowerModel_nne_240724

	IcurrSrc_0_0	pkg_bump_MA_ns_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R 	*** add 'R' if repeat
	IcurrSrc_0_1	pkg_bump_MA_ns_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R
	IcurrSrc_0_2	pkg_bump_MA_ns_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R
	IcurrSrc_0_3	pkg_bump_MA_ns_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_MA)  td= 0.   R

	IcurrSrc_1_0	pkg_bump_PA_ns_3	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= 0.   R
	IcurrSrc_1_1	pkg_bump_PA_ns_2	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= 0.   R
	IcurrSrc_1_2	pkg_bump_PA_ns_1	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= 0.   R
	IcurrSrc_1_3	pkg_bump_PA_ns_0	ref_gnd	PWL  pwlfile = str(pwl_file_in_PA)  td= 0.   R

	*** R_leak ***

										*** test to short bumps to PCB
											* R_0_bump_merge pkg_bump_one	pkg_bump_MA_ns_3	1.n
											* R_1_bump_merge pkg_bump_one	pkg_bump_MA_ns_2	1.n
											* R_2_bump_merge pkg_bump_one	pkg_bump_MA_ns_1	1.n
											* R_3_bump_merge pkg_bump_one	pkg_bump_MA_ns_0	1.n
											* R_4_bump_merge pkg_bump_one	pkg_bump_PA_ns_3	1.n
											* R_5_bump_merge pkg_bump_one	pkg_bump_PA_ns_2	1.n
											* R_6_bump_merge pkg_bump_one	pkg_bump_PA_ns_1	1.n
											* R_7_bump_merge pkg_bump_one	pkg_bump_PA_ns_0	1.n

											* R_bump_to_PCB  pkg_bump_one bga_pcb	1.n
										*** test to short bumps to PCB   end

	.if (is_MIM == 1)
		C_MIM_bump_0_0 pkg_bump_MA_ns_3	ref_gnd	273.3n
		C_MIM_bump_0_1 pkg_bump_MA_ns_2	ref_gnd	273.3n
		C_MIM_bump_0_2 pkg_bump_MA_ns_1	ref_gnd	273.3n
		C_MIM_bump_0_3 pkg_bump_MA_ns_0	ref_gnd	273.3n

		C_MIM_bump_1_0 pkg_bump_PA_ns_3	ref_gnd	334.1n
		C_MIM_bump_1_1 pkg_bump_PA_ns_2	ref_gnd	334.1n
		C_MIM_bump_1_2 pkg_bump_PA_ns_1	ref_gnd	334.1n
		C_MIM_bump_1_3 pkg_bump_PA_ns_0	ref_gnd	334.1n
	.endif

					* Xblk_die_0_0	pkg_bump_MA_ns_3	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
					* Xblk_die_0_1	pkg_bump_MA_ns_2	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
					* Xblk_die_0_2	pkg_bump_MA_ns_1	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
					* Xblk_die_0_3	pkg_bump_MA_ns_0	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_MA'	R_die_1= 'Rdie_MA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_MA)
					* Xblk_die_1_0	pkg_bump_PA_ns_3	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 1500.p
					* Xblk_die_1_1	pkg_bump_PA_ns_2	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 1000.p
					* Xblk_die_1_2	pkg_bump_PA_ns_1	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p		* 500.p
					* Xblk_die_1_3	pkg_bump_PA_ns_0	ref_gnd	model_die_lumped_nne_tile	C_die= 'Cdie_PA'	R_die_1= 'Rdie_PA' 	R_die_2= 1.e-5	R_leak= 'Rleak'		pwl_file_in = str(pwl_file_in_PA) delay = 0.p

.endif
*** approach 1: multi grp modeling END

*** approach 2: single grp modeling

*** approach 2: single grp modeling	END

X_probe_filter10
+ pkg_bump_PA_ns_3
+ ref_gnd
+ pkg_bump_PA_ns_3_hf
+ pkg_bump_PA_ns_3_lf
+ meas_filter

X_probe_filter13
+ pkg_bump_PA_ns_0
+ ref_gnd
+ pkg_bump_PA_ns_0_hf
+ pkg_bump_PA_ns_0_lf
+ meas_filter

.if (single_bga_grp !=1 )
	X_probe_filter_bga_0
	+ bga_pcb_0
	+ ref_gnd
	+ bga_pcb_0_hf
	+ bga_pcb_0_lf
	+ meas_filter
.endif
.if (single_bga_grp ==1 )
	X_probe_filter_bga
	+ bga_pcb
	+ ref_gnd
	+ bga_pcb_hf
	+ bga_pcb_lf
	+ meas_filter
.endif

*************************************** Analysis I: AC simulation *************
.if ( is_ac_run == 1 )
	.if ( 1 )
		*** NOTE: DO not include port def if tran analysis later
		P1 pkg_bump_MA_ns_3	ref_gnd	port=1	z0 = 0.1
		P2 pkg_bump_MA_ns_2	ref_gnd	port=2	z0 = 0.1
		P3 pkg_bump_MA_ns_1	ref_gnd	port=3	z0 = 0.1
		P4 pkg_bump_MA_ns_0	ref_gnd	port=4	z0 = 0.1
		P5 pkg_bump_PA_ns_3	ref_gnd	port=5	z0 = 0.1
		P6 pkg_bump_PA_ns_2	ref_gnd	port=6	z0 = 0.1
		P7 pkg_bump_PA_ns_1	ref_gnd	port=7	z0 = 0.1
		P8 pkg_bump_PA_ns_0	ref_gnd	port=8	z0 = 0.1

		.lin 	sparcalc=1 	filename=impedance_plot	noisecalc=0 	gdcalc=0	format=touchstone 	dataformat=MA
		**.probe  ac s11(db) s11(p) s21(db) s21(p)
		.probe ac zin(1)(m) zin(1)(p) zin(5)(m) zin(5)(p) zin(8)(m) zin(8)(p)

		.ac 	dec 50 1. 1.G

	.endif

	.if ( 0 )
		*i_ac_pkg_bump_0_0 pkg_bump_MA_ns_3 ref_gnd dc=0 ac=-1.
		* .probe ac v(pkg_bump_MA_ns_3)

		i_ac_pkg_bump_1_0 pkg_bump_PA_ns_3 ref_gnd dc=0 ac=-1.
		.probe ac v(pkg_bump_PA_ns_3)	vi(pkg_bump_PA_ns_3)	vr(pkg_bump_PA_ns_3)

		.ac 	dec 50 1. 1.G

		* .param v_imag = vi(pkg_bump_PA_ns_3)
		* .param acl = 'v_imag / 2./pi '
		* .print 'vi(pkg_bump_PA_ns_3) / 2. '		*** works
				* .print 'vi(pkg_bump_PA_ns_3) / pi '						*** NOT work
				* .measure ac ACL param = 'vi(pkg_bump_PA_ns_3) / 2.'		*** NOT work

		.param pfreq = 100.e6
		.param dfreq = 10.e6
		.measure ac zval_1   find vi(pkg_bump_PA_ns_3)	at = 'pfreq - dfreq '
		.measure ac zval_2   find vi(pkg_bump_PA_ns_3)	at = 'pfreq + dfreq '
		.measure ac acl      param='(zval_2 - zval_1)/2./pi/(dfreq+dfreq)'

	.endif

.endif

*************************************** Analysis II: Transient simulation *****
.if ( is_ac_run != 1 )
	.tran tStep tSTOP

	.probe tran v(pkg_bump_PA_ns_3) v(pkg_bump_PA_ns_0) v(pkg_bump_MA_ns_3) v(pkg_bump_MA_ns_0)
	.probe tran v(pkg_bump_PA_ns_3_edge) v(pkg_bump_PA_ns_0_edge)
	.probe tran v(bga_pkg) v(bga_pcb) v(bga_pcb_0) v(bga_pcb_1) v(bga_pcb_2) v(bga_pcb_3) v(bga_pcb_4) v(bga_pcb_5)
	.probe tran v(bga_pcb_0_hf) v(bga_pcb_0_lf) v(bga_pcb_hf) v(bga_pcb_lf)

	* .probe tran v(pkg_bump_PA_ns_2) v(pkg_bump_PA_ns_1)
	.probe tran v(pkg_bump_PA_ns_3_hf)  v(pkg_bump_PA_ns_3_lf)
	.probe tran v(pkg_bump_PA_ns_0_hf)  v(pkg_bump_PA_ns_0_lf)
	.probe tran v(pmic_pwr)

	.probe x(Xblk_die_1_0.pin_bump)	x(Xblk_PCB.a_1)	x(Xblk_pkg.a_1)
	.probe x(Xblk_pkg.a_9)  x(Xblk_pkg.a_10)   x(Xblk_pkg.a_11) x(Xblk_pkg.a_12)  x(Xblk_pkg.a_13)   x(Xblk_pkg.a_14)
	.probe x(xblk_PMIC.pin_out)

	* .param vdd_meas_start = 0.u
	* .param vdd_meas_end   = 3.u      ** 50.u
	* .meas tran pkg_bump_1_0_p2p 		PP	V(pkg_bump_PA_ns_3)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmax	MAX	V(pkg_bump_PA_ns_3)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmin	MIN	V(pkg_bump_PA_ns_3)	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmax_t	WHEN	V(pkg_bump_PA_ns_3) = 'pkg_bump_1_0_cpu_vmax' 	from='vdd_meas_start' to='vdd_meas_end'
	* .meas tran pkg_bump_1_0_cpu_vmin_t	WHEN	V(pkg_bump_PA_ns_3) = 'pkg_bump_1_0_cpu_vmin' 	from='vdd_meas_start' to='vdd_meas_end'

	*.probe i(*)
	*.probe x(*)

.endif
