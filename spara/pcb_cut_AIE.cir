**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 22-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Tue Apr 22 09:49:36 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Tue Apr 22 09:49:36 2025
**
**  Modal data exported
**  Port[1] = PORT_5_L29_SOC_VNPU_Group_U43_GND_Group
**  Port[2] = PORT_6_U1_SOC_VNPU_Group_U1_GRP_1_1_GND
**  Port[3] = SOC_VNPU_C483_1
**  Port[4] = SOC_VNPU_C484_1
**  Port[5] = SOC_VNPU_C486_1
**  Port[6] = SOC_VNPU_C487_1
**  Port[7] = SOC_VNPU_C488_1
**  Port[8] = SOC_VNPU_C489_1
**  Port[9] = SOC_VNPU_C556_1
**  Port[10] = SOC_VNPU_C556_3
**  Port[11] = SOC_VNPU_C558_1
**  Port[12] = SOC_VNPU_C558_3
**  Port[13] = SOC_VNPU_C647_1
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_AIE
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 9.5642212853648667e-01
GC_1_2 ref NI_1 NS_2 0 -1.1119044672858640e+00
GC_1_3 ref NI_1 NS_3 0 8.4838681353716294e-01
GC_1_4 ref NI_1 NS_4 0 -7.7099887990989557e-01
GC_1_5 ref NI_1 NS_5 0 -1.6914882709648602e-03
GC_1_6 ref NI_1 NS_6 0 -5.3871660645617581e-01
GC_1_7 ref NI_1 NS_7 0 -8.2501556025827705e-02
GC_1_8 ref NI_1 NS_8 0 1.2082156678972483e-01
GC_1_9 ref NI_1 NS_9 0 -8.8795110717503165e-02
GC_1_10 ref NI_1 NS_10 0 6.9565727234607022e-02
GC_1_11 ref NI_1 NS_11 0 1.5011111333219628e-04
GC_1_12 ref NI_1 NS_12 0 4.5187642853581234e-02
GC_1_13 ref NI_1 NS_13 0 -9.7809799924076971e-02
GC_1_14 ref NI_1 NS_14 0 1.0294243861118037e-01
GC_1_15 ref NI_1 NS_15 0 -1.3189915392204216e-01
GC_1_16 ref NI_1 NS_16 0 8.5653502238051002e-02
GC_1_17 ref NI_1 NS_17 0 1.4977972596211817e-04
GC_1_18 ref NI_1 NS_18 0 4.9558514170471982e-02
GC_1_19 ref NI_1 NS_19 0 -8.0348087997474782e-02
GC_1_20 ref NI_1 NS_20 0 9.9678960650693413e-02
GC_1_21 ref NI_1 NS_21 0 -1.5393742515429173e-02
GC_1_22 ref NI_1 NS_22 0 6.0339132525089510e-02
GC_1_23 ref NI_1 NS_23 0 1.1275302820982453e-04
GC_1_24 ref NI_1 NS_24 0 3.6916220456234022e-02
GC_1_25 ref NI_1 NS_25 0 -8.5173705584541209e-02
GC_1_26 ref NI_1 NS_26 0 1.3104959929574847e-01
GC_1_27 ref NI_1 NS_27 0 5.6827972257087425e-02
GC_1_28 ref NI_1 NS_28 0 3.8677981756644643e-02
GC_1_29 ref NI_1 NS_29 0 7.3000062702841629e-05
GC_1_30 ref NI_1 NS_30 0 2.9247499467810561e-02
GC_1_31 ref NI_1 NS_31 0 -9.2726363968916550e-02
GC_1_32 ref NI_1 NS_32 0 1.0021273053467608e-01
GC_1_33 ref NI_1 NS_33 0 -1.4227664606248636e-01
GC_1_34 ref NI_1 NS_34 0 8.9258756864467215e-02
GC_1_35 ref NI_1 NS_35 0 1.5091573585670961e-04
GC_1_36 ref NI_1 NS_36 0 5.0268499764145581e-02
GC_1_37 ref NI_1 NS_37 0 -8.7997661759115664e-02
GC_1_38 ref NI_1 NS_38 0 1.1481434787656987e-01
GC_1_39 ref NI_1 NS_39 0 -1.0862168310632958e-01
GC_1_40 ref NI_1 NS_40 0 8.3231888657276543e-02
GC_1_41 ref NI_1 NS_41 0 1.2843421734731975e-04
GC_1_42 ref NI_1 NS_42 0 4.5383185680239295e-02
GC_1_43 ref NI_1 NS_43 0 -8.8969175088524408e-02
GC_1_44 ref NI_1 NS_44 0 1.0910221852346853e-01
GC_1_45 ref NI_1 NS_45 0 -1.2366649500582309e-01
GC_1_46 ref NI_1 NS_46 0 8.7111106459710388e-02
GC_1_47 ref NI_1 NS_47 0 1.3757479447066155e-04
GC_1_48 ref NI_1 NS_48 0 4.7133841732284784e-02
GC_1_49 ref NI_1 NS_49 0 -8.9461642049513720e-02
GC_1_50 ref NI_1 NS_50 0 1.0058444873320004e-01
GC_1_51 ref NI_1 NS_51 0 -9.5342722334281982e-02
GC_1_52 ref NI_1 NS_52 0 4.0917762372597630e-02
GC_1_53 ref NI_1 NS_53 0 1.7941127105825669e-04
GC_1_54 ref NI_1 NS_54 0 5.4142401368190346e-02
GC_1_55 ref NI_1 NS_55 0 -7.4224962872939088e-02
GC_1_56 ref NI_1 NS_56 0 7.7582066309278497e-02
GC_1_57 ref NI_1 NS_57 0 -9.5102156255969530e-02
GC_1_58 ref NI_1 NS_58 0 4.5153072441942249e-02
GC_1_59 ref NI_1 NS_59 0 1.5256316819164470e-04
GC_1_60 ref NI_1 NS_60 0 5.4445303105076372e-02
GC_1_61 ref NI_1 NS_61 0 -7.8263352661033625e-02
GC_1_62 ref NI_1 NS_62 0 9.0636076969904222e-02
GC_1_63 ref NI_1 NS_63 0 -8.6515242866074871e-02
GC_1_64 ref NI_1 NS_64 0 4.4528763863783155e-02
GC_1_65 ref NI_1 NS_65 0 1.5303008229908214e-04
GC_1_66 ref NI_1 NS_66 0 5.2442609259559250e-02
GC_1_67 ref NI_1 NS_67 0 -5.0970127666659426e-02
GC_1_68 ref NI_1 NS_68 0 3.7876382368004335e-02
GC_1_69 ref NI_1 NS_69 0 -8.5511469618228003e-02
GC_1_70 ref NI_1 NS_70 0 6.0698540269731975e-02
GC_1_71 ref NI_1 NS_71 0 1.3785426259671344e-04
GC_1_72 ref NI_1 NS_72 0 5.0426323752899772e-02
GC_1_73 ref NI_1 NS_73 0 -5.1540468337112795e-02
GC_1_74 ref NI_1 NS_74 0 5.1025229559038973e-02
GC_1_75 ref NI_1 NS_75 0 5.1280818827382703e-02
GC_1_76 ref NI_1 NS_76 0 7.1789136825840955e-02
GC_1_77 ref NI_1 NS_77 0 1.9764943441903955e-04
GC_1_78 ref NI_1 NS_78 0 2.4071977843126164e-02
GD_1_1 ref NI_1 NA_1 0 6.2442513182919406e+00
GD_1_2 ref NI_1 NA_2 0 2.1454582072692081e-03
GD_1_3 ref NI_1 NA_3 0 4.9584310454166454e-03
GD_1_4 ref NI_1 NA_4 0 4.7404148172695715e-03
GD_1_5 ref NI_1 NA_5 0 3.9242222332340803e-03
GD_1_6 ref NI_1 NA_6 0 5.0388600572999626e-03
GD_1_7 ref NI_1 NA_7 0 4.9118159250207552e-03
GD_1_8 ref NI_1 NA_8 0 5.2707883459921761e-03
GD_1_9 ref NI_1 NA_9 0 6.9509496154141343e-03
GD_1_10 ref NI_1 NA_10 0 5.1524909234639529e-03
GD_1_11 ref NI_1 NA_11 0 5.8395102066899031e-03
GD_1_12 ref NI_1 NA_12 0 4.5484537959436999e-03
GD_1_13 ref NI_1 NA_13 0 6.7570357928566855e-03
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -8.2501556025827649e-02
GC_2_2 ref NI_2 NS_2 0 1.2082156678972479e-01
GC_2_3 ref NI_2 NS_3 0 -8.8795110717503373e-02
GC_2_4 ref NI_2 NS_4 0 6.9565727234607230e-02
GC_2_5 ref NI_2 NS_5 0 1.5011111333221284e-04
GC_2_6 ref NI_2 NS_6 0 4.5187642853581185e-02
GC_2_7 ref NI_2 NS_7 0 7.4281619708293176e+00
GC_2_8 ref NI_2 NS_8 0 -1.1490330847776260e+01
GC_2_9 ref NI_2 NS_9 0 -1.0881204588688780e+00
GC_2_10 ref NI_2 NS_10 0 5.4321512719711362e-02
GC_2_11 ref NI_2 NS_11 0 -3.2316357372786091e-04
GC_2_12 ref NI_2 NS_12 0 -1.4208042474894166e-02
GC_2_13 ref NI_2 NS_13 0 9.4568551258849290e-02
GC_2_14 ref NI_2 NS_14 0 9.6316645331399076e-01
GC_2_15 ref NI_2 NS_15 0 7.6259887711271568e-02
GC_2_16 ref NI_2 NS_16 0 -7.4870166940990565e-02
GC_2_17 ref NI_2 NS_17 0 -4.8719495722559646e-06
GC_2_18 ref NI_2 NS_18 0 -3.4020280619352864e-03
GC_2_19 ref NI_2 NS_19 0 -2.1438673277248087e-02
GC_2_20 ref NI_2 NS_20 0 3.7581527710045637e-01
GC_2_21 ref NI_2 NS_21 0 3.0017619311068217e-01
GC_2_22 ref NI_2 NS_22 0 -6.5734439542371806e-02
GC_2_23 ref NI_2 NS_23 0 5.0642230488491720e-06
GC_2_24 ref NI_2 NS_24 0 -1.1904973082267165e-03
GC_2_25 ref NI_2 NS_25 0 -6.6796924828072424e-02
GC_2_26 ref NI_2 NS_26 0 5.8792487505725632e-01
GC_2_27 ref NI_2 NS_27 0 1.6023660732570413e-01
GC_2_28 ref NI_2 NS_28 0 -2.5277694454087337e-02
GC_2_29 ref NI_2 NS_29 0 1.1386275891081882e-05
GC_2_30 ref NI_2 NS_30 0 -3.8979428479315065e-04
GC_2_31 ref NI_2 NS_31 0 3.2408556204979212e-02
GC_2_32 ref NI_2 NS_32 0 1.0498953226790655e+00
GC_2_33 ref NI_2 NS_33 0 6.9492082292475346e-02
GC_2_34 ref NI_2 NS_34 0 -8.1761942116282418e-02
GC_2_35 ref NI_2 NS_35 0 -7.2735494608579471e-06
GC_2_36 ref NI_2 NS_36 0 -3.4670715536521618e-03
GC_2_37 ref NI_2 NS_37 0 -5.0273337370984517e-01
GC_2_38 ref NI_2 NS_38 0 5.9712835085453442e-01
GC_2_39 ref NI_2 NS_39 0 4.8053766189673236e-01
GC_2_40 ref NI_2 NS_40 0 -1.6221700922685486e-01
GC_2_41 ref NI_2 NS_41 0 -4.0711603294643956e-06
GC_2_42 ref NI_2 NS_42 0 -4.3375336318752437e-04
GC_2_43 ref NI_2 NS_43 0 -4.6379346388260362e-01
GC_2_44 ref NI_2 NS_44 0 7.0123034526827166e-01
GC_2_45 ref NI_2 NS_45 0 4.3037626489789288e-01
GC_2_46 ref NI_2 NS_46 0 -1.5777970841846439e-01
GC_2_47 ref NI_2 NS_47 0 -2.7828419775002548e-05
GC_2_48 ref NI_2 NS_48 0 -1.1096513576034572e-03
GC_2_49 ref NI_2 NS_49 0 -2.0713436477150865e-01
GC_2_50 ref NI_2 NS_50 0 1.0003815768182072e+00
GC_2_51 ref NI_2 NS_51 0 5.5316383230621831e-02
GC_2_52 ref NI_2 NS_52 0 -3.8842918691161125e-02
GC_2_53 ref NI_2 NS_53 0 1.5128565150341865e-07
GC_2_54 ref NI_2 NS_54 0 -1.8790525973552863e-03
GC_2_55 ref NI_2 NS_55 0 -2.1446597282799018e-01
GC_2_56 ref NI_2 NS_56 0 6.0823569681668765e-01
GC_2_57 ref NI_2 NS_57 0 2.1913250879998708e-01
GC_2_58 ref NI_2 NS_58 0 -4.6818022724109162e-02
GC_2_59 ref NI_2 NS_59 0 7.3899970290119699e-06
GC_2_60 ref NI_2 NS_60 0 -9.6820726173238220e-04
GC_2_61 ref NI_2 NS_61 0 -1.6287015717195549e-01
GC_2_62 ref NI_2 NS_62 0 6.8815749579240659e-01
GC_2_63 ref NI_2 NS_63 0 1.2640884595402707e-01
GC_2_64 ref NI_2 NS_64 0 -1.5175724829869579e-02
GC_2_65 ref NI_2 NS_65 0 -1.7425842811418879e-06
GC_2_66 ref NI_2 NS_66 0 -1.0984892583106576e-03
GC_2_67 ref NI_2 NS_67 0 -1.6540873249407090e-01
GC_2_68 ref NI_2 NS_68 0 4.0136782355755840e-01
GC_2_69 ref NI_2 NS_69 0 1.5821158654611278e-01
GC_2_70 ref NI_2 NS_70 0 2.9256691553763866e-02
GC_2_71 ref NI_2 NS_71 0 4.3733854058443348e-05
GC_2_72 ref NI_2 NS_72 0 -3.7508792691200697e-04
GC_2_73 ref NI_2 NS_73 0 1.7787891559942817e-01
GC_2_74 ref NI_2 NS_74 0 -9.2261835815657806e-02
GC_2_75 ref NI_2 NS_75 0 2.6314494832480290e-01
GC_2_76 ref NI_2 NS_76 0 4.5798329342947232e-02
GC_2_77 ref NI_2 NS_77 0 2.2121001293330915e-05
GC_2_78 ref NI_2 NS_78 0 -2.7310271844591420e-03
GD_2_1 ref NI_2 NA_1 0 2.1454582072692081e-03
GD_2_2 ref NI_2 NA_2 0 5.7596387397332380e+00
GD_2_3 ref NI_2 NA_3 0 -2.7267829341827195e-02
GD_2_4 ref NI_2 NA_4 0 -2.0980136741883322e-02
GD_2_5 ref NI_2 NA_5 0 -2.1239750895699294e-02
GD_2_6 ref NI_2 NA_6 0 -2.5156977005475714e-02
GD_2_7 ref NI_2 NA_7 0 -6.4296010676113723e-03
GD_2_8 ref NI_2 NA_8 0 -8.3049820843678710e-03
GD_2_9 ref NI_2 NA_9 0 9.9243343399885373e-03
GD_2_10 ref NI_2 NA_10 0 -1.9729308570271063e-03
GD_2_11 ref NI_2 NA_11 0 -5.6599150376835760e-04
GD_2_12 ref NI_2 NA_12 0 3.1420536878030460e-04
GD_2_13 ref NI_2 NA_13 0 -2.0390220525193924e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 -9.7809799924076721e-02
GC_3_2 ref NI_3 NS_2 0 1.0294243861117995e-01
GC_3_3 ref NI_3 NS_3 0 -1.3189915392204174e-01
GC_3_4 ref NI_3 NS_4 0 8.5653502238050711e-02
GC_3_5 ref NI_3 NS_5 0 1.4977972596209819e-04
GC_3_6 ref NI_3 NS_6 0 4.9558514170472023e-02
GC_3_7 ref NI_3 NS_7 0 9.4568551258849234e-02
GC_3_8 ref NI_3 NS_8 0 9.6316645331399053e-01
GC_3_9 ref NI_3 NS_9 0 7.6259887711271609e-02
GC_3_10 ref NI_3 NS_10 0 -7.4870166940990607e-02
GC_3_11 ref NI_3 NS_11 0 -4.8719495722588945e-06
GC_3_12 ref NI_3 NS_12 0 -3.4020280619352721e-03
GC_3_13 ref NI_3 NS_13 0 3.7714706845351204e-01
GC_3_14 ref NI_3 NS_14 0 -6.4823626272724830e+00
GC_3_15 ref NI_3 NS_15 0 -1.2176620664689766e+00
GC_3_16 ref NI_3 NS_16 0 -5.8034788834000255e-02
GC_3_17 ref NI_3 NS_17 0 -1.4309891905238517e-04
GC_3_18 ref NI_3 NS_18 0 -1.6375701124567359e-02
GC_3_19 ref NI_3 NS_19 0 -3.4070827998510966e-01
GC_3_20 ref NI_3 NS_20 0 1.7003770423938616e-01
GC_3_21 ref NI_3 NS_21 0 4.5654556098619370e-01
GC_3_22 ref NI_3 NS_22 0 -6.8742418443240347e-02
GC_3_23 ref NI_3 NS_23 0 3.0781590591979205e-06
GC_3_24 ref NI_3 NS_24 0 -1.4382294412861941e-03
GC_3_25 ref NI_3 NS_25 0 4.3598789960047806e-03
GC_3_26 ref NI_3 NS_26 0 -1.2422021687501965e-01
GC_3_27 ref NI_3 NS_27 0 1.8670574506239995e-01
GC_3_28 ref NI_3 NS_28 0 1.1511010938442522e-01
GC_3_29 ref NI_3 NS_29 0 2.7314106970404133e-05
GC_3_30 ref NI_3 NS_30 0 -6.8389874184426674e-04
GC_3_31 ref NI_3 NS_31 0 5.9255278795660216e-01
GC_3_32 ref NI_3 NS_32 0 6.0021740502763676e-01
GC_3_33 ref NI_3 NS_33 0 3.2480900883740094e-01
GC_3_34 ref NI_3 NS_34 0 -2.2845349119481928e-01
GC_3_35 ref NI_3 NS_35 0 1.5400310227697143e-05
GC_3_36 ref NI_3 NS_36 0 -4.0409570405857175e-03
GC_3_37 ref NI_3 NS_37 0 1.4699541684047515e+00
GC_3_38 ref NI_3 NS_38 0 2.9780102620063627e+00
GC_3_39 ref NI_3 NS_39 0 -1.1190118308315224e+00
GC_3_40 ref NI_3 NS_40 0 9.9179616581173101e-03
GC_3_41 ref NI_3 NS_41 0 -7.7182826420411780e-05
GC_3_42 ref NI_3 NS_42 0 -1.2529648974510338e-02
GC_3_43 ref NI_3 NS_43 0 -1.6296148099825920e+00
GC_3_44 ref NI_3 NS_44 0 1.3389993256889783e+00
GC_3_45 ref NI_3 NS_45 0 7.7336171200119253e-01
GC_3_46 ref NI_3 NS_46 0 -3.5478658428047416e-01
GC_3_47 ref NI_3 NS_47 0 -7.0325680281709311e-06
GC_3_48 ref NI_3 NS_48 0 -4.6121885946954008e-04
GC_3_49 ref NI_3 NS_49 0 -1.9029859776463057e-01
GC_3_50 ref NI_3 NS_50 0 6.9879943881776219e-01
GC_3_51 ref NI_3 NS_51 0 2.1168187605759986e-01
GC_3_52 ref NI_3 NS_52 0 -6.1252888101746457e-02
GC_3_53 ref NI_3 NS_53 0 -3.4257054057732019e-05
GC_3_54 ref NI_3 NS_54 0 -2.7996315641792336e-03
GC_3_55 ref NI_3 NS_55 0 2.5422594092082723e-02
GC_3_56 ref NI_3 NS_56 0 -7.9832850467573074e-02
GC_3_57 ref NI_3 NS_57 0 1.8788423090611803e-01
GC_3_58 ref NI_3 NS_58 0 1.0257478868322645e-01
GC_3_59 ref NI_3 NS_59 0 -6.6535879540578857e-06
GC_3_60 ref NI_3 NS_60 0 -1.3894176976335174e-03
GC_3_61 ref NI_3 NS_61 0 -4.6995837294447756e-02
GC_3_62 ref NI_3 NS_62 0 4.2414075527849343e-02
GC_3_63 ref NI_3 NS_63 0 8.0385617009922968e-03
GC_3_64 ref NI_3 NS_64 0 1.9297311939960829e-01
GC_3_65 ref NI_3 NS_65 0 -1.3676626624182220e-06
GC_3_66 ref NI_3 NS_66 0 -3.5372912463083414e-04
GC_3_67 ref NI_3 NS_67 0 -4.7198953191925949e-02
GC_3_68 ref NI_3 NS_68 0 4.2850384055449872e-02
GC_3_69 ref NI_3 NS_69 0 -2.0195704095570599e-01
GC_3_70 ref NI_3 NS_70 0 3.1644366368340138e-01
GC_3_71 ref NI_3 NS_71 0 8.0942688378693957e-05
GC_3_72 ref NI_3 NS_72 0 7.3781233828758286e-04
GC_3_73 ref NI_3 NS_73 0 2.0740950373418590e-01
GC_3_74 ref NI_3 NS_74 0 -5.3621403993574823e-01
GC_3_75 ref NI_3 NS_75 0 5.2799569502765820e-01
GC_3_76 ref NI_3 NS_76 0 -1.2891209724355696e-02
GC_3_77 ref NI_3 NS_77 0 1.5556034889055490e-05
GC_3_78 ref NI_3 NS_78 0 -4.9037589307426941e-03
GD_3_1 ref NI_3 NA_1 0 4.9584310454166454e-03
GD_3_2 ref NI_3 NA_2 0 -2.7267829341827195e-02
GD_3_3 ref NI_3 NA_3 0 6.2102829328253488e+00
GD_3_4 ref NI_3 NA_4 0 4.6198712912359731e-03
GD_3_5 ref NI_3 NA_5 0 -3.8553070488529743e-03
GD_3_6 ref NI_3 NA_6 0 1.6504067958910625e-02
GD_3_7 ref NI_3 NA_7 0 -2.5580225401434252e-02
GD_3_8 ref NI_3 NA_8 0 2.8683119224982501e-02
GD_3_9 ref NI_3 NA_9 0 1.8648689193088323e-02
GD_3_10 ref NI_3 NA_10 0 1.8271937290814974e-03
GD_3_11 ref NI_3 NA_11 0 3.0883748361200877e-03
GD_3_12 ref NI_3 NA_12 0 2.9660110992255073e-03
GD_3_13 ref NI_3 NA_13 0 -9.3039066157370801e-03
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -8.0348087997474948e-02
GC_4_2 ref NI_4 NS_2 0 9.9678960650693829e-02
GC_4_3 ref NI_4 NS_3 0 -1.5393742515429867e-02
GC_4_4 ref NI_4 NS_4 0 6.0339132525090079e-02
GC_4_5 ref NI_4 NS_5 0 1.1275302820986777e-04
GC_4_6 ref NI_4 NS_6 0 3.6916220456233904e-02
GC_4_7 ref NI_4 NS_7 0 -2.1438673277247813e-02
GC_4_8 ref NI_4 NS_8 0 3.7581527710045598e-01
GC_4_9 ref NI_4 NS_9 0 3.0017619311068244e-01
GC_4_10 ref NI_4 NS_10 0 -6.5734439542372000e-02
GC_4_11 ref NI_4 NS_11 0 5.0642230488429861e-06
GC_4_12 ref NI_4 NS_12 0 -1.1904973082266918e-03
GC_4_13 ref NI_4 NS_13 0 -3.4070827998510933e-01
GC_4_14 ref NI_4 NS_14 0 1.7003770423938566e-01
GC_4_15 ref NI_4 NS_15 0 4.5654556098619398e-01
GC_4_16 ref NI_4 NS_16 0 -6.8742418443240513e-02
GC_4_17 ref NI_4 NS_17 0 3.0781590591878142e-06
GC_4_18 ref NI_4 NS_18 0 -1.4382294412861678e-03
GC_4_19 ref NI_4 NS_19 0 2.6221054938508637e+00
GC_4_20 ref NI_4 NS_20 0 -4.8737772814403355e+00
GC_4_21 ref NI_4 NS_21 0 -3.0554557383633725e+00
GC_4_22 ref NI_4 NS_22 0 4.0000246540735845e-01
GC_4_23 ref NI_4 NS_23 0 -2.3520188793530499e-04
GC_4_24 ref NI_4 NS_24 0 -2.4420237563948056e-02
GC_4_25 ref NI_4 NS_25 0 -7.1271265842298459e-01
GC_4_26 ref NI_4 NS_26 0 1.6424886633104843e+00
GC_4_27 ref NI_4 NS_27 0 1.2561904075882266e-01
GC_4_28 ref NI_4 NS_28 0 -1.6854282787685426e-01
GC_4_29 ref NI_4 NS_29 0 -8.7655996700399836e-06
GC_4_30 ref NI_4 NS_30 0 1.0231562027219073e-03
GC_4_31 ref NI_4 NS_31 0 2.3135805213332968e-02
GC_4_32 ref NI_4 NS_32 0 -2.8648445236085429e-01
GC_4_33 ref NI_4 NS_33 0 4.4103143246271914e-01
GC_4_34 ref NI_4 NS_34 0 -2.6940472050294463e-03
GC_4_35 ref NI_4 NS_35 0 1.4227618280788230e-05
GC_4_36 ref NI_4 NS_36 0 -2.1081750107257396e-03
GC_4_37 ref NI_4 NS_37 0 -5.7007197951177292e-02
GC_4_38 ref NI_4 NS_38 0 7.4146385426737427e-01
GC_4_39 ref NI_4 NS_39 0 1.0719957156734723e-01
GC_4_40 ref NI_4 NS_40 0 -2.6247737909546702e-02
GC_4_41 ref NI_4 NS_41 0 4.3725334529832247e-06
GC_4_42 ref NI_4 NS_42 0 -2.8282823476321029e-03
GC_4_43 ref NI_4 NS_43 0 5.9243067277263251e-02
GC_4_44 ref NI_4 NS_44 0 1.0607113385022675e-01
GC_4_45 ref NI_4 NS_45 0 2.4587036829200709e-01
GC_4_46 ref NI_4 NS_46 0 2.1702476153715362e-02
GC_4_47 ref NI_4 NS_47 0 1.3079280740328008e-05
GC_4_48 ref NI_4 NS_48 0 -2.7301403950007377e-03
GC_4_49 ref NI_4 NS_49 0 -1.3093514320184105e-01
GC_4_50 ref NI_4 NS_50 0 8.3384481418898079e-02
GC_4_51 ref NI_4 NS_51 0 3.0125704537744247e-01
GC_4_52 ref NI_4 NS_52 0 3.2976607524393244e-03
GC_4_53 ref NI_4 NS_53 0 1.3194587484957260e-04
GC_4_54 ref NI_4 NS_54 0 -2.1941980799977868e-04
GC_4_55 ref NI_4 NS_55 0 -5.7884845375060490e-01
GC_4_56 ref NI_4 NS_56 0 1.2875952499761025e+00
GC_4_57 ref NI_4 NS_57 0 2.5234434474864614e-01
GC_4_58 ref NI_4 NS_58 0 -1.8249348694680076e-01
GC_4_59 ref NI_4 NS_59 0 -6.0036682597465394e-05
GC_4_60 ref NI_4 NS_60 0 4.7828092828991665e-04
GC_4_61 ref NI_4 NS_61 0 -9.0607902965079840e-02
GC_4_62 ref NI_4 NS_62 0 2.0212472274190091e-01
GC_4_63 ref NI_4 NS_63 0 2.4305704204245310e-01
GC_4_64 ref NI_4 NS_64 0 1.3956767019201873e-02
GC_4_65 ref NI_4 NS_65 0 6.2386373291827093e-06
GC_4_66 ref NI_4 NS_66 0 -2.6673133699846026e-04
GC_4_67 ref NI_4 NS_67 0 1.2188386163772011e-01
GC_4_68 ref NI_4 NS_68 0 -4.2338454296917233e-01
GC_4_69 ref NI_4 NS_69 0 3.2636208565179164e-01
GC_4_70 ref NI_4 NS_70 0 7.7048408259749776e-02
GC_4_71 ref NI_4 NS_71 0 3.0867579043878649e-05
GC_4_72 ref NI_4 NS_72 0 8.1825345593519971e-05
GC_4_73 ref NI_4 NS_73 0 -2.5721321599951769e-01
GC_4_74 ref NI_4 NS_74 0 4.7019356434765153e-01
GC_4_75 ref NI_4 NS_75 0 3.8499135539895446e-01
GC_4_76 ref NI_4 NS_76 0 -1.1038776808391050e-01
GC_4_77 ref NI_4 NS_77 0 -5.8559113982413182e-06
GC_4_78 ref NI_4 NS_78 0 -1.0051616957734758e-03
GD_4_1 ref NI_4 NA_1 0 4.7404148172695715e-03
GD_4_2 ref NI_4 NA_2 0 -2.0980136741883322e-02
GD_4_3 ref NI_4 NA_3 0 4.6198712912359731e-03
GD_4_4 ref NI_4 NA_4 0 6.1584347939180564e+00
GD_4_5 ref NI_4 NA_5 0 1.4852755630005949e-02
GD_4_6 ref NI_4 NA_6 0 -2.0237176129739754e-03
GD_4_7 ref NI_4 NA_7 0 1.4571130845571149e-03
GD_4_8 ref NI_4 NA_8 0 -1.8994752231359859e-03
GD_4_9 ref NI_4 NA_9 0 1.4816230172855719e-02
GD_4_10 ref NI_4 NA_10 0 3.3516155628758267e-02
GD_4_11 ref NI_4 NA_11 0 7.8778196291870908e-03
GD_4_12 ref NI_4 NA_12 0 -1.8473977240455305e-03
GD_4_13 ref NI_4 NA_13 0 6.4351783368903513e-03
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -8.5173705584540724e-02
GC_5_2 ref NI_5 NS_2 0 1.3104959929574772e-01
GC_5_3 ref NI_5 NS_3 0 5.6827972257088175e-02
GC_5_4 ref NI_5 NS_4 0 3.8677981756644109e-02
GC_5_5 ref NI_5 NS_5 0 7.3000062702806298e-05
GC_5_6 ref NI_5 NS_6 0 2.9247499467810661e-02
GC_5_7 ref NI_5 NS_7 0 -6.6796924828072271e-02
GC_5_8 ref NI_5 NS_8 0 5.8792487505725610e-01
GC_5_9 ref NI_5 NS_9 0 1.6023660732570427e-01
GC_5_10 ref NI_5 NS_10 0 -2.5277694454087441e-02
GC_5_11 ref NI_5 NS_11 0 1.1386275891078286e-05
GC_5_12 ref NI_5 NS_12 0 -3.8979428479313461e-04
GC_5_13 ref NI_5 NS_13 0 4.3598789960048326e-03
GC_5_14 ref NI_5 NS_14 0 -1.2422021687501968e-01
GC_5_15 ref NI_5 NS_15 0 1.8670574506239995e-01
GC_5_16 ref NI_5 NS_16 0 1.1511010938442526e-01
GC_5_17 ref NI_5 NS_17 0 2.7314106970407829e-05
GC_5_18 ref NI_5 NS_18 0 -6.8389874184428018e-04
GC_5_19 ref NI_5 NS_19 0 -7.1271265842298459e-01
GC_5_20 ref NI_5 NS_20 0 1.6424886633104843e+00
GC_5_21 ref NI_5 NS_21 0 1.2561904075882269e-01
GC_5_22 ref NI_5 NS_22 0 -1.6854282787685429e-01
GC_5_23 ref NI_5 NS_23 0 -8.7655996700408815e-06
GC_5_24 ref NI_5 NS_24 0 1.0231562027219108e-03
GC_5_25 ref NI_5 NS_25 0 2.2060018353217719e+00
GC_5_26 ref NI_5 NS_26 0 -3.8014378289325066e+00
GC_5_27 ref NI_5 NS_27 0 -2.8433639069288632e+00
GC_5_28 ref NI_5 NS_28 0 7.0338567290377088e-02
GC_5_29 ref NI_5 NS_29 0 -1.5537269794439924e-04
GC_5_30 ref NI_5 NS_30 0 -2.4483617937586816e-02
GC_5_31 ref NI_5 NS_31 0 4.8957273468736823e-02
GC_5_32 ref NI_5 NS_32 0 -1.7588642583576297e-01
GC_5_33 ref NI_5 NS_33 0 1.1302455866512166e-01
GC_5_34 ref NI_5 NS_34 0 1.6591576996843621e-01
GC_5_35 ref NI_5 NS_35 0 2.9181970347296631e-05
GC_5_36 ref NI_5 NS_36 0 -4.5232865648135956e-04
GC_5_37 ref NI_5 NS_37 0 -1.4329691286289999e-02
GC_5_38 ref NI_5 NS_38 0 3.8455738169295428e-02
GC_5_39 ref NI_5 NS_39 0 1.4239210745175762e-01
GC_5_40 ref NI_5 NS_40 0 1.0578462001959772e-01
GC_5_41 ref NI_5 NS_41 0 1.8913693190233540e-05
GC_5_42 ref NI_5 NS_42 0 -4.7218021765367047e-04
GC_5_43 ref NI_5 NS_43 0 6.2761345585429285e-02
GC_5_44 ref NI_5 NS_44 0 -7.7823231384293493e-02
GC_5_45 ref NI_5 NS_45 0 6.6550467381746706e-02
GC_5_46 ref NI_5 NS_46 0 1.6898900750740375e-01
GC_5_47 ref NI_5 NS_47 0 2.4036370039767635e-05
GC_5_48 ref NI_5 NS_48 0 -3.5841973712514539e-04
GC_5_49 ref NI_5 NS_49 0 -2.2714331827963608e-02
GC_5_50 ref NI_5 NS_50 0 -1.8768532359487982e-02
GC_5_51 ref NI_5 NS_51 0 1.2160946127486735e-01
GC_5_52 ref NI_5 NS_52 0 1.2094766141159730e-01
GC_5_53 ref NI_5 NS_53 0 5.4247137228966720e-05
GC_5_54 ref NI_5 NS_54 0 1.6620202515908271e-03
GC_5_55 ref NI_5 NS_55 0 1.0024833754106191e-02
GC_5_56 ref NI_5 NS_56 0 -1.4140328177469536e-01
GC_5_57 ref NI_5 NS_57 0 3.1656105259706580e-01
GC_5_58 ref NI_5 NS_58 0 3.0783483216511916e-02
GC_5_59 ref NI_5 NS_59 0 1.6888622567549679e-05
GC_5_60 ref NI_5 NS_60 0 4.8111497720834125e-04
GC_5_61 ref NI_5 NS_61 0 6.0876355134979604e-02
GC_5_62 ref NI_5 NS_62 0 -2.3060740016154790e-01
GC_5_63 ref NI_5 NS_63 0 6.1397177588869556e-01
GC_5_64 ref NI_5 NS_64 0 -1.3429705480433035e-01
GC_5_65 ref NI_5 NS_65 0 1.8751729781951755e-05
GC_5_66 ref NI_5 NS_66 0 -1.3548532379330240e-03
GC_5_67 ref NI_5 NS_67 0 -7.9245053074059679e-01
GC_5_68 ref NI_5 NS_68 0 1.6286416763812446e+00
GC_5_69 ref NI_5 NS_69 0 9.3297471620699846e-01
GC_5_70 ref NI_5 NS_70 0 -6.4678885413003262e-01
GC_5_71 ref NI_5 NS_71 0 -1.3686241111311934e-04
GC_5_72 ref NI_5 NS_72 0 -2.5794441886692943e-03
GC_5_73 ref NI_5 NS_73 0 -6.7895228677687228e-02
GC_5_74 ref NI_5 NS_74 0 8.4524201723109441e-02
GC_5_75 ref NI_5 NS_75 0 1.3148498963120783e-01
GC_5_76 ref NI_5 NS_76 0 1.0593691052260122e-01
GC_5_77 ref NI_5 NS_77 0 4.0637344533097219e-05
GC_5_78 ref NI_5 NS_78 0 6.3547164816095717e-04
GD_5_1 ref NI_5 NA_1 0 3.9242222332340803e-03
GD_5_2 ref NI_5 NA_2 0 -2.1239750895699294e-02
GD_5_3 ref NI_5 NA_3 0 -3.8553070488529743e-03
GD_5_4 ref NI_5 NA_4 0 1.4852755630005949e-02
GD_5_5 ref NI_5 NA_5 0 6.1672605789719999e+00
GD_5_6 ref NI_5 NA_6 0 -4.2954461714599873e-03
GD_5_7 ref NI_5 NA_7 0 -2.6901070424624396e-03
GD_5_8 ref NI_5 NA_8 0 -4.0032731182972408e-03
GD_5_9 ref NI_5 NA_9 0 8.3828603028791512e-03
GD_5_10 ref NI_5 NA_10 0 3.7005318463858862e-03
GD_5_11 ref NI_5 NA_11 0 5.2146133896335410e-04
GD_5_12 ref NI_5 NA_12 0 4.7779621709688067e-02
GD_5_13 ref NI_5 NA_13 0 -2.9925042882661651e-04
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -9.2726363968916467e-02
GC_6_2 ref NI_6 NS_2 0 1.0021273053467597e-01
GC_6_3 ref NI_6 NS_3 0 -1.4227664606248644e-01
GC_6_4 ref NI_6 NS_4 0 8.9258756864467270e-02
GC_6_5 ref NI_6 NS_5 0 1.5091573585671405e-04
GC_6_6 ref NI_6 NS_6 0 5.0268499764145547e-02
GC_6_7 ref NI_6 NS_7 0 3.2408556204979323e-02
GC_6_8 ref NI_6 NS_8 0 1.0498953226790655e+00
GC_6_9 ref NI_6 NS_9 0 6.9492082292475402e-02
GC_6_10 ref NI_6 NS_10 0 -8.1761942116282418e-02
GC_6_11 ref NI_6 NS_11 0 -7.2735494608537899e-06
GC_6_12 ref NI_6 NS_12 0 -3.4670715536521666e-03
GC_6_13 ref NI_6 NS_13 0 5.9255278795660205e-01
GC_6_14 ref NI_6 NS_14 0 6.0021740502763687e-01
GC_6_15 ref NI_6 NS_15 0 3.2480900883740060e-01
GC_6_16 ref NI_6 NS_16 0 -2.2845349119481903e-01
GC_6_17 ref NI_6 NS_17 0 1.5400310227718922e-05
GC_6_18 ref NI_6 NS_18 0 -4.0409570405857808e-03
GC_6_19 ref NI_6 NS_19 0 2.3135805213333232e-02
GC_6_20 ref NI_6 NS_20 0 -2.8648445236085479e-01
GC_6_21 ref NI_6 NS_21 0 4.4103143246271986e-01
GC_6_22 ref NI_6 NS_22 0 -2.6940472050299437e-03
GC_6_23 ref NI_6 NS_23 0 1.4227618280751922e-05
GC_6_24 ref NI_6 NS_24 0 -2.1081750107256377e-03
GC_6_25 ref NI_6 NS_25 0 4.8957273468736760e-02
GC_6_26 ref NI_6 NS_26 0 -1.7588642583576281e-01
GC_6_27 ref NI_6 NS_27 0 1.1302455866512155e-01
GC_6_28 ref NI_6 NS_28 0 1.6591576996843635e-01
GC_6_29 ref NI_6 NS_29 0 2.9181970347306985e-05
GC_6_30 ref NI_6 NS_30 0 -4.5232865648138807e-04
GC_6_31 ref NI_6 NS_31 0 2.2862349714645153e-01
GC_6_32 ref NI_6 NS_32 0 -6.0345737279335152e+00
GC_6_33 ref NI_6 NS_33 0 -1.1406893862358669e+00
GC_6_34 ref NI_6 NS_34 0 -1.8167375563474755e-01
GC_6_35 ref NI_6 NS_35 0 -1.7555727474173383e-04
GC_6_36 ref NI_6 NS_36 0 -1.8658942459503523e-02
GC_6_37 ref NI_6 NS_37 0 -1.6059729325982912e+00
GC_6_38 ref NI_6 NS_38 0 1.2568452669706693e+00
GC_6_39 ref NI_6 NS_39 0 8.1810847974451484e-01
GC_6_40 ref NI_6 NS_40 0 -3.6751027618209825e-01
GC_6_41 ref NI_6 NS_41 0 -6.7039420363434159e-06
GC_6_42 ref NI_6 NS_42 0 -3.0033326206612278e-04
GC_6_43 ref NI_6 NS_43 0 1.2749009393479587e+00
GC_6_44 ref NI_6 NS_44 0 3.5324530693737484e+00
GC_6_45 ref NI_6 NS_45 0 -1.0194075223351264e+00
GC_6_46 ref NI_6 NS_46 0 -1.5016078711663450e-01
GC_6_47 ref NI_6 NS_47 0 -1.2094494048102898e-04
GC_6_48 ref NI_6 NS_48 0 -1.2901639307361174e-02
GC_6_49 ref NI_6 NS_49 0 -9.9476942387274989e-02
GC_6_50 ref NI_6 NS_50 0 1.3375218041655887e-01
GC_6_51 ref NI_6 NS_51 0 2.4514076444962249e-01
GC_6_52 ref NI_6 NS_52 0 3.5060229790194103e-02
GC_6_53 ref NI_6 NS_53 0 5.6514958245558553e-05
GC_6_54 ref NI_6 NS_54 0 -3.0159973785480972e-03
GC_6_55 ref NI_6 NS_55 0 6.9423321462049659e-02
GC_6_56 ref NI_6 NS_56 0 -1.5516680768435001e-01
GC_6_57 ref NI_6 NS_57 0 4.3086962990365067e-02
GC_6_58 ref NI_6 NS_58 0 2.0325313743202258e-01
GC_6_59 ref NI_6 NS_59 0 1.1539597824310288e-05
GC_6_60 ref NI_6 NS_60 0 -1.1606044344834069e-03
GC_6_61 ref NI_6 NS_61 0 -6.2412948499240957e-02
GC_6_62 ref NI_6 NS_62 0 3.0342912076304827e-02
GC_6_63 ref NI_6 NS_63 0 -8.3846919637682440e-02
GC_6_64 ref NI_6 NS_64 0 2.5200669529528602e-01
GC_6_65 ref NI_6 NS_65 0 1.4252865190879154e-05
GC_6_66 ref NI_6 NS_66 0 3.9511961976946907e-04
GC_6_67 ref NI_6 NS_67 0 -9.3780218727297554e-02
GC_6_68 ref NI_6 NS_68 0 9.3135773940547784e-02
GC_6_69 ref NI_6 NS_69 0 -2.8789094353712380e-01
GC_6_70 ref NI_6 NS_70 0 3.5999277676623365e-01
GC_6_71 ref NI_6 NS_71 0 5.2769550578870644e-05
GC_6_72 ref NI_6 NS_72 0 2.4420170777265980e-03
GC_6_73 ref NI_6 NS_73 0 1.2358789285046329e-01
GC_6_74 ref NI_6 NS_74 0 -4.4461610397387191e-01
GC_6_75 ref NI_6 NS_75 0 7.0701587622253015e-01
GC_6_76 ref NI_6 NS_76 0 -1.3179659139350333e-01
GC_6_77 ref NI_6 NS_77 0 -1.8497942864350318e-05
GC_6_78 ref NI_6 NS_78 0 -5.0045696314857738e-03
GD_6_1 ref NI_6 NA_1 0 5.0388600572999626e-03
GD_6_2 ref NI_6 NA_2 0 -2.5156977005475714e-02
GD_6_3 ref NI_6 NA_3 0 1.6504067958910625e-02
GD_6_4 ref NI_6 NA_4 0 -2.0237176129739754e-03
GD_6_5 ref NI_6 NA_5 0 -4.2954461714599873e-03
GD_6_6 ref NI_6 NA_6 0 6.2192982990590506e+00
GD_6_7 ref NI_6 NA_7 0 2.9164085012981636e-02
GD_6_8 ref NI_6 NA_8 0 -2.9008738943814255e-02
GD_6_9 ref NI_6 NA_9 0 1.2295257835025426e-02
GD_6_10 ref NI_6 NA_10 0 -9.9489485899230162e-05
GD_6_11 ref NI_6 NA_11 0 3.9482003498681733e-03
GD_6_12 ref NI_6 NA_12 0 4.9870681313751745e-03
GD_6_13 ref NI_6 NA_13 0 -8.4947089984468774e-03
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -8.7997661759115539e-02
GC_7_2 ref NI_7 NS_2 0 1.1481434787656973e-01
GC_7_3 ref NI_7 NS_3 0 -1.0862168310632947e-01
GC_7_4 ref NI_7 NS_4 0 8.3231888657276445e-02
GC_7_5 ref NI_7 NS_5 0 1.2843421734731216e-04
GC_7_6 ref NI_7 NS_6 0 4.5383185680239316e-02
GC_7_7 ref NI_7 NS_7 0 -5.0273337370984539e-01
GC_7_8 ref NI_7 NS_8 0 5.9712835085453475e-01
GC_7_9 ref NI_7 NS_9 0 4.8053766189673214e-01
GC_7_10 ref NI_7 NS_10 0 -1.6221700922685478e-01
GC_7_11 ref NI_7 NS_11 0 -4.0711603294617664e-06
GC_7_12 ref NI_7 NS_12 0 -4.3375336318753039e-04
GC_7_13 ref NI_7 NS_13 0 1.4699541684047515e+00
GC_7_14 ref NI_7 NS_14 0 2.9780102620063627e+00
GC_7_15 ref NI_7 NS_15 0 -1.1190118308315224e+00
GC_7_16 ref NI_7 NS_16 0 9.9179616581172789e-03
GC_7_17 ref NI_7 NS_17 0 -7.7182826420415710e-05
GC_7_18 ref NI_7 NS_18 0 -1.2529648974510333e-02
GC_7_19 ref NI_7 NS_19 0 -5.7007197951177521e-02
GC_7_20 ref NI_7 NS_20 0 7.4146385426737449e-01
GC_7_21 ref NI_7 NS_21 0 1.0719957156734705e-01
GC_7_22 ref NI_7 NS_22 0 -2.6247737909546636e-02
GC_7_23 ref NI_7 NS_23 0 4.3725334529833255e-06
GC_7_24 ref NI_7 NS_24 0 -2.8282823476321059e-03
GC_7_25 ref NI_7 NS_25 0 -1.4329691286290231e-02
GC_7_26 ref NI_7 NS_26 0 3.8455738169295761e-02
GC_7_27 ref NI_7 NS_27 0 1.4239210745175745e-01
GC_7_28 ref NI_7 NS_28 0 1.0578462001959783e-01
GC_7_29 ref NI_7 NS_29 0 1.8913693190239703e-05
GC_7_30 ref NI_7 NS_30 0 -4.7218021765369042e-04
GC_7_31 ref NI_7 NS_31 0 -1.6059729325982912e+00
GC_7_32 ref NI_7 NS_32 0 1.2568452669706696e+00
GC_7_33 ref NI_7 NS_33 0 8.1810847974451473e-01
GC_7_34 ref NI_7 NS_34 0 -3.6751027618209819e-01
GC_7_35 ref NI_7 NS_35 0 -6.7039420363467210e-06
GC_7_36 ref NI_7 NS_36 0 -3.0033326206611779e-04
GC_7_37 ref NI_7 NS_37 0 6.4709811529201922e-01
GC_7_38 ref NI_7 NS_38 0 -6.3602180182751731e+00
GC_7_39 ref NI_7 NS_39 0 -1.4323912321300398e+00
GC_7_40 ref NI_7 NS_40 0 1.1943150602165305e-02
GC_7_41 ref NI_7 NS_41 0 -1.0791276368246112e-04
GC_7_42 ref NI_7 NS_42 0 -1.8076071514851834e-02
GC_7_43 ref NI_7 NS_43 0 6.4696328334831110e-01
GC_7_44 ref NI_7 NS_44 0 4.4814185554153341e-01
GC_7_45 ref NI_7 NS_45 0 3.7353201219137777e-01
GC_7_46 ref NI_7 NS_46 0 -2.3203618403527451e-01
GC_7_47 ref NI_7 NS_47 0 2.7776819608000134e-05
GC_7_48 ref NI_7 NS_48 0 -3.9728181366146965e-03
GC_7_49 ref NI_7 NS_49 0 -2.3405132429516584e-01
GC_7_50 ref NI_7 NS_50 0 2.7330790842263630e-01
GC_7_51 ref NI_7 NS_51 0 3.4024930532111686e-01
GC_7_52 ref NI_7 NS_52 0 -3.8267070192192769e-02
GC_7_53 ref NI_7 NS_53 0 -3.7629330508474899e-05
GC_7_54 ref NI_7 NS_54 0 -1.0819006719960090e-03
GC_7_55 ref NI_7 NS_55 0 3.8418940504856836e-02
GC_7_56 ref NI_7 NS_56 0 -2.8611992014933468e-01
GC_7_57 ref NI_7 NS_57 0 2.1311740453375100e-01
GC_7_58 ref NI_7 NS_58 0 1.3194266363480855e-01
GC_7_59 ref NI_7 NS_59 0 -3.6205714999770823e-06
GC_7_60 ref NI_7 NS_60 0 -6.9373660473762578e-04
GC_7_61 ref NI_7 NS_61 0 1.3034483255237081e-02
GC_7_62 ref NI_7 NS_62 0 -9.9119582219076963e-02
GC_7_63 ref NI_7 NS_63 0 -2.3116040550811970e-02
GC_7_64 ref NI_7 NS_64 0 2.3454451714312752e-01
GC_7_65 ref NI_7 NS_65 0 7.7661610396582302e-06
GC_7_66 ref NI_7 NS_66 0 2.7342692316824525e-04
GC_7_67 ref NI_7 NS_67 0 -3.9799102518439204e-03
GC_7_68 ref NI_7 NS_68 0 -7.1940164686763342e-02
GC_7_69 ref NI_7 NS_69 0 -2.1967235535045709e-01
GC_7_70 ref NI_7 NS_70 0 3.4600174098055692e-01
GC_7_71 ref NI_7 NS_71 0 7.5267639928254155e-05
GC_7_72 ref NI_7 NS_72 0 1.4747608941755731e-03
GC_7_73 ref NI_7 NS_73 0 7.5275077340919858e-02
GC_7_74 ref NI_7 NS_74 0 9.1850535191622631e-02
GC_7_75 ref NI_7 NS_75 0 5.0980451372713098e-01
GC_7_76 ref NI_7 NS_76 0 -1.3258782911843650e-01
GC_7_77 ref NI_7 NS_77 0 -8.0130313062858626e-06
GC_7_78 ref NI_7 NS_78 0 -4.8477910603431547e-03
GD_7_1 ref NI_7 NA_1 0 4.9118159250207552e-03
GD_7_2 ref NI_7 NA_2 0 -6.4296010676113723e-03
GD_7_3 ref NI_7 NA_3 0 -2.5580225401434252e-02
GD_7_4 ref NI_7 NA_4 0 1.4571130845571149e-03
GD_7_5 ref NI_7 NA_5 0 -2.6901070424624396e-03
GD_7_6 ref NI_7 NA_6 0 2.9164085012981636e-02
GD_7_7 ref NI_7 NA_7 0 6.2111666918847614e+00
GD_7_8 ref NI_7 NA_8 0 1.5933630886444426e-02
GD_7_9 ref NI_7 NA_9 0 1.4392278026378717e-02
GD_7_10 ref NI_7 NA_10 0 8.0734226611505565e-05
GD_7_11 ref NI_7 NA_11 0 2.0736566972507035e-03
GD_7_12 ref NI_7 NA_12 0 2.1145695926045732e-03
GD_7_13 ref NI_7 NA_13 0 -6.0711034534450224e-03
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -8.8969175088524352e-02
GC_8_2 ref NI_8 NS_2 0 1.0910221852346844e-01
GC_8_3 ref NI_8 NS_3 0 -1.2366649500582312e-01
GC_8_4 ref NI_8 NS_4 0 8.7111106459710430e-02
GC_8_5 ref NI_8 NS_5 0 1.3757479447066586e-04
GC_8_6 ref NI_8 NS_6 0 4.7133841732284756e-02
GC_8_7 ref NI_8 NS_7 0 -4.6379346388260356e-01
GC_8_8 ref NI_8 NS_8 0 7.0123034526827155e-01
GC_8_9 ref NI_8 NS_9 0 4.3037626489789316e-01
GC_8_10 ref NI_8 NS_10 0 -1.5777970841846459e-01
GC_8_11 ref NI_8 NS_11 0 -2.7828419775009730e-05
GC_8_12 ref NI_8 NS_12 0 -1.1096513576034292e-03
GC_8_13 ref NI_8 NS_13 0 -1.6296148099825920e+00
GC_8_14 ref NI_8 NS_14 0 1.3389993256889783e+00
GC_8_15 ref NI_8 NS_15 0 7.7336171200119253e-01
GC_8_16 ref NI_8 NS_16 0 -3.5478658428047416e-01
GC_8_17 ref NI_8 NS_17 0 -7.0325680281716731e-06
GC_8_18 ref NI_8 NS_18 0 -4.6121885946953905e-04
GC_8_19 ref NI_8 NS_19 0 5.9243067277262855e-02
GC_8_20 ref NI_8 NS_20 0 1.0607113385022739e-01
GC_8_21 ref NI_8 NS_21 0 2.4587036829200654e-01
GC_8_22 ref NI_8 NS_22 0 2.1702476153715813e-02
GC_8_23 ref NI_8 NS_23 0 1.3079280740358897e-05
GC_8_24 ref NI_8 NS_24 0 -2.7301403950008214e-03
GC_8_25 ref NI_8 NS_25 0 6.2761345585429201e-02
GC_8_26 ref NI_8 NS_26 0 -7.7823231384293423e-02
GC_8_27 ref NI_8 NS_27 0 6.6550467381746650e-02
GC_8_28 ref NI_8 NS_28 0 1.6898900750740378e-01
GC_8_29 ref NI_8 NS_29 0 2.4036370039770057e-05
GC_8_30 ref NI_8 NS_30 0 -3.5841973712514864e-04
GC_8_31 ref NI_8 NS_31 0 1.2749009393479587e+00
GC_8_32 ref NI_8 NS_32 0 3.5324530693737484e+00
GC_8_33 ref NI_8 NS_33 0 -1.0194075223351262e+00
GC_8_34 ref NI_8 NS_34 0 -1.5016078711663458e-01
GC_8_35 ref NI_8 NS_35 0 -1.2094494048103090e-04
GC_8_36 ref NI_8 NS_36 0 -1.2901639307361167e-02
GC_8_37 ref NI_8 NS_37 0 6.4696328334831121e-01
GC_8_38 ref NI_8 NS_38 0 4.4814185554153324e-01
GC_8_39 ref NI_8 NS_39 0 3.7353201219137805e-01
GC_8_40 ref NI_8 NS_40 0 -2.3203618403527465e-01
GC_8_41 ref NI_8 NS_41 0 2.7776819607995489e-05
GC_8_42 ref NI_8 NS_42 0 -3.9728181366146774e-03
GC_8_43 ref NI_8 NS_43 0 4.4731037875545587e-01
GC_8_44 ref NI_8 NS_44 0 -6.2345043238738205e+00
GC_8_45 ref NI_8 NS_45 0 -1.1448030646035361e+00
GC_8_46 ref NI_8 NS_46 0 -1.6322722497698378e-01
GC_8_47 ref NI_8 NS_47 0 -1.2001821467955908e-04
GC_8_48 ref NI_8 NS_48 0 -1.9479472721850122e-02
GC_8_49 ref NI_8 NS_49 0 1.8865916598805627e-02
GC_8_50 ref NI_8 NS_50 0 -1.9093623454271413e-01
GC_8_51 ref NI_8 NS_51 0 2.9068841991149169e-01
GC_8_52 ref NI_8 NS_52 0 6.3853861671356024e-02
GC_8_53 ref NI_8 NS_53 0 6.0748172968590353e-05
GC_8_54 ref NI_8 NS_54 0 -2.1869742077396150e-03
GC_8_55 ref NI_8 NS_55 0 1.3134964744517383e-01
GC_8_56 ref NI_8 NS_56 0 -2.9410252220821559e-01
GC_8_57 ref NI_8 NS_57 0 2.8652375209574196e-02
GC_8_58 ref NI_8 NS_58 0 2.3494672107935044e-01
GC_8_59 ref NI_8 NS_59 0 1.2609337192889525e-05
GC_8_60 ref NI_8 NS_60 0 -7.7802207024783225e-04
GC_8_61 ref NI_8 NS_61 0 8.4073344782822253e-03
GC_8_62 ref NI_8 NS_62 0 -6.9271567048320479e-02
GC_8_63 ref NI_8 NS_63 0 -1.2456834024717232e-01
GC_8_64 ref NI_8 NS_64 0 2.8887325194944113e-01
GC_8_65 ref NI_8 NS_65 0 1.8937979014084643e-05
GC_8_66 ref NI_8 NS_66 0 8.2787855104002155e-04
GC_8_67 ref NI_8 NS_67 0 -5.8685375551388003e-02
GC_8_68 ref NI_8 NS_68 0 2.8034596938590426e-02
GC_8_69 ref NI_8 NS_69 0 -3.1936421650338415e-01
GC_8_70 ref NI_8 NS_70 0 3.8812953184740462e-01
GC_8_71 ref NI_8 NS_71 0 5.3579148454438497e-05
GC_8_72 ref NI_8 NS_72 0 2.9370341249685748e-03
GC_8_73 ref NI_8 NS_73 0 4.7975809913005041e-02
GC_8_74 ref NI_8 NS_74 0 2.7180230489899304e-01
GC_8_75 ref NI_8 NS_75 0 6.1730955530603449e-01
GC_8_76 ref NI_8 NS_76 0 -2.3546650450568385e-01
GC_8_77 ref NI_8 NS_77 0 -5.6015071638577535e-05
GC_8_78 ref NI_8 NS_78 0 -4.9920407671309270e-03
GD_8_1 ref NI_8 NA_1 0 5.2707883459921761e-03
GD_8_2 ref NI_8 NA_2 0 -8.3049820843678710e-03
GD_8_3 ref NI_8 NA_3 0 2.8683119224982501e-02
GD_8_4 ref NI_8 NA_4 0 -1.8994752231359859e-03
GD_8_5 ref NI_8 NA_5 0 -4.0032731182972408e-03
GD_8_6 ref NI_8 NA_6 0 -2.9008738943814255e-02
GD_8_7 ref NI_8 NA_7 0 1.5933630886444426e-02
GD_8_8 ref NI_8 NA_8 0 6.2183826711491772e+00
GD_8_9 ref NI_8 NA_9 0 7.7928912580632788e-03
GD_8_10 ref NI_8 NA_10 0 -1.8910319627530737e-03
GD_8_11 ref NI_8 NA_11 0 2.5831825600522995e-03
GD_8_12 ref NI_8 NA_12 0 4.2617755496269453e-03
GD_8_13 ref NI_8 NA_13 0 -6.7024090727304426e-03
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -8.9461642049514109e-02
GC_9_2 ref NI_9 NS_2 0 1.0058444873320078e-01
GC_9_3 ref NI_9 NS_3 0 -9.5342722334282981e-02
GC_9_4 ref NI_9 NS_4 0 4.0917762372598407e-02
GC_9_5 ref NI_9 NS_5 0 1.7941127105831193e-04
GC_9_6 ref NI_9 NS_6 0 5.4142401368190179e-02
GC_9_7 ref NI_9 NS_7 0 -2.0713436477150834e-01
GC_9_8 ref NI_9 NS_8 0 1.0003815768182065e+00
GC_9_9 ref NI_9 NS_9 0 5.5316383230622261e-02
GC_9_10 ref NI_9 NS_10 0 -3.8842918691161431e-02
GC_9_11 ref NI_9 NS_11 0 1.5128565148434186e-07
GC_9_12 ref NI_9 NS_12 0 -1.8790525973552282e-03
GC_9_13 ref NI_9 NS_13 0 -1.9029859776463010e-01
GC_9_14 ref NI_9 NS_14 0 6.9879943881776141e-01
GC_9_15 ref NI_9 NS_15 0 2.1168187605760061e-01
GC_9_16 ref NI_9 NS_16 0 -6.1252888101746998e-02
GC_9_17 ref NI_9 NS_17 0 -3.4257054057767222e-05
GC_9_18 ref NI_9 NS_18 0 -2.7996315641791360e-03
GC_9_19 ref NI_9 NS_19 0 -1.3093514320184116e-01
GC_9_20 ref NI_9 NS_20 0 8.3384481418898260e-02
GC_9_21 ref NI_9 NS_21 0 3.0125704537744236e-01
GC_9_22 ref NI_9 NS_22 0 3.2976607524393669e-03
GC_9_23 ref NI_9 NS_23 0 1.3194587484957338e-04
GC_9_24 ref NI_9 NS_24 0 -2.1941980799978117e-04
GC_9_25 ref NI_9 NS_25 0 -2.2714331827963563e-02
GC_9_26 ref NI_9 NS_26 0 -1.8768532359488086e-02
GC_9_27 ref NI_9 NS_27 0 1.2160946127486751e-01
GC_9_28 ref NI_9 NS_28 0 1.2094766141159716e-01
GC_9_29 ref NI_9 NS_29 0 5.4247137228955471e-05
GC_9_30 ref NI_9 NS_30 0 1.6620202515908586e-03
GC_9_31 ref NI_9 NS_31 0 -9.9476942387275114e-02
GC_9_32 ref NI_9 NS_32 0 1.3375218041655912e-01
GC_9_33 ref NI_9 NS_33 0 2.4514076444962213e-01
GC_9_34 ref NI_9 NS_34 0 3.5060229790194360e-02
GC_9_35 ref NI_9 NS_35 0 5.6514958245577486e-05
GC_9_36 ref NI_9 NS_36 0 -3.0159973785481484e-03
GC_9_37 ref NI_9 NS_37 0 -2.3405132429516567e-01
GC_9_38 ref NI_9 NS_38 0 2.7330790842263614e-01
GC_9_39 ref NI_9 NS_39 0 3.4024930532111697e-01
GC_9_40 ref NI_9 NS_40 0 -3.8267070192192831e-02
GC_9_41 ref NI_9 NS_41 0 -3.7629330508475902e-05
GC_9_42 ref NI_9 NS_42 0 -1.0819006719960036e-03
GC_9_43 ref NI_9 NS_43 0 1.8865916598805835e-02
GC_9_44 ref NI_9 NS_44 0 -1.9093623454271444e-01
GC_9_45 ref NI_9 NS_45 0 2.9068841991149208e-01
GC_9_46 ref NI_9 NS_46 0 6.3853861671355788e-02
GC_9_47 ref NI_9 NS_47 0 6.0748172968574049e-05
GC_9_48 ref NI_9 NS_48 0 -2.1869742077395707e-03
GC_9_49 ref NI_9 NS_49 0 2.2746339727797054e+00
GC_9_50 ref NI_9 NS_50 0 -4.0286997639588566e+00
GC_9_51 ref NI_9 NS_51 0 -1.6571953159676096e+00
GC_9_52 ref NI_9 NS_52 0 -4.8402407648517798e-01
GC_9_53 ref NI_9 NS_53 0 -9.9586406428611328e-04
GC_9_54 ref NI_9 NS_54 0 -4.4994392117707838e-02
GC_9_55 ref NI_9 NS_55 0 -7.6035636596566070e-01
GC_9_56 ref NI_9 NS_56 0 1.4889961875304183e+00
GC_9_57 ref NI_9 NS_57 0 1.9269182658763193e-01
GC_9_58 ref NI_9 NS_58 0 -1.8263574156125081e-01
GC_9_59 ref NI_9 NS_59 0 4.6583788115402413e-04
GC_9_60 ref NI_9 NS_60 0 -1.1905947643953009e-03
GC_9_61 ref NI_9 NS_61 0 -1.9396084903833644e-01
GC_9_62 ref NI_9 NS_62 0 2.5453034293065091e-01
GC_9_63 ref NI_9 NS_63 0 1.7902191243238755e-01
GC_9_64 ref NI_9 NS_64 0 4.4506928663807239e-02
GC_9_65 ref NI_9 NS_65 0 2.8048596395760952e-05
GC_9_66 ref NI_9 NS_66 0 9.6023627378738680e-04
GC_9_67 ref NI_9 NS_67 0 -1.0420190140287633e-01
GC_9_68 ref NI_9 NS_68 0 8.8904743166397057e-02
GC_9_69 ref NI_9 NS_69 0 -4.3227494458319797e-02
GC_9_70 ref NI_9 NS_70 0 2.0375424808656389e-01
GC_9_71 ref NI_9 NS_71 0 5.7786552350081375e-05
GC_9_72 ref NI_9 NS_72 0 2.8681674120570318e-03
GC_9_73 ref NI_9 NS_73 0 7.7289114142464851e-02
GC_9_74 ref NI_9 NS_74 0 -1.1652490260914380e-01
GC_9_75 ref NI_9 NS_75 0 -7.2612581832404766e-02
GC_9_76 ref NI_9 NS_76 0 2.6183653111267724e-01
GC_9_77 ref NI_9 NS_77 0 4.7699417207742859e-05
GC_9_78 ref NI_9 NS_78 0 -4.4721678617812760e-04
GD_9_1 ref NI_9 NA_1 0 6.9509496154141343e-03
GD_9_2 ref NI_9 NA_2 0 9.9243343399885373e-03
GD_9_3 ref NI_9 NA_3 0 1.8648689193088323e-02
GD_9_4 ref NI_9 NA_4 0 1.4816230172855719e-02
GD_9_5 ref NI_9 NA_5 0 8.3828603028791512e-03
GD_9_6 ref NI_9 NA_6 0 1.2295257835025426e-02
GD_9_7 ref NI_9 NA_7 0 1.4392278026378717e-02
GD_9_8 ref NI_9 NA_8 0 7.7928912580632788e-03
GD_9_9 ref NI_9 NA_9 0 6.0101222478555405e+00
GD_9_10 ref NI_9 NA_10 0 9.2640460754068329e-02
GD_9_11 ref NI_9 NA_11 0 2.7486764576401368e-02
GD_9_12 ref NI_9 NA_12 0 1.6202196239374637e-02
GD_9_13 ref NI_9 NA_13 0 2.1558473779472085e-03
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -7.4224962872938269e-02
GC_10_2 ref NI_10 NS_2 0 7.7582066309277192e-02
GC_10_3 ref NI_10 NS_3 0 -9.5102156255968143e-02
GC_10_4 ref NI_10 NS_4 0 4.5153072441941271e-02
GC_10_5 ref NI_10 NS_5 0 1.5256316819158074e-04
GC_10_6 ref NI_10 NS_6 0 5.4445303105076566e-02
GC_10_7 ref NI_10 NS_7 0 -2.1446597282798988e-01
GC_10_8 ref NI_10 NS_8 0 6.0823569681668721e-01
GC_10_9 ref NI_10 NS_9 0 2.1913250879998739e-01
GC_10_10 ref NI_10 NS_10 0 -4.6818022724109343e-02
GC_10_11 ref NI_10 NS_11 0 7.3899970290056096e-06
GC_10_12 ref NI_10 NS_12 0 -9.6820726173235336e-04
GC_10_13 ref NI_10 NS_13 0 2.5422594092082782e-02
GC_10_14 ref NI_10 NS_14 0 -7.9832850467573130e-02
GC_10_15 ref NI_10 NS_15 0 1.8788423090611783e-01
GC_10_16 ref NI_10 NS_16 0 1.0257478868322656e-01
GC_10_17 ref NI_10 NS_17 0 -6.6535879540449133e-06
GC_10_18 ref NI_10 NS_18 0 -1.3894176976335503e-03
GC_10_19 ref NI_10 NS_19 0 -5.7884845375060490e-01
GC_10_20 ref NI_10 NS_20 0 1.2875952499761025e+00
GC_10_21 ref NI_10 NS_21 0 2.5234434474864631e-01
GC_10_22 ref NI_10 NS_22 0 -1.8249348694680090e-01
GC_10_23 ref NI_10 NS_23 0 -6.0036682597475091e-05
GC_10_24 ref NI_10 NS_24 0 4.7828092828994760e-04
GC_10_25 ref NI_10 NS_25 0 1.0024833754106162e-02
GC_10_26 ref NI_10 NS_26 0 -1.4140328177469527e-01
GC_10_27 ref NI_10 NS_27 0 3.1656105259706563e-01
GC_10_28 ref NI_10 NS_28 0 3.0783483216512007e-02
GC_10_29 ref NI_10 NS_29 0 1.6888622567558966e-05
GC_10_30 ref NI_10 NS_30 0 4.8111497720832049e-04
GC_10_31 ref NI_10 NS_31 0 6.9423321462049978e-02
GC_10_32 ref NI_10 NS_32 0 -1.5516680768435051e-01
GC_10_33 ref NI_10 NS_33 0 4.3086962990365615e-02
GC_10_34 ref NI_10 NS_34 0 2.0325313743202217e-01
GC_10_35 ref NI_10 NS_35 0 1.1539597824285080e-05
GC_10_36 ref NI_10 NS_36 0 -1.1606044344833317e-03
GC_10_37 ref NI_10 NS_37 0 3.8418940504857120e-02
GC_10_38 ref NI_10 NS_38 0 -2.8611992014933513e-01
GC_10_39 ref NI_10 NS_39 0 2.1311740453375125e-01
GC_10_40 ref NI_10 NS_40 0 1.3194266363480839e-01
GC_10_41 ref NI_10 NS_41 0 -3.6205714999852083e-06
GC_10_42 ref NI_10 NS_42 0 -6.9373660473759542e-04
GC_10_43 ref NI_10 NS_43 0 1.3134964744517394e-01
GC_10_44 ref NI_10 NS_44 0 -2.9410252220821576e-01
GC_10_45 ref NI_10 NS_45 0 2.8652375209574307e-02
GC_10_46 ref NI_10 NS_46 0 2.3494672107935038e-01
GC_10_47 ref NI_10 NS_47 0 1.2609337192886884e-05
GC_10_48 ref NI_10 NS_48 0 -7.7802207024782358e-04
GC_10_49 ref NI_10 NS_49 0 -7.6035636596566059e-01
GC_10_50 ref NI_10 NS_50 0 1.4889961875304178e+00
GC_10_51 ref NI_10 NS_51 0 1.9269182658763195e-01
GC_10_52 ref NI_10 NS_52 0 -1.8263574156125081e-01
GC_10_53 ref NI_10 NS_53 0 4.6583788115402489e-04
GC_10_54 ref NI_10 NS_54 0 -1.1905947643952996e-03
GC_10_55 ref NI_10 NS_55 0 1.6353308723579620e+00
GC_10_56 ref NI_10 NS_56 0 -2.6924134720369919e+00
GC_10_57 ref NI_10 NS_57 0 -1.7065565891919992e+00
GC_10_58 ref NI_10 NS_58 0 -7.1333974010143586e-01
GC_10_59 ref NI_10 NS_59 0 -6.3025883679562104e-04
GC_10_60 ref NI_10 NS_60 0 -4.5344072874332897e-02
GC_10_61 ref NI_10 NS_61 0 -1.7637433283909257e-01
GC_10_62 ref NI_10 NS_62 0 3.2821950593097254e-01
GC_10_63 ref NI_10 NS_63 0 4.6851810398011556e-01
GC_10_64 ref NI_10 NS_64 0 -1.3723659480847369e-01
GC_10_65 ref NI_10 NS_65 0 -1.1920277832455873e-05
GC_10_66 ref NI_10 NS_66 0 -2.7952603623492070e-03
GC_10_67 ref NI_10 NS_67 0 8.0889549489680482e-02
GC_10_68 ref NI_10 NS_68 0 -1.7881151837721049e-01
GC_10_69 ref NI_10 NS_69 0 1.1104423102946194e-01
GC_10_70 ref NI_10 NS_70 0 1.5916089346529802e-01
GC_10_71 ref NI_10 NS_71 0 2.5950674487793018e-05
GC_10_72 ref NI_10 NS_72 0 -4.0461610147197942e-04
GC_10_73 ref NI_10 NS_73 0 4.7063190809655542e-02
GC_10_74 ref NI_10 NS_74 0 -1.2050837548148556e-01
GC_10_75 ref NI_10 NS_75 0 -1.8203157363985678e-01
GC_10_76 ref NI_10 NS_76 0 3.3219929626944300e-01
GC_10_77 ref NI_10 NS_77 0 4.1113758885532124e-05
GC_10_78 ref NI_10 NS_78 0 8.6874656320199372e-04
GD_10_1 ref NI_10 NA_1 0 5.1524909234639529e-03
GD_10_2 ref NI_10 NA_2 0 -1.9729308570271063e-03
GD_10_3 ref NI_10 NA_3 0 1.8271937290814974e-03
GD_10_4 ref NI_10 NA_4 0 3.3516155628758267e-02
GD_10_5 ref NI_10 NA_5 0 3.7005318463858862e-03
GD_10_6 ref NI_10 NA_6 0 -9.9489485899230162e-05
GD_10_7 ref NI_10 NA_7 0 8.0734226611505565e-05
GD_10_8 ref NI_10 NA_8 0 -1.8910319627530737e-03
GD_10_9 ref NI_10 NA_9 0 9.2640460754068329e-02
GD_10_10 ref NI_10 NA_10 0 6.0959890009301194e+00
GD_10_11 ref NI_10 NA_11 0 2.2928369480492952e-02
GD_10_12 ref NI_10 NA_12 0 6.1505810266883074e-03
GD_10_13 ref NI_10 NA_13 0 -3.0871012156818956e-04
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -7.8263352661032112e-02
GC_11_2 ref NI_11 NS_2 0 9.0636076969901697e-02
GC_11_3 ref NI_11 NS_3 0 -8.6515242866072109e-02
GC_11_4 ref NI_11 NS_4 0 4.4528763863781080e-02
GC_11_5 ref NI_11 NS_5 0 1.5303008229893984e-04
GC_11_6 ref NI_11 NS_6 0 5.2442609259559667e-02
GC_11_7 ref NI_11 NS_7 0 -1.6287015717195574e-01
GC_11_8 ref NI_11 NS_8 0 6.8815749579240704e-01
GC_11_9 ref NI_11 NS_9 0 1.2640884595402668e-01
GC_11_10 ref NI_11 NS_10 0 -1.5175724829869288e-02
GC_11_11 ref NI_11 NS_11 0 -1.7425842811211845e-06
GC_11_12 ref NI_11 NS_12 0 -1.0984892583107146e-03
GC_11_13 ref NI_11 NS_13 0 -4.6995837294447951e-02
GC_11_14 ref NI_11 NS_14 0 4.2414075527849704e-02
GC_11_15 ref NI_11 NS_15 0 8.0385617009917990e-03
GC_11_16 ref NI_11 NS_16 0 1.9297311939960871e-01
GC_11_17 ref NI_11 NS_17 0 -1.3676626623920008e-06
GC_11_18 ref NI_11 NS_18 0 -3.5372912463091372e-04
GC_11_19 ref NI_11 NS_19 0 -9.0607902965080298e-02
GC_11_20 ref NI_11 NS_20 0 2.0212472274190163e-01
GC_11_21 ref NI_11 NS_21 0 2.4305704204245249e-01
GC_11_22 ref NI_11 NS_22 0 1.3956767019202305e-02
GC_11_23 ref NI_11 NS_23 0 6.2386373292078797e-06
GC_11_24 ref NI_11 NS_24 0 -2.6673133699853610e-04
GC_11_25 ref NI_11 NS_25 0 6.0876355134979257e-02
GC_11_26 ref NI_11 NS_26 0 -2.3060740016154738e-01
GC_11_27 ref NI_11 NS_27 0 6.1397177588869534e-01
GC_11_28 ref NI_11 NS_28 0 -1.3429705480432996e-01
GC_11_29 ref NI_11 NS_29 0 1.8751729781975126e-05
GC_11_30 ref NI_11 NS_30 0 -1.3548532379330928e-03
GC_11_31 ref NI_11 NS_31 0 -6.2412948499240659e-02
GC_11_32 ref NI_11 NS_32 0 3.0342912076304299e-02
GC_11_33 ref NI_11 NS_33 0 -8.3846919637681760e-02
GC_11_34 ref NI_11 NS_34 0 2.5200669529528547e-01
GC_11_35 ref NI_11 NS_35 0 1.4252865190839545e-05
GC_11_36 ref NI_11 NS_36 0 3.9511961976957635e-04
GC_11_37 ref NI_11 NS_37 0 1.3034483255237468e-02
GC_11_38 ref NI_11 NS_38 0 -9.9119582219077573e-02
GC_11_39 ref NI_11 NS_39 0 -2.3116040550811279e-02
GC_11_40 ref NI_11 NS_40 0 2.3454451714312705e-01
GC_11_41 ref NI_11 NS_41 0 7.7661610396236239e-06
GC_11_42 ref NI_11 NS_42 0 2.7342692316834234e-04
GC_11_43 ref NI_11 NS_43 0 8.4073344782819252e-03
GC_11_44 ref NI_11 NS_44 0 -6.9271567048320007e-02
GC_11_45 ref NI_11 NS_45 0 -1.2456834024717285e-01
GC_11_46 ref NI_11 NS_46 0 2.8887325194944152e-01
GC_11_47 ref NI_11 NS_47 0 1.8937979014107310e-05
GC_11_48 ref NI_11 NS_48 0 8.2787855103995151e-04
GC_11_49 ref NI_11 NS_49 0 -1.9396084903833691e-01
GC_11_50 ref NI_11 NS_50 0 2.5453034293065169e-01
GC_11_51 ref NI_11 NS_51 0 1.7902191243238672e-01
GC_11_52 ref NI_11 NS_52 0 4.4506928663807836e-02
GC_11_53 ref NI_11 NS_53 0 2.8048596395796524e-05
GC_11_54 ref NI_11 NS_54 0 9.6023627378728034e-04
GC_11_55 ref NI_11 NS_55 0 -1.7637433283909246e-01
GC_11_56 ref NI_11 NS_56 0 3.2821950593097232e-01
GC_11_57 ref NI_11 NS_57 0 4.6851810398011584e-01
GC_11_58 ref NI_11 NS_58 0 -1.3723659480847394e-01
GC_11_59 ref NI_11 NS_59 0 -1.1920277832480583e-05
GC_11_60 ref NI_11 NS_60 0 -2.7952603623491476e-03
GC_11_61 ref NI_11 NS_61 0 1.4734557392428467e+00
GC_11_62 ref NI_11 NS_62 0 -2.2236664047111856e+00
GC_11_63 ref NI_11 NS_63 0 -1.7748505979050899e+00
GC_11_64 ref NI_11 NS_64 0 -7.7197317345916239e-01
GC_11_65 ref NI_11 NS_65 0 -5.8880555671193791e-04
GC_11_66 ref NI_11 NS_66 0 -4.2955873905835419e-02
GC_11_67 ref NI_11 NS_67 0 -3.5199187541587929e-01
GC_11_68 ref NI_11 NS_68 0 6.7069721017737416e-01
GC_11_69 ref NI_11 NS_69 0 8.0841206253496867e-01
GC_11_70 ref NI_11 NS_70 0 -3.9889268930835992e-01
GC_11_71 ref NI_11 NS_71 0 3.4211593096776608e-04
GC_11_72 ref NI_11 NS_72 0 -7.6803676901242802e-03
GC_11_73 ref NI_11 NS_73 0 -8.1036577308438898e-02
GC_11_74 ref NI_11 NS_74 0 1.0055844352518843e-01
GC_11_75 ref NI_11 NS_75 0 -2.9174565594103608e-01
GC_11_76 ref NI_11 NS_76 0 3.5827004441054816e-01
GC_11_77 ref NI_11 NS_77 0 3.1496741556370730e-05
GC_11_78 ref NI_11 NS_78 0 3.3446688743696915e-03
GD_11_1 ref NI_11 NA_1 0 5.8395102066899031e-03
GD_11_2 ref NI_11 NA_2 0 -5.6599150376835760e-04
GD_11_3 ref NI_11 NA_3 0 3.0883748361200877e-03
GD_11_4 ref NI_11 NA_4 0 7.8778196291870908e-03
GD_11_5 ref NI_11 NA_5 0 5.2146133896335410e-04
GD_11_6 ref NI_11 NA_6 0 3.9482003498681733e-03
GD_11_7 ref NI_11 NA_7 0 2.0736566972507035e-03
GD_11_8 ref NI_11 NA_8 0 2.5831825600522995e-03
GD_11_9 ref NI_11 NA_9 0 2.7486764576401368e-02
GD_11_10 ref NI_11 NA_10 0 2.2928369480492952e-02
GD_11_11 ref NI_11 NA_11 0 6.1095976985029630e+00
GD_11_12 ref NI_11 NA_12 0 5.8344833145324494e-02
GD_11_13 ref NI_11 NA_13 0 4.8077950920211235e-03
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -5.0970127666660404e-02
GC_12_2 ref NI_12 NS_2 0 3.7876382368006049e-02
GC_12_3 ref NI_12 NS_3 0 -8.5511469618230099e-02
GC_12_4 ref NI_12 NS_4 0 6.0698540269733557e-02
GC_12_5 ref NI_12 NS_5 0 1.3785426259682314e-04
GC_12_6 ref NI_12 NS_6 0 5.0426323752899453e-02
GC_12_7 ref NI_12 NS_7 0 -1.6540873249407065e-01
GC_12_8 ref NI_12 NS_8 0 4.0136782355755807e-01
GC_12_9 ref NI_12 NS_9 0 1.5821158654611328e-01
GC_12_10 ref NI_12 NS_10 0 2.9256691553763533e-02
GC_12_11 ref NI_12 NS_11 0 4.3733854058423270e-05
GC_12_12 ref NI_12 NS_12 0 -3.7508792691194354e-04
GC_12_13 ref NI_12 NS_13 0 -4.7198953191925477e-02
GC_12_14 ref NI_12 NS_14 0 4.2850384055449123e-02
GC_12_15 ref NI_12 NS_15 0 -2.0195704095570524e-01
GC_12_16 ref NI_12 NS_16 0 3.1644366368340093e-01
GC_12_17 ref NI_12 NS_17 0 8.0942688378660347e-05
GC_12_18 ref NI_12 NS_18 0 7.3781233828767881e-04
GC_12_19 ref NI_12 NS_19 0 1.2188386163772028e-01
GC_12_20 ref NI_12 NS_20 0 -4.2338454296917277e-01
GC_12_21 ref NI_12 NS_21 0 3.2636208565179203e-01
GC_12_22 ref NI_12 NS_22 0 7.7048408259749429e-02
GC_12_23 ref NI_12 NS_23 0 3.0867579043854268e-05
GC_12_24 ref NI_12 NS_24 0 8.1825345593592016e-05
GC_12_25 ref NI_12 NS_25 0 -7.9245053074059646e-01
GC_12_26 ref NI_12 NS_26 0 1.6286416763812446e+00
GC_12_27 ref NI_12 NS_27 0 9.3297471620699879e-01
GC_12_28 ref NI_12 NS_28 0 -6.4678885413003284e-01
GC_12_29 ref NI_12 NS_29 0 -1.3686241111314021e-04
GC_12_30 ref NI_12 NS_30 0 -2.5794441886692332e-03
GC_12_31 ref NI_12 NS_31 0 -9.3780218727297887e-02
GC_12_32 ref NI_12 NS_32 0 9.3135773940548366e-02
GC_12_33 ref NI_12 NS_33 0 -2.8789094353712447e-01
GC_12_34 ref NI_12 NS_34 0 3.5999277676623409e-01
GC_12_35 ref NI_12 NS_35 0 5.2769550578905915e-05
GC_12_36 ref NI_12 NS_36 0 2.4420170777265013e-03
GC_12_37 ref NI_12 NS_37 0 -3.9799102518440427e-03
GC_12_38 ref NI_12 NS_38 0 -7.1940164686763078e-02
GC_12_39 ref NI_12 NS_39 0 -2.1967235535045745e-01
GC_12_40 ref NI_12 NS_40 0 3.4600174098055714e-01
GC_12_41 ref NI_12 NS_41 0 7.5267639928278915e-05
GC_12_42 ref NI_12 NS_42 0 1.4747608941755087e-03
GC_12_43 ref NI_12 NS_43 0 -5.8685375551387794e-02
GC_12_44 ref NI_12 NS_44 0 2.8034596938590062e-02
GC_12_45 ref NI_12 NS_45 0 -3.1936421650338376e-01
GC_12_46 ref NI_12 NS_46 0 3.8812953184740429e-01
GC_12_47 ref NI_12 NS_47 0 5.3579148454416074e-05
GC_12_48 ref NI_12 NS_48 0 2.9370341249686364e-03
GC_12_49 ref NI_12 NS_49 0 -1.0420190140287618e-01
GC_12_50 ref NI_12 NS_50 0 8.8904743166396766e-02
GC_12_51 ref NI_12 NS_51 0 -4.3227494458319471e-02
GC_12_52 ref NI_12 NS_52 0 2.0375424808656367e-01
GC_12_53 ref NI_12 NS_53 0 5.7786552350064909e-05
GC_12_54 ref NI_12 NS_54 0 2.8681674120570808e-03
GC_12_55 ref NI_12 NS_55 0 8.0889549489680107e-02
GC_12_56 ref NI_12 NS_56 0 -1.7881151837720990e-01
GC_12_57 ref NI_12 NS_57 0 1.1104423102946134e-01
GC_12_58 ref NI_12 NS_58 0 1.5916089346529844e-01
GC_12_59 ref NI_12 NS_59 0 2.5950674487819824e-05
GC_12_60 ref NI_12 NS_60 0 -4.0461610147205716e-04
GC_12_61 ref NI_12 NS_61 0 -3.5199187541587951e-01
GC_12_62 ref NI_12 NS_62 0 6.7069721017737427e-01
GC_12_63 ref NI_12 NS_63 0 8.0841206253496811e-01
GC_12_64 ref NI_12 NS_64 0 -3.9889268930835975e-01
GC_12_65 ref NI_12 NS_65 0 3.4211593096777790e-04
GC_12_66 ref NI_12 NS_66 0 -7.6803676901243054e-03
GC_12_67 ref NI_12 NS_67 0 1.7170998007405074e+00
GC_12_68 ref NI_12 NS_68 0 -2.5328657875349654e+00
GC_12_69 ref NI_12 NS_69 0 -7.3114787965411887e-01
GC_12_70 ref NI_12 NS_70 0 -1.3357947232736158e+00
GC_12_71 ref NI_12 NS_71 0 -8.4159413503709021e-04
GC_12_72 ref NI_12 NS_72 0 -5.3529778580593927e-02
GC_12_73 ref NI_12 NS_73 0 -1.1570785879049780e-01
GC_12_74 ref NI_12 NS_74 0 1.3139334930031304e-01
GC_12_75 ref NI_12 NS_75 0 -4.2105601118727570e-01
GC_12_76 ref NI_12 NS_76 0 4.2785925963558830e-01
GC_12_77 ref NI_12 NS_77 0 1.0103647855471915e-04
GC_12_78 ref NI_12 NS_78 0 4.8857794585429474e-03
GD_12_1 ref NI_12 NA_1 0 4.5484537959436999e-03
GD_12_2 ref NI_12 NA_2 0 3.1420536878030460e-04
GD_12_3 ref NI_12 NA_3 0 2.9660110992255073e-03
GD_12_4 ref NI_12 NA_4 0 -1.8473977240455305e-03
GD_12_5 ref NI_12 NA_5 0 4.7779621709688067e-02
GD_12_6 ref NI_12 NA_6 0 4.9870681313751745e-03
GD_12_7 ref NI_12 NA_7 0 2.1145695926045732e-03
GD_12_8 ref NI_12 NA_8 0 4.2617755496269453e-03
GD_12_9 ref NI_12 NA_9 0 1.6202196239374637e-02
GD_12_10 ref NI_12 NA_10 0 6.1505810266883074e-03
GD_12_11 ref NI_12 NA_11 0 5.8344833145324494e-02
GD_12_12 ref NI_12 NA_12 0 6.1210732462037525e+00
GD_12_13 ref NI_12 NA_13 0 5.7221515280330400e-03
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -5.1540468337112795e-02
GC_13_2 ref NI_13 NS_2 0 5.1025229559038938e-02
GC_13_3 ref NI_13 NS_3 0 5.1280818827382821e-02
GC_13_4 ref NI_13 NS_4 0 7.1789136825840844e-02
GC_13_5 ref NI_13 NS_5 0 1.9764943441903012e-04
GC_13_6 ref NI_13 NS_6 0 2.4071977843126192e-02
GC_13_7 ref NI_13 NS_7 0 1.7787891559942795e-01
GC_13_8 ref NI_13 NS_8 0 -9.2261835815657486e-02
GC_13_9 ref NI_13 NS_9 0 2.6314494832480273e-01
GC_13_10 ref NI_13 NS_10 0 4.5798329342947336e-02
GC_13_11 ref NI_13 NS_11 0 2.2121001293335099e-05
GC_13_12 ref NI_13 NS_12 0 -2.7310271844591502e-03
GC_13_13 ref NI_13 NS_13 0 2.0740950373418604e-01
GC_13_14 ref NI_13 NS_14 0 -5.3621403993574834e-01
GC_13_15 ref NI_13 NS_15 0 5.2799569502765853e-01
GC_13_16 ref NI_13 NS_16 0 -1.2891209724356039e-02
GC_13_17 ref NI_13 NS_17 0 1.5556034889028063e-05
GC_13_18 ref NI_13 NS_18 0 -4.9037589307426204e-03
GC_13_19 ref NI_13 NS_19 0 -2.5721321599951830e-01
GC_13_20 ref NI_13 NS_20 0 4.7019356434765242e-01
GC_13_21 ref NI_13 NS_21 0 3.8499135539895363e-01
GC_13_22 ref NI_13 NS_22 0 -1.1038776808390999e-01
GC_13_23 ref NI_13 NS_23 0 -5.8559113982068566e-06
GC_13_24 ref NI_13 NS_24 0 -1.0051616957735719e-03
GC_13_25 ref NI_13 NS_25 0 -6.7895228677687283e-02
GC_13_26 ref NI_13 NS_26 0 8.4524201723109399e-02
GC_13_27 ref NI_13 NS_27 0 1.3148498963120805e-01
GC_13_28 ref NI_13 NS_28 0 1.0593691052260103e-01
GC_13_29 ref NI_13 NS_29 0 4.0637344533079865e-05
GC_13_30 ref NI_13 NS_30 0 6.3547164816100672e-04
GC_13_31 ref NI_13 NS_31 0 1.2358789285046304e-01
GC_13_32 ref NI_13 NS_32 0 -4.4461610397387152e-01
GC_13_33 ref NI_13 NS_33 0 7.0701587622252993e-01
GC_13_34 ref NI_13 NS_34 0 -1.3179659139350325e-01
GC_13_35 ref NI_13 NS_35 0 -1.8497942864345985e-05
GC_13_36 ref NI_13 NS_36 0 -5.0045696314857877e-03
GC_13_37 ref NI_13 NS_37 0 7.5275077340919885e-02
GC_13_38 ref NI_13 NS_38 0 9.1850535191622590e-02
GC_13_39 ref NI_13 NS_39 0 5.0980451372713098e-01
GC_13_40 ref NI_13 NS_40 0 -1.3258782911843653e-01
GC_13_41 ref NI_13 NS_41 0 -8.0130313062826609e-06
GC_13_42 ref NI_13 NS_42 0 -4.8477910603431564e-03
GC_13_43 ref NI_13 NS_43 0 4.7975809913004937e-02
GC_13_44 ref NI_13 NS_44 0 2.7180230489899315e-01
GC_13_45 ref NI_13 NS_45 0 6.1730955530603449e-01
GC_13_46 ref NI_13 NS_46 0 -2.3546650450568388e-01
GC_13_47 ref NI_13 NS_47 0 -5.6015071638586019e-05
GC_13_48 ref NI_13 NS_48 0 -4.9920407671309071e-03
GC_13_49 ref NI_13 NS_49 0 7.7289114142464185e-02
GC_13_50 ref NI_13 NS_50 0 -1.1652490260914282e-01
GC_13_51 ref NI_13 NS_51 0 -7.2612581832405737e-02
GC_13_52 ref NI_13 NS_52 0 2.6183653111267791e-01
GC_13_53 ref NI_13 NS_53 0 4.7699417207786051e-05
GC_13_54 ref NI_13 NS_54 0 -4.4721678617825066e-04
GC_13_55 ref NI_13 NS_55 0 4.7063190809655597e-02
GC_13_56 ref NI_13 NS_56 0 -1.2050837548148582e-01
GC_13_57 ref NI_13 NS_57 0 -1.8203157363985628e-01
GC_13_58 ref NI_13 NS_58 0 3.3219929626944261e-01
GC_13_59 ref NI_13 NS_59 0 4.1113758885497734e-05
GC_13_60 ref NI_13 NS_60 0 8.6874656320208652e-04
GC_13_61 ref NI_13 NS_61 0 -8.1036577308438204e-02
GC_13_62 ref NI_13 NS_62 0 1.0055844352518718e-01
GC_13_63 ref NI_13 NS_63 0 -2.9174565594103447e-01
GC_13_64 ref NI_13 NS_64 0 3.5827004441054688e-01
GC_13_65 ref NI_13 NS_65 0 3.1496741556285139e-05
GC_13_66 ref NI_13 NS_66 0 3.3446688743699357e-03
GC_13_67 ref NI_13 NS_67 0 -1.1570785879049884e-01
GC_13_68 ref NI_13 NS_68 0 1.3139334930031468e-01
GC_13_69 ref NI_13 NS_69 0 -4.2105601118727726e-01
GC_13_70 ref NI_13 NS_70 0 4.2785925963558952e-01
GC_13_71 ref NI_13 NS_71 0 1.0103647855480046e-04
GC_13_72 ref NI_13 NS_72 0 4.8857794585427132e-03
GC_13_73 ref NI_13 NS_73 0 2.6836504533785333e-01
GC_13_74 ref NI_13 NS_74 0 -2.1665579681101771e-01
GC_13_75 ref NI_13 NS_75 0 -2.1391139196992563e+00
GC_13_76 ref NI_13 NS_76 0 -1.0167293427721538e+00
GC_13_77 ref NI_13 NS_77 0 -3.9086743898864425e-04
GC_13_78 ref NI_13 NS_78 0 -8.0573407241221109e-03
GD_13_1 ref NI_13 NA_1 0 6.7570357928566855e-03
GD_13_2 ref NI_13 NA_2 0 -2.0390220525193924e-02
GD_13_3 ref NI_13 NA_3 0 -9.3039066157370801e-03
GD_13_4 ref NI_13 NA_4 0 6.4351783368903513e-03
GD_13_5 ref NI_13 NA_5 0 -2.9925042882661651e-04
GD_13_6 ref NI_13 NA_6 0 -8.4947089984468774e-03
GD_13_7 ref NI_13 NA_7 0 -6.0711034534450224e-03
GD_13_8 ref NI_13 NA_8 0 -6.7024090727304426e-03
GD_13_9 ref NI_13 NA_9 0 2.1558473779472085e-03
GD_13_10 ref NI_13 NA_10 0 -3.0871012156818956e-04
GD_13_11 ref NI_13 NA_11 0 4.8077950920211235e-03
GD_13_12 ref NI_13 NA_12 0 5.7221515280330400e-03
GD_13_13 ref NI_13 NA_13 0 6.2628130781800841e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 2.5565512596468570e-01
GS_1_1 0 NS_1 NA_1 0 2.9530483206597378e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 3.9215704814476232e-01
GS_2_1 0 NS_2 NA_1 0 2.9530483206597378e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 1.0163607614746504e+00
GS_3_1 0 NS_3 NA_1 0 2.9530483206597378e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 1.6113878944543225e+00
GS_4_1 0 NS_4 NA_1 0 2.9530483206597378e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 7.7996511620030518e+01
GS_5_1 0 NS_5 NA_1 0 2.9530483206597378e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 5.9444954075889171e+00
GS_6_1 0 NS_6 NA_1 0 2.9530483206597378e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 2.5565512596468570e-01
GS_7_2 0 NS_7 NA_2 0 2.9530483206597378e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 3.9215704814476232e-01
GS_8_2 0 NS_8 NA_2 0 2.9530483206597378e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 1.0163607614746504e+00
GS_9_2 0 NS_9 NA_2 0 2.9530483206597378e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 1.6113878944543225e+00
GS_10_2 0 NS_10 NA_2 0 2.9530483206597378e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 7.7996511620030518e+01
GS_11_2 0 NS_11 NA_2 0 2.9530483206597378e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 5.9444954075889171e+00
GS_12_2 0 NS_12 NA_2 0 2.9530483206597378e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 2.5565512596468570e-01
GS_13_3 0 NS_13 NA_3 0 2.9530483206597378e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 3.9215704814476232e-01
GS_14_3 0 NS_14 NA_3 0 2.9530483206597378e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 1.0163607614746504e+00
GS_15_3 0 NS_15 NA_3 0 2.9530483206597378e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 1.6113878944543225e+00
GS_16_3 0 NS_16 NA_3 0 2.9530483206597378e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 7.7996511620030518e+01
GS_17_3 0 NS_17 NA_3 0 2.9530483206597378e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 5.9444954075889171e+00
GS_18_3 0 NS_18 NA_3 0 2.9530483206597378e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 2.5565512596468570e-01
GS_19_4 0 NS_19 NA_4 0 2.9530483206597378e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 3.9215704814476232e-01
GS_20_4 0 NS_20 NA_4 0 2.9530483206597378e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 1.0163607614746504e+00
GS_21_4 0 NS_21 NA_4 0 2.9530483206597378e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 1.6113878944543225e+00
GS_22_4 0 NS_22 NA_4 0 2.9530483206597378e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 7.7996511620030518e+01
GS_23_4 0 NS_23 NA_4 0 2.9530483206597378e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 5.9444954075889171e+00
GS_24_4 0 NS_24 NA_4 0 2.9530483206597378e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 2.5565512596468570e-01
GS_25_5 0 NS_25 NA_5 0 2.9530483206597378e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 3.9215704814476232e-01
GS_26_5 0 NS_26 NA_5 0 2.9530483206597378e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 1.0163607614746504e+00
GS_27_5 0 NS_27 NA_5 0 2.9530483206597378e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 1.6113878944543225e+00
GS_28_5 0 NS_28 NA_5 0 2.9530483206597378e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 7.7996511620030518e+01
GS_29_5 0 NS_29 NA_5 0 2.9530483206597378e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 5.9444954075889171e+00
GS_30_5 0 NS_30 NA_5 0 2.9530483206597378e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 2.5565512596468570e-01
GS_31_6 0 NS_31 NA_6 0 2.9530483206597378e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 3.9215704814476232e-01
GS_32_6 0 NS_32 NA_6 0 2.9530483206597378e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 1.0163607614746504e+00
GS_33_6 0 NS_33 NA_6 0 2.9530483206597378e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 1.6113878944543225e+00
GS_34_6 0 NS_34 NA_6 0 2.9530483206597378e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 7.7996511620030518e+01
GS_35_6 0 NS_35 NA_6 0 2.9530483206597378e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 5.9444954075889171e+00
GS_36_6 0 NS_36 NA_6 0 2.9530483206597378e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 2.5565512596468570e-01
GS_37_7 0 NS_37 NA_7 0 2.9530483206597378e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 3.9215704814476232e-01
GS_38_7 0 NS_38 NA_7 0 2.9530483206597378e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 1.0163607614746504e+00
GS_39_7 0 NS_39 NA_7 0 2.9530483206597378e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 1.6113878944543225e+00
GS_40_7 0 NS_40 NA_7 0 2.9530483206597378e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 7.7996511620030518e+01
GS_41_7 0 NS_41 NA_7 0 2.9530483206597378e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 5.9444954075889171e+00
GS_42_7 0 NS_42 NA_7 0 2.9530483206597378e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 2.5565512596468570e-01
GS_43_8 0 NS_43 NA_8 0 2.9530483206597378e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 3.9215704814476232e-01
GS_44_8 0 NS_44 NA_8 0 2.9530483206597378e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 1.0163607614746504e+00
GS_45_8 0 NS_45 NA_8 0 2.9530483206597378e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 1.6113878944543225e+00
GS_46_8 0 NS_46 NA_8 0 2.9530483206597378e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 7.7996511620030518e+01
GS_47_8 0 NS_47 NA_8 0 2.9530483206597378e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 5.9444954075889171e+00
GS_48_8 0 NS_48 NA_8 0 2.9530483206597378e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 2.5565512596468570e-01
GS_49_9 0 NS_49 NA_9 0 2.9530483206597378e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 3.9215704814476232e-01
GS_50_9 0 NS_50 NA_9 0 2.9530483206597378e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 1.0163607614746504e+00
GS_51_9 0 NS_51 NA_9 0 2.9530483206597378e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 1.6113878944543225e+00
GS_52_9 0 NS_52 NA_9 0 2.9530483206597378e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 7.7996511620030518e+01
GS_53_9 0 NS_53 NA_9 0 2.9530483206597378e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 5.9444954075889171e+00
GS_54_9 0 NS_54 NA_9 0 2.9530483206597378e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 2.5565512596468570e-01
GS_55_10 0 NS_55 NA_10 0 2.9530483206597378e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 3.9215704814476232e-01
GS_56_10 0 NS_56 NA_10 0 2.9530483206597378e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 1.0163607614746504e+00
GS_57_10 0 NS_57 NA_10 0 2.9530483206597378e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 1.6113878944543225e+00
GS_58_10 0 NS_58 NA_10 0 2.9530483206597378e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 7.7996511620030518e+01
GS_59_10 0 NS_59 NA_10 0 2.9530483206597378e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 5.9444954075889171e+00
GS_60_10 0 NS_60 NA_10 0 2.9530483206597378e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 2.5565512596468570e-01
GS_61_11 0 NS_61 NA_11 0 2.9530483206597378e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 3.9215704814476232e-01
GS_62_11 0 NS_62 NA_11 0 2.9530483206597378e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 1.0163607614746504e+00
GS_63_11 0 NS_63 NA_11 0 2.9530483206597378e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 1.6113878944543225e+00
GS_64_11 0 NS_64 NA_11 0 2.9530483206597378e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 7.7996511620030518e+01
GS_65_11 0 NS_65 NA_11 0 2.9530483206597378e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 5.9444954075889171e+00
GS_66_11 0 NS_66 NA_11 0 2.9530483206597378e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 2.5565512596468570e-01
GS_67_12 0 NS_67 NA_12 0 2.9530483206597378e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 3.9215704814476232e-01
GS_68_12 0 NS_68 NA_12 0 2.9530483206597378e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 1.0163607614746504e+00
GS_69_12 0 NS_69 NA_12 0 2.9530483206597378e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 1.6113878944543225e+00
GS_70_12 0 NS_70 NA_12 0 2.9530483206597378e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 7.7996511620030518e+01
GS_71_12 0 NS_71 NA_12 0 2.9530483206597378e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 5.9444954075889171e+00
GS_72_12 0 NS_72 NA_12 0 2.9530483206597378e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 2.5565512596468570e-01
GS_73_13 0 NS_73 NA_13 0 2.9530483206597378e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 3.9215704814476232e-01
GS_74_13 0 NS_74 NA_13 0 2.9530483206597378e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 1.0163607614746504e+00
GS_75_13 0 NS_75 NA_13 0 2.9530483206597378e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 1.6113878944543225e+00
GS_76_13 0 NS_76 NA_13 0 2.9530483206597378e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 7.7996511620030518e+01
GS_77_13 0 NS_77 NA_13 0 2.9530483206597378e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 5.9444954075889171e+00
GS_78_13 0 NS_78 NA_13 0 2.9530483206597378e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
