**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 22-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Tue Apr 22 07:41:11 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Tue Apr 22 07:41:11 2025
**
**  Modal data exported
**  Port[1] = PORT_1_L19_PWR_VECMX0_Group_U25_GND_Group
**  Port[2] = PORT_2_U1_PWR_VECMX0_Group_U1_GRP_0_0_GND
**  Port[3] = PWR_VECMX0_C445_1
**  Port[4] = PWR_VECMX0_C446_1
**  Port[5] = PWR_VECMX0_C447_1
**  Port[6] = PWR_VECMX0_C448_1
**  Port[7] = PWR_VECMX0_C449_1
**  Port[8] = PWR_VECMX0_C450_1
**  Port[9] = PWR_VECMX0_C636_1
**  Port[10] = PWR_VECMX0_C654_1
**  Port[11] = PWR_VECMX0_C654_3
**  Port[12] = PWR_VECMX0_C655_1
**  Port[13] = PWR_VECMX0_C655_3
**  Port[14] = PWR_VECMX0_C656_1
**  Port[15] = PWR_VECMX0_C656_3
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_ECCX02
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 6.0950913346492952e-01
GC_1_2 ref NI_1 NS_2 0 -8.0244049274801910e-01
GC_1_3 ref NI_1 NS_3 0 9.9108145023201333e-01
GC_1_4 ref NI_1 NS_4 0 -9.9134571448946129e-01
GC_1_5 ref NI_1 NS_5 0 -1.4923529877326159e-03
GC_1_6 ref NI_1 NS_6 0 -4.8685234241852193e-01
GC_1_7 ref NI_1 NS_7 0 -5.0175410656391535e-02
GC_1_8 ref NI_1 NS_8 0 8.2775118104953013e-02
GC_1_9 ref NI_1 NS_9 0 -8.9177437488917100e-02
GC_1_10 ref NI_1 NS_10 0 7.5888766664394827e-02
GC_1_11 ref NI_1 NS_11 0 9.8664034836189234e-05
GC_1_12 ref NI_1 NS_12 0 3.5975220488828077e-02
GC_1_13 ref NI_1 NS_13 0 -6.7159702594761339e-02
GC_1_14 ref NI_1 NS_14 0 4.6767334741925494e-02
GC_1_15 ref NI_1 NS_15 0 -4.5539283464730865e-02
GC_1_16 ref NI_1 NS_16 0 7.9167931656297874e-02
GC_1_17 ref NI_1 NS_17 0 7.8705776217482799e-05
GC_1_18 ref NI_1 NS_18 0 2.9718260669246269e-02
GC_1_19 ref NI_1 NS_19 0 -4.7514330871037236e-02
GC_1_20 ref NI_1 NS_20 0 4.2964229982663235e-02
GC_1_21 ref NI_1 NS_21 0 -1.0602569367939192e-01
GC_1_22 ref NI_1 NS_22 0 9.7094191473476407e-02
GC_1_23 ref NI_1 NS_23 0 9.3704893261775009e-05
GC_1_24 ref NI_1 NS_24 0 3.6305661484278016e-02
GC_1_25 ref NI_1 NS_25 0 -3.5531853803831802e-02
GC_1_26 ref NI_1 NS_26 0 5.7720978301799328e-02
GC_1_27 ref NI_1 NS_27 0 -6.8045401133633929e-02
GC_1_28 ref NI_1 NS_28 0 8.2547396239519205e-02
GC_1_29 ref NI_1 NS_29 0 8.5806969224125530e-05
GC_1_30 ref NI_1 NS_30 0 3.0751267096458049e-02
GC_1_31 ref NI_1 NS_31 0 -5.0649006884194003e-03
GC_1_32 ref NI_1 NS_32 0 6.3528075098999048e-02
GC_1_33 ref NI_1 NS_33 0 -2.0704306523457835e-02
GC_1_34 ref NI_1 NS_34 0 6.3004164997562617e-02
GC_1_35 ref NI_1 NS_35 0 7.0780069263253739e-05
GC_1_36 ref NI_1 NS_36 0 2.4516801215804018e-02
GC_1_37 ref NI_1 NS_37 0 -3.5662417742133190e-02
GC_1_38 ref NI_1 NS_38 0 3.5556110935076837e-02
GC_1_39 ref NI_1 NS_39 0 -1.2508336514343477e-01
GC_1_40 ref NI_1 NS_40 0 1.0151198309774997e-01
GC_1_41 ref NI_1 NS_41 0 1.2536027200132186e-04
GC_1_42 ref NI_1 NS_42 0 3.8587246663571932e-02
GC_1_43 ref NI_1 NS_43 0 -3.9911582083377438e-02
GC_1_44 ref NI_1 NS_44 0 4.4932927173714075e-02
GC_1_45 ref NI_1 NS_45 0 -1.0249637965447281e-01
GC_1_46 ref NI_1 NS_46 0 9.9022840358156630e-02
GC_1_47 ref NI_1 NS_47 0 1.0569306372346198e-04
GC_1_48 ref NI_1 NS_48 0 3.4316651943477466e-02
GC_1_49 ref NI_1 NS_49 0 -3.4531024174210646e-02
GC_1_50 ref NI_1 NS_50 0 6.3170048631924963e-02
GC_1_51 ref NI_1 NS_51 0 1.5533475736166708e-01
GC_1_52 ref NI_1 NS_52 0 -3.6432527574634557e-03
GC_1_53 ref NI_1 NS_53 0 1.3280798848196003e-04
GC_1_54 ref NI_1 NS_54 0 7.5808773139794360e-03
GC_1_55 ref NI_1 NS_55 0 -4.6849659324584444e-02
GC_1_56 ref NI_1 NS_56 0 7.3420992941727853e-02
GC_1_57 ref NI_1 NS_57 0 -4.5287687193110250e-02
GC_1_58 ref NI_1 NS_58 0 6.3428275024300595e-02
GC_1_59 ref NI_1 NS_59 0 7.8382130617474908e-05
GC_1_60 ref NI_1 NS_60 0 3.0392421330292473e-02
GC_1_61 ref NI_1 NS_61 0 -2.6837014328159176e-02
GC_1_62 ref NI_1 NS_62 0 1.8857535436388656e-02
GC_1_63 ref NI_1 NS_63 0 -1.0191774226913219e-01
GC_1_64 ref NI_1 NS_64 0 7.9922331949966258e-02
GC_1_65 ref NI_1 NS_65 0 1.2675097997493593e-04
GC_1_66 ref NI_1 NS_66 0 4.0512629909907234e-02
GC_1_67 ref NI_1 NS_67 0 -5.2245774330048449e-02
GC_1_68 ref NI_1 NS_68 0 7.0326009117092705e-02
GC_1_69 ref NI_1 NS_69 0 -1.0227526720589995e-01
GC_1_70 ref NI_1 NS_70 0 5.4398188994579148e-02
GC_1_71 ref NI_1 NS_71 0 1.1580796534214847e-04
GC_1_72 ref NI_1 NS_72 0 4.5455283305654633e-02
GC_1_73 ref NI_1 NS_73 0 -5.5985869250389550e-02
GC_1_74 ref NI_1 NS_74 0 7.5458711939465989e-02
GC_1_75 ref NI_1 NS_75 0 -1.2550811412716356e-01
GC_1_76 ref NI_1 NS_76 0 6.5708006896318352e-02
GC_1_77 ref NI_1 NS_77 0 1.6013542675849071e-04
GC_1_78 ref NI_1 NS_78 0 4.6232786006945185e-02
GC_1_79 ref NI_1 NS_79 0 -3.9816151589141494e-02
GC_1_80 ref NI_1 NS_80 0 5.2238720193437442e-02
GC_1_81 ref NI_1 NS_81 0 -9.5526074753898974e-02
GC_1_82 ref NI_1 NS_82 0 6.5526111130590023e-02
GC_1_83 ref NI_1 NS_83 0 1.1545250642128189e-04
GC_1_84 ref NI_1 NS_84 0 4.1497049354131892e-02
GC_1_85 ref NI_1 NS_85 0 -4.8487895635254713e-02
GC_1_86 ref NI_1 NS_86 0 6.2647363860173139e-02
GC_1_87 ref NI_1 NS_87 0 -1.1621205518153155e-01
GC_1_88 ref NI_1 NS_88 0 6.4112214867624903e-02
GC_1_89 ref NI_1 NS_89 0 1.2863440679201414e-04
GC_1_90 ref NI_1 NS_90 0 4.5800029135893719e-02
GD_1_1 ref NI_1 NA_1 0 6.2766230417343660e+00
GD_1_2 ref NI_1 NA_2 0 6.5498061624012067e-04
GD_1_3 ref NI_1 NA_3 0 1.2253653909014219e-03
GD_1_4 ref NI_1 NA_4 0 1.4512456909433857e-03
GD_1_5 ref NI_1 NA_5 0 1.7312102688575633e-03
GD_1_6 ref NI_1 NA_6 0 1.8547005358803812e-03
GD_1_7 ref NI_1 NA_7 0 1.6223587319857625e-03
GD_1_8 ref NI_1 NA_8 0 1.8888480138871328e-03
GD_1_9 ref NI_1 NA_9 0 2.8312439096860481e-03
GD_1_10 ref NI_1 NA_10 0 3.8753455629879081e-03
GD_1_11 ref NI_1 NA_11 0 2.2026101820709779e-03
GD_1_12 ref NI_1 NA_12 0 2.7728255086615357e-03
GD_1_13 ref NI_1 NA_13 0 2.6130732546968448e-03
GD_1_14 ref NI_1 NA_14 0 2.6281496304284171e-03
GD_1_15 ref NI_1 NA_15 0 2.5314038940497923e-03
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -5.0175410656391591e-02
GC_2_2 ref NI_2 NS_2 0 8.2775118104953097e-02
GC_2_3 ref NI_2 NS_3 0 -8.9177437488917238e-02
GC_2_4 ref NI_2 NS_4 0 7.5888766664394938e-02
GC_2_5 ref NI_2 NS_5 0 9.8664034836193815e-05
GC_2_6 ref NI_2 NS_6 0 3.5975220488828057e-02
GC_2_7 ref NI_2 NS_7 0 4.0240424603201159e+00
GC_2_8 ref NI_2 NS_8 0 -7.2112052531952200e+00
GC_2_9 ref NI_2 NS_9 0 -1.6004683520863647e+00
GC_2_10 ref NI_2 NS_10 0 4.5554318795650695e-01
GC_2_11 ref NI_2 NS_11 0 -3.7937686778636464e-04
GC_2_12 ref NI_2 NS_12 0 -2.1244022294873519e-02
GC_2_13 ref NI_2 NS_13 0 -1.2167343442152509e-01
GC_2_14 ref NI_2 NS_14 0 2.7877861699428258e-01
GC_2_15 ref NI_2 NS_15 0 2.2421136921042423e-01
GC_2_16 ref NI_2 NS_16 0 -6.8118858837880325e-02
GC_2_17 ref NI_2 NS_17 0 4.7208652573137745e-06
GC_2_18 ref NI_2 NS_18 0 -2.1390814628383467e-04
GC_2_19 ref NI_2 NS_19 0 -1.5291591181827185e-01
GC_2_20 ref NI_2 NS_20 0 3.3142409369295639e-01
GC_2_21 ref NI_2 NS_21 0 2.5226642681853884e-01
GC_2_22 ref NI_2 NS_22 0 -9.6968752853529863e-02
GC_2_23 ref NI_2 NS_23 0 3.4206846891339252e-06
GC_2_24 ref NI_2 NS_24 0 -3.1316457006743829e-04
GC_2_25 ref NI_2 NS_25 0 -3.4687327084293498e-04
GC_2_26 ref NI_2 NS_26 0 1.7140109006748819e-01
GC_2_27 ref NI_2 NS_27 0 2.3883008827848112e-01
GC_2_28 ref NI_2 NS_28 0 -7.3132275003889191e-02
GC_2_29 ref NI_2 NS_29 0 1.0170105779951134e-05
GC_2_30 ref NI_2 NS_30 0 -1.4868804248297120e-04
GC_2_31 ref NI_2 NS_31 0 -4.7517567953705894e-04
GC_2_32 ref NI_2 NS_32 0 1.6121969985114967e-01
GC_2_33 ref NI_2 NS_33 0 2.2168761965662576e-01
GC_2_34 ref NI_2 NS_34 0 -5.8095107859851607e-02
GC_2_35 ref NI_2 NS_35 0 7.0840786045036775e-06
GC_2_36 ref NI_2 NS_36 0 4.2193271459403168e-05
GC_2_37 ref NI_2 NS_37 0 -1.4381451890802349e-01
GC_2_38 ref NI_2 NS_38 0 3.2491305232862489e-01
GC_2_39 ref NI_2 NS_39 0 2.3666937831643331e-01
GC_2_40 ref NI_2 NS_40 0 -8.6455255578042955e-02
GC_2_41 ref NI_2 NS_41 0 8.5925359843315096e-06
GC_2_42 ref NI_2 NS_42 0 -2.3252195186357032e-04
GC_2_43 ref NI_2 NS_43 0 -1.5861286877382395e-02
GC_2_44 ref NI_2 NS_44 0 1.7187230879854701e-01
GC_2_45 ref NI_2 NS_45 0 2.4553098677954760e-01
GC_2_46 ref NI_2 NS_46 0 -7.5868892636198601e-02
GC_2_47 ref NI_2 NS_47 0 1.0933240090899239e-05
GC_2_48 ref NI_2 NS_48 0 -6.1508082115473839e-05
GC_2_49 ref NI_2 NS_49 0 3.6286679621450491e-02
GC_2_50 ref NI_2 NS_50 0 6.1464673378840975e-03
GC_2_51 ref NI_2 NS_51 0 1.5965407041876353e-01
GC_2_52 ref NI_2 NS_52 0 2.2700884038021476e-02
GC_2_53 ref NI_2 NS_53 0 1.9226038003571764e-05
GC_2_54 ref NI_2 NS_54 0 2.0487438110341237e-05
GC_2_55 ref NI_2 NS_55 0 -1.1433354673640030e-01
GC_2_56 ref NI_2 NS_56 0 4.5931957650576233e-01
GC_2_57 ref NI_2 NS_57 0 1.6336589178131544e-01
GC_2_58 ref NI_2 NS_58 0 -7.7903250482077843e-02
GC_2_59 ref NI_2 NS_59 0 6.4918342113397830e-06
GC_2_60 ref NI_2 NS_60 0 2.4503753378453630e-04
GC_2_61 ref NI_2 NS_61 0 -1.3064734282980522e-01
GC_2_62 ref NI_2 NS_62 0 4.7755984831739196e-01
GC_2_63 ref NI_2 NS_63 0 1.6364827866809764e-01
GC_2_64 ref NI_2 NS_64 0 -7.9805825275965692e-02
GC_2_65 ref NI_2 NS_65 0 3.5403513110839069e-05
GC_2_66 ref NI_2 NS_66 0 -3.1529074838552632e-04
GC_2_67 ref NI_2 NS_67 0 -1.2102446271694994e-01
GC_2_68 ref NI_2 NS_68 0 4.9452610258327007e-01
GC_2_69 ref NI_2 NS_69 0 2.1884342532724432e-01
GC_2_70 ref NI_2 NS_70 0 -1.2508735973790383e-01
GC_2_71 ref NI_2 NS_71 0 -8.9165802763164391e-06
GC_2_72 ref NI_2 NS_72 0 -8.5091371919174131e-05
GC_2_73 ref NI_2 NS_73 0 -1.7991176946763221e-01
GC_2_74 ref NI_2 NS_74 0 7.3503829415735145e-01
GC_2_75 ref NI_2 NS_75 0 1.5483551459326650e-01
GC_2_76 ref NI_2 NS_76 0 -1.3782931146218977e-01
GC_2_77 ref NI_2 NS_77 0 5.8058584060299730e-05
GC_2_78 ref NI_2 NS_78 0 4.2185953495318371e-04
GC_2_79 ref NI_2 NS_79 0 -1.0278371684821358e-01
GC_2_80 ref NI_2 NS_80 0 4.4238206187847001e-01
GC_2_81 ref NI_2 NS_81 0 1.7309612129892149e-01
GC_2_82 ref NI_2 NS_82 0 -8.0680381051292716e-02
GC_2_83 ref NI_2 NS_83 0 8.5972966381174959e-06
GC_2_84 ref NI_2 NS_84 0 -4.4557126323250987e-04
GC_2_85 ref NI_2 NS_85 0 -1.4612078984238849e-01
GC_2_86 ref NI_2 NS_86 0 5.9269367620702706e-01
GC_2_87 ref NI_2 NS_87 0 1.6193014179026419e-01
GC_2_88 ref NI_2 NS_88 0 -1.0443256201372801e-01
GC_2_89 ref NI_2 NS_89 0 3.1718459689779030e-05
GC_2_90 ref NI_2 NS_90 0 -1.0524039556770218e-03
GD_2_1 ref NI_2 NA_1 0 6.5498061624012067e-04
GD_2_2 ref NI_2 NA_2 0 6.0750006992625609e+00
GD_2_3 ref NI_2 NA_3 0 -7.0929898715994541e-03
GD_2_4 ref NI_2 NA_4 0 -6.8006502689023527e-03
GD_2_5 ref NI_2 NA_5 0 -7.0006572156772248e-03
GD_2_6 ref NI_2 NA_6 0 -7.0236862186463210e-03
GD_2_7 ref NI_2 NA_7 0 -4.1267542655523586e-03
GD_2_8 ref NI_2 NA_8 0 -4.6384830310238333e-03
GD_2_9 ref NI_2 NA_9 0 -6.1962367837532940e-03
GD_2_10 ref NI_2 NA_10 0 -3.9956052692034647e-04
GD_2_11 ref NI_2 NA_11 0 8.4381215335007742e-04
GD_2_12 ref NI_2 NA_12 0 1.1995028181740670e-03
GD_2_13 ref NI_2 NA_13 0 -8.8106050799719165e-04
GD_2_14 ref NI_2 NA_14 0 8.0155841281056921e-04
GD_2_15 ref NI_2 NA_15 0 5.6324529501405678e-04
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 -6.7159702594761631e-02
GC_3_2 ref NI_3 NS_2 0 4.6767334741926021e-02
GC_3_3 ref NI_3 NS_3 0 -4.5539283464731760e-02
GC_3_4 ref NI_3 NS_4 0 7.9167931656298651e-02
GC_3_5 ref NI_3 NS_5 0 7.8705776217514539e-05
GC_3_6 ref NI_3 NS_6 0 2.9718260669246169e-02
GC_3_7 ref NI_3 NS_7 0 -1.2167343442152484e-01
GC_3_8 ref NI_3 NS_8 0 2.7877861699428225e-01
GC_3_9 ref NI_3 NS_9 0 2.2421136921042448e-01
GC_3_10 ref NI_3 NS_10 0 -6.8118858837880561e-02
GC_3_11 ref NI_3 NS_11 0 4.7208652573062834e-06
GC_3_12 ref NI_3 NS_12 0 -2.1390814628381114e-04
GC_3_13 ref NI_3 NS_13 0 -2.9952947698597816e+00
GC_3_14 ref NI_3 NS_14 0 -2.6622108946706584e+00
GC_3_15 ref NI_3 NS_15 0 -1.0968534020700178e+00
GC_3_16 ref NI_3 NS_16 0 1.0198757159229634e-01
GC_3_17 ref NI_3 NS_17 0 -1.4826021623773249e-04
GC_3_18 ref NI_3 NS_18 0 -1.4110352273826550e-02
GC_3_19 ref NI_3 NS_19 0 -1.3839840655469651e-01
GC_3_20 ref NI_3 NS_20 0 -7.9706056077594352e-03
GC_3_21 ref NI_3 NS_21 0 4.1590880604014524e-01
GC_3_22 ref NI_3 NS_22 0 -1.3234781325595937e-01
GC_3_23 ref NI_3 NS_23 0 -3.4594241958703802e-06
GC_3_24 ref NI_3 NS_24 0 8.2379676571512348e-04
GC_3_25 ref NI_3 NS_25 0 -6.5568416280635478e-01
GC_3_26 ref NI_3 NS_26 0 9.3251791462979983e-01
GC_3_27 ref NI_3 NS_27 0 8.9961820353727490e-02
GC_3_28 ref NI_3 NS_28 0 -4.6195106389439113e-02
GC_3_29 ref NI_3 NS_29 0 -1.2309795843159092e-06
GC_3_30 ref NI_3 NS_30 0 -1.1058475255003781e-03
GC_3_31 ref NI_3 NS_31 0 4.4177042646571119e+00
GC_3_32 ref NI_3 NS_32 0 1.7660098741178684e-01
GC_3_33 ref NI_3 NS_33 0 -1.2984037195985898e+00
GC_3_34 ref NI_3 NS_34 0 2.6938912736759507e-01
GC_3_35 ref NI_3 NS_35 0 -7.4142372375799557e-05
GC_3_36 ref NI_3 NS_36 0 -1.3400050135587935e-02
GC_3_37 ref NI_3 NS_37 0 4.1023808165099748e-02
GC_3_38 ref NI_3 NS_38 0 -1.8913708720508318e-01
GC_3_39 ref NI_3 NS_39 0 1.4605987391765959e-01
GC_3_40 ref NI_3 NS_40 0 8.3086558040657441e-02
GC_3_41 ref NI_3 NS_41 0 2.7214066364406989e-05
GC_3_42 ref NI_3 NS_42 0 -3.1734538839188773e-04
GC_3_43 ref NI_3 NS_43 0 -9.7170442832346174e-02
GC_3_44 ref NI_3 NS_44 0 7.1930635762940537e-02
GC_3_45 ref NI_3 NS_45 0 1.3998522450789422e-01
GC_3_46 ref NI_3 NS_46 0 4.4789464972796060e-02
GC_3_47 ref NI_3 NS_47 0 1.1028021689740854e-05
GC_3_48 ref NI_3 NS_48 0 -7.6880990150047124e-04
GC_3_49 ref NI_3 NS_49 0 -3.6569014243951548e-01
GC_3_50 ref NI_3 NS_50 0 2.5828674799264573e-01
GC_3_51 ref NI_3 NS_51 0 4.4224182319394612e-01
GC_3_52 ref NI_3 NS_52 0 -1.8127372166295030e-01
GC_3_53 ref NI_3 NS_53 0 -1.4938879719784500e-05
GC_3_54 ref NI_3 NS_54 0 1.3533579558550688e-03
GC_3_55 ref NI_3 NS_55 0 -3.3042267426274063e-01
GC_3_56 ref NI_3 NS_56 0 2.7143324663037016e-01
GC_3_57 ref NI_3 NS_57 0 4.9786210426870875e-01
GC_3_58 ref NI_3 NS_58 0 -2.3512343219665491e-01
GC_3_59 ref NI_3 NS_59 0 7.6592429509807835e-05
GC_3_60 ref NI_3 NS_60 0 8.4069236069397825e-04
GC_3_61 ref NI_3 NS_61 0 3.1486881020890412e-01
GC_3_62 ref NI_3 NS_62 0 6.6004324251126822e-01
GC_3_63 ref NI_3 NS_63 0 2.1778563233426015e-01
GC_3_64 ref NI_3 NS_64 0 -2.5602792594911705e-01
GC_3_65 ref NI_3 NS_65 0 1.6797663073927246e-05
GC_3_66 ref NI_3 NS_66 0 -6.6962442270593141e-05
GC_3_67 ref NI_3 NS_67 0 5.3940967884975786e-02
GC_3_68 ref NI_3 NS_68 0 -1.0201700979579745e-01
GC_3_69 ref NI_3 NS_69 0 -1.3145429580713859e-02
GC_3_70 ref NI_3 NS_70 0 1.6981652084730367e-01
GC_3_71 ref NI_3 NS_71 0 1.1850053302151265e-05
GC_3_72 ref NI_3 NS_72 0 5.8460960319492569e-04
GC_3_73 ref NI_3 NS_73 0 8.9797053424554990e-02
GC_3_74 ref NI_3 NS_74 0 -1.6585923542552089e-01
GC_3_75 ref NI_3 NS_75 0 -9.0989720473628424e-02
GC_3_76 ref NI_3 NS_76 0 2.3632141214028379e-01
GC_3_77 ref NI_3 NS_77 0 7.0205679337794049e-05
GC_3_78 ref NI_3 NS_78 0 4.8964839093901506e-05
GC_3_79 ref NI_3 NS_79 0 3.0781972461723869e-02
GC_3_80 ref NI_3 NS_80 0 4.9400282861412681e-01
GC_3_81 ref NI_3 NS_81 0 2.2328812646186855e-01
GC_3_82 ref NI_3 NS_82 0 -1.5089905103539908e-01
GC_3_83 ref NI_3 NS_83 0 -6.8293998884797405e-05
GC_3_84 ref NI_3 NS_84 0 -1.5913025676351663e-03
GC_3_85 ref NI_3 NS_85 0 4.4197155619572062e-02
GC_3_86 ref NI_3 NS_86 0 -2.5218959138745001e-01
GC_3_87 ref NI_3 NS_87 0 2.2858235170534016e-01
GC_3_88 ref NI_3 NS_88 0 3.7301676873578105e-02
GC_3_89 ref NI_3 NS_89 0 2.8070577924449948e-05
GC_3_90 ref NI_3 NS_90 0 1.9983893564776576e-04
GD_3_1 ref NI_3 NA_1 0 1.2253653909014219e-03
GD_3_2 ref NI_3 NA_2 0 -7.0929898715994541e-03
GD_3_3 ref NI_3 NA_3 0 6.2596601800397531e+00
GD_3_4 ref NI_3 NA_4 0 4.7428267197936929e-03
GD_3_5 ref NI_3 NA_5 0 -3.1528927773131127e-04
GD_3_6 ref NI_3 NA_6 0 -2.9322620694754917e-02
GD_3_7 ref NI_3 NA_7 0 -1.2013390949558707e-03
GD_3_8 ref NI_3 NA_8 0 -1.1643808076733883e-03
GD_3_9 ref NI_3 NA_9 0 2.4009103720656006e-03
GD_3_10 ref NI_3 NA_10 0 7.5156868501123856e-03
GD_3_11 ref NI_3 NA_11 0 3.0772390110657376e-02
GD_3_12 ref NI_3 NA_12 0 6.9693660521130357e-05
GD_3_13 ref NI_3 NA_13 0 -1.7843299901629485e-03
GD_3_14 ref NI_3 NA_14 0 1.2669859597916772e-02
GD_3_15 ref NI_3 NA_15 0 -1.4806539194794023e-03
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -4.7514330871037416e-02
GC_4_2 ref NI_4 NS_2 0 4.2964229982663561e-02
GC_4_3 ref NI_4 NS_3 0 -1.0602569367939248e-01
GC_4_4 ref NI_4 NS_4 0 9.7094191473476921e-02
GC_4_5 ref NI_4 NS_5 0 9.3704893261799350e-05
GC_4_6 ref NI_4 NS_6 0 3.6305661484277940e-02
GC_4_7 ref NI_4 NS_7 0 -1.5291591181827136e-01
GC_4_8 ref NI_4 NS_8 0 3.3142409369295567e-01
GC_4_9 ref NI_4 NS_9 0 2.5226642681854000e-01
GC_4_10 ref NI_4 NS_10 0 -9.6968752853530751e-02
GC_4_11 ref NI_4 NS_11 0 3.4206846891019658e-06
GC_4_12 ref NI_4 NS_12 0 -3.1316457006731762e-04
GC_4_13 ref NI_4 NS_13 0 -1.3839840655469621e-01
GC_4_14 ref NI_4 NS_14 0 -7.9706056077599348e-03
GC_4_15 ref NI_4 NS_15 0 4.1590880604014591e-01
GC_4_16 ref NI_4 NS_16 0 -1.3234781325596007e-01
GC_4_17 ref NI_4 NS_17 0 -3.4594241958956201e-06
GC_4_18 ref NI_4 NS_18 0 8.2379676571522464e-04
GC_4_19 ref NI_4 NS_19 0 -1.2507291903690803e+00
GC_4_20 ref NI_4 NS_20 0 -3.7492602522336314e+00
GC_4_21 ref NI_4 NS_21 0 -1.3870103799526237e+00
GC_4_22 ref NI_4 NS_22 0 2.9346966986558293e-01
GC_4_23 ref NI_4 NS_23 0 -1.6846899518795962e-04
GC_4_24 ref NI_4 NS_24 0 -1.7483665770978447e-02
GC_4_25 ref NI_4 NS_25 0 3.3580173169980831e+00
GC_4_26 ref NI_4 NS_26 0 5.8819357037453479e-01
GC_4_27 ref NI_4 NS_27 0 -1.3208358765537316e+00
GC_4_28 ref NI_4 NS_28 0 3.8466027726490043e-01
GC_4_29 ref NI_4 NS_29 0 -8.3889772597655254e-05
GC_4_30 ref NI_4 NS_30 0 -1.6198693524263601e-02
GC_4_31 ref NI_4 NS_31 0 -6.8227444025497197e-01
GC_4_32 ref NI_4 NS_32 0 7.2467511866746603e-01
GC_4_33 ref NI_4 NS_33 0 2.1655176260950770e-01
GC_4_34 ref NI_4 NS_34 0 -7.8495710882075076e-02
GC_4_35 ref NI_4 NS_35 0 -1.1324547262154408e-06
GC_4_36 ref NI_4 NS_36 0 -6.1716854802810973e-04
GC_4_37 ref NI_4 NS_37 0 -9.9733068624744500e-02
GC_4_38 ref NI_4 NS_38 0 -5.3752430912502994e-02
GC_4_39 ref NI_4 NS_39 0 4.6587906583731165e-01
GC_4_40 ref NI_4 NS_40 0 -1.6028729485101192e-01
GC_4_41 ref NI_4 NS_41 0 9.6661990705233826e-07
GC_4_42 ref NI_4 NS_42 0 -3.2246370314555859e-04
GC_4_43 ref NI_4 NS_43 0 -4.9009556877695298e-01
GC_4_44 ref NI_4 NS_44 0 6.4075427886842562e-01
GC_4_45 ref NI_4 NS_45 0 1.9681835261718486e-01
GC_4_46 ref NI_4 NS_46 0 -7.0071876079169634e-02
GC_4_47 ref NI_4 NS_47 0 -6.0802808104182213e-06
GC_4_48 ref NI_4 NS_48 0 -2.6603399554054009e-03
GC_4_49 ref NI_4 NS_49 0 -3.4939253156974331e-01
GC_4_50 ref NI_4 NS_50 0 1.9586936793230564e-01
GC_4_51 ref NI_4 NS_51 0 4.9188783823516280e-01
GC_4_52 ref NI_4 NS_52 0 -2.0148598613197163e-01
GC_4_53 ref NI_4 NS_53 0 -3.5580417967967293e-05
GC_4_54 ref NI_4 NS_54 0 9.7356056234606440e-04
GC_4_55 ref NI_4 NS_55 0 -5.1876054330059398e-03
GC_4_56 ref NI_4 NS_56 0 -4.7836845470842625e-02
GC_4_57 ref NI_4 NS_57 0 1.3802294059959710e-02
GC_4_58 ref NI_4 NS_58 0 1.4368513673849023e-01
GC_4_59 ref NI_4 NS_59 0 3.9711649533360386e-05
GC_4_60 ref NI_4 NS_60 0 1.1086263938461438e-03
GC_4_61 ref NI_4 NS_61 0 1.1782284633533793e-01
GC_4_62 ref NI_4 NS_62 0 -2.2148659795138334e-01
GC_4_63 ref NI_4 NS_63 0 6.8386989274755131e-02
GC_4_64 ref NI_4 NS_64 0 1.3031957553065729e-01
GC_4_65 ref NI_4 NS_65 0 3.7703178424560379e-05
GC_4_66 ref NI_4 NS_66 0 5.2278082899748224e-04
GC_4_67 ref NI_4 NS_67 0 -5.4244218474600092e-02
GC_4_68 ref NI_4 NS_68 0 6.1881312422343748e-01
GC_4_69 ref NI_4 NS_69 0 1.5476448637082194e-01
GC_4_70 ref NI_4 NS_70 0 -1.1725911781875065e-01
GC_4_71 ref NI_4 NS_71 0 -5.4267707972286529e-05
GC_4_72 ref NI_4 NS_72 0 -2.3575202910410516e-03
GC_4_73 ref NI_4 NS_73 0 6.5732233370242796e-02
GC_4_74 ref NI_4 NS_74 0 -3.0741257922453313e-01
GC_4_75 ref NI_4 NS_75 0 3.4019425289043576e-01
GC_4_76 ref NI_4 NS_76 0 -3.1081134366624207e-02
GC_4_77 ref NI_4 NS_77 0 3.7501697156237693e-05
GC_4_78 ref NI_4 NS_78 0 -5.6581864014639850e-04
GC_4_79 ref NI_4 NS_79 0 -1.9240449810889892e-01
GC_4_80 ref NI_4 NS_80 0 4.6174062849499625e-02
GC_4_81 ref NI_4 NS_81 0 3.4021239755907323e-01
GC_4_82 ref NI_4 NS_82 0 -9.3587069405769371e-02
GC_4_83 ref NI_4 NS_83 0 1.4320483501432989e-04
GC_4_84 ref NI_4 NS_84 0 2.7163204850224757e-03
GC_4_85 ref NI_4 NS_85 0 1.3245346895754784e-01
GC_4_86 ref NI_4 NS_86 0 1.0178619578225248e+00
GC_4_87 ref NI_4 NS_87 0 -6.4123619927671016e-02
GC_4_88 ref NI_4 NS_88 0 -1.1458989328800524e-01
GC_4_89 ref NI_4 NS_89 0 1.2054378594002514e-05
GC_4_90 ref NI_4 NS_90 0 3.6725305860005303e-05
GD_4_1 ref NI_4 NA_1 0 1.4512456909433857e-03
GD_4_2 ref NI_4 NA_2 0 -6.8006502689023527e-03
GD_4_3 ref NI_4 NA_3 0 4.7428267197936929e-03
GD_4_4 ref NI_4 NA_4 0 6.2588141022218666e+00
GD_4_5 ref NI_4 NA_5 0 -3.8468213170620727e-02
GD_4_6 ref NI_4 NA_6 0 2.0876877096130558e-04
GD_4_7 ref NI_4 NA_7 0 6.5733364198284220e-03
GD_4_8 ref NI_4 NA_8 0 -1.5160773357608028e-03
GD_4_9 ref NI_4 NA_9 0 3.1030506489028043e-03
GD_4_10 ref NI_4 NA_10 0 6.6947475519355849e-04
GD_4_11 ref NI_4 NA_11 0 -5.0086049853633179e-04
GD_4_12 ref NI_4 NA_12 0 1.3368868100897107e-02
GD_4_13 ref NI_4 NA_13 0 -1.8129841350004458e-03
GD_4_14 ref NI_4 NA_14 0 3.4152785419609005e-03
GD_4_15 ref NI_4 NA_15 0 3.4487694813259077e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -3.5531853803831594e-02
GC_5_2 ref NI_5 NS_2 0 5.7720978301798981e-02
GC_5_3 ref NI_5 NS_3 0 -6.8045401133633471e-02
GC_5_4 ref NI_5 NS_4 0 8.2547396239518872e-02
GC_5_5 ref NI_5 NS_5 0 8.5806969224110419e-05
GC_5_6 ref NI_5 NS_6 0 3.0751267096458090e-02
GC_5_7 ref NI_5 NS_7 0 -3.4687327084316629e-04
GC_5_8 ref NI_5 NS_8 0 1.7140109006748858e-01
GC_5_9 ref NI_5 NS_9 0 2.3883008827848060e-01
GC_5_10 ref NI_5 NS_10 0 -7.3132275003888761e-02
GC_5_11 ref NI_5 NS_11 0 1.0170105779964733e-05
GC_5_12 ref NI_5 NS_12 0 -1.4868804248303159e-04
GC_5_13 ref NI_5 NS_13 0 -6.5568416280635511e-01
GC_5_14 ref NI_5 NS_14 0 9.3251791462980038e-01
GC_5_15 ref NI_5 NS_15 0 8.9961820353726851e-02
GC_5_16 ref NI_5 NS_16 0 -4.6195106389438557e-02
GC_5_17 ref NI_5 NS_17 0 -1.2309795842956005e-06
GC_5_18 ref NI_5 NS_18 0 -1.1058475255004557e-03
GC_5_19 ref NI_5 NS_19 0 3.3580173169980814e+00
GC_5_20 ref NI_5 NS_20 0 5.8819357037453568e-01
GC_5_21 ref NI_5 NS_21 0 -1.3208358765537331e+00
GC_5_22 ref NI_5 NS_22 0 3.8466027726490160e-01
GC_5_23 ref NI_5 NS_23 0 -8.3889772597613621e-05
GC_5_24 ref NI_5 NS_24 0 -1.6198693524263768e-02
GC_5_25 ref NI_5 NS_25 0 -2.5877693797017929e+00
GC_5_26 ref NI_5 NS_26 0 -4.0053876014231751e+00
GC_5_27 ref NI_5 NS_27 0 -7.0317463276770487e-01
GC_5_28 ref NI_5 NS_28 0 1.0248937616565580e-01
GC_5_29 ref NI_5 NS_29 0 -1.7647125610241820e-04
GC_5_30 ref NI_5 NS_30 0 -1.3576588164433431e-02
GC_5_31 ref NI_5 NS_31 0 9.3395994566440088e-01
GC_5_32 ref NI_5 NS_32 0 7.5343900395632296e-02
GC_5_33 ref NI_5 NS_33 0 -2.4548523898900495e-03
GC_5_34 ref NI_5 NS_34 0 -4.2582333921569543e-02
GC_5_35 ref NI_5 NS_35 0 -7.7075093536340192e-06
GC_5_36 ref NI_5 NS_36 0 -1.5296995990763289e-03
GC_5_37 ref NI_5 NS_37 0 -9.3935735173974733e-01
GC_5_38 ref NI_5 NS_38 0 1.0286343790138479e+00
GC_5_39 ref NI_5 NS_39 0 1.6177204102041007e-01
GC_5_40 ref NI_5 NS_40 0 -6.7472656824650798e-02
GC_5_41 ref NI_5 NS_41 0 2.1869637973433661e-05
GC_5_42 ref NI_5 NS_42 0 -2.2075907343706552e-03
GC_5_43 ref NI_5 NS_43 0 1.2280751205277760e+00
GC_5_44 ref NI_5 NS_44 0 -3.2192362670575586e-01
GC_5_45 ref NI_5 NS_45 0 1.7042259620698677e-01
GC_5_46 ref NI_5 NS_46 0 -1.1599312632745254e-01
GC_5_47 ref NI_5 NS_47 0 -1.3865254093135477e-05
GC_5_48 ref NI_5 NS_48 0 -1.8739570150779743e-03
GC_5_49 ref NI_5 NS_49 0 -1.1736249939973881e-01
GC_5_50 ref NI_5 NS_50 0 6.6227573502648740e-01
GC_5_51 ref NI_5 NS_51 0 2.5834974982293757e-01
GC_5_52 ref NI_5 NS_52 0 -1.9704880514147255e-01
GC_5_53 ref NI_5 NS_53 0 -4.7665491286171580e-05
GC_5_54 ref NI_5 NS_54 0 -9.7059266506928417e-05
GC_5_55 ref NI_5 NS_55 0 3.8630981798488201e-02
GC_5_56 ref NI_5 NS_56 0 -6.7083221350287114e-03
GC_5_57 ref NI_5 NS_57 0 2.7073673314290642e-02
GC_5_58 ref NI_5 NS_58 0 1.1289336258318795e-01
GC_5_59 ref NI_5 NS_59 0 5.0146584890240106e-05
GC_5_60 ref NI_5 NS_60 0 1.3506706410906831e-03
GC_5_61 ref NI_5 NS_61 0 2.1938088172073864e-02
GC_5_62 ref NI_5 NS_62 0 -1.5273828200541764e-01
GC_5_63 ref NI_5 NS_63 0 1.4641905993924326e-01
GC_5_64 ref NI_5 NS_64 0 6.7966441161493682e-02
GC_5_65 ref NI_5 NS_65 0 3.5480196597897005e-05
GC_5_66 ref NI_5 NS_66 0 1.7763744796266527e-03
GC_5_67 ref NI_5 NS_67 0 -2.9608375604105042e-01
GC_5_68 ref NI_5 NS_68 0 3.8982990763774811e-01
GC_5_69 ref NI_5 NS_69 0 2.2560943409643877e-01
GC_5_70 ref NI_5 NS_70 0 -6.7830441922878820e-02
GC_5_71 ref NI_5 NS_71 0 -2.5801024609141462e-05
GC_5_72 ref NI_5 NS_72 0 -5.7079226009413826e-04
GC_5_73 ref NI_5 NS_73 0 1.4058655600083264e-01
GC_5_74 ref NI_5 NS_74 0 -3.7929665658993128e-01
GC_5_75 ref NI_5 NS_75 0 3.4174161735925612e-01
GC_5_76 ref NI_5 NS_76 0 -3.2368128466226595e-02
GC_5_77 ref NI_5 NS_77 0 6.1993075929206567e-05
GC_5_78 ref NI_5 NS_78 0 6.3692428358761170e-04
GC_5_79 ref NI_5 NS_79 0 1.2643171482094301e-01
GC_5_80 ref NI_5 NS_80 0 -1.7836999842719423e-01
GC_5_81 ref NI_5 NS_81 0 2.6563122398841593e-01
GC_5_82 ref NI_5 NS_82 0 -3.9303805250107897e-02
GC_5_83 ref NI_5 NS_83 0 1.0132948840037452e-04
GC_5_84 ref NI_5 NS_84 0 3.2014482757338108e-03
GC_5_85 ref NI_5 NS_85 0 -8.5328089866309542e-01
GC_5_86 ref NI_5 NS_86 0 8.2068997897661222e-01
GC_5_87 ref NI_5 NS_87 0 2.9662831920728844e-01
GC_5_88 ref NI_5 NS_88 0 -1.4221160825342133e-01
GC_5_89 ref NI_5 NS_89 0 -7.8102778572157319e-07
GC_5_90 ref NI_5 NS_90 0 2.1357406588013075e-03
GD_5_1 ref NI_5 NA_1 0 1.7312102688575633e-03
GD_5_2 ref NI_5 NA_2 0 -7.0006572156772248e-03
GD_5_3 ref NI_5 NA_3 0 -3.1528927773131127e-04
GD_5_4 ref NI_5 NA_4 0 -3.8468213170620727e-02
GD_5_5 ref NI_5 NA_5 0 6.2716358775146039e+00
GD_5_6 ref NI_5 NA_6 0 6.6743734653543251e-04
GD_5_7 ref NI_5 NA_7 0 -6.7078361442700673e-03
GD_5_8 ref NI_5 NA_8 0 1.0215314680367158e-02
GD_5_9 ref NI_5 NA_9 0 1.7427013674287560e-03
GD_5_10 ref NI_5 NA_10 0 2.1647666729029706e-03
GD_5_11 ref NI_5 NA_11 0 2.6210299861583780e-03
GD_5_12 ref NI_5 NA_12 0 8.4060419354320560e-03
GD_5_13 ref NI_5 NA_13 0 1.1241364878725926e-03
GD_5_14 ref NI_5 NA_14 0 5.7872920238125902e-03
GD_5_15 ref NI_5 NA_15 0 1.1913504055976883e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -5.0649006884191687e-03
GC_6_2 ref NI_6 NS_2 0 6.3528075098998715e-02
GC_6_3 ref NI_6 NS_3 0 -2.0704306523457557e-02
GC_6_4 ref NI_6 NS_4 0 6.3004164997562423e-02
GC_6_5 ref NI_6 NS_5 0 7.0780069263252736e-05
GC_6_6 ref NI_6 NS_6 0 2.4516801215804032e-02
GC_6_7 ref NI_6 NS_7 0 -4.7517567953706111e-04
GC_6_8 ref NI_6 NS_8 0 1.6121969985114973e-01
GC_6_9 ref NI_6 NS_9 0 2.2168761965662553e-01
GC_6_10 ref NI_6 NS_10 0 -5.8095107859851343e-02
GC_6_11 ref NI_6 NS_11 0 7.0840786045197220e-06
GC_6_12 ref NI_6 NS_12 0 4.2193271459355558e-05
GC_6_13 ref NI_6 NS_13 0 4.4177042646571119e+00
GC_6_14 ref NI_6 NS_14 0 1.7660098741178673e-01
GC_6_15 ref NI_6 NS_15 0 -1.2984037195985898e+00
GC_6_16 ref NI_6 NS_16 0 2.6938912736759518e-01
GC_6_17 ref NI_6 NS_17 0 -7.4142372375792916e-05
GC_6_18 ref NI_6 NS_18 0 -1.3400050135587954e-02
GC_6_19 ref NI_6 NS_19 0 -6.8227444025497230e-01
GC_6_20 ref NI_6 NS_20 0 7.2467511866746637e-01
GC_6_21 ref NI_6 NS_21 0 2.1655176260950706e-01
GC_6_22 ref NI_6 NS_22 0 -7.8495710882074562e-02
GC_6_23 ref NI_6 NS_23 0 -1.1324547261921738e-06
GC_6_24 ref NI_6 NS_24 0 -6.1716854802819029e-04
GC_6_25 ref NI_6 NS_25 0 9.3395994566440088e-01
GC_6_26 ref NI_6 NS_26 0 7.5343900395631880e-02
GC_6_27 ref NI_6 NS_27 0 -2.4548523898895690e-03
GC_6_28 ref NI_6 NS_28 0 -4.2582333921569911e-02
GC_6_29 ref NI_6 NS_29 0 -7.7075093536415341e-06
GC_6_30 ref NI_6 NS_30 0 -1.5296995990762856e-03
GC_6_31 ref NI_6 NS_31 0 -3.3152689168041953e+00
GC_6_32 ref NI_6 NS_32 0 -2.8430143838577959e+00
GC_6_33 ref NI_6 NS_33 0 -9.7450491934898464e-01
GC_6_34 ref NI_6 NS_34 0 1.1493175572104156e-01
GC_6_35 ref NI_6 NS_35 0 -1.3306401555136622e-04
GC_6_36 ref NI_6 NS_36 0 -1.2190648359640345e-02
GC_6_37 ref NI_6 NS_37 0 -1.6890105914063142e-01
GC_6_38 ref NI_6 NS_38 0 7.9538156929274753e-02
GC_6_39 ref NI_6 NS_39 0 1.7267482853705832e-01
GC_6_40 ref NI_6 NS_40 0 2.9852852138449806e-02
GC_6_41 ref NI_6 NS_41 0 2.7020463505500297e-05
GC_6_42 ref NI_6 NS_42 0 -2.0146513957719213e-04
GC_6_43 ref NI_6 NS_43 0 1.6989869288746021e-01
GC_6_44 ref NI_6 NS_44 0 3.9720059063807364e-02
GC_6_45 ref NI_6 NS_45 0 1.5122959040783943e-01
GC_6_46 ref NI_6 NS_46 0 -4.9278263996369604e-03
GC_6_47 ref NI_6 NS_47 0 7.0116830737786681e-06
GC_6_48 ref NI_6 NS_48 0 -7.1492031737836802e-04
GC_6_49 ref NI_6 NS_49 0 -7.6956447391513860e-02
GC_6_50 ref NI_6 NS_50 0 4.9950124804397578e-01
GC_6_51 ref NI_6 NS_51 0 2.9741222788746574e-01
GC_6_52 ref NI_6 NS_52 0 -1.9204265148964200e-01
GC_6_53 ref NI_6 NS_53 0 -2.4482327048505086e-05
GC_6_54 ref NI_6 NS_54 0 5.4826986201990011e-04
GC_6_55 ref NI_6 NS_55 0 1.3054061758480331e-01
GC_6_56 ref NI_6 NS_56 0 -4.3244685824616507e-03
GC_6_57 ref NI_6 NS_57 0 3.4016596995608550e-01
GC_6_58 ref NI_6 NS_58 0 -1.3188999004954868e-01
GC_6_59 ref NI_6 NS_59 0 4.1958365854442797e-05
GC_6_60 ref NI_6 NS_60 0 9.0948081787440703e-04
GC_6_61 ref NI_6 NS_61 0 -9.5907496709735851e-01
GC_6_62 ref NI_6 NS_62 0 8.8353255890910576e-01
GC_6_63 ref NI_6 NS_63 0 4.8016069322462079e-01
GC_6_64 ref NI_6 NS_64 0 -2.7470267231384465e-01
GC_6_65 ref NI_6 NS_65 0 1.4269363062257555e-06
GC_6_66 ref NI_6 NS_66 0 2.5541902369118981e-03
GC_6_67 ref NI_6 NS_67 0 5.7616543100324713e-02
GC_6_68 ref NI_6 NS_68 0 -9.4128253059578670e-02
GC_6_69 ref NI_6 NS_69 0 2.2785277633978227e-02
GC_6_70 ref NI_6 NS_70 0 1.3951404820994279e-01
GC_6_71 ref NI_6 NS_71 0 1.5477997399905977e-05
GC_6_72 ref NI_6 NS_72 0 8.4816662722998217e-04
GC_6_73 ref NI_6 NS_73 0 1.1821013420233344e-01
GC_6_74 ref NI_6 NS_74 0 -2.1782546292631857e-01
GC_6_75 ref NI_6 NS_75 0 -1.7725606680488903e-02
GC_6_76 ref NI_6 NS_76 0 1.8998851980732628e-01
GC_6_77 ref NI_6 NS_77 0 7.5308456886326127e-05
GC_6_78 ref NI_6 NS_78 0 4.9522066647519187e-04
GC_6_79 ref NI_6 NS_79 0 -3.8113731546158580e-01
GC_6_80 ref NI_6 NS_80 0 4.7089673442013913e-01
GC_6_81 ref NI_6 NS_81 0 3.0113453036423532e-01
GC_6_82 ref NI_6 NS_82 0 -1.3229909550623864e-01
GC_6_83 ref NI_6 NS_83 0 -3.3220484907097620e-05
GC_6_84 ref NI_6 NS_84 0 4.8742207673475483e-04
GC_6_85 ref NI_6 NS_85 0 1.3231161832804916e-01
GC_6_86 ref NI_6 NS_86 0 -3.4126340560951351e-01
GC_6_87 ref NI_6 NS_87 0 2.4086585599734187e-01
GC_6_88 ref NI_6 NS_88 0 3.3200313835084656e-02
GC_6_89 ref NI_6 NS_89 0 3.6550591600769980e-05
GC_6_90 ref NI_6 NS_90 0 8.2783298651697545e-04
GD_6_1 ref NI_6 NA_1 0 1.8547005358803812e-03
GD_6_2 ref NI_6 NA_2 0 -7.0236862186463210e-03
GD_6_3 ref NI_6 NA_3 0 -2.9322620694754917e-02
GD_6_4 ref NI_6 NA_4 0 2.0876877096130558e-04
GD_6_5 ref NI_6 NA_5 0 6.6743734653543251e-04
GD_6_6 ref NI_6 NA_6 0 6.2669577892869404e+00
GD_6_7 ref NI_6 NA_7 0 -1.8282832798492022e-03
GD_6_8 ref NI_6 NA_8 0 1.3498489876024190e-04
GD_6_9 ref NI_6 NA_9 0 1.0538536736557937e-03
GD_6_10 ref NI_6 NA_10 0 1.0073943245451125e-02
GD_6_11 ref NI_6 NA_11 0 1.2716071583201169e-02
GD_6_12 ref NI_6 NA_12 0 1.3019082543866405e-03
GD_6_13 ref NI_6 NA_13 0 -1.3838668793743382e-03
GD_6_14 ref NI_6 NA_14 0 9.0629330846263758e-03
GD_6_15 ref NI_6 NA_15 0 4.6296525207887283e-04
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -3.5662417742134092e-02
GC_7_2 ref NI_7 NS_2 0 3.5556110935078308e-02
GC_7_3 ref NI_7 NS_3 0 -1.2508336514343707e-01
GC_7_4 ref NI_7 NS_4 0 1.0151198309775193e-01
GC_7_5 ref NI_7 NS_5 0 1.2536027200139776e-04
GC_7_6 ref NI_7 NS_6 0 3.8587246663571668e-02
GC_7_7 ref NI_7 NS_7 0 -1.4381451890802288e-01
GC_7_8 ref NI_7 NS_8 0 3.2491305232862383e-01
GC_7_9 ref NI_7 NS_9 0 2.3666937831643475e-01
GC_7_10 ref NI_7 NS_10 0 -8.6455255578044135e-02
GC_7_11 ref NI_7 NS_11 0 8.5925359842861120e-06
GC_7_12 ref NI_7 NS_12 0 -2.3252195186341523e-04
GC_7_13 ref NI_7 NS_13 0 4.1023808165100040e-02
GC_7_14 ref NI_7 NS_14 0 -1.8913708720508365e-01
GC_7_15 ref NI_7 NS_15 0 1.4605987391766037e-01
GC_7_16 ref NI_7 NS_16 0 8.3086558040656816e-02
GC_7_17 ref NI_7 NS_17 0 2.7214066364381564e-05
GC_7_18 ref NI_7 NS_18 0 -3.1734538839180295e-04
GC_7_19 ref NI_7 NS_19 0 -9.9733068624744570e-02
GC_7_20 ref NI_7 NS_20 0 -5.3752430912502883e-02
GC_7_21 ref NI_7 NS_21 0 4.6587906583731137e-01
GC_7_22 ref NI_7 NS_22 0 -1.6028729485101173e-01
GC_7_23 ref NI_7 NS_23 0 9.6661990705671488e-07
GC_7_24 ref NI_7 NS_24 0 -3.2246370314558792e-04
GC_7_25 ref NI_7 NS_25 0 -9.3935735173974699e-01
GC_7_26 ref NI_7 NS_26 0 1.0286343790138475e+00
GC_7_27 ref NI_7 NS_27 0 1.6177204102041112e-01
GC_7_28 ref NI_7 NS_28 0 -6.7472656824651686e-02
GC_7_29 ref NI_7 NS_29 0 2.1869637973402602e-05
GC_7_30 ref NI_7 NS_30 0 -2.2075907343705420e-03
GC_7_31 ref NI_7 NS_31 0 -1.6890105914063128e-01
GC_7_32 ref NI_7 NS_32 0 7.9538156929274476e-02
GC_7_33 ref NI_7 NS_33 0 1.7267482853705893e-01
GC_7_34 ref NI_7 NS_34 0 2.9852852138449286e-02
GC_7_35 ref NI_7 NS_35 0 2.7020463505473666e-05
GC_7_36 ref NI_7 NS_36 0 -2.0146513957711284e-04
GC_7_37 ref NI_7 NS_37 0 -5.5986900125631660e+00
GC_7_38 ref NI_7 NS_38 0 -2.9475287820675294e-02
GC_7_39 ref NI_7 NS_39 0 -1.4102208137850911e+00
GC_7_40 ref NI_7 NS_40 0 1.6745407272161697e-01
GC_7_41 ref NI_7 NS_41 0 -2.9485116837969571e-04
GC_7_42 ref NI_7 NS_42 0 -2.7746206217732754e-02
GC_7_43 ref NI_7 NS_43 0 7.3508013404939581e+00
GC_7_44 ref NI_7 NS_44 0 -2.2980246734046816e+00
GC_7_45 ref NI_7 NS_45 0 -5.8420779927509425e-01
GC_7_46 ref NI_7 NS_46 0 -1.5850000772617057e-01
GC_7_47 ref NI_7 NS_47 0 -5.9806980914960060e-05
GC_7_48 ref NI_7 NS_48 0 -8.0791451893089984e-03
GC_7_49 ref NI_7 NS_49 0 -7.2097678194519632e-01
GC_7_50 ref NI_7 NS_50 0 5.5155648328989149e-01
GC_7_51 ref NI_7 NS_51 0 6.1259796181758674e-01
GC_7_52 ref NI_7 NS_52 0 -3.1902204280502650e-01
GC_7_53 ref NI_7 NS_53 0 -9.0977189563203588e-06
GC_7_54 ref NI_7 NS_54 0 1.3032522845674644e-03
GC_7_55 ref NI_7 NS_55 0 -2.5918084226637873e-02
GC_7_56 ref NI_7 NS_56 0 -2.4921665900562552e-03
GC_7_57 ref NI_7 NS_57 0 -1.3714546687802334e-01
GC_7_58 ref NI_7 NS_58 0 2.3911276932618758e-01
GC_7_59 ref NI_7 NS_59 0 3.5135403848776721e-05
GC_7_60 ref NI_7 NS_60 0 2.7966063890861041e-03
GC_7_61 ref NI_7 NS_61 0 3.8532646296450229e-02
GC_7_62 ref NI_7 NS_62 0 -8.5827606942417312e-02
GC_7_63 ref NI_7 NS_63 0 -1.6834318657961267e-01
GC_7_64 ref NI_7 NS_64 0 2.7590283691001294e-01
GC_7_65 ref NI_7 NS_65 0 3.8308749443234319e-05
GC_7_66 ref NI_7 NS_66 0 1.7799696279204463e-03
GC_7_67 ref NI_7 NS_67 0 -9.4195418418926077e-02
GC_7_68 ref NI_7 NS_68 0 -2.8379445122457596e-02
GC_7_69 ref NI_7 NS_69 0 3.8787184941028485e-01
GC_7_70 ref NI_7 NS_70 0 -1.1172018443325300e-01
GC_7_71 ref NI_7 NS_71 0 7.1981120523640995e-05
GC_7_72 ref NI_7 NS_72 0 -8.2766985890966676e-04
GC_7_73 ref NI_7 NS_73 0 4.2650904985942339e-01
GC_7_74 ref NI_7 NS_74 0 7.9334469856558310e-01
GC_7_75 ref NI_7 NS_75 0 3.0721686420975880e-01
GC_7_76 ref NI_7 NS_76 0 -3.6536334803306558e-01
GC_7_77 ref NI_7 NS_77 0 -7.1353245445242452e-05
GC_7_78 ref NI_7 NS_78 0 -3.1603962245270976e-03
GC_7_79 ref NI_7 NS_79 0 2.2031070722906616e-02
GC_7_80 ref NI_7 NS_80 0 -6.4496184028518477e-02
GC_7_81 ref NI_7 NS_81 0 -8.4391511851478057e-02
GC_7_82 ref NI_7 NS_82 0 2.1421607584972746e-01
GC_7_83 ref NI_7 NS_83 0 6.6725735379741458e-05
GC_7_84 ref NI_7 NS_84 0 8.5585084664242892e-04
GC_7_85 ref NI_7 NS_85 0 1.1826108137409076e-01
GC_7_86 ref NI_7 NS_86 0 -2.0473703610907470e-01
GC_7_87 ref NI_7 NS_87 0 8.1860384579782536e-02
GC_7_88 ref NI_7 NS_88 0 1.1946549271212835e-01
GC_7_89 ref NI_7 NS_89 0 2.8960124079840678e-05
GC_7_90 ref NI_7 NS_90 0 -4.9553790593203468e-04
GD_7_1 ref NI_7 NA_1 0 1.6223587319857625e-03
GD_7_2 ref NI_7 NA_2 0 -4.1267542655523586e-03
GD_7_3 ref NI_7 NA_3 0 -1.2013390949558707e-03
GD_7_4 ref NI_7 NA_4 0 6.5733364198284220e-03
GD_7_5 ref NI_7 NA_5 0 -6.7078361442700673e-03
GD_7_6 ref NI_7 NA_6 0 -1.8282832798492022e-03
GD_7_7 ref NI_7 NA_7 0 6.1999029073949954e+00
GD_7_8 ref NI_7 NA_8 0 3.0870460085867864e-02
GD_7_9 ref NI_7 NA_9 0 2.6785209602830993e-03
GD_7_10 ref NI_7 NA_10 0 1.4235068637646849e-03
GD_7_11 ref NI_7 NA_11 0 6.7983943692531657e-04
GD_7_12 ref NI_7 NA_12 0 7.1688407323282789e-03
GD_7_13 ref NI_7 NA_13 0 4.2152201383920292e-02
GD_7_14 ref NI_7 NA_14 0 1.1066519318759195e-03
GD_7_15 ref NI_7 NA_15 0 1.0218591981311857e-03
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -3.9911582083376577e-02
GC_8_2 ref NI_8 NS_2 0 4.4932927173712681e-02
GC_8_3 ref NI_8 NS_3 0 -1.0249637965447070e-01
GC_8_4 ref NI_8 NS_4 0 9.9022840358154882e-02
GC_8_5 ref NI_8 NS_5 0 1.0569306372339613e-04
GC_8_6 ref NI_8 NS_6 0 3.4316651943477702e-02
GC_8_7 ref NI_8 NS_7 0 -1.5861286877382887e-02
GC_8_8 ref NI_8 NS_8 0 1.7187230879854776e-01
GC_8_9 ref NI_8 NS_9 0 2.4553098677954649e-01
GC_8_10 ref NI_8 NS_10 0 -7.5868892636197643e-02
GC_8_11 ref NI_8 NS_11 0 1.0933240090938570e-05
GC_8_12 ref NI_8 NS_12 0 -6.1508082115606803e-05
GC_8_13 ref NI_8 NS_13 0 -9.7170442832346535e-02
GC_8_14 ref NI_8 NS_14 0 7.1930635762941120e-02
GC_8_15 ref NI_8 NS_15 0 1.3998522450789355e-01
GC_8_16 ref NI_8 NS_16 0 4.4789464972796587e-02
GC_8_17 ref NI_8 NS_17 0 1.1028021689762242e-05
GC_8_18 ref NI_8 NS_18 0 -7.6880990150053987e-04
GC_8_19 ref NI_8 NS_19 0 -4.9009556877695354e-01
GC_8_20 ref NI_8 NS_20 0 6.4075427886842640e-01
GC_8_21 ref NI_8 NS_21 0 1.9681835261718367e-01
GC_8_22 ref NI_8 NS_22 0 -7.0071876079168691e-02
GC_8_23 ref NI_8 NS_23 0 -6.0802808103846865e-06
GC_8_24 ref NI_8 NS_24 0 -2.6603399554055267e-03
GC_8_25 ref NI_8 NS_25 0 1.2280751205277760e+00
GC_8_26 ref NI_8 NS_26 0 -3.2192362670575575e-01
GC_8_27 ref NI_8 NS_27 0 1.7042259620698677e-01
GC_8_28 ref NI_8 NS_28 0 -1.1599312632745258e-01
GC_8_29 ref NI_8 NS_29 0 -1.3865254093131325e-05
GC_8_30 ref NI_8 NS_30 0 -1.8739570150779737e-03
GC_8_31 ref NI_8 NS_31 0 1.6989869288745968e-01
GC_8_32 ref NI_8 NS_32 0 3.9720059063808176e-02
GC_8_33 ref NI_8 NS_33 0 1.5122959040783851e-01
GC_8_34 ref NI_8 NS_34 0 -4.9278263996362032e-03
GC_8_35 ref NI_8 NS_35 0 7.0116830738027721e-06
GC_8_36 ref NI_8 NS_36 0 -7.1492031737845833e-04
GC_8_37 ref NI_8 NS_37 0 7.3508013404939581e+00
GC_8_38 ref NI_8 NS_38 0 -2.2980246734046808e+00
GC_8_39 ref NI_8 NS_39 0 -5.8420779927509514e-01
GC_8_40 ref NI_8 NS_40 0 -1.5850000772616987e-01
GC_8_41 ref NI_8 NS_41 0 -5.9806980914931742e-05
GC_8_42 ref NI_8 NS_42 0 -8.0791451893090886e-03
GC_8_43 ref NI_8 NS_43 0 -6.9209226772178551e+00
GC_8_44 ref NI_8 NS_44 0 1.2811284979613974e-01
GC_8_45 ref NI_8 NS_45 0 -1.1887306037850087e+00
GC_8_46 ref NI_8 NS_46 0 1.9063093404800444e-01
GC_8_47 ref NI_8 NS_47 0 -2.0070872143866477e-04
GC_8_48 ref NI_8 NS_48 0 -2.2613766175451491e-02
GC_8_49 ref NI_8 NS_49 0 2.2370925573005959e-01
GC_8_50 ref NI_8 NS_50 0 4.6803418098231597e-01
GC_8_51 ref NI_8 NS_51 0 3.8046668630003661e-01
GC_8_52 ref NI_8 NS_52 0 -2.9661340433867761e-01
GC_8_53 ref NI_8 NS_53 0 -5.6470511025896004e-05
GC_8_54 ref NI_8 NS_54 0 -5.8060569799958954e-04
GC_8_55 ref NI_8 NS_55 0 2.3939944187062395e-02
GC_8_56 ref NI_8 NS_56 0 -1.1883909639535702e-02
GC_8_57 ref NI_8 NS_57 0 -1.0828253657769815e-01
GC_8_58 ref NI_8 NS_58 0 2.1267372487023534e-01
GC_8_59 ref NI_8 NS_59 0 4.2836366676232185e-05
GC_8_60 ref NI_8 NS_60 0 2.2650017592064052e-03
GC_8_61 ref NI_8 NS_61 0 4.4666548224552065e-02
GC_8_62 ref NI_8 NS_62 0 -1.0694150346039398e-01
GC_8_63 ref NI_8 NS_63 0 -1.0522312607855736e-01
GC_8_64 ref NI_8 NS_64 0 2.3471569796364067e-01
GC_8_65 ref NI_8 NS_65 0 3.9310891113959425e-05
GC_8_66 ref NI_8 NS_66 0 1.7041772244313386e-03
GC_8_67 ref NI_8 NS_67 0 7.9847059898450798e-02
GC_8_68 ref NI_8 NS_68 0 -2.3235795127057737e-01
GC_8_69 ref NI_8 NS_69 0 3.6273547123301914e-01
GC_8_70 ref NI_8 NS_70 0 -7.2756390986605649e-02
GC_8_71 ref NI_8 NS_71 0 4.2357611594070162e-05
GC_8_72 ref NI_8 NS_72 0 -3.7206128709021105e-05
GC_8_73 ref NI_8 NS_73 0 -1.3483160796997442e+00
GC_8_74 ref NI_8 NS_74 0 1.3739546453419138e+00
GC_8_75 ref NI_8 NS_75 0 4.8234352478261844e-01
GC_8_76 ref NI_8 NS_76 0 -3.2788637732535308e-01
GC_8_77 ref NI_8 NS_77 0 -9.9935899057972304e-06
GC_8_78 ref NI_8 NS_78 0 2.9767093808766098e-04
GC_8_79 ref NI_8 NS_79 0 7.5852263553863084e-02
GC_8_80 ref NI_8 NS_80 0 -9.1356238896463396e-02
GC_8_81 ref NI_8 NS_81 0 -4.3233048452901268e-02
GC_8_82 ref NI_8 NS_82 0 1.8078578205369850e-01
GC_8_83 ref NI_8 NS_83 0 6.8949652699185871e-05
GC_8_84 ref NI_8 NS_84 0 9.3015788386915325e-04
GC_8_85 ref NI_8 NS_85 0 3.5446577864245959e-02
GC_8_86 ref NI_8 NS_86 0 -1.5850642689566108e-01
GC_8_87 ref NI_8 NS_87 0 1.1793894557168286e-01
GC_8_88 ref NI_8 NS_88 0 9.3342398194276963e-02
GC_8_89 ref NI_8 NS_89 0 2.9678704159425555e-05
GC_8_90 ref NI_8 NS_90 0 2.5706684454745380e-04
GD_8_1 ref NI_8 NA_1 0 1.8888480138871328e-03
GD_8_2 ref NI_8 NA_2 0 -4.6384830310238333e-03
GD_8_3 ref NI_8 NA_3 0 -1.1643808076733883e-03
GD_8_4 ref NI_8 NA_4 0 -1.5160773357608028e-03
GD_8_5 ref NI_8 NA_5 0 1.0215314680367158e-02
GD_8_6 ref NI_8 NA_6 0 1.3498489876024190e-04
GD_8_7 ref NI_8 NA_7 0 3.0870460085867864e-02
GD_8_8 ref NI_8 NA_8 0 6.2053769425299938e+00
GD_8_9 ref NI_8 NA_9 0 6.8428377246712753e-03
GD_8_10 ref NI_8 NA_10 0 2.0513873011445212e-03
GD_8_11 ref NI_8 NA_11 0 1.1158001886748435e-03
GD_8_12 ref NI_8 NA_12 0 5.3292406517779769e-03
GD_8_13 ref NI_8 NA_13 0 9.9476517494580703e-03
GD_8_14 ref NI_8 NA_14 0 2.1181626795225461e-03
GD_8_15 ref NI_8 NA_15 0 2.0145885955921371e-03
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -3.4531024174210306e-02
GC_9_2 ref NI_9 NS_2 0 6.3170048631924339e-02
GC_9_3 ref NI_9 NS_3 0 1.5533475736166832e-01
GC_9_4 ref NI_9 NS_4 0 -3.6432527574645516e-03
GC_9_5 ref NI_9 NS_5 0 1.3280798848191419e-04
GC_9_6 ref NI_9 NS_6 0 7.5808773139795982e-03
GC_9_7 ref NI_9 NS_7 0 3.6286679621450046e-02
GC_9_8 ref NI_9 NS_8 0 6.1464673378847029e-03
GC_9_9 ref NI_9 NS_9 0 1.5965407041876314e-01
GC_9_10 ref NI_9 NS_10 0 2.2700884038021715e-02
GC_9_11 ref NI_9 NS_11 0 1.9226038003573906e-05
GC_9_12 ref NI_9 NS_12 0 2.0487438110332472e-05
GC_9_13 ref NI_9 NS_13 0 -3.6569014243951564e-01
GC_9_14 ref NI_9 NS_14 0 2.5828674799264600e-01
GC_9_15 ref NI_9 NS_15 0 4.4224182319394634e-01
GC_9_16 ref NI_9 NS_16 0 -1.8127372166295069e-01
GC_9_17 ref NI_9 NS_17 0 -1.4938879719803397e-05
GC_9_18 ref NI_9 NS_18 0 1.3533579558551376e-03
GC_9_19 ref NI_9 NS_19 0 -3.4939253156974337e-01
GC_9_20 ref NI_9 NS_20 0 1.9586936793230555e-01
GC_9_21 ref NI_9 NS_21 0 4.9188783823516324e-01
GC_9_22 ref NI_9 NS_22 0 -2.0148598613197216e-01
GC_9_23 ref NI_9 NS_23 0 -3.5580417967995021e-05
GC_9_24 ref NI_9 NS_24 0 9.7356056234615450e-04
GC_9_25 ref NI_9 NS_25 0 -1.1736249939973915e-01
GC_9_26 ref NI_9 NS_26 0 6.6227573502648807e-01
GC_9_27 ref NI_9 NS_27 0 2.5834974982293735e-01
GC_9_28 ref NI_9 NS_28 0 -1.9704880514147241e-01
GC_9_29 ref NI_9 NS_29 0 -4.7665491286169046e-05
GC_9_30 ref NI_9 NS_30 0 -9.7059266506926655e-05
GC_9_31 ref NI_9 NS_31 0 -7.6956447391514513e-02
GC_9_32 ref NI_9 NS_32 0 4.9950124804397678e-01
GC_9_33 ref NI_9 NS_33 0 2.9741222788746496e-01
GC_9_34 ref NI_9 NS_34 0 -1.9204265148964142e-01
GC_9_35 ref NI_9 NS_35 0 -2.4482327048492011e-05
GC_9_36 ref NI_9 NS_36 0 5.4826986201985013e-04
GC_9_37 ref NI_9 NS_37 0 -7.2097678194519577e-01
GC_9_38 ref NI_9 NS_38 0 5.5155648328989060e-01
GC_9_39 ref NI_9 NS_39 0 6.1259796181758852e-01
GC_9_40 ref NI_9 NS_40 0 -3.1902204280502799e-01
GC_9_41 ref NI_9 NS_41 0 -9.0977189563833628e-06
GC_9_42 ref NI_9 NS_42 0 1.3032522845676912e-03
GC_9_43 ref NI_9 NS_43 0 2.2370925573005851e-01
GC_9_44 ref NI_9 NS_44 0 4.6803418098231769e-01
GC_9_45 ref NI_9 NS_45 0 3.8046668630003450e-01
GC_9_46 ref NI_9 NS_46 0 -2.9661340433867600e-01
GC_9_47 ref NI_9 NS_47 0 -5.6470511025836623e-05
GC_9_48 ref NI_9 NS_48 0 -5.8060569799979901e-04
GC_9_49 ref NI_9 NS_49 0 1.0250659377467830e+00
GC_9_50 ref NI_9 NS_50 0 -1.7564509077603314e+00
GC_9_51 ref NI_9 NS_51 0 -2.7620630293232673e+00
GC_9_52 ref NI_9 NS_52 0 3.1738693051567873e-01
GC_9_53 ref NI_9 NS_53 0 -2.3732385297275355e-04
GC_9_54 ref NI_9 NS_54 0 -1.6021803936436659e-02
GC_9_55 ref NI_9 NS_55 0 -5.4838381819855139e-03
GC_9_56 ref NI_9 NS_56 0 6.3972839237165027e-03
GC_9_57 ref NI_9 NS_57 0 -4.3352956039857060e-02
GC_9_58 ref NI_9 NS_58 0 1.6822417206270784e-01
GC_9_59 ref NI_9 NS_59 0 4.1908204878676144e-05
GC_9_60 ref NI_9 NS_60 0 1.9395376007989792e-03
GC_9_61 ref NI_9 NS_61 0 1.2869685494486513e-01
GC_9_62 ref NI_9 NS_62 0 -2.4835560972932794e-01
GC_9_63 ref NI_9 NS_63 0 -1.8827596111324202e-02
GC_9_64 ref NI_9 NS_64 0 1.9463299714803353e-01
GC_9_65 ref NI_9 NS_65 0 4.4242491771224844e-05
GC_9_66 ref NI_9 NS_66 0 2.0439740416477530e-03
GC_9_67 ref NI_9 NS_67 0 1.0998166744087856e-01
GC_9_68 ref NI_9 NS_68 0 -1.6523597666881812e-01
GC_9_69 ref NI_9 NS_69 0 2.6656346785048133e-04
GC_9_70 ref NI_9 NS_70 0 1.6727293593206766e-01
GC_9_71 ref NI_9 NS_71 0 3.0113451657421869e-05
GC_9_72 ref NI_9 NS_72 0 4.5994103234052930e-04
GC_9_73 ref NI_9 NS_73 0 2.3504875657731503e-01
GC_9_74 ref NI_9 NS_74 0 -4.2292540310553695e-01
GC_9_75 ref NI_9 NS_75 0 1.6545444398792056e-01
GC_9_76 ref NI_9 NS_76 0 9.3362498287958159e-02
GC_9_77 ref NI_9 NS_77 0 5.1845773313482656e-05
GC_9_78 ref NI_9 NS_78 0 2.5348524458811437e-04
GC_9_79 ref NI_9 NS_79 0 6.6857523604282237e-02
GC_9_80 ref NI_9 NS_80 0 -1.0897241935826651e-01
GC_9_81 ref NI_9 NS_81 0 -2.0356043409568716e-02
GC_9_82 ref NI_9 NS_82 0 1.6964457156898605e-01
GC_9_83 ref NI_9 NS_83 0 7.8633515787449160e-05
GC_9_84 ref NI_9 NS_84 0 1.3191323032712998e-03
GC_9_85 ref NI_9 NS_85 0 1.5945255257891336e-01
GC_9_86 ref NI_9 NS_86 0 -2.8316861400519916e-01
GC_9_87 ref NI_9 NS_87 0 -8.9590181527550508e-03
GC_9_88 ref NI_9 NS_88 0 1.9420409522176449e-01
GC_9_89 ref NI_9 NS_89 0 3.8484963490815261e-05
GC_9_90 ref NI_9 NS_90 0 1.2095973614718485e-03
GD_9_1 ref NI_9 NA_1 0 2.8312439096860481e-03
GD_9_2 ref NI_9 NA_2 0 -6.1962367837532940e-03
GD_9_3 ref NI_9 NA_3 0 2.4009103720656006e-03
GD_9_4 ref NI_9 NA_4 0 3.1030506489028043e-03
GD_9_5 ref NI_9 NA_5 0 1.7427013674287560e-03
GD_9_6 ref NI_9 NA_6 0 1.0538536736557937e-03
GD_9_7 ref NI_9 NA_7 0 2.6785209602830993e-03
GD_9_8 ref NI_9 NA_8 0 6.8428377246712753e-03
GD_9_9 ref NI_9 NA_9 0 6.2567173001773542e+00
GD_9_10 ref NI_9 NA_10 0 1.9450746385324214e-03
GD_9_11 ref NI_9 NA_11 0 -7.9392687401972251e-04
GD_9_12 ref NI_9 NA_12 0 2.8894057910010360e-04
GD_9_13 ref NI_9 NA_13 0 -2.0422175885430288e-03
GD_9_14 ref NI_9 NA_14 0 1.0230697443482160e-03
GD_9_15 ref NI_9 NA_15 0 -1.5523341082128662e-03
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -4.6849659324584167e-02
GC_10_2 ref NI_10 NS_2 0 7.3420992941727492e-02
GC_10_3 ref NI_10 NS_3 0 -4.5287687193109993e-02
GC_10_4 ref NI_10 NS_4 0 6.3428275024300443e-02
GC_10_5 ref NI_10 NS_5 0 7.8382130617473390e-05
GC_10_6 ref NI_10 NS_6 0 3.0392421330292477e-02
GC_10_7 ref NI_10 NS_7 0 -1.1433354673640002e-01
GC_10_8 ref NI_10 NS_8 0 4.5931957650576200e-01
GC_10_9 ref NI_10 NS_9 0 1.6336589178131558e-01
GC_10_10 ref NI_10 NS_10 0 -7.7903250482077843e-02
GC_10_11 ref NI_10 NS_11 0 6.4918342113468108e-06
GC_10_12 ref NI_10 NS_12 0 2.4503753378451863e-04
GC_10_13 ref NI_10 NS_13 0 -3.3042267426274030e-01
GC_10_14 ref NI_10 NS_14 0 2.7143324663036961e-01
GC_10_15 ref NI_10 NS_15 0 4.9786210426870930e-01
GC_10_16 ref NI_10 NS_16 0 -2.3512343219665530e-01
GC_10_17 ref NI_10 NS_17 0 7.6592429509795393e-05
GC_10_18 ref NI_10 NS_18 0 8.4069236069402747e-04
GC_10_19 ref NI_10 NS_19 0 -5.1876054330057108e-03
GC_10_20 ref NI_10 NS_20 0 -4.7836845470842895e-02
GC_10_21 ref NI_10 NS_21 0 1.3802294059959710e-02
GC_10_22 ref NI_10 NS_22 0 1.4368513673849032e-01
GC_10_23 ref NI_10 NS_23 0 3.9711649533367684e-05
GC_10_24 ref NI_10 NS_24 0 1.1086263938461154e-03
GC_10_25 ref NI_10 NS_25 0 3.8630981798488444e-02
GC_10_26 ref NI_10 NS_26 0 -6.7083221350290306e-03
GC_10_27 ref NI_10 NS_27 0 2.7073673314290791e-02
GC_10_28 ref NI_10 NS_28 0 1.1289336258318791e-01
GC_10_29 ref NI_10 NS_29 0 5.0146584890245947e-05
GC_10_30 ref NI_10 NS_30 0 1.3506706410906790e-03
GC_10_31 ref NI_10 NS_31 0 1.3054061758480334e-01
GC_10_32 ref NI_10 NS_32 0 -4.3244685824616975e-03
GC_10_33 ref NI_10 NS_33 0 3.4016596995608545e-01
GC_10_34 ref NI_10 NS_34 0 -1.3188999004954860e-01
GC_10_35 ref NI_10 NS_35 0 4.1958365854446944e-05
GC_10_36 ref NI_10 NS_36 0 9.0948081787438817e-04
GC_10_37 ref NI_10 NS_37 0 -2.5918084226637567e-02
GC_10_38 ref NI_10 NS_38 0 -2.4921665900566759e-03
GC_10_39 ref NI_10 NS_39 0 -1.3714546687802304e-01
GC_10_40 ref NI_10 NS_40 0 2.3911276932618739e-01
GC_10_41 ref NI_10 NS_41 0 3.5135403848775000e-05
GC_10_42 ref NI_10 NS_42 0 2.7966063890861206e-03
GC_10_43 ref NI_10 NS_43 0 2.3939944187062596e-02
GC_10_44 ref NI_10 NS_44 0 -1.1883909639535921e-02
GC_10_45 ref NI_10 NS_45 0 -1.0828253657769815e-01
GC_10_46 ref NI_10 NS_46 0 2.1267372487023545e-01
GC_10_47 ref NI_10 NS_47 0 4.2836366676239320e-05
GC_10_48 ref NI_10 NS_48 0 2.2650017592063787e-03
GC_10_49 ref NI_10 NS_49 0 -5.4838381819849779e-03
GC_10_50 ref NI_10 NS_50 0 6.3972839237158236e-03
GC_10_51 ref NI_10 NS_51 0 -4.3352956039856796e-02
GC_10_52 ref NI_10 NS_52 0 1.6822417206270779e-01
GC_10_53 ref NI_10 NS_53 0 4.1908204878683367e-05
GC_10_54 ref NI_10 NS_54 0 1.9395376007989573e-03
GC_10_55 ref NI_10 NS_55 0 9.9311317081256867e-01
GC_10_56 ref NI_10 NS_56 0 -2.0405824231825873e+00
GC_10_57 ref NI_10 NS_57 0 -1.2752413016197413e+00
GC_10_58 ref NI_10 NS_58 0 -5.4153296930930706e-01
GC_10_59 ref NI_10 NS_59 0 -7.0097823514705525e-04
GC_10_60 ref NI_10 NS_60 0 -4.5197365140339250e-02
GC_10_61 ref NI_10 NS_61 0 -4.0793399949282300e-01
GC_10_62 ref NI_10 NS_62 0 1.2090336076614683e+00
GC_10_63 ref NI_10 NS_63 0 6.3877709819624406e-01
GC_10_64 ref NI_10 NS_64 0 -5.6452362445993842e-01
GC_10_65 ref NI_10 NS_65 0 2.8194870433518487e-04
GC_10_66 ref NI_10 NS_66 0 -5.2059937729076215e-03
GC_10_67 ref NI_10 NS_67 0 -2.3688113275504862e-02
GC_10_68 ref NI_10 NS_68 0 2.5608414319381604e-02
GC_10_69 ref NI_10 NS_69 0 -1.0863324990868888e-01
GC_10_70 ref NI_10 NS_70 0 2.0810113935210253e-01
GC_10_71 ref NI_10 NS_71 0 2.5241805965337175e-05
GC_10_72 ref NI_10 NS_72 0 3.2596311099510862e-03
GC_10_73 ref NI_10 NS_73 0 -3.2529632162318668e-02
GC_10_74 ref NI_10 NS_74 0 1.4120664591200533e-02
GC_10_75 ref NI_10 NS_75 0 -1.1523536600967305e-01
GC_10_76 ref NI_10 NS_76 0 2.1391133622868902e-01
GC_10_77 ref NI_10 NS_77 0 1.0206752108645039e-05
GC_10_78 ref NI_10 NS_78 0 4.4962827286047034e-03
GC_10_79 ref NI_10 NS_79 0 4.2037407126047817e-02
GC_10_80 ref NI_10 NS_80 0 -1.0805653115720512e-01
GC_10_81 ref NI_10 NS_81 0 2.4234108289274695e-01
GC_10_82 ref NI_10 NS_82 0 -1.2998549433962918e-02
GC_10_83 ref NI_10 NS_83 0 -1.7173032876313061e-05
GC_10_84 ref NI_10 NS_84 0 8.3753432111381297e-04
GC_10_85 ref NI_10 NS_85 0 2.2918894288143796e-02
GC_10_86 ref NI_10 NS_86 0 -6.2267354501586471e-02
GC_10_87 ref NI_10 NS_87 0 4.8339430301726737e-03
GC_10_88 ref NI_10 NS_88 0 1.4612277080276131e-01
GC_10_89 ref NI_10 NS_89 0 -1.1761771479091941e-07
GC_10_90 ref NI_10 NS_90 0 2.1094460489658076e-03
GD_10_1 ref NI_10 NA_1 0 3.8753455629879081e-03
GD_10_2 ref NI_10 NA_2 0 -3.9956052692034647e-04
GD_10_3 ref NI_10 NA_3 0 7.5156868501123856e-03
GD_10_4 ref NI_10 NA_4 0 6.6947475519355849e-04
GD_10_5 ref NI_10 NA_5 0 2.1647666729029706e-03
GD_10_6 ref NI_10 NA_6 0 1.0073943245451125e-02
GD_10_7 ref NI_10 NA_7 0 1.4235068637646849e-03
GD_10_8 ref NI_10 NA_8 0 2.0513873011445212e-03
GD_10_9 ref NI_10 NA_9 0 1.9450746385324214e-03
GD_10_10 ref NI_10 NA_10 0 6.1763157069668750e+00
GD_10_11 ref NI_10 NA_11 0 5.4768878340921652e-02
GD_10_12 ref NI_10 NA_12 0 4.1063837917316116e-03
GD_10_13 ref NI_10 NA_13 0 2.8246203552388565e-03
GD_10_14 ref NI_10 NA_14 0 4.6215425986309228e-03
GD_10_15 ref NI_10 NA_15 0 2.5058026747434444e-03
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -2.6837014328159187e-02
GC_11_2 ref NI_11 NS_2 0 1.8857535436388698e-02
GC_11_3 ref NI_11 NS_3 0 -1.0191774226913226e-01
GC_11_4 ref NI_11 NS_4 0 7.9922331949966327e-02
GC_11_5 ref NI_11 NS_5 0 1.2675097997494041e-04
GC_11_6 ref NI_11 NS_6 0 4.0512629909907213e-02
GC_11_7 ref NI_11 NS_7 0 -1.3064734282980520e-01
GC_11_8 ref NI_11 NS_8 0 4.7755984831739196e-01
GC_11_9 ref NI_11 NS_9 0 1.6364827866809764e-01
GC_11_10 ref NI_11 NS_10 0 -7.9805825275965692e-02
GC_11_11 ref NI_11 NS_11 0 3.5403513110838276e-05
GC_11_12 ref NI_11 NS_12 0 -3.1529074838552263e-04
GC_11_13 ref NI_11 NS_13 0 3.1486881020890395e-01
GC_11_14 ref NI_11 NS_14 0 6.6004324251126856e-01
GC_11_15 ref NI_11 NS_15 0 2.1778563233425990e-01
GC_11_16 ref NI_11 NS_16 0 -2.5602792594911689e-01
GC_11_17 ref NI_11 NS_17 0 1.6797663073935475e-05
GC_11_18 ref NI_11 NS_18 0 -6.6962442270616208e-05
GC_11_19 ref NI_11 NS_19 0 1.1782284633533767e-01
GC_11_20 ref NI_11 NS_20 0 -2.2148659795138284e-01
GC_11_21 ref NI_11 NS_21 0 6.8386989274754464e-02
GC_11_22 ref NI_11 NS_22 0 1.3031957553065787e-01
GC_11_23 ref NI_11 NS_23 0 3.7703178424578458e-05
GC_11_24 ref NI_11 NS_24 0 5.2278082899740949e-04
GC_11_25 ref NI_11 NS_25 0 2.1938088172074120e-02
GC_11_26 ref NI_11 NS_26 0 -1.5273828200541809e-01
GC_11_27 ref NI_11 NS_27 0 1.4641905993924392e-01
GC_11_28 ref NI_11 NS_28 0 6.7966441161493127e-02
GC_11_29 ref NI_11 NS_29 0 3.5480196597877950e-05
GC_11_30 ref NI_11 NS_30 0 1.7763744796267336e-03
GC_11_31 ref NI_11 NS_31 0 -9.5907496709735851e-01
GC_11_32 ref NI_11 NS_32 0 8.8353255890910576e-01
GC_11_33 ref NI_11 NS_33 0 4.8016069322462085e-01
GC_11_34 ref NI_11 NS_34 0 -2.7470267231384476e-01
GC_11_35 ref NI_11 NS_35 0 1.4269363062196912e-06
GC_11_36 ref NI_11 NS_36 0 2.5541902369119133e-03
GC_11_37 ref NI_11 NS_37 0 3.8532646296450139e-02
GC_11_38 ref NI_11 NS_38 0 -8.5827606942417145e-02
GC_11_39 ref NI_11 NS_39 0 -1.6834318657961286e-01
GC_11_40 ref NI_11 NS_40 0 2.7590283691001311e-01
GC_11_41 ref NI_11 NS_41 0 3.8308749443243263e-05
GC_11_42 ref NI_11 NS_42 0 1.7799696279204248e-03
GC_11_43 ref NI_11 NS_43 0 4.4666548224552023e-02
GC_11_44 ref NI_11 NS_44 0 -1.0694150346039386e-01
GC_11_45 ref NI_11 NS_45 0 -1.0522312607855758e-01
GC_11_46 ref NI_11 NS_46 0 2.3471569796364078e-01
GC_11_47 ref NI_11 NS_47 0 3.9310891113967882e-05
GC_11_48 ref NI_11 NS_48 0 1.7041772244313102e-03
GC_11_49 ref NI_11 NS_49 0 1.2869685494486552e-01
GC_11_50 ref NI_11 NS_50 0 -2.4835560972932841e-01
GC_11_51 ref NI_11 NS_51 0 -1.8827596111323903e-02
GC_11_52 ref NI_11 NS_52 0 1.9463299714803337e-01
GC_11_53 ref NI_11 NS_53 0 4.4242491771225718e-05
GC_11_54 ref NI_11 NS_54 0 2.0439740416477521e-03
GC_11_55 ref NI_11 NS_55 0 -4.0793399949282316e-01
GC_11_56 ref NI_11 NS_56 0 1.2090336076614685e+00
GC_11_57 ref NI_11 NS_57 0 6.3877709819624406e-01
GC_11_58 ref NI_11 NS_58 0 -5.6452362445993864e-01
GC_11_59 ref NI_11 NS_59 0 2.8194870433517690e-04
GC_11_60 ref NI_11 NS_60 0 -5.2059937729075963e-03
GC_11_61 ref NI_11 NS_61 0 1.1788677445249913e+00
GC_11_62 ref NI_11 NS_62 0 -2.8753298396753415e+00
GC_11_63 ref NI_11 NS_63 0 -1.4439937295342684e+00
GC_11_64 ref NI_11 NS_64 0 -2.1785314476471881e-01
GC_11_65 ref NI_11 NS_65 0 -6.1469313659776536e-04
GC_11_66 ref NI_11 NS_66 0 -4.8772531238583397e-02
GC_11_67 ref NI_11 NS_67 0 -1.6331612998721622e-02
GC_11_68 ref NI_11 NS_68 0 1.0905184864993018e-02
GC_11_69 ref NI_11 NS_69 0 -9.6601746516354267e-02
GC_11_70 ref NI_11 NS_70 0 2.0438774995600509e-01
GC_11_71 ref NI_11 NS_71 0 -2.7027008800883373e-06
GC_11_72 ref NI_11 NS_72 0 2.9396552545769869e-03
GC_11_73 ref NI_11 NS_73 0 -5.4001455046756616e-02
GC_11_74 ref NI_11 NS_74 0 7.8594691871626529e-02
GC_11_75 ref NI_11 NS_75 0 -1.5648537370523266e-01
GC_11_76 ref NI_11 NS_76 0 2.3533283679414005e-01
GC_11_77 ref NI_11 NS_77 0 1.9595502935096226e-05
GC_11_78 ref NI_11 NS_78 0 2.8784413124353678e-03
GC_11_79 ref NI_11 NS_79 0 -1.2603055595171575e-01
GC_11_80 ref NI_11 NS_80 0 2.6994961302382470e-01
GC_11_81 ref NI_11 NS_81 0 3.5686818415695237e-01
GC_11_82 ref NI_11 NS_82 0 -1.5951421425180221e-01
GC_11_83 ref NI_11 NS_83 0 -3.9085364113014231e-05
GC_11_84 ref NI_11 NS_84 0 -1.0681435392822780e-03
GC_11_85 ref NI_11 NS_85 0 2.7738189764489976e-03
GC_11_86 ref NI_11 NS_86 0 -2.4565960220312353e-02
GC_11_87 ref NI_11 NS_87 0 7.0867953628516930e-02
GC_11_88 ref NI_11 NS_88 0 9.7251810828610841e-02
GC_11_89 ref NI_11 NS_89 0 -2.5214273820095932e-06
GC_11_90 ref NI_11 NS_90 0 3.1162603683831600e-04
GD_11_1 ref NI_11 NA_1 0 2.2026101820709779e-03
GD_11_2 ref NI_11 NA_2 0 8.4381215335007742e-04
GD_11_3 ref NI_11 NA_3 0 3.0772390110657376e-02
GD_11_4 ref NI_11 NA_4 0 -5.0086049853633179e-04
GD_11_5 ref NI_11 NA_5 0 2.6210299861583780e-03
GD_11_6 ref NI_11 NA_6 0 1.2716071583201169e-02
GD_11_7 ref NI_11 NA_7 0 6.7983943692531657e-04
GD_11_8 ref NI_11 NA_8 0 1.1158001886748435e-03
GD_11_9 ref NI_11 NA_9 0 -7.9392687401972251e-04
GD_11_10 ref NI_11 NA_10 0 5.4768878340921652e-02
GD_11_11 ref NI_11 NA_11 0 6.1582885794415754e+00
GD_11_12 ref NI_11 NA_12 0 3.9587698528937079e-03
GD_11_13 ref NI_11 NA_13 0 3.4378630731823887e-03
GD_11_14 ref NI_11 NA_14 0 1.2914039188742241e-02
GD_11_15 ref NI_11 NA_15 0 3.6693847611312699e-03
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -5.2245774330048220e-02
GC_12_2 ref NI_12 NS_2 0 7.0326009117092303e-02
GC_12_3 ref NI_12 NS_3 0 -1.0227526720589940e-01
GC_12_4 ref NI_12 NS_4 0 5.4398188994578697e-02
GC_12_5 ref NI_12 NS_5 0 1.1580796534212997e-04
GC_12_6 ref NI_12 NS_6 0 4.5455283305654688e-02
GC_12_7 ref NI_12 NS_7 0 -1.2102446271694994e-01
GC_12_8 ref NI_12 NS_8 0 4.9452610258327007e-01
GC_12_9 ref NI_12 NS_9 0 2.1884342532724432e-01
GC_12_10 ref NI_12 NS_10 0 -1.2508735973790377e-01
GC_12_11 ref NI_12 NS_11 0 -8.9165802763132882e-06
GC_12_12 ref NI_12 NS_12 0 -8.5091371919187805e-05
GC_12_13 ref NI_12 NS_13 0 5.3940967884975786e-02
GC_12_14 ref NI_12 NS_14 0 -1.0201700979579750e-01
GC_12_15 ref NI_12 NS_15 0 -1.3145429580713797e-02
GC_12_16 ref NI_12 NS_16 0 1.6981652084730367e-01
GC_12_17 ref NI_12 NS_17 0 1.1850053302150352e-05
GC_12_18 ref NI_12 NS_18 0 5.8460960319492981e-04
GC_12_19 ref NI_12 NS_19 0 -5.4244218474600113e-02
GC_12_20 ref NI_12 NS_20 0 6.1881312422343759e-01
GC_12_21 ref NI_12 NS_21 0 1.5476448637082177e-01
GC_12_22 ref NI_12 NS_22 0 -1.1725911781875042e-01
GC_12_23 ref NI_12 NS_23 0 -5.4267707972280783e-05
GC_12_24 ref NI_12 NS_24 0 -2.3575202910410820e-03
GC_12_25 ref NI_12 NS_25 0 -2.9608375604105025e-01
GC_12_26 ref NI_12 NS_26 0 3.8982990763774800e-01
GC_12_27 ref NI_12 NS_27 0 2.2560943409643899e-01
GC_12_28 ref NI_12 NS_28 0 -6.7830441922878945e-02
GC_12_29 ref NI_12 NS_29 0 -2.5801024609144135e-05
GC_12_30 ref NI_12 NS_30 0 -5.7079226009412157e-04
GC_12_31 ref NI_12 NS_31 0 5.7616543100324567e-02
GC_12_32 ref NI_12 NS_32 0 -9.4128253059578504e-02
GC_12_33 ref NI_12 NS_33 0 2.2785277633978033e-02
GC_12_34 ref NI_12 NS_34 0 1.3951404820994295e-01
GC_12_35 ref NI_12 NS_35 0 1.5477997399907760e-05
GC_12_36 ref NI_12 NS_36 0 8.4816662722996569e-04
GC_12_37 ref NI_12 NS_37 0 -9.4195418418925800e-02
GC_12_38 ref NI_12 NS_38 0 -2.8379445122458026e-02
GC_12_39 ref NI_12 NS_39 0 3.8787184941028546e-01
GC_12_40 ref NI_12 NS_40 0 -1.1172018443325338e-01
GC_12_41 ref NI_12 NS_41 0 7.1981120523629150e-05
GC_12_42 ref NI_12 NS_42 0 -8.2766985890961775e-04
GC_12_43 ref NI_12 NS_43 0 7.9847059898450840e-02
GC_12_44 ref NI_12 NS_44 0 -2.3235795127057737e-01
GC_12_45 ref NI_12 NS_45 0 3.6273547123301897e-01
GC_12_46 ref NI_12 NS_46 0 -7.2756390986605537e-02
GC_12_47 ref NI_12 NS_47 0 4.2357611594073374e-05
GC_12_48 ref NI_12 NS_48 0 -3.7206128709039279e-05
GC_12_49 ref NI_12 NS_49 0 1.0998166744087906e-01
GC_12_50 ref NI_12 NS_50 0 -1.6523597666881881e-01
GC_12_51 ref NI_12 NS_51 0 2.6656346785094368e-04
GC_12_52 ref NI_12 NS_52 0 1.6727293593206738e-01
GC_12_53 ref NI_12 NS_53 0 3.0113451657417441e-05
GC_12_54 ref NI_12 NS_54 0 4.5994103234054274e-04
GC_12_55 ref NI_12 NS_55 0 -2.3688113275504880e-02
GC_12_56 ref NI_12 NS_56 0 2.5608414319381569e-02
GC_12_57 ref NI_12 NS_57 0 -1.0863324990868860e-01
GC_12_58 ref NI_12 NS_58 0 2.0810113935210225e-01
GC_12_59 ref NI_12 NS_59 0 2.5241805965323246e-05
GC_12_60 ref NI_12 NS_60 0 3.2596311099511292e-03
GC_12_61 ref NI_12 NS_61 0 -1.6331612998721566e-02
GC_12_62 ref NI_12 NS_62 0 1.0905184864992938e-02
GC_12_63 ref NI_12 NS_63 0 -9.6601746516354225e-02
GC_12_64 ref NI_12 NS_64 0 2.0438774995600512e-01
GC_12_65 ref NI_12 NS_65 0 -2.7027008800866788e-06
GC_12_66 ref NI_12 NS_66 0 2.9396552545769760e-03
GC_12_67 ref NI_12 NS_67 0 1.1051304769132106e+00
GC_12_68 ref NI_12 NS_68 0 -2.6363769366895973e+00
GC_12_69 ref NI_12 NS_69 0 -1.6999405492793189e+00
GC_12_70 ref NI_12 NS_70 0 -1.0421835824857072e-01
GC_12_71 ref NI_12 NS_71 0 -5.3342725580751065e-04
GC_12_72 ref NI_12 NS_72 0 -4.3920516350853728e-02
GC_12_73 ref NI_12 NS_73 0 -3.8163709155022790e-01
GC_12_74 ref NI_12 NS_74 0 1.2103531916126358e+00
GC_12_75 ref NI_12 NS_75 0 2.9812580851058412e-01
GC_12_76 ref NI_12 NS_76 0 -3.2251580218575465e-01
GC_12_77 ref NI_12 NS_77 0 3.1668174362263057e-04
GC_12_78 ref NI_12 NS_78 0 -5.1245864159606422e-03
GC_12_79 ref NI_12 NS_79 0 1.9928613029386439e-02
GC_12_80 ref NI_12 NS_80 0 -8.0198702573512984e-02
GC_12_81 ref NI_12 NS_81 0 8.6906200996392083e-02
GC_12_82 ref NI_12 NS_82 0 9.1085838134372710e-02
GC_12_83 ref NI_12 NS_83 0 2.6047333125298186e-05
GC_12_84 ref NI_12 NS_84 0 1.9016554859073425e-03
GC_12_85 ref NI_12 NS_85 0 -1.7209332608748873e-01
GC_12_86 ref NI_12 NS_86 0 3.3243267225923284e-01
GC_12_87 ref NI_12 NS_87 0 3.4388209542455628e-01
GC_12_88 ref NI_12 NS_88 0 -1.6147629165956615e-01
GC_12_89 ref NI_12 NS_89 0 -1.5948067167338999e-05
GC_12_90 ref NI_12 NS_90 0 -5.5114835328314851e-04
GD_12_1 ref NI_12 NA_1 0 2.7728255086615357e-03
GD_12_2 ref NI_12 NA_2 0 1.1995028181740670e-03
GD_12_3 ref NI_12 NA_3 0 6.9693660521130357e-05
GD_12_4 ref NI_12 NA_4 0 1.3368868100897107e-02
GD_12_5 ref NI_12 NA_5 0 8.4060419354320560e-03
GD_12_6 ref NI_12 NA_6 0 1.3019082543866405e-03
GD_12_7 ref NI_12 NA_7 0 7.1688407323282789e-03
GD_12_8 ref NI_12 NA_8 0 5.3292406517779769e-03
GD_12_9 ref NI_12 NA_9 0 2.8894057910010360e-04
GD_12_10 ref NI_12 NA_10 0 4.1063837917316116e-03
GD_12_11 ref NI_12 NA_11 0 3.9587698528937079e-03
GD_12_12 ref NI_12 NA_12 0 6.1623661819060702e+00
GD_12_13 ref NI_12 NA_13 0 4.9456134010121437e-02
GD_12_14 ref NI_12 NA_14 0 4.5841400709194678e-03
GD_12_15 ref NI_12 NA_15 0 1.4235234657557407e-02
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -5.5985869250389550e-02
GC_13_2 ref NI_13 NS_2 0 7.5458711939465961e-02
GC_13_3 ref NI_13 NS_3 0 -1.2550811412716342e-01
GC_13_4 ref NI_13 NS_4 0 6.5708006896318213e-02
GC_13_5 ref NI_13 NS_5 0 1.6013542675848667e-04
GC_13_6 ref NI_13 NS_6 0 4.6232786006945213e-02
GC_13_7 ref NI_13 NS_7 0 -1.7991176946763232e-01
GC_13_8 ref NI_13 NS_8 0 7.3503829415735145e-01
GC_13_9 ref NI_13 NS_9 0 1.5483551459326647e-01
GC_13_10 ref NI_13 NS_10 0 -1.3782931146218980e-01
GC_13_11 ref NI_13 NS_11 0 5.8058584060298171e-05
GC_13_12 ref NI_13 NS_12 0 4.2185953495319216e-04
GC_13_13 ref NI_13 NS_13 0 8.9797053424554713e-02
GC_13_14 ref NI_13 NS_14 0 -1.6585923542552053e-01
GC_13_15 ref NI_13 NS_15 0 -9.0989720473628605e-02
GC_13_16 ref NI_13 NS_16 0 2.3632141214028379e-01
GC_13_17 ref NI_13 NS_17 0 7.0205679337793128e-05
GC_13_18 ref NI_13 NS_18 0 4.8964839093908126e-05
GC_13_19 ref NI_13 NS_19 0 6.5732233370242615e-02
GC_13_20 ref NI_13 NS_20 0 -3.0741257922453280e-01
GC_13_21 ref NI_13 NS_21 0 3.4019425289043548e-01
GC_13_22 ref NI_13 NS_22 0 -3.1081134366624009e-02
GC_13_23 ref NI_13 NS_23 0 3.7501697156243358e-05
GC_13_24 ref NI_13 NS_24 0 -5.6581864014642268e-04
GC_13_25 ref NI_13 NS_25 0 1.4058655600083259e-01
GC_13_26 ref NI_13 NS_26 0 -3.7929665658993128e-01
GC_13_27 ref NI_13 NS_27 0 3.4174161735925640e-01
GC_13_28 ref NI_13 NS_28 0 -3.2368128466226803e-02
GC_13_29 ref NI_13 NS_29 0 6.1993075929199168e-05
GC_13_30 ref NI_13 NS_30 0 6.3692428358765073e-04
GC_13_31 ref NI_13 NS_31 0 1.1821013420233314e-01
GC_13_32 ref NI_13 NS_32 0 -2.1782546292631813e-01
GC_13_33 ref NI_13 NS_33 0 -1.7725606680489159e-02
GC_13_34 ref NI_13 NS_34 0 1.8998851980732648e-01
GC_13_35 ref NI_13 NS_35 0 7.5308456886325490e-05
GC_13_36 ref NI_13 NS_36 0 4.9522066647519002e-04
GC_13_37 ref NI_13 NS_37 0 4.2650904985942334e-01
GC_13_38 ref NI_13 NS_38 0 7.9334469856558332e-01
GC_13_39 ref NI_13 NS_39 0 3.0721686420975891e-01
GC_13_40 ref NI_13 NS_40 0 -3.6536334803306569e-01
GC_13_41 ref NI_13 NS_41 0 -7.1353245445246572e-05
GC_13_42 ref NI_13 NS_42 0 -3.1603962245270729e-03
GC_13_43 ref NI_13 NS_43 0 -1.3483160796997442e+00
GC_13_44 ref NI_13 NS_44 0 1.3739546453419138e+00
GC_13_45 ref NI_13 NS_45 0 4.8234352478261827e-01
GC_13_46 ref NI_13 NS_46 0 -3.2788637732535308e-01
GC_13_47 ref NI_13 NS_47 0 -9.9935899057964613e-06
GC_13_48 ref NI_13 NS_48 0 2.9767093808765892e-04
GC_13_49 ref NI_13 NS_49 0 2.3504875657731508e-01
GC_13_50 ref NI_13 NS_50 0 -4.2292540310553706e-01
GC_13_51 ref NI_13 NS_51 0 1.6545444398792036e-01
GC_13_52 ref NI_13 NS_52 0 9.3362498287958354e-02
GC_13_53 ref NI_13 NS_53 0 5.1845773313493660e-05
GC_13_54 ref NI_13 NS_54 0 2.5348524458807686e-04
GC_13_55 ref NI_13 NS_55 0 -3.2529632162318918e-02
GC_13_56 ref NI_13 NS_56 0 1.4120664591200819e-02
GC_13_57 ref NI_13 NS_57 0 -1.1523536600967291e-01
GC_13_58 ref NI_13 NS_58 0 2.1391133622868885e-01
GC_13_59 ref NI_13 NS_59 0 1.0206752108630274e-05
GC_13_60 ref NI_13 NS_60 0 4.4962827286047528e-03
GC_13_61 ref NI_13 NS_61 0 -5.4001455046756783e-02
GC_13_62 ref NI_13 NS_62 0 7.8594691871626779e-02
GC_13_63 ref NI_13 NS_63 0 -1.5648537370523291e-01
GC_13_64 ref NI_13 NS_64 0 2.3533283679414027e-01
GC_13_65 ref NI_13 NS_65 0 1.9595502935103223e-05
GC_13_66 ref NI_13 NS_66 0 2.8784413124353448e-03
GC_13_67 ref NI_13 NS_67 0 -3.8163709155022818e-01
GC_13_68 ref NI_13 NS_68 0 1.2103531916126358e+00
GC_13_69 ref NI_13 NS_69 0 2.9812580851058385e-01
GC_13_70 ref NI_13 NS_70 0 -3.2251580218575454e-01
GC_13_71 ref NI_13 NS_71 0 3.1668174362263669e-04
GC_13_72 ref NI_13 NS_72 0 -5.1245864159606535e-03
GC_13_73 ref NI_13 NS_73 0 1.1318618376054290e+00
GC_13_74 ref NI_13 NS_74 0 -2.8690569069672742e+00
GC_13_75 ref NI_13 NS_75 0 -1.6264275353203268e+00
GC_13_76 ref NI_13 NS_76 0 -7.3932833486682656e-02
GC_13_77 ref NI_13 NS_77 0 -7.7211388938622011e-04
GC_13_78 ref NI_13 NS_78 0 -4.7003376332104135e-02
GC_13_79 ref NI_13 NS_79 0 2.0277262429924401e-03
GC_13_80 ref NI_13 NS_80 0 -4.1106414476842774e-02
GC_13_81 ref NI_13 NS_81 0 -5.0593279325706023e-02
GC_13_82 ref NI_13 NS_82 0 1.8260527278647268e-01
GC_13_83 ref NI_13 NS_83 0 2.8099346293375384e-05
GC_13_84 ref NI_13 NS_84 0 2.2873596441426751e-03
GC_13_85 ref NI_13 NS_85 0 -1.3857694170720126e-03
GC_13_86 ref NI_13 NS_86 0 -9.0593921597828912e-03
GC_13_87 ref NI_13 NS_87 0 1.5548008501216348e-01
GC_13_88 ref NI_13 NS_88 0 3.5403938485890615e-02
GC_13_89 ref NI_13 NS_89 0 -1.9344634543219438e-05
GC_13_90 ref NI_13 NS_90 0 -4.1989235240993505e-04
GD_13_1 ref NI_13 NA_1 0 2.6130732546968448e-03
GD_13_2 ref NI_13 NA_2 0 -8.8106050799719165e-04
GD_13_3 ref NI_13 NA_3 0 -1.7843299901629485e-03
GD_13_4 ref NI_13 NA_4 0 -1.8129841350004458e-03
GD_13_5 ref NI_13 NA_5 0 1.1241364878725926e-03
GD_13_6 ref NI_13 NA_6 0 -1.3838668793743382e-03
GD_13_7 ref NI_13 NA_7 0 4.2152201383920292e-02
GD_13_8 ref NI_13 NA_8 0 9.9476517494580703e-03
GD_13_9 ref NI_13 NA_9 0 -2.0422175885430288e-03
GD_13_10 ref NI_13 NA_10 0 2.8246203552388565e-03
GD_13_11 ref NI_13 NA_11 0 3.4378630731823887e-03
GD_13_12 ref NI_13 NA_12 0 4.9456134010121437e-02
GD_13_13 ref NI_13 NA_13 0 6.1729098843892416e+00
GD_13_14 ref NI_13 NA_14 0 2.6025767534666160e-03
GD_13_15 ref NI_13 NA_15 0 3.0686886442040308e-03
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 -3.9816151589141362e-02
GC_14_2 ref NI_14 NS_2 0 5.2238720193437220e-02
GC_14_3 ref NI_14 NS_3 0 -9.5526074753898710e-02
GC_14_4 ref NI_14 NS_4 0 6.5526111130589787e-02
GC_14_5 ref NI_14 NS_5 0 1.1545250642127261e-04
GC_14_6 ref NI_14 NS_6 0 4.1497049354131926e-02
GC_14_7 ref NI_14 NS_7 0 -1.0278371684821366e-01
GC_14_8 ref NI_14 NS_8 0 4.4238206187847023e-01
GC_14_9 ref NI_14 NS_9 0 1.7309612129892127e-01
GC_14_10 ref NI_14 NS_10 0 -8.0680381051292507e-02
GC_14_11 ref NI_14 NS_11 0 8.5972966381245906e-06
GC_14_12 ref NI_14 NS_12 0 -4.4557126323253719e-04
GC_14_13 ref NI_14 NS_13 0 3.0781972461723754e-02
GC_14_14 ref NI_14 NS_14 0 4.9400282861412692e-01
GC_14_15 ref NI_14 NS_15 0 2.2328812646186844e-01
GC_14_16 ref NI_14 NS_16 0 -1.5089905103539900e-01
GC_14_17 ref NI_14 NS_17 0 -6.8293998884793623e-05
GC_14_18 ref NI_14 NS_18 0 -1.5913025676351793e-03
GC_14_19 ref NI_14 NS_19 0 -1.9240449810889892e-01
GC_14_20 ref NI_14 NS_20 0 4.6174062849499681e-02
GC_14_21 ref NI_14 NS_21 0 3.4021239755907307e-01
GC_14_22 ref NI_14 NS_22 0 -9.3587069405769246e-02
GC_14_23 ref NI_14 NS_23 0 1.4320483501433255e-04
GC_14_24 ref NI_14 NS_24 0 2.7163204850224557e-03
GC_14_25 ref NI_14 NS_25 0 1.2643171482094323e-01
GC_14_26 ref NI_14 NS_26 0 -1.7836999842719453e-01
GC_14_27 ref NI_14 NS_27 0 2.6563122398841632e-01
GC_14_28 ref NI_14 NS_28 0 -3.9303805250108258e-02
GC_14_29 ref NI_14 NS_29 0 1.0132948840036412e-04
GC_14_30 ref NI_14 NS_30 0 3.2014482757338593e-03
GC_14_31 ref NI_14 NS_31 0 -3.8113731546158597e-01
GC_14_32 ref NI_14 NS_32 0 4.7089673442013941e-01
GC_14_33 ref NI_14 NS_33 0 3.0113453036423526e-01
GC_14_34 ref NI_14 NS_34 0 -1.3229909550623856e-01
GC_14_35 ref NI_14 NS_35 0 -3.3220484907101957e-05
GC_14_36 ref NI_14 NS_36 0 4.8742207673475863e-04
GC_14_37 ref NI_14 NS_37 0 2.2031070722906665e-02
GC_14_38 ref NI_14 NS_38 0 -6.4496184028518547e-02
GC_14_39 ref NI_14 NS_39 0 -8.4391511851477946e-02
GC_14_40 ref NI_14 NS_40 0 2.1421607584972735e-01
GC_14_41 ref NI_14 NS_41 0 6.6725735379738897e-05
GC_14_42 ref NI_14 NS_42 0 8.5585084664244540e-04
GC_14_43 ref NI_14 NS_43 0 7.5852263553863097e-02
GC_14_44 ref NI_14 NS_44 0 -9.1356238896463396e-02
GC_14_45 ref NI_14 NS_45 0 -4.3233048452901282e-02
GC_14_46 ref NI_14 NS_46 0 1.8078578205369855e-01
GC_14_47 ref NI_14 NS_47 0 6.8949652699185979e-05
GC_14_48 ref NI_14 NS_48 0 9.3015788386914804e-04
GC_14_49 ref NI_14 NS_49 0 6.6857523604282626e-02
GC_14_50 ref NI_14 NS_50 0 -1.0897241935826703e-01
GC_14_51 ref NI_14 NS_51 0 -2.0356043409568498e-02
GC_14_52 ref NI_14 NS_52 0 1.6964457156898599e-01
GC_14_53 ref NI_14 NS_53 0 7.8633515787452507e-05
GC_14_54 ref NI_14 NS_54 0 1.3191323032712876e-03
GC_14_55 ref NI_14 NS_55 0 4.2037407126047609e-02
GC_14_56 ref NI_14 NS_56 0 -1.0805653115720489e-01
GC_14_57 ref NI_14 NS_57 0 2.4234108289274681e-01
GC_14_58 ref NI_14 NS_58 0 -1.2998549433962885e-02
GC_14_59 ref NI_14 NS_59 0 -1.7173032876317652e-05
GC_14_60 ref NI_14 NS_60 0 8.3753432111382208e-04
GC_14_61 ref NI_14 NS_61 0 -1.2603055595171553e-01
GC_14_62 ref NI_14 NS_62 0 2.6994961302382436e-01
GC_14_63 ref NI_14 NS_63 0 3.5686818415695276e-01
GC_14_64 ref NI_14 NS_64 0 -1.5951421425180254e-01
GC_14_65 ref NI_14 NS_65 0 -3.9085364113028041e-05
GC_14_66 ref NI_14 NS_66 0 -1.0681435392822314e-03
GC_14_67 ref NI_14 NS_67 0 1.9928613029386529e-02
GC_14_68 ref NI_14 NS_68 0 -8.0198702573513123e-02
GC_14_69 ref NI_14 NS_69 0 8.6906200996392291e-02
GC_14_70 ref NI_14 NS_70 0 9.1085838134372529e-02
GC_14_71 ref NI_14 NS_71 0 2.6047333125293528e-05
GC_14_72 ref NI_14 NS_72 0 1.9016554859073627e-03
GC_14_73 ref NI_14 NS_73 0 2.0277262429926808e-03
GC_14_74 ref NI_14 NS_74 0 -4.1106414476843128e-02
GC_14_75 ref NI_14 NS_75 0 -5.0593279325705655e-02
GC_14_76 ref NI_14 NS_76 0 1.8260527278647240e-01
GC_14_77 ref NI_14 NS_77 0 2.8099346293364664e-05
GC_14_78 ref NI_14 NS_78 0 2.2873596441427080e-03
GC_14_79 ref NI_14 NS_79 0 1.0481864067054811e+00
GC_14_80 ref NI_14 NS_80 0 -2.5242419919758086e+00
GC_14_81 ref NI_14 NS_81 0 -1.8238117051467870e+00
GC_14_82 ref NI_14 NS_82 0 -1.2664113491681742e-02
GC_14_83 ref NI_14 NS_83 0 -7.8529062011302778e-04
GC_14_84 ref NI_14 NS_84 0 -4.7006392573395193e-02
GC_14_85 ref NI_14 NS_85 0 -3.8059585805773116e-01
GC_14_86 ref NI_14 NS_86 0 1.2383081885922844e+00
GC_14_87 ref NI_14 NS_87 0 2.0788167697737356e-01
GC_14_88 ref NI_14 NS_88 0 -2.6911587879727583e-01
GC_14_89 ref NI_14 NS_89 0 3.2070851572032333e-04
GC_14_90 ref NI_14 NS_90 0 -3.9886615209110843e-03
GD_14_1 ref NI_14 NA_1 0 2.6281496304284171e-03
GD_14_2 ref NI_14 NA_2 0 8.0155841281056921e-04
GD_14_3 ref NI_14 NA_3 0 1.2669859597916772e-02
GD_14_4 ref NI_14 NA_4 0 3.4152785419609005e-03
GD_14_5 ref NI_14 NA_5 0 5.7872920238125902e-03
GD_14_6 ref NI_14 NA_6 0 9.0629330846263758e-03
GD_14_7 ref NI_14 NA_7 0 1.1066519318759195e-03
GD_14_8 ref NI_14 NA_8 0 2.1181626795225461e-03
GD_14_9 ref NI_14 NA_9 0 1.0230697443482160e-03
GD_14_10 ref NI_14 NA_10 0 4.6215425986309228e-03
GD_14_11 ref NI_14 NA_11 0 1.2914039188742241e-02
GD_14_12 ref NI_14 NA_12 0 4.5841400709194678e-03
GD_14_13 ref NI_14 NA_13 0 2.6025767534666160e-03
GD_14_14 ref NI_14 NA_14 0 6.1652317709981386e+00
GD_14_15 ref NI_14 NA_15 0 5.0883558302825989e-02
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -4.8487895635254526e-02
GC_15_2 ref NI_15 NS_2 0 6.2647363860172819e-02
GC_15_3 ref NI_15 NS_3 0 -1.1621205518153109e-01
GC_15_4 ref NI_15 NS_4 0 6.4112214867624528e-02
GC_15_5 ref NI_15 NS_5 0 1.2863440679200091e-04
GC_15_6 ref NI_15 NS_6 0 4.5800029135893761e-02
GC_15_7 ref NI_15 NS_7 0 -1.4612078984238860e-01
GC_15_8 ref NI_15 NS_8 0 5.9269367620702729e-01
GC_15_9 ref NI_15 NS_9 0 1.6193014179026397e-01
GC_15_10 ref NI_15 NS_10 0 -1.0443256201372786e-01
GC_15_11 ref NI_15 NS_11 0 3.1718459689784485e-05
GC_15_12 ref NI_15 NS_12 0 -1.0524039556770431e-03
GC_15_13 ref NI_15 NS_13 0 4.4197155619572034e-02
GC_15_14 ref NI_15 NS_14 0 -2.5218959138745001e-01
GC_15_15 ref NI_15 NS_15 0 2.2858235170534030e-01
GC_15_16 ref NI_15 NS_16 0 3.7301676873577973e-02
GC_15_17 ref NI_15 NS_17 0 2.8070577924442864e-05
GC_15_18 ref NI_15 NS_18 0 1.9983893564779148e-04
GC_15_19 ref NI_15 NS_19 0 1.3245346895754759e-01
GC_15_20 ref NI_15 NS_20 0 1.0178619578225252e+00
GC_15_21 ref NI_15 NS_21 0 -6.4123619927671544e-02
GC_15_22 ref NI_15 NS_22 0 -1.1458989328800483e-01
GC_15_23 ref NI_15 NS_23 0 1.2054378594014429e-05
GC_15_24 ref NI_15 NS_24 0 3.6725305859953479e-05
GC_15_25 ref NI_15 NS_25 0 -8.5328089866309542e-01
GC_15_26 ref NI_15 NS_26 0 8.2068997897661222e-01
GC_15_27 ref NI_15 NS_27 0 2.9662831920728838e-01
GC_15_28 ref NI_15 NS_28 0 -1.4221160825342130e-01
GC_15_29 ref NI_15 NS_29 0 -7.8102778572039010e-07
GC_15_30 ref NI_15 NS_30 0 2.1357406588013131e-03
GC_15_31 ref NI_15 NS_31 0 1.3231161832804886e-01
GC_15_32 ref NI_15 NS_32 0 -3.4126340560951307e-01
GC_15_33 ref NI_15 NS_33 0 2.4086585599734145e-01
GC_15_34 ref NI_15 NS_34 0 3.3200313835084955e-02
GC_15_35 ref NI_15 NS_35 0 3.6550591600774080e-05
GC_15_36 ref NI_15 NS_36 0 8.2783298651695051e-04
GC_15_37 ref NI_15 NS_37 0 1.1826108137409065e-01
GC_15_38 ref NI_15 NS_38 0 -2.0473703610907451e-01
GC_15_39 ref NI_15 NS_39 0 8.1860384579782439e-02
GC_15_40 ref NI_15 NS_40 0 1.1946549271212835e-01
GC_15_41 ref NI_15 NS_41 0 2.8960124079838933e-05
GC_15_42 ref NI_15 NS_42 0 -4.9553790593202492e-04
GC_15_43 ref NI_15 NS_43 0 3.5446577864245814e-02
GC_15_44 ref NI_15 NS_44 0 -1.5850642689566088e-01
GC_15_45 ref NI_15 NS_45 0 1.1793894557168251e-01
GC_15_46 ref NI_15 NS_46 0 9.3342398194277199e-02
GC_15_47 ref NI_15 NS_47 0 2.9678704159434889e-05
GC_15_48 ref NI_15 NS_48 0 2.5706684454741792e-04
GC_15_49 ref NI_15 NS_49 0 1.5945255257891358e-01
GC_15_50 ref NI_15 NS_50 0 -2.8316861400519944e-01
GC_15_51 ref NI_15 NS_51 0 -8.9590181527550179e-03
GC_15_52 ref NI_15 NS_52 0 1.9420409522176452e-01
GC_15_53 ref NI_15 NS_53 0 3.8484963490819361e-05
GC_15_54 ref NI_15 NS_54 0 1.2095973614718307e-03
GC_15_55 ref NI_15 NS_55 0 2.2918894288143303e-02
GC_15_56 ref NI_15 NS_56 0 -6.2267354501585749e-02
GC_15_57 ref NI_15 NS_57 0 4.8339430301719997e-03
GC_15_58 ref NI_15 NS_58 0 1.4612277080276184e-01
GC_15_59 ref NI_15 NS_59 0 -1.1761771477857356e-07
GC_15_60 ref NI_15 NS_60 0 2.1094460489657586e-03
GC_15_61 ref NI_15 NS_61 0 2.7738189764488549e-03
GC_15_62 ref NI_15 NS_62 0 -2.4565960220312141e-02
GC_15_63 ref NI_15 NS_63 0 7.0867953628516708e-02
GC_15_64 ref NI_15 NS_64 0 9.7251810828611007e-02
GC_15_65 ref NI_15 NS_65 0 -2.5214273820063597e-06
GC_15_66 ref NI_15 NS_66 0 3.1162603683829903e-04
GC_15_67 ref NI_15 NS_67 0 -1.7209332608748895e-01
GC_15_68 ref NI_15 NS_68 0 3.3243267225923312e-01
GC_15_69 ref NI_15 NS_69 0 3.4388209542455594e-01
GC_15_70 ref NI_15 NS_70 0 -1.6147629165956590e-01
GC_15_71 ref NI_15 NS_71 0 -1.5948067167331346e-05
GC_15_72 ref NI_15 NS_72 0 -5.5114835328317203e-04
GC_15_73 ref NI_15 NS_73 0 -1.3857694170719913e-03
GC_15_74 ref NI_15 NS_74 0 -9.0593921597828826e-03
GC_15_75 ref NI_15 NS_75 0 1.5548008501216334e-01
GC_15_76 ref NI_15 NS_76 0 3.5403938485890775e-02
GC_15_77 ref NI_15 NS_77 0 -1.9344634543211703e-05
GC_15_78 ref NI_15 NS_78 0 -4.1989235240996335e-04
GC_15_79 ref NI_15 NS_79 0 -3.8059585805773116e-01
GC_15_80 ref NI_15 NS_80 0 1.2383081885922840e+00
GC_15_81 ref NI_15 NS_81 0 2.0788167697737361e-01
GC_15_82 ref NI_15 NS_82 0 -2.6911587879727594e-01
GC_15_83 ref NI_15 NS_83 0 3.2070851572031786e-04
GC_15_84 ref NI_15 NS_84 0 -3.9886615209110661e-03
GC_15_85 ref NI_15 NS_85 0 1.0996262888115409e+00
GC_15_86 ref NI_15 NS_86 0 -2.8514390932761664e+00
GC_15_87 ref NI_15 NS_87 0 -1.6636669824339134e+00
GC_15_88 ref NI_15 NS_88 0 -6.4129868267333356e-02
GC_15_89 ref NI_15 NS_89 0 -5.9879012207907849e-04
GC_15_90 ref NI_15 NS_90 0 -4.4688406716101137e-02
GD_15_1 ref NI_15 NA_1 0 2.5314038940497923e-03
GD_15_2 ref NI_15 NA_2 0 5.6324529501405678e-04
GD_15_3 ref NI_15 NA_3 0 -1.4806539194794023e-03
GD_15_4 ref NI_15 NA_4 0 3.4487694813259077e-02
GD_15_5 ref NI_15 NA_5 0 1.1913504055976883e-02
GD_15_6 ref NI_15 NA_6 0 4.6296525207887283e-04
GD_15_7 ref NI_15 NA_7 0 1.0218591981311857e-03
GD_15_8 ref NI_15 NA_8 0 2.0145885955921371e-03
GD_15_9 ref NI_15 NA_9 0 -1.5523341082128662e-03
GD_15_10 ref NI_15 NA_10 0 2.5058026747434444e-03
GD_15_11 ref NI_15 NA_11 0 3.6693847611312699e-03
GD_15_12 ref NI_15 NA_12 0 1.4235234657557407e-02
GD_15_13 ref NI_15 NA_13 0 3.0686886442040308e-03
GD_15_14 ref NI_15 NA_14 0 5.0883558302825989e-02
GD_15_15 ref NI_15 NA_15 0 6.1598888187568672e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 3.7518760328871237e-01
GS_1_1 0 NS_1 NA_1 0 2.8688996335459294e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 5.4263720141451799e-01
GS_2_1 0 NS_2 NA_1 0 2.8688996335459294e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 1.4472485643712456e+00
GS_3_1 0 NS_3 NA_1 0 2.8688996335459294e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 1.9785433287714529e+00
GS_4_1 0 NS_4 NA_1 0 2.8688996335459294e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 9.0004571759051146e+01
GS_5_1 0 NS_5 NA_1 0 2.8688996335459294e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 6.5779281773441536e+00
GS_6_1 0 NS_6 NA_1 0 2.8688996335459294e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 3.7518760328871237e-01
GS_7_2 0 NS_7 NA_2 0 2.8688996335459294e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 5.4263720141451799e-01
GS_8_2 0 NS_8 NA_2 0 2.8688996335459294e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 1.4472485643712456e+00
GS_9_2 0 NS_9 NA_2 0 2.8688996335459294e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 1.9785433287714529e+00
GS_10_2 0 NS_10 NA_2 0 2.8688996335459294e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 9.0004571759051146e+01
GS_11_2 0 NS_11 NA_2 0 2.8688996335459294e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 6.5779281773441536e+00
GS_12_2 0 NS_12 NA_2 0 2.8688996335459294e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 3.7518760328871237e-01
GS_13_3 0 NS_13 NA_3 0 2.8688996335459294e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 5.4263720141451799e-01
GS_14_3 0 NS_14 NA_3 0 2.8688996335459294e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 1.4472485643712456e+00
GS_15_3 0 NS_15 NA_3 0 2.8688996335459294e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 1.9785433287714529e+00
GS_16_3 0 NS_16 NA_3 0 2.8688996335459294e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 9.0004571759051146e+01
GS_17_3 0 NS_17 NA_3 0 2.8688996335459294e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 6.5779281773441536e+00
GS_18_3 0 NS_18 NA_3 0 2.8688996335459294e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 3.7518760328871237e-01
GS_19_4 0 NS_19 NA_4 0 2.8688996335459294e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 5.4263720141451799e-01
GS_20_4 0 NS_20 NA_4 0 2.8688996335459294e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 1.4472485643712456e+00
GS_21_4 0 NS_21 NA_4 0 2.8688996335459294e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 1.9785433287714529e+00
GS_22_4 0 NS_22 NA_4 0 2.8688996335459294e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 9.0004571759051146e+01
GS_23_4 0 NS_23 NA_4 0 2.8688996335459294e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 6.5779281773441536e+00
GS_24_4 0 NS_24 NA_4 0 2.8688996335459294e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 3.7518760328871237e-01
GS_25_5 0 NS_25 NA_5 0 2.8688996335459294e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 5.4263720141451799e-01
GS_26_5 0 NS_26 NA_5 0 2.8688996335459294e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 1.4472485643712456e+00
GS_27_5 0 NS_27 NA_5 0 2.8688996335459294e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 1.9785433287714529e+00
GS_28_5 0 NS_28 NA_5 0 2.8688996335459294e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 9.0004571759051146e+01
GS_29_5 0 NS_29 NA_5 0 2.8688996335459294e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 6.5779281773441536e+00
GS_30_5 0 NS_30 NA_5 0 2.8688996335459294e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 3.7518760328871237e-01
GS_31_6 0 NS_31 NA_6 0 2.8688996335459294e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 5.4263720141451799e-01
GS_32_6 0 NS_32 NA_6 0 2.8688996335459294e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 1.4472485643712456e+00
GS_33_6 0 NS_33 NA_6 0 2.8688996335459294e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 1.9785433287714529e+00
GS_34_6 0 NS_34 NA_6 0 2.8688996335459294e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 9.0004571759051146e+01
GS_35_6 0 NS_35 NA_6 0 2.8688996335459294e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 6.5779281773441536e+00
GS_36_6 0 NS_36 NA_6 0 2.8688996335459294e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 3.7518760328871237e-01
GS_37_7 0 NS_37 NA_7 0 2.8688996335459294e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 5.4263720141451799e-01
GS_38_7 0 NS_38 NA_7 0 2.8688996335459294e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 1.4472485643712456e+00
GS_39_7 0 NS_39 NA_7 0 2.8688996335459294e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 1.9785433287714529e+00
GS_40_7 0 NS_40 NA_7 0 2.8688996335459294e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 9.0004571759051146e+01
GS_41_7 0 NS_41 NA_7 0 2.8688996335459294e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 6.5779281773441536e+00
GS_42_7 0 NS_42 NA_7 0 2.8688996335459294e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 3.7518760328871237e-01
GS_43_8 0 NS_43 NA_8 0 2.8688996335459294e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 5.4263720141451799e-01
GS_44_8 0 NS_44 NA_8 0 2.8688996335459294e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 1.4472485643712456e+00
GS_45_8 0 NS_45 NA_8 0 2.8688996335459294e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 1.9785433287714529e+00
GS_46_8 0 NS_46 NA_8 0 2.8688996335459294e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 9.0004571759051146e+01
GS_47_8 0 NS_47 NA_8 0 2.8688996335459294e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 6.5779281773441536e+00
GS_48_8 0 NS_48 NA_8 0 2.8688996335459294e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 3.7518760328871237e-01
GS_49_9 0 NS_49 NA_9 0 2.8688996335459294e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 5.4263720141451799e-01
GS_50_9 0 NS_50 NA_9 0 2.8688996335459294e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 1.4472485643712456e+00
GS_51_9 0 NS_51 NA_9 0 2.8688996335459294e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 1.9785433287714529e+00
GS_52_9 0 NS_52 NA_9 0 2.8688996335459294e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 9.0004571759051146e+01
GS_53_9 0 NS_53 NA_9 0 2.8688996335459294e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 6.5779281773441536e+00
GS_54_9 0 NS_54 NA_9 0 2.8688996335459294e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 3.7518760328871237e-01
GS_55_10 0 NS_55 NA_10 0 2.8688996335459294e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 5.4263720141451799e-01
GS_56_10 0 NS_56 NA_10 0 2.8688996335459294e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 1.4472485643712456e+00
GS_57_10 0 NS_57 NA_10 0 2.8688996335459294e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 1.9785433287714529e+00
GS_58_10 0 NS_58 NA_10 0 2.8688996335459294e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 9.0004571759051146e+01
GS_59_10 0 NS_59 NA_10 0 2.8688996335459294e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 6.5779281773441536e+00
GS_60_10 0 NS_60 NA_10 0 2.8688996335459294e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 3.7518760328871237e-01
GS_61_11 0 NS_61 NA_11 0 2.8688996335459294e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 5.4263720141451799e-01
GS_62_11 0 NS_62 NA_11 0 2.8688996335459294e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 1.4472485643712456e+00
GS_63_11 0 NS_63 NA_11 0 2.8688996335459294e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 1.9785433287714529e+00
GS_64_11 0 NS_64 NA_11 0 2.8688996335459294e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 9.0004571759051146e+01
GS_65_11 0 NS_65 NA_11 0 2.8688996335459294e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 6.5779281773441536e+00
GS_66_11 0 NS_66 NA_11 0 2.8688996335459294e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 3.7518760328871237e-01
GS_67_12 0 NS_67 NA_12 0 2.8688996335459294e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 5.4263720141451799e-01
GS_68_12 0 NS_68 NA_12 0 2.8688996335459294e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 1.4472485643712456e+00
GS_69_12 0 NS_69 NA_12 0 2.8688996335459294e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 1.9785433287714529e+00
GS_70_12 0 NS_70 NA_12 0 2.8688996335459294e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 9.0004571759051146e+01
GS_71_12 0 NS_71 NA_12 0 2.8688996335459294e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 6.5779281773441536e+00
GS_72_12 0 NS_72 NA_12 0 2.8688996335459294e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 3.7518760328871237e-01
GS_73_13 0 NS_73 NA_13 0 2.8688996335459294e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 5.4263720141451799e-01
GS_74_13 0 NS_74 NA_13 0 2.8688996335459294e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 1.4472485643712456e+00
GS_75_13 0 NS_75 NA_13 0 2.8688996335459294e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 1.9785433287714529e+00
GS_76_13 0 NS_76 NA_13 0 2.8688996335459294e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 9.0004571759051146e+01
GS_77_13 0 NS_77 NA_13 0 2.8688996335459294e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 6.5779281773441536e+00
GS_78_13 0 NS_78 NA_13 0 2.8688996335459294e+00
*
* Real pole n. 79
CS_79 NS_79 0 1.0000000000000001e-09
RS_79 NS_79 0 3.7518760328871237e-01
GS_79_14 0 NS_79 NA_14 0 2.8688996335459294e+00
*
* Real pole n. 80
CS_80 NS_80 0 1.0000000000000001e-09
RS_80 NS_80 0 5.4263720141451799e-01
GS_80_14 0 NS_80 NA_14 0 2.8688996335459294e+00
*
* Real pole n. 81
CS_81 NS_81 0 1.0000000000000001e-09
RS_81 NS_81 0 1.4472485643712456e+00
GS_81_14 0 NS_81 NA_14 0 2.8688996335459294e+00
*
* Real pole n. 82
CS_82 NS_82 0 1.0000000000000001e-09
RS_82 NS_82 0 1.9785433287714529e+00
GS_82_14 0 NS_82 NA_14 0 2.8688996335459294e+00
*
* Real pole n. 83
CS_83 NS_83 0 1.0000000000000001e-09
RS_83 NS_83 0 9.0004571759051146e+01
GS_83_14 0 NS_83 NA_14 0 2.8688996335459294e+00
*
* Real pole n. 84
CS_84 NS_84 0 1.0000000000000001e-09
RS_84 NS_84 0 6.5779281773441536e+00
GS_84_14 0 NS_84 NA_14 0 2.8688996335459294e+00
*
* Real pole n. 85
CS_85 NS_85 0 1.0000000000000001e-09
RS_85 NS_85 0 3.7518760328871237e-01
GS_85_15 0 NS_85 NA_15 0 2.8688996335459294e+00
*
* Real pole n. 86
CS_86 NS_86 0 1.0000000000000001e-09
RS_86 NS_86 0 5.4263720141451799e-01
GS_86_15 0 NS_86 NA_15 0 2.8688996335459294e+00
*
* Real pole n. 87
CS_87 NS_87 0 1.0000000000000001e-09
RS_87 NS_87 0 1.4472485643712456e+00
GS_87_15 0 NS_87 NA_15 0 2.8688996335459294e+00
*
* Real pole n. 88
CS_88 NS_88 0 1.0000000000000001e-09
RS_88 NS_88 0 1.9785433287714529e+00
GS_88_15 0 NS_88 NA_15 0 2.8688996335459294e+00
*
* Real pole n. 89
CS_89 NS_89 0 1.0000000000000001e-09
RS_89 NS_89 0 9.0004571759051146e+01
GS_89_15 0 NS_89 NA_15 0 2.8688996335459294e+00
*
* Real pole n. 90
CS_90 NS_90 0 1.0000000000000001e-09
RS_90 NS_90 0 6.5779281773441536e+00
GS_90_15 0 NS_90 NA_15 0 2.8688996335459294e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
