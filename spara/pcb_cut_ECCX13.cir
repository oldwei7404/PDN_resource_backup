**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 22-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Tue Apr 22 07:49:21 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Tue Apr 22 07:49:21 2025
**
**  Modal data exported
**  Port[1] = PORT_1_L38_PWR_VECMX1_Group_U51_GND_Group
**  Port[2] = PORT_2_U1_PWR_VECMX1_Group_U1_GRP_0_0_GND
**  Port[3] = PWR_VECMX1_C513_1
**  Port[4] = PWR_VECMX1_C514_1
**  Port[5] = PWR_VECMX1_C515_1
**  Port[6] = PWR_VECMX1_C516_1
**  Port[7] = PWR_VECMX1_C517_1
**  Port[8] = PWR_VECMX1_C518_1
**  Port[9] = PWR_VECMX1_C519_1
**  Port[10] = PWR_VECMX1_C659_1
**  Port[11] = PWR_VECMX1_C659_3
**  Port[12] = PWR_VECMX1_C661_1
**  Port[13] = PWR_VECMX1_C661_3
**  Port[14] = PWR_VECMX1_C663_1
**  Port[15] = PWR_VECMX1_C663_3
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_ECCX13
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 2.8294158886135197e+00
GC_1_2 ref NI_1 NS_2 0 -1.5283477230547065e+00
GC_1_3 ref NI_1 NS_3 0 3.0004550140161562e-01
GC_1_4 ref NI_1 NS_4 0 -2.0234023239174612e+00
GC_1_5 ref NI_1 NS_5 0 -8.5906558329428381e-02
GC_1_6 ref NI_1 NS_6 0 -3.1328404341246473e-03
GC_1_7 ref NI_1 NS_7 0 -3.7298013462720866e-02
GC_1_8 ref NI_1 NS_8 0 1.6945090279657829e-01
GC_1_9 ref NI_1 NS_9 0 7.1154149122683481e-03
GC_1_10 ref NI_1 NS_10 0 1.1732132598066231e-01
GC_1_11 ref NI_1 NS_11 0 5.1482093248391677e-03
GC_1_12 ref NI_1 NS_12 0 2.4235239551727072e-04
GC_1_13 ref NI_1 NS_13 0 -1.8923344987336921e-01
GC_1_14 ref NI_1 NS_14 0 1.3635939679226858e-01
GC_1_15 ref NI_1 NS_15 0 -1.9606835335280848e-01
GC_1_16 ref NI_1 NS_16 0 2.2188947780922583e-01
GC_1_17 ref NI_1 NS_17 0 8.5211835048899908e-03
GC_1_18 ref NI_1 NS_18 0 2.3201373182415525e-04
GC_1_19 ref NI_1 NS_19 0 -1.6797199193066752e-02
GC_1_20 ref NI_1 NS_20 0 1.0479084400589438e-01
GC_1_21 ref NI_1 NS_21 0 5.8674528291138128e-01
GC_1_22 ref NI_1 NS_22 0 -1.5166754589427411e-01
GC_1_23 ref NI_1 NS_23 0 -1.6117882626885589e-03
GC_1_24 ref NI_1 NS_24 0 2.1695304546388936e-04
GC_1_25 ref NI_1 NS_25 0 2.6304760598677274e-02
GC_1_26 ref NI_1 NS_26 0 -2.9541989643236691e-02
GC_1_27 ref NI_1 NS_27 0 2.5548276920809576e-01
GC_1_28 ref NI_1 NS_28 0 4.6002391137703331e-02
GC_1_29 ref NI_1 NS_29 0 6.1357764421664284e-04
GC_1_30 ref NI_1 NS_30 0 2.2730535132994497e-04
GC_1_31 ref NI_1 NS_31 0 -8.5065685510711531e-02
GC_1_32 ref NI_1 NS_32 0 7.0941456932537880e-02
GC_1_33 ref NI_1 NS_33 0 1.5972187079032077e-01
GC_1_34 ref NI_1 NS_34 0 7.1271765453285313e-02
GC_1_35 ref NI_1 NS_35 0 2.4270833796915100e-03
GC_1_36 ref NI_1 NS_36 0 2.0852348986165941e-04
GC_1_37 ref NI_1 NS_37 0 -1.3538025041223520e-01
GC_1_38 ref NI_1 NS_38 0 9.0526481593625405e-02
GC_1_39 ref NI_1 NS_39 0 -3.2057450314467509e-02
GC_1_40 ref NI_1 NS_40 0 1.5618832234931498e-01
GC_1_41 ref NI_1 NS_41 0 5.5752315149012041e-03
GC_1_42 ref NI_1 NS_42 0 2.2522786261233572e-04
GC_1_43 ref NI_1 NS_43 0 5.5781600719814048e-03
GC_1_44 ref NI_1 NS_44 0 -1.6752836269216281e-01
GC_1_45 ref NI_1 NS_45 0 2.4058414286052071e-01
GC_1_46 ref NI_1 NS_46 0 8.2942811300594721e-02
GC_1_47 ref NI_1 NS_47 0 1.6207033807985336e-03
GC_1_48 ref NI_1 NS_48 0 2.2837035421019973e-04
GC_1_49 ref NI_1 NS_49 0 -5.3339823439948204e-02
GC_1_50 ref NI_1 NS_50 0 -9.4565275569901394e-02
GC_1_51 ref NI_1 NS_51 0 6.1291408647157331e-01
GC_1_52 ref NI_1 NS_52 0 -1.2059565972535675e-01
GC_1_53 ref NI_1 NS_53 0 -8.8787904055515011e-04
GC_1_54 ref NI_1 NS_54 0 2.2877273745407079e-04
GC_1_55 ref NI_1 NS_55 0 -2.0354714861540510e-01
GC_1_56 ref NI_1 NS_56 0 1.5721839680742211e-01
GC_1_57 ref NI_1 NS_57 0 -2.7319983447571022e-01
GC_1_58 ref NI_1 NS_58 0 2.5358210748041327e-01
GC_1_59 ref NI_1 NS_59 0 9.2193184136463227e-03
GC_1_60 ref NI_1 NS_60 0 2.4078543294738091e-04
GC_1_61 ref NI_1 NS_61 0 -1.0761581536149759e-01
GC_1_62 ref NI_1 NS_62 0 3.3194725745724789e-02
GC_1_63 ref NI_1 NS_63 0 -1.8147681311714239e-01
GC_1_64 ref NI_1 NS_64 0 2.4479244200611786e-01
GC_1_65 ref NI_1 NS_65 0 6.1388395921930447e-03
GC_1_66 ref NI_1 NS_66 0 2.2420124716002421e-04
GC_1_67 ref NI_1 NS_67 0 -2.6630079186767630e-01
GC_1_68 ref NI_1 NS_68 0 2.1445928094826266e-01
GC_1_69 ref NI_1 NS_69 0 -3.3044180826656672e-01
GC_1_70 ref NI_1 NS_70 0 2.6213928842249301e-01
GC_1_71 ref NI_1 NS_71 0 1.1922566212528784e-02
GC_1_72 ref NI_1 NS_72 0 2.2179525456143587e-04
GC_1_73 ref NI_1 NS_73 0 -2.3136037423212191e-01
GC_1_74 ref NI_1 NS_74 0 1.6403105979157606e-01
GC_1_75 ref NI_1 NS_75 0 -3.0282039945697170e-01
GC_1_76 ref NI_1 NS_76 0 2.6328658902892776e-01
GC_1_77 ref NI_1 NS_77 0 1.0741074374666447e-02
GC_1_78 ref NI_1 NS_78 0 2.2173437617408514e-04
GC_1_79 ref NI_1 NS_79 0 -2.8981917102680965e-01
GC_1_80 ref NI_1 NS_80 0 2.3475540595994199e-01
GC_1_81 ref NI_1 NS_81 0 -3.6377033616113175e-01
GC_1_82 ref NI_1 NS_82 0 2.7110386130334485e-01
GC_1_83 ref NI_1 NS_83 0 1.3193996793747937e-02
GC_1_84 ref NI_1 NS_84 0 2.1377171299778172e-04
GC_1_85 ref NI_1 NS_85 0 -3.1919259634735192e-01
GC_1_86 ref NI_1 NS_86 0 2.6403977357452479e-01
GC_1_87 ref NI_1 NS_87 0 -4.0328225438680049e-01
GC_1_88 ref NI_1 NS_88 0 2.8030919187247150e-01
GC_1_89 ref NI_1 NS_89 0 1.4556930012423539e-02
GC_1_90 ref NI_1 NS_90 0 2.1341709137334084e-04
GD_1_1 ref NI_1 NA_1 0 5.8090203224852575e+00
GD_1_2 ref NI_1 NA_2 0 4.5719163395697575e-04
GD_1_3 ref NI_1 NA_3 0 2.4889311435698249e-02
GD_1_4 ref NI_1 NA_4 0 2.2487014666400830e-02
GD_1_5 ref NI_1 NA_5 0 1.1164115316707862e-02
GD_1_6 ref NI_1 NA_6 0 1.9099007717877474e-02
GD_1_7 ref NI_1 NA_7 0 2.1632807751874945e-02
GD_1_8 ref NI_1 NA_8 0 1.0086116819132856e-02
GD_1_9 ref NI_1 NA_9 0 2.2374376787883184e-02
GD_1_10 ref NI_1 NA_10 0 2.8418586545599984e-02
GD_1_11 ref NI_1 NA_11 0 1.9852899866368699e-02
GD_1_12 ref NI_1 NA_12 0 3.3253050395705003e-02
GD_1_13 ref NI_1 NA_13 0 3.0449620543573711e-02
GD_1_14 ref NI_1 NA_14 0 3.4628072556284265e-02
GD_1_15 ref NI_1 NA_15 0 3.7646898533982343e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -3.7298013462721533e-02
GC_2_2 ref NI_2 NS_2 0 1.6945090279657837e-01
GC_2_3 ref NI_2 NS_3 0 7.1154149122684696e-03
GC_2_4 ref NI_2 NS_4 0 1.1732132598066222e-01
GC_2_5 ref NI_2 NS_5 0 5.1482093248391928e-03
GC_2_6 ref NI_2 NS_6 0 2.4235239551726175e-04
GC_2_7 ref NI_2 NS_7 0 1.0896920975909099e+01
GC_2_8 ref NI_2 NS_8 0 -9.1770732571256790e+00
GC_2_9 ref NI_2 NS_9 0 -1.8404823976254452e+00
GC_2_10 ref NI_2 NS_10 0 9.9561456377442001e-02
GC_2_11 ref NI_2 NS_11 0 -1.0078161872706890e-02
GC_2_12 ref NI_2 NS_12 0 -3.1158411760662979e-04
GC_2_13 ref NI_2 NS_13 0 8.9495799894263595e-02
GC_2_14 ref NI_2 NS_14 0 4.8304657850698157e-01
GC_2_15 ref NI_2 NS_15 0 2.7287991544835138e-01
GC_2_16 ref NI_2 NS_16 0 -6.2049483400178761e-02
GC_2_17 ref NI_2 NS_17 0 5.7455070353248775e-04
GC_2_18 ref NI_2 NS_18 0 -1.4115510444465101e-05
GC_2_19 ref NI_2 NS_19 0 -8.8246650725050876e-03
GC_2_20 ref NI_2 NS_20 0 3.3459177038780497e-01
GC_2_21 ref NI_2 NS_21 0 3.2855669899146328e-01
GC_2_22 ref NI_2 NS_22 0 -5.6249752767458604e-02
GC_2_23 ref NI_2 NS_23 0 1.3180357237358169e-03
GC_2_24 ref NI_2 NS_24 0 -1.7809917006933656e-05
GC_2_25 ref NI_2 NS_25 0 -1.3902157902169457e-01
GC_2_26 ref NI_2 NS_26 0 3.5575907040338922e-01
GC_2_27 ref NI_2 NS_27 0 3.6442594344646084e-01
GC_2_28 ref NI_2 NS_28 0 -7.6345284055620966e-02
GC_2_29 ref NI_2 NS_29 0 1.6111909849801801e-03
GC_2_30 ref NI_2 NS_30 0 -1.3366734211263263e-05
GC_2_31 ref NI_2 NS_31 0 2.0165134868447723e-01
GC_2_32 ref NI_2 NS_32 0 3.7152686433294579e-01
GC_2_33 ref NI_2 NS_33 0 2.6889947525678248e-01
GC_2_34 ref NI_2 NS_34 0 -4.0957259858943544e-02
GC_2_35 ref NI_2 NS_35 0 5.8300665530560747e-04
GC_2_36 ref NI_2 NS_36 0 4.9292473530157064e-07
GC_2_37 ref NI_2 NS_37 0 1.1704594995063677e-01
GC_2_38 ref NI_2 NS_38 0 3.3941502864857520e-01
GC_2_39 ref NI_2 NS_39 0 3.1429581047521521e-01
GC_2_40 ref NI_2 NS_40 0 -5.4119287929968292e-02
GC_2_41 ref NI_2 NS_41 0 7.1011485158549729e-04
GC_2_42 ref NI_2 NS_42 0 -6.9703298494641361e-06
GC_2_43 ref NI_2 NS_43 0 2.6234780600978230e-01
GC_2_44 ref NI_2 NS_44 0 8.6143629998427018e-01
GC_2_45 ref NI_2 NS_45 0 1.6758146078693970e-02
GC_2_46 ref NI_2 NS_46 0 -2.0696401471779296e-02
GC_2_47 ref NI_2 NS_47 0 1.5852080349406701e-04
GC_2_48 ref NI_2 NS_48 0 -7.7441916091467525e-06
GC_2_49 ref NI_2 NS_49 0 2.0665713694483992e-01
GC_2_50 ref NI_2 NS_50 0 6.4408042941771471e-01
GC_2_51 ref NI_2 NS_51 0 1.2203477160710424e-01
GC_2_52 ref NI_2 NS_52 0 -2.4015673873265361e-02
GC_2_53 ref NI_2 NS_53 0 4.0570581231904056e-04
GC_2_54 ref NI_2 NS_54 0 -1.4237365126675825e-05
GC_2_55 ref NI_2 NS_55 0 4.7961030725391235e-02
GC_2_56 ref NI_2 NS_56 0 4.9667221613239854e-01
GC_2_57 ref NI_2 NS_57 0 1.5139063697189625e-01
GC_2_58 ref NI_2 NS_58 0 -8.1710680909096965e-03
GC_2_59 ref NI_2 NS_59 0 1.1780498027618976e-03
GC_2_60 ref NI_2 NS_60 0 5.4374272135015394e-06
GC_2_61 ref NI_2 NS_61 0 -8.1050221651890967e-03
GC_2_62 ref NI_2 NS_62 0 3.3557693140380090e-01
GC_2_63 ref NI_2 NS_63 0 2.2695487308578316e-01
GC_2_64 ref NI_2 NS_64 0 -8.8838784794353070e-03
GC_2_65 ref NI_2 NS_65 0 1.1426270882693430e-03
GC_2_66 ref NI_2 NS_66 0 1.2516638467550344e-05
GC_2_67 ref NI_2 NS_67 0 1.1540871891129671e-02
GC_2_68 ref NI_2 NS_68 0 6.8622512687017678e-01
GC_2_69 ref NI_2 NS_69 0 1.4616692438438603e-01
GC_2_70 ref NI_2 NS_70 0 -4.6382374956075417e-02
GC_2_71 ref NI_2 NS_71 0 1.1805711600061278e-03
GC_2_72 ref NI_2 NS_72 0 -1.2345919484868535e-05
GC_2_73 ref NI_2 NS_73 0 -3.7150460451359411e-02
GC_2_74 ref NI_2 NS_74 0 5.4594155967986091e-01
GC_2_75 ref NI_2 NS_75 0 1.7544485026107931e-01
GC_2_76 ref NI_2 NS_76 0 -3.1473848873043948e-02
GC_2_77 ref NI_2 NS_77 0 1.5243602321499069e-03
GC_2_78 ref NI_2 NS_78 0 2.3914621000721347e-05
GC_2_79 ref NI_2 NS_79 0 2.8538877472031252e-02
GC_2_80 ref NI_2 NS_80 0 6.7715443226913130e-01
GC_2_81 ref NI_2 NS_81 0 1.6048101698991787e-01
GC_2_82 ref NI_2 NS_82 0 -5.0160573144773228e-02
GC_2_83 ref NI_2 NS_83 0 1.0981987233878846e-03
GC_2_84 ref NI_2 NS_84 0 -2.3901063299645050e-05
GC_2_85 ref NI_2 NS_85 0 -3.1451040061733198e-03
GC_2_86 ref NI_2 NS_86 0 3.5145909389381436e-01
GC_2_87 ref NI_2 NS_87 0 2.4847572957444336e-01
GC_2_88 ref NI_2 NS_88 0 -2.7320838193255818e-02
GC_2_89 ref NI_2 NS_89 0 1.5274914744615186e-03
GC_2_90 ref NI_2 NS_90 0 3.1948346289565368e-05
GD_2_1 ref NI_2 NA_1 0 4.5719163395695228e-04
GD_2_2 ref NI_2 NA_2 0 4.7883691653651335e+00
GD_2_3 ref NI_2 NA_3 0 -5.0548360481774392e-02
GD_2_4 ref NI_2 NA_4 0 -3.8411049571945612e-02
GD_2_5 ref NI_2 NA_5 0 -2.5703546554041102e-02
GD_2_6 ref NI_2 NA_6 0 -5.8937994139873877e-02
GD_2_7 ref NI_2 NA_7 0 -4.9259253124151421e-02
GD_2_8 ref NI_2 NA_8 0 -6.6479802706188765e-02
GD_2_9 ref NI_2 NA_9 0 -6.0065389981327530e-02
GD_2_10 ref NI_2 NA_10 0 -2.7331490197953758e-02
GD_2_11 ref NI_2 NA_11 0 -1.9755744015921509e-02
GD_2_12 ref NI_2 NA_12 0 -2.6330427883547475e-02
GD_2_13 ref NI_2 NA_13 0 -1.7941836240240774e-02
GD_2_14 ref NI_2 NA_14 0 -3.2273633968247534e-02
GD_2_15 ref NI_2 NA_15 0 -1.9136658706434714e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 -1.8923344987336171e-01
GC_3_2 ref NI_3 NS_2 0 1.3635939679226566e-01
GC_3_3 ref NI_3 NS_3 0 -1.9606835335280709e-01
GC_3_4 ref NI_3 NS_4 0 2.2188947780922536e-01
GC_3_5 ref NI_3 NS_5 0 8.5211835048900047e-03
GC_3_6 ref NI_3 NS_6 0 2.3201373182415725e-04
GC_3_7 ref NI_3 NS_7 0 8.9495799894265246e-02
GC_3_8 ref NI_3 NS_8 0 4.8304657850698107e-01
GC_3_9 ref NI_3 NS_9 0 2.7287991544835144e-01
GC_3_10 ref NI_3 NS_10 0 -6.2049483400178733e-02
GC_3_11 ref NI_3 NS_11 0 5.7455070353246021e-04
GC_3_12 ref NI_3 NS_12 0 -1.4115510444450808e-05
GC_3_13 ref NI_3 NS_13 0 1.9833218126580792e+00
GC_3_14 ref NI_3 NS_14 0 -3.3492095173633283e+00
GC_3_15 ref NI_3 NS_15 0 -3.4398393058972130e+00
GC_3_16 ref NI_3 NS_16 0 -3.4711098580928072e-02
GC_3_17 ref NI_3 NS_17 0 -1.9922225257439662e-02
GC_3_18 ref NI_3 NS_18 0 -3.0394679292947759e-04
GC_3_19 ref NI_3 NS_19 0 8.6240684933458739e-02
GC_3_20 ref NI_3 NS_20 0 -7.0111356016991019e-02
GC_3_21 ref NI_3 NS_21 0 4.8654273551738562e-02
GC_3_22 ref NI_3 NS_22 0 1.7346235223350434e-01
GC_3_23 ref NI_3 NS_23 0 1.0547442053094277e-03
GC_3_24 ref NI_3 NS_24 0 3.0626370013518422e-05
GC_3_25 ref NI_3 NS_25 0 7.3949317672423187e-02
GC_3_26 ref NI_3 NS_26 0 -8.2742259664517814e-02
GC_3_27 ref NI_3 NS_27 0 1.4609684877527482e-01
GC_3_28 ref NI_3 NS_28 0 1.2386133352634721e-01
GC_3_29 ref NI_3 NS_29 0 1.1350874394413396e-03
GC_3_30 ref NI_3 NS_30 0 3.1837665568698435e-05
GC_3_31 ref NI_3 NS_31 0 -1.9843458757357763e-01
GC_3_32 ref NI_3 NS_32 0 2.6100514654906992e-01
GC_3_33 ref NI_3 NS_33 0 3.2398652613557738e-01
GC_3_34 ref NI_3 NS_34 0 -4.6029443196734798e-02
GC_3_35 ref NI_3 NS_35 0 2.8794542598160212e-03
GC_3_36 ref NI_3 NS_36 0 2.6476169945532682e-05
GC_3_37 ref NI_3 NS_37 0 -6.7075156976491890e-01
GC_3_38 ref NI_3 NS_38 0 1.8608719199908657e+00
GC_3_39 ref NI_3 NS_39 0 7.8519177432100129e-02
GC_3_40 ref NI_3 NS_40 0 -2.6222366841461914e-01
GC_3_41 ref NI_3 NS_41 0 2.7784779968475898e-03
GC_3_42 ref NI_3 NS_42 0 -2.0937599349042523e-05
GC_3_43 ref NI_3 NS_43 0 9.1845755901838771e-02
GC_3_44 ref NI_3 NS_44 0 -1.9327664807700107e-01
GC_3_45 ref NI_3 NS_45 0 1.6423020018729756e-01
GC_3_46 ref NI_3 NS_46 0 1.4038528415567919e-01
GC_3_47 ref NI_3 NS_47 0 9.0277046962420368e-04
GC_3_48 ref NI_3 NS_48 0 2.7858111709517376e-05
GC_3_49 ref NI_3 NS_49 0 8.2812719061336346e-02
GC_3_50 ref NI_3 NS_50 0 -1.3692925923901528e-01
GC_3_51 ref NI_3 NS_51 0 7.0263885657784103e-02
GC_3_52 ref NI_3 NS_52 0 1.7792242791302876e-01
GC_3_53 ref NI_3 NS_53 0 9.8409892921603190e-04
GC_3_54 ref NI_3 NS_54 0 2.9685532393196638e-05
GC_3_55 ref NI_3 NS_55 0 2.4186832222275509e-02
GC_3_56 ref NI_3 NS_56 0 -6.2277537708093689e-02
GC_3_57 ref NI_3 NS_57 0 5.9782840777493580e-02
GC_3_58 ref NI_3 NS_58 0 1.6237452491925969e-01
GC_3_59 ref NI_3 NS_59 0 2.1182573674077068e-03
GC_3_60 ref NI_3 NS_60 0 1.1513870670427011e-05
GC_3_61 ref NI_3 NS_61 0 8.8814443970102214e-02
GC_3_62 ref NI_3 NS_62 0 -1.5800019718704153e-01
GC_3_63 ref NI_3 NS_63 0 -9.9004423565398365e-03
GC_3_64 ref NI_3 NS_64 0 2.1338664392103196e-01
GC_3_65 ref NI_3 NS_65 0 2.7187858615333269e-03
GC_3_66 ref NI_3 NS_66 0 6.2766511087690387e-05
GC_3_67 ref NI_3 NS_67 0 2.0653576210138695e-02
GC_3_68 ref NI_3 NS_68 0 1.0516626293913366e-01
GC_3_69 ref NI_3 NS_69 0 3.9458101222955244e-01
GC_3_70 ref NI_3 NS_70 0 -3.9075999675185033e-02
GC_3_71 ref NI_3 NS_71 0 -4.8522836208121422e-04
GC_3_72 ref NI_3 NS_72 0 -4.4796244173580304e-05
GC_3_73 ref NI_3 NS_73 0 8.4444930385578418e-02
GC_3_74 ref NI_3 NS_74 0 -4.2663865559049990e-01
GC_3_75 ref NI_3 NS_75 0 4.5553299263151986e-01
GC_3_76 ref NI_3 NS_76 0 3.8553295380536812e-02
GC_3_77 ref NI_3 NS_77 0 1.0832863694020928e-03
GC_3_78 ref NI_3 NS_78 0 1.2271080643185643e-06
GC_3_79 ref NI_3 NS_79 0 -3.4371441512165835e-01
GC_3_80 ref NI_3 NS_80 0 6.1306980202073769e-01
GC_3_81 ref NI_3 NS_81 0 9.2292915846197665e-01
GC_3_82 ref NI_3 NS_82 0 -4.2393637897404196e-01
GC_3_83 ref NI_3 NS_83 0 -1.8087252687354761e-03
GC_3_84 ref NI_3 NS_84 0 1.0120640737131698e-05
GC_3_85 ref NI_3 NS_85 0 -4.0523175680963452e-01
GC_3_86 ref NI_3 NS_86 0 8.8269096332289554e-01
GC_3_87 ref NI_3 NS_87 0 7.7527687797717804e-01
GC_3_88 ref NI_3 NS_88 0 -4.0475976864099289e-01
GC_3_89 ref NI_3 NS_89 0 -1.3572810778231651e-03
GC_3_90 ref NI_3 NS_90 0 -6.5084111776694809e-05
GD_3_1 ref NI_3 NA_1 0 2.4889311435697260e-02
GD_3_2 ref NI_3 NA_2 0 -5.0548360481774593e-02
GD_3_3 ref NI_3 NA_3 0 6.0538491669983179e+00
GD_3_4 ref NI_3 NA_4 0 -1.4136398833343817e-02
GD_3_5 ref NI_3 NA_5 0 -1.1305134108151722e-02
GD_3_6 ref NI_3 NA_6 0 1.0392993223355665e-02
GD_3_7 ref NI_3 NA_7 0 4.7617019928979799e-02
GD_3_8 ref NI_3 NA_8 0 -1.3589339495301684e-02
GD_3_9 ref NI_3 NA_9 0 -1.3620823263572484e-02
GD_3_10 ref NI_3 NA_10 0 -1.9426641590957617e-03
GD_3_11 ref NI_3 NA_11 0 -8.6729736336420196e-03
GD_3_12 ref NI_3 NA_12 0 1.4078778464121718e-03
GD_3_13 ref NI_3 NA_13 0 -7.6983523845179161e-03
GD_3_14 ref NI_3 NA_14 0 4.6223706625726356e-02
GD_3_15 ref NI_3 NA_15 0 6.4462565923683268e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -1.6797199193088933e-02
GC_4_2 ref NI_4 NS_2 0 1.0479084400590341e-01
GC_4_3 ref NI_4 NS_3 0 5.8674528291137651e-01
GC_4_4 ref NI_4 NS_4 0 -1.5166754589427273e-01
GC_4_5 ref NI_4 NS_5 0 -1.6117882626886138e-03
GC_4_6 ref NI_4 NS_6 0 2.1695304546388489e-04
GC_4_7 ref NI_4 NS_7 0 -8.8246650725160112e-03
GC_4_8 ref NI_4 NS_8 0 3.3459177038780946e-01
GC_4_9 ref NI_4 NS_9 0 3.2855669899146112e-01
GC_4_10 ref NI_4 NS_10 0 -5.6249752767457931e-02
GC_4_11 ref NI_4 NS_11 0 1.3180357237357846e-03
GC_4_12 ref NI_4 NS_12 0 -1.7809917006933185e-05
GC_4_13 ref NI_4 NS_13 0 8.6240684933404463e-02
GC_4_14 ref NI_4 NS_14 0 -7.0111356016968510e-02
GC_4_15 ref NI_4 NS_15 0 4.8654273551726933e-02
GC_4_16 ref NI_4 NS_16 0 1.7346235223350776e-01
GC_4_17 ref NI_4 NS_17 0 1.0547442053093091e-03
GC_4_18 ref NI_4 NS_18 0 3.0626370013510121e-05
GC_4_19 ref NI_4 NS_19 0 6.3691809251866419e-02
GC_4_20 ref NI_4 NS_20 0 -6.5810677148629226e+00
GC_4_21 ref NI_4 NS_21 0 -1.2455091151266615e+00
GC_4_22 ref NI_4 NS_22 0 -4.2757455405861727e-01
GC_4_23 ref NI_4 NS_23 0 -6.8283729622094936e-03
GC_4_24 ref NI_4 NS_24 0 -2.5735323447748299e-04
GC_4_25 ref NI_4 NS_25 0 2.2488337571093078e-01
GC_4_26 ref NI_4 NS_26 0 3.9794994451739280e-01
GC_4_27 ref NI_4 NS_27 0 6.3097995239823101e-01
GC_4_28 ref NI_4 NS_28 0 -2.3495523102938085e-01
GC_4_29 ref NI_4 NS_29 0 -1.6516061328507730e-03
GC_4_30 ref NI_4 NS_30 0 -4.8692946658416757e-05
GC_4_31 ref NI_4 NS_31 0 1.4701853170075110e-01
GC_4_32 ref NI_4 NS_32 0 1.7237580938093955e-01
GC_4_33 ref NI_4 NS_33 0 4.6621307648184657e-01
GC_4_34 ref NI_4 NS_34 0 -9.2594659597541887e-02
GC_4_35 ref NI_4 NS_35 0 -1.6274790633355153e-03
GC_4_36 ref NI_4 NS_36 0 -1.6623087324216444e-05
GC_4_37 ref NI_4 NS_37 0 1.3801618892971040e-01
GC_4_38 ref NI_4 NS_38 0 -3.6151989803172462e-02
GC_4_39 ref NI_4 NS_39 0 2.4646010803727722e-01
GC_4_40 ref NI_4 NS_40 0 6.5020316600371511e-02
GC_4_41 ref NI_4 NS_41 0 -4.5147876593036303e-04
GC_4_42 ref NI_4 NS_42 0 2.7262991808111673e-05
GC_4_43 ref NI_4 NS_43 0 -3.8431774900662485e-01
GC_4_44 ref NI_4 NS_44 0 2.5863143903052360e-02
GC_4_45 ref NI_4 NS_45 0 9.4756187894166943e-01
GC_4_46 ref NI_4 NS_46 0 -2.9509695047735079e-01
GC_4_47 ref NI_4 NS_47 0 9.9393363608453488e-04
GC_4_48 ref NI_4 NS_48 0 -7.7110727469743392e-05
GC_4_49 ref NI_4 NS_49 0 7.7633435713466592e-01
GC_4_50 ref NI_4 NS_50 0 5.9632498379512278e+00
GC_4_51 ref NI_4 NS_51 0 -1.7548113263710392e+00
GC_4_52 ref NI_4 NS_52 0 -2.7317226485425777e-01
GC_4_53 ref NI_4 NS_53 0 -5.6639222293354058e-03
GC_4_54 ref NI_4 NS_54 0 -6.5647126099547745e-05
GC_4_55 ref NI_4 NS_55 0 1.0229690203215910e-01
GC_4_56 ref NI_4 NS_56 0 -1.3899659475829071e-01
GC_4_57 ref NI_4 NS_57 0 6.8990978704857375e-02
GC_4_58 ref NI_4 NS_58 0 1.6995164970513352e-01
GC_4_59 ref NI_4 NS_59 0 1.5807544516258454e-03
GC_4_60 ref NI_4 NS_60 0 8.9491918196321575e-05
GC_4_61 ref NI_4 NS_61 0 1.9793576614831973e-01
GC_4_62 ref NI_4 NS_62 0 -3.6088097200321473e-01
GC_4_63 ref NI_4 NS_63 0 3.4788505413095777e-01
GC_4_64 ref NI_4 NS_64 0 8.5208988076174608e-02
GC_4_65 ref NI_4 NS_65 0 -1.1392398086229019e-03
GC_4_66 ref NI_4 NS_66 0 1.7828469423724948e-05
GC_4_67 ref NI_4 NS_67 0 -1.3914497733307021e-02
GC_4_68 ref NI_4 NS_68 0 -1.7975806316094564e-02
GC_4_69 ref NI_4 NS_69 0 -1.0330878130816008e-01
GC_4_70 ref NI_4 NS_70 0 2.3359886326943627e-01
GC_4_71 ref NI_4 NS_71 0 3.3200642573073770e-03
GC_4_72 ref NI_4 NS_72 0 4.2465659831593268e-05
GC_4_73 ref NI_4 NS_73 0 2.6546583111174731e-02
GC_4_74 ref NI_4 NS_74 0 -1.0881415361460553e-01
GC_4_75 ref NI_4 NS_75 0 -1.5709296096372848e-02
GC_4_76 ref NI_4 NS_76 0 2.1144601744593153e-01
GC_4_77 ref NI_4 NS_77 0 2.3331679690657046e-03
GC_4_78 ref NI_4 NS_78 0 3.1410517259483244e-05
GC_4_79 ref NI_4 NS_79 0 -5.2724999574351408e-02
GC_4_80 ref NI_4 NS_80 0 2.4421707297852053e-02
GC_4_81 ref NI_4 NS_81 0 -1.8774173452006998e-01
GC_4_82 ref NI_4 NS_82 0 2.6715017988947443e-01
GC_4_83 ref NI_4 NS_83 0 4.4277308780158444e-03
GC_4_84 ref NI_4 NS_84 0 1.6612024078592435e-05
GC_4_85 ref NI_4 NS_85 0 -9.4877423570930264e-02
GC_4_86 ref NI_4 NS_86 0 6.5305996218679219e-02
GC_4_87 ref NI_4 NS_87 0 -2.5989076021812357e-01
GC_4_88 ref NI_4 NS_88 0 2.9300572358520105e-01
GC_4_89 ref NI_4 NS_89 0 5.4066780504001119e-03
GC_4_90 ref NI_4 NS_90 0 2.0914656320965366e-05
GD_4_1 ref NI_4 NA_1 0 2.2487014666404011e-02
GD_4_2 ref NI_4 NA_2 0 -3.8411049571944036e-02
GD_4_3 ref NI_4 NA_3 0 -1.4136398833335955e-02
GD_4_4 ref NI_4 NA_4 0 6.2260426667037754e+00
GD_4_5 ref NI_4 NA_5 0 -2.0807538786786949e-02
GD_4_6 ref NI_4 NA_6 0 -2.5106679461013970e-02
GD_4_7 ref NI_4 NA_7 0 -2.0764525687544159e-02
GD_4_8 ref NI_4 NA_8 0 1.2356443000595270e-02
GD_4_9 ref NI_4 NA_9 0 -6.2203831471274812e-02
GD_4_10 ref NI_4 NA_10 0 -9.4542822469531121e-03
GD_4_11 ref NI_4 NA_11 0 -1.7955062167332770e-02
GD_4_12 ref NI_4 NA_12 0 5.9638608451162976e-04
GD_4_13 ref NI_4 NA_13 0 -2.4344517932064296e-03
GD_4_14 ref NI_4 NA_14 0 3.5085994598591675e-03
GD_4_15 ref NI_4 NA_15 0 8.7812591843325471e-03
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 2.6304760598684938e-02
GC_5_2 ref NI_5 NS_2 0 -2.9541989643239543e-02
GC_5_3 ref NI_5 NS_3 0 2.5548276920809715e-01
GC_5_4 ref NI_5 NS_4 0 4.6002391137702853e-02
GC_5_5 ref NI_5 NS_5 0 6.1357764421666886e-04
GC_5_6 ref NI_5 NS_6 0 2.2730535132994413e-04
GC_5_7 ref NI_5 NS_7 0 -1.3902157902170503e-01
GC_5_8 ref NI_5 NS_8 0 3.5575907040339366e-01
GC_5_9 ref NI_5 NS_9 0 3.6442594344645879e-01
GC_5_10 ref NI_5 NS_10 0 -7.6345284055620313e-02
GC_5_11 ref NI_5 NS_11 0 1.6111909849801462e-03
GC_5_12 ref NI_5 NS_12 0 -1.3366734211257949e-05
GC_5_13 ref NI_5 NS_13 0 7.3949317672453246e-02
GC_5_14 ref NI_5 NS_14 0 -8.2742259664530388e-02
GC_5_15 ref NI_5 NS_15 0 1.4609684877528120e-01
GC_5_16 ref NI_5 NS_16 0 1.2386133352634532e-01
GC_5_17 ref NI_5 NS_17 0 1.1350874394414046e-03
GC_5_18 ref NI_5 NS_18 0 3.1837665568704798e-05
GC_5_19 ref NI_5 NS_19 0 2.2488337571097708e-01
GC_5_20 ref NI_5 NS_20 0 3.9794994451737303e-01
GC_5_21 ref NI_5 NS_21 0 6.3097995239824134e-01
GC_5_22 ref NI_5 NS_22 0 -2.3495523102938387e-01
GC_5_23 ref NI_5 NS_23 0 -1.6516061328506557e-03
GC_5_24 ref NI_5 NS_24 0 -4.8692946658411668e-05
GC_5_25 ref NI_5 NS_25 0 3.6472886613124822e-01
GC_5_26 ref NI_5 NS_26 0 -6.9472671623538700e+00
GC_5_27 ref NI_5 NS_27 0 -1.5282629147323847e+00
GC_5_28 ref NI_5 NS_28 0 -1.9767695029690710e-01
GC_5_29 ref NI_5 NS_29 0 -8.8722328950154739e-03
GC_5_30 ref NI_5 NS_30 0 -2.1895139175868167e-04
GC_5_31 ref NI_5 NS_31 0 -7.0865093479073230e-02
GC_5_32 ref NI_5 NS_32 0 1.3404405006124644e+00
GC_5_33 ref NI_5 NS_33 0 9.1886184030476686e-02
GC_5_34 ref NI_5 NS_34 0 -1.6293003230758363e-01
GC_5_35 ref NI_5 NS_35 0 -2.1552314446469169e-04
GC_5_36 ref NI_5 NS_36 0 -2.6408834773025991e-05
GC_5_37 ref NI_5 NS_37 0 1.6116995885143388e-02
GC_5_38 ref NI_5 NS_38 0 1.1124872878275188e-01
GC_5_39 ref NI_5 NS_39 0 3.2111951602924665e-01
GC_5_40 ref NI_5 NS_40 0 -7.0985010982572436e-03
GC_5_41 ref NI_5 NS_41 0 3.4813623683181965e-04
GC_5_42 ref NI_5 NS_42 0 1.2752919680020620e-05
GC_5_43 ref NI_5 NS_43 0 9.9246737165700361e-01
GC_5_44 ref NI_5 NS_44 0 5.3267774773875143e+00
GC_5_45 ref NI_5 NS_45 0 -1.9152956198752062e+00
GC_5_46 ref NI_5 NS_46 0 -4.4253674823938709e-02
GC_5_47 ref NI_5 NS_47 0 -6.8300272488125017e-03
GC_5_48 ref NI_5 NS_48 0 -5.2592146657219796e-05
GC_5_49 ref NI_5 NS_49 0 -3.6778270845161731e-01
GC_5_50 ref NI_5 NS_50 0 2.1113736448302872e-02
GC_5_51 ref NI_5 NS_51 0 9.7562439666458733e-01
GC_5_52 ref NI_5 NS_52 0 -3.0879175443371576e-01
GC_5_53 ref NI_5 NS_53 0 7.2496948452899148e-04
GC_5_54 ref NI_5 NS_54 0 -7.3910244917566915e-05
GC_5_55 ref NI_5 NS_55 0 9.1513508563792423e-02
GC_5_56 ref NI_5 NS_56 0 -2.3316542753651748e-01
GC_5_57 ref NI_5 NS_57 0 2.6571214213547778e-01
GC_5_58 ref NI_5 NS_58 0 9.3617500798792899e-02
GC_5_59 ref NI_5 NS_59 0 5.1326754457619596e-04
GC_5_60 ref NI_5 NS_60 0 5.5710936584958989e-05
GC_5_61 ref NI_5 NS_61 0 -2.0414368380655482e-01
GC_5_62 ref NI_5 NS_62 0 -1.4219246348771244e-01
GC_5_63 ref NI_5 NS_63 0 6.5878840659923621e-01
GC_5_64 ref NI_5 NS_64 0 -1.2182004408440159e-01
GC_5_65 ref NI_5 NS_65 0 8.5679381581859422e-04
GC_5_66 ref NI_5 NS_66 0 -9.5383879037090579e-06
GC_5_67 ref NI_5 NS_67 0 6.7861311946222948e-03
GC_5_68 ref NI_5 NS_68 0 -7.8024132496394033e-02
GC_5_69 ref NI_5 NS_69 0 -1.2920017697529399e-02
GC_5_70 ref NI_5 NS_70 0 2.0063266769244736e-01
GC_5_71 ref NI_5 NS_71 0 2.8073154600143676e-03
GC_5_72 ref NI_5 NS_72 0 3.7135266920070630e-05
GC_5_73 ref NI_5 NS_73 0 1.4670701583470253e-02
GC_5_74 ref NI_5 NS_74 0 -1.7828482985543431e-01
GC_5_75 ref NI_5 NS_75 0 1.2629763919436299e-01
GC_5_76 ref NI_5 NS_76 0 1.5294485963521159e-01
GC_5_77 ref NI_5 NS_77 0 2.0669071155091498e-03
GC_5_78 ref NI_5 NS_78 0 3.4710443622944326e-05
GC_5_79 ref NI_5 NS_79 0 -1.8123887753589786e-02
GC_5_80 ref NI_5 NS_80 0 -3.5560262580514826e-02
GC_5_81 ref NI_5 NS_81 0 -1.1263869049163884e-01
GC_5_82 ref NI_5 NS_82 0 2.4192153300959274e-01
GC_5_83 ref NI_5 NS_83 0 3.6675573399123800e-03
GC_5_84 ref NI_5 NS_84 0 2.6640195213428399e-05
GC_5_85 ref NI_5 NS_85 0 -5.5867121831026351e-02
GC_5_86 ref NI_5 NS_86 0 -2.2341992057962170e-03
GC_5_87 ref NI_5 NS_87 0 -1.8214198294244968e-01
GC_5_88 ref NI_5 NS_88 0 2.6857516901722006e-01
GC_5_89 ref NI_5 NS_89 0 4.5256810426185191e-03
GC_5_90 ref NI_5 NS_90 0 3.0271329542431038e-05
GD_5_1 ref NI_5 NA_1 0 1.1164115316706871e-02
GD_5_2 ref NI_5 NA_2 0 -2.5703546554039756e-02
GD_5_3 ref NI_5 NA_3 0 -1.1305134108155916e-02
GD_5_4 ref NI_5 NA_4 0 -2.0807538786793783e-02
GD_5_5 ref NI_5 NA_5 0 6.2015183488753536e+00
GD_5_6 ref NI_5 NA_6 0 1.5410112024706816e-03
GD_5_7 ref NI_5 NA_7 0 -7.6273765591675568e-03
GD_5_8 ref NI_5 NA_8 0 -8.0080016650164065e-02
GD_5_9 ref NI_5 NA_9 0 1.1519039721188852e-02
GD_5_10 ref NI_5 NA_10 0 -5.3660095696814892e-03
GD_5_11 ref NI_5 NA_11 0 2.1888759840426299e-02
GD_5_12 ref NI_5 NA_12 0 2.0310766291634029e-04
GD_5_13 ref NI_5 NA_13 0 5.6023465176499278e-05
GD_5_14 ref NI_5 NA_14 0 1.5322527904746809e-03
GD_5_15 ref NI_5 NA_15 0 6.1551014558953124e-03
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -8.5065685510699832e-02
GC_6_2 ref NI_6 NS_2 0 7.0941456932533037e-02
GC_6_3 ref NI_6 NS_3 0 1.5972187079032357e-01
GC_6_4 ref NI_6 NS_4 0 7.1271765453284425e-02
GC_6_5 ref NI_6 NS_5 0 2.4270833796915569e-03
GC_6_6 ref NI_6 NS_6 0 2.0852348986165201e-04
GC_6_7 ref NI_6 NS_7 0 2.0165134868447140e-01
GC_6_8 ref NI_6 NS_8 0 3.7152686433294813e-01
GC_6_9 ref NI_6 NS_9 0 2.6889947525678121e-01
GC_6_10 ref NI_6 NS_10 0 -4.0957259858943107e-02
GC_6_11 ref NI_6 NS_11 0 5.8300665530558048e-04
GC_6_12 ref NI_6 NS_12 0 4.9292473530606765e-07
GC_6_13 ref NI_6 NS_13 0 -1.9843458757355117e-01
GC_6_14 ref NI_6 NS_14 0 2.6100514654905865e-01
GC_6_15 ref NI_6 NS_15 0 3.2398652613558326e-01
GC_6_16 ref NI_6 NS_16 0 -4.6029443196736491e-02
GC_6_17 ref NI_6 NS_17 0 2.8794542598160715e-03
GC_6_18 ref NI_6 NS_18 0 2.6476169945541633e-05
GC_6_19 ref NI_6 NS_19 0 1.4701853170077972e-01
GC_6_20 ref NI_6 NS_20 0 1.7237580938092725e-01
GC_6_21 ref NI_6 NS_21 0 4.6621307648185306e-01
GC_6_22 ref NI_6 NS_22 0 -9.2594659597543788e-02
GC_6_23 ref NI_6 NS_23 0 -1.6274790633354381e-03
GC_6_24 ref NI_6 NS_24 0 -1.6623087324216021e-05
GC_6_25 ref NI_6 NS_25 0 -7.0865093479067456e-02
GC_6_26 ref NI_6 NS_26 0 1.3404405006124618e+00
GC_6_27 ref NI_6 NS_27 0 9.1886184030478033e-02
GC_6_28 ref NI_6 NS_28 0 -1.6293003230758399e-01
GC_6_29 ref NI_6 NS_29 0 -2.1552314446466689e-04
GC_6_30 ref NI_6 NS_30 0 -2.6408834773031043e-05
GC_6_31 ref NI_6 NS_31 0 2.1941988479423826e+00
GC_6_32 ref NI_6 NS_32 0 -4.0399161648572433e+00
GC_6_33 ref NI_6 NS_33 0 -3.7234390152770627e+00
GC_6_34 ref NI_6 NS_34 0 2.5399600282223517e-01
GC_6_35 ref NI_6 NS_35 0 -1.8679308903461155e-02
GC_6_36 ref NI_6 NS_36 0 -2.2150692979600308e-04
GC_6_37 ref NI_6 NS_37 0 -5.5807270237328399e-01
GC_6_38 ref NI_6 NS_38 0 1.6797325860184011e+00
GC_6_39 ref NI_6 NS_39 0 -3.4049947383670419e-02
GC_6_40 ref NI_6 NS_40 0 -1.6497693016561935e-01
GC_6_41 ref NI_6 NS_41 0 2.6595072819089287e-03
GC_6_42 ref NI_6 NS_42 0 -3.6730669613491245e-07
GC_6_43 ref NI_6 NS_43 0 -5.4409608147291144e-01
GC_6_44 ref NI_6 NS_44 0 1.2450446833929199e-01
GC_6_45 ref NI_6 NS_45 0 7.8099480995587445e-01
GC_6_46 ref NI_6 NS_46 0 -2.3339442889861875e-01
GC_6_47 ref NI_6 NS_47 0 2.1301163455419445e-03
GC_6_48 ref NI_6 NS_48 0 -3.3138958826312476e-05
GC_6_49 ref NI_6 NS_49 0 3.7956877969939198e-02
GC_6_50 ref NI_6 NS_50 0 -2.3503606447927883e-01
GC_6_51 ref NI_6 NS_51 0 6.7231977204389970e-01
GC_6_52 ref NI_6 NS_52 0 -1.0634634894755761e-01
GC_6_53 ref NI_6 NS_53 0 -9.5243405098453143e-04
GC_6_54 ref NI_6 NS_54 0 -1.5606791303066288e-05
GC_6_55 ref NI_6 NS_55 0 1.1190541535988481e-01
GC_6_56 ref NI_6 NS_56 0 -3.2942744484496961e-01
GC_6_57 ref NI_6 NS_57 0 3.9405772933381134e-01
GC_6_58 ref NI_6 NS_58 0 5.1357715062862130e-02
GC_6_59 ref NI_6 NS_59 0 1.7735971500204898e-04
GC_6_60 ref NI_6 NS_60 0 2.7728322342980903e-05
GC_6_61 ref NI_6 NS_61 0 -2.6582117013539863e-01
GC_6_62 ref NI_6 NS_62 0 8.5397442719767791e-01
GC_6_63 ref NI_6 NS_63 0 2.6984864064485475e-01
GC_6_64 ref NI_6 NS_64 0 -1.3719006916206836e-01
GC_6_65 ref NI_6 NS_65 0 7.3677529132955830e-04
GC_6_66 ref NI_6 NS_66 0 -1.1218343051462728e-04
GC_6_67 ref NI_6 NS_67 0 6.5570085855520710e-02
GC_6_68 ref NI_6 NS_68 0 -7.3179878621427136e-02
GC_6_69 ref NI_6 NS_69 0 8.0447865081476652e-02
GC_6_70 ref NI_6 NS_70 0 1.4570269154832860e-01
GC_6_71 ref NI_6 NS_71 0 2.7110535582158929e-03
GC_6_72 ref NI_6 NS_72 0 6.5292669387365305e-05
GC_6_73 ref NI_6 NS_73 0 7.4058152673172771e-04
GC_6_74 ref NI_6 NS_74 0 -1.7215189267110009e-01
GC_6_75 ref NI_6 NS_75 0 2.8330340201701165e-01
GC_6_76 ref NI_6 NS_76 0 6.8471645029442960e-02
GC_6_77 ref NI_6 NS_77 0 2.2703093309139515e-03
GC_6_78 ref NI_6 NS_78 0 1.0992822388221610e-05
GC_6_79 ref NI_6 NS_79 0 4.5169620033741385e-02
GC_6_80 ref NI_6 NS_80 0 -1.0675464113492865e-01
GC_6_81 ref NI_6 NS_81 0 6.1010694505433775e-02
GC_6_82 ref NI_6 NS_82 0 1.6490281276521518e-01
GC_6_83 ref NI_6 NS_83 0 2.8146720705261963e-03
GC_6_84 ref NI_6 NS_84 0 5.5477450925677234e-05
GC_6_85 ref NI_6 NS_85 0 3.9652487601003171e-02
GC_6_86 ref NI_6 NS_86 0 -1.2283916374315590e-01
GC_6_87 ref NI_6 NS_87 0 -1.3755907180321356e-03
GC_6_88 ref NI_6 NS_88 0 1.9972101556700159e-01
GC_6_89 ref NI_6 NS_89 0 3.4572527272259471e-03
GC_6_90 ref NI_6 NS_90 0 4.2442789048787630e-05
GD_6_1 ref NI_6 NA_1 0 1.9099007717875583e-02
GD_6_2 ref NI_6 NA_2 0 -5.8937994139873100e-02
GD_6_3 ref NI_6 NA_3 0 1.0392993223351835e-02
GD_6_4 ref NI_6 NA_4 0 -2.5106679461018338e-02
GD_6_5 ref NI_6 NA_5 0 1.5410112024694948e-03
GD_6_6 ref NI_6 NA_6 0 6.0567064054233164e+00
GD_6_7 ref NI_6 NA_7 0 3.6712291649924692e-02
GD_6_8 ref NI_6 NA_8 0 3.5852363855125462e-02
GD_6_9 ref NI_6 NA_9 0 -1.2732968887360594e-02
GD_6_10 ref NI_6 NA_10 0 -1.3233685801611189e-02
GD_6_11 ref NI_6 NA_11 0 3.3433766281579159e-02
GD_6_12 ref NI_6 NA_12 0 -5.0992054923520757e-03
GD_6_13 ref NI_6 NA_13 0 2.2585996328195247e-03
GD_6_14 ref NI_6 NA_14 0 -3.9357337833767466e-03
GD_6_15 ref NI_6 NA_15 0 -1.9352643691753605e-03
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -1.3538025041221929e-01
GC_7_2 ref NI_7 NS_2 0 9.0526481593619340e-02
GC_7_3 ref NI_7 NS_3 0 -3.2057450314464282e-02
GC_7_4 ref NI_7 NS_4 0 1.5618832234931396e-01
GC_7_5 ref NI_7 NS_5 0 5.5752315149012561e-03
GC_7_6 ref NI_7 NS_6 0 2.2522786261233016e-04
GC_7_7 ref NI_7 NS_7 0 1.1704594995063916e-01
GC_7_8 ref NI_7 NS_8 0 3.3941502864857426e-01
GC_7_9 ref NI_7 NS_9 0 3.1429581047521560e-01
GC_7_10 ref NI_7 NS_10 0 -5.4119287929968334e-02
GC_7_11 ref NI_7 NS_11 0 7.1011485158546932e-04
GC_7_12 ref NI_7 NS_12 0 -6.9703298494489361e-06
GC_7_13 ref NI_7 NS_13 0 -6.7075156976491135e-01
GC_7_14 ref NI_7 NS_14 0 1.8608719199908628e+00
GC_7_15 ref NI_7 NS_15 0 7.8519177432101503e-02
GC_7_16 ref NI_7 NS_16 0 -2.6222366841461942e-01
GC_7_17 ref NI_7 NS_17 0 2.7784779968475716e-03
GC_7_18 ref NI_7 NS_18 0 -2.0937599349025894e-05
GC_7_19 ref NI_7 NS_19 0 1.3801618892974374e-01
GC_7_20 ref NI_7 NS_20 0 -3.6151989803186110e-02
GC_7_21 ref NI_7 NS_21 0 2.4646010803728424e-01
GC_7_22 ref NI_7 NS_22 0 6.5020316600369402e-02
GC_7_23 ref NI_7 NS_23 0 -4.5147876593028545e-04
GC_7_24 ref NI_7 NS_24 0 2.7262991808116159e-05
GC_7_25 ref NI_7 NS_25 0 1.6116995885129340e-02
GC_7_26 ref NI_7 NS_26 0 1.1124872878275768e-01
GC_7_27 ref NI_7 NS_27 0 3.2111951602924377e-01
GC_7_28 ref NI_7 NS_28 0 -7.0985010982564491e-03
GC_7_29 ref NI_7 NS_29 0 3.4813623683182268e-04
GC_7_30 ref NI_7 NS_30 0 1.2752919679999949e-05
GC_7_31 ref NI_7 NS_31 0 -5.5807270237328388e-01
GC_7_32 ref NI_7 NS_32 0 1.6797325860184011e+00
GC_7_33 ref NI_7 NS_33 0 -3.4049947383670419e-02
GC_7_34 ref NI_7 NS_34 0 -1.6497693016561935e-01
GC_7_35 ref NI_7 NS_35 0 2.6595072819089217e-03
GC_7_36 ref NI_7 NS_36 0 -3.6730669613081826e-07
GC_7_37 ref NI_7 NS_37 0 1.9631193329706547e+00
GC_7_38 ref NI_7 NS_38 0 -3.6855163026248734e+00
GC_7_39 ref NI_7 NS_39 0 -3.6890821358236332e+00
GC_7_40 ref NI_7 NS_40 0 1.5885515524542729e-01
GC_7_41 ref NI_7 NS_41 0 -1.7330851779277505e-02
GC_7_42 ref NI_7 NS_42 0 -2.4867604101939093e-04
GC_7_43 ref NI_7 NS_43 0 5.3610913603096250e-02
GC_7_44 ref NI_7 NS_44 0 -2.9143389737504893e-01
GC_7_45 ref NI_7 NS_45 0 4.5800975466405563e-01
GC_7_46 ref NI_7 NS_46 0 1.1688489959640310e-02
GC_7_47 ref NI_7 NS_47 0 3.2523946068255542e-04
GC_7_48 ref NI_7 NS_48 0 1.5426621925835709e-05
GC_7_49 ref NI_7 NS_49 0 1.2349597739952763e-01
GC_7_50 ref NI_7 NS_50 0 -2.3774388615900349e-01
GC_7_51 ref NI_7 NS_51 0 3.2614091146130719e-01
GC_7_52 ref NI_7 NS_52 0 6.9416339218760600e-02
GC_7_53 ref NI_7 NS_53 0 -3.5443302643960910e-04
GC_7_54 ref NI_7 NS_54 0 2.7226073473725364e-05
GC_7_55 ref NI_7 NS_55 0 -3.1000417191429704e-02
GC_7_56 ref NI_7 NS_56 0 1.5229805596896498e-01
GC_7_57 ref NI_7 NS_57 0 2.1221836665262092e-01
GC_7_58 ref NI_7 NS_58 0 4.0903841119945716e-02
GC_7_59 ref NI_7 NS_59 0 1.2618388373344821e-03
GC_7_60 ref NI_7 NS_60 0 -3.2398384756097138e-05
GC_7_61 ref NI_7 NS_61 0 1.2515393537851127e-01
GC_7_62 ref NI_7 NS_62 0 -3.9650639414123140e-01
GC_7_63 ref NI_7 NS_63 0 3.3816245249562593e-01
GC_7_64 ref NI_7 NS_64 0 9.3225111042200284e-02
GC_7_65 ref NI_7 NS_65 0 7.6475029304757700e-04
GC_7_66 ref NI_7 NS_66 0 2.1187669956198485e-05
GC_7_67 ref NI_7 NS_67 0 6.4833208127945810e-02
GC_7_68 ref NI_7 NS_68 0 -3.1590123607300796e-01
GC_7_69 ref NI_7 NS_69 0 4.8389874220583018e-01
GC_7_70 ref NI_7 NS_70 0 7.3720191850443401e-04
GC_7_71 ref NI_7 NS_71 0 9.1220646709108406e-04
GC_7_72 ref NI_7 NS_72 0 -3.1354872162340222e-06
GC_7_73 ref NI_7 NS_73 0 -4.2875135874666342e-01
GC_7_74 ref NI_7 NS_74 0 1.1091163677578424e+00
GC_7_75 ref NI_7 NS_75 0 1.8825485625134150e-01
GC_7_76 ref NI_7 NS_76 0 -1.5518013246942833e-01
GC_7_77 ref NI_7 NS_77 0 2.0530833026454962e-03
GC_7_78 ref NI_7 NS_78 0 -9.1319753398601302e-05
GC_7_79 ref NI_7 NS_79 0 6.1569310234565959e-02
GC_7_80 ref NI_7 NS_80 0 -2.0421671255525123e-01
GC_7_81 ref NI_7 NS_81 0 4.3803292434541685e-01
GC_7_82 ref NI_7 NS_82 0 -5.8136753516510754e-03
GC_7_83 ref NI_7 NS_83 0 7.7897258215704789e-04
GC_7_84 ref NI_7 NS_84 0 5.4163147204828272e-05
GC_7_85 ref NI_7 NS_85 0 7.7736461648453242e-02
GC_7_86 ref NI_7 NS_86 0 -3.3753779005469259e-01
GC_7_87 ref NI_7 NS_87 0 4.2669656784023624e-01
GC_7_88 ref NI_7 NS_88 0 2.9662813423346996e-02
GC_7_89 ref NI_7 NS_89 0 1.2107162690109616e-03
GC_7_90 ref NI_7 NS_90 0 3.4475647825871592e-05
GD_7_1 ref NI_7 NA_1 0 2.1632807751872762e-02
GD_7_2 ref NI_7 NA_2 0 -4.9259253124151789e-02
GD_7_3 ref NI_7 NA_3 0 4.7617019928978738e-02
GD_7_4 ref NI_7 NA_4 0 -2.0764525687548881e-02
GD_7_5 ref NI_7 NA_5 0 -7.6273765591654873e-03
GD_7_6 ref NI_7 NA_6 0 3.6712291649924685e-02
GD_7_7 ref NI_7 NA_7 0 6.0730578314309689e+00
GD_7_8 ref NI_7 NA_8 0 -1.0308533461751474e-02
GD_7_9 ref NI_7 NA_9 0 -1.8296250500816919e-02
GD_7_10 ref NI_7 NA_10 0 5.6215368252870608e-03
GD_7_11 ref NI_7 NA_11 0 -1.2306111455658237e-02
GD_7_12 ref NI_7 NA_12 0 -7.7073742670788863e-03
GD_7_13 ref NI_7 NA_13 0 5.6565506889569468e-02
GD_7_14 ref NI_7 NA_14 0 -1.5106827211115721e-03
GD_7_15 ref NI_7 NA_15 0 -1.7700368394011298e-03
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 5.5781600719837727e-03
GC_8_2 ref NI_8 NS_2 0 -1.6752836269216334e-01
GC_8_3 ref NI_8 NS_3 0 2.4058414286052113e-01
GC_8_4 ref NI_8 NS_4 0 8.2942811300594541e-02
GC_8_5 ref NI_8 NS_5 0 1.6207033807985618e-03
GC_8_6 ref NI_8 NS_6 0 2.2837035421018794e-04
GC_8_7 ref NI_8 NS_7 0 2.6234780600978480e-01
GC_8_8 ref NI_8 NS_8 0 8.6143629998426896e-01
GC_8_9 ref NI_8 NS_9 0 1.6758146078694559e-02
GC_8_10 ref NI_8 NS_10 0 -2.0696401471779344e-02
GC_8_11 ref NI_8 NS_11 0 1.5852080349403148e-04
GC_8_12 ref NI_8 NS_12 0 -7.7441916091265677e-06
GC_8_13 ref NI_8 NS_13 0 9.1845755901842990e-02
GC_8_14 ref NI_8 NS_14 0 -1.9327664807700312e-01
GC_8_15 ref NI_8 NS_15 0 1.6423020018729884e-01
GC_8_16 ref NI_8 NS_16 0 1.4038528415567877e-01
GC_8_17 ref NI_8 NS_17 0 9.0277046962423057e-04
GC_8_18 ref NI_8 NS_18 0 2.7858111709513161e-05
GC_8_19 ref NI_8 NS_19 0 -3.8431774900663201e-01
GC_8_20 ref NI_8 NS_20 0 2.5863143903055524e-02
GC_8_21 ref NI_8 NS_21 0 9.4756187894166788e-01
GC_8_22 ref NI_8 NS_22 0 -2.9509695047735041e-01
GC_8_23 ref NI_8 NS_23 0 9.9393363608453120e-04
GC_8_24 ref NI_8 NS_24 0 -7.7110727469749355e-05
GC_8_25 ref NI_8 NS_25 0 9.9246737165701537e-01
GC_8_26 ref NI_8 NS_26 0 5.3267774773875090e+00
GC_8_27 ref NI_8 NS_27 0 -1.9152956198752038e+00
GC_8_28 ref NI_8 NS_28 0 -4.4253674823939618e-02
GC_8_29 ref NI_8 NS_29 0 -6.8300272488124435e-03
GC_8_30 ref NI_8 NS_30 0 -5.2592146657233199e-05
GC_8_31 ref NI_8 NS_31 0 -5.4409608147291322e-01
GC_8_32 ref NI_8 NS_32 0 1.2450446833929311e-01
GC_8_33 ref NI_8 NS_33 0 7.8099480995587367e-01
GC_8_34 ref NI_8 NS_34 0 -2.3339442889861861e-01
GC_8_35 ref NI_8 NS_35 0 2.1301163455419284e-03
GC_8_36 ref NI_8 NS_36 0 -3.3138958826306702e-05
GC_8_37 ref NI_8 NS_37 0 5.3610913603100364e-02
GC_8_38 ref NI_8 NS_38 0 -2.9143389737505043e-01
GC_8_39 ref NI_8 NS_39 0 4.5800975466405663e-01
GC_8_40 ref NI_8 NS_40 0 1.1688489959639959e-02
GC_8_41 ref NI_8 NS_41 0 3.2523946068258231e-04
GC_8_42 ref NI_8 NS_42 0 1.5426621925828970e-05
GC_8_43 ref NI_8 NS_43 0 3.8215081973305293e-01
GC_8_44 ref NI_8 NS_44 0 -6.9751503141012767e+00
GC_8_45 ref NI_8 NS_45 0 -1.5828397157384602e+00
GC_8_46 ref NI_8 NS_46 0 -1.6220887593762895e-01
GC_8_47 ref NI_8 NS_47 0 -8.9681857627916389e-03
GC_8_48 ref NI_8 NS_48 0 -1.8112087840277882e-04
GC_8_49 ref NI_8 NS_49 0 1.9641107618448642e-01
GC_8_50 ref NI_8 NS_50 0 4.8051570673819172e-01
GC_8_51 ref NI_8 NS_51 0 5.5586374206341638e-01
GC_8_52 ref NI_8 NS_52 0 -2.1293459788134642e-01
GC_8_53 ref NI_8 NS_53 0 -1.4677581267646146e-03
GC_8_54 ref NI_8 NS_54 0 -6.5366639110611680e-05
GC_8_55 ref NI_8 NS_55 0 1.8500655395713387e-02
GC_8_56 ref NI_8 NS_56 0 3.4118925008331863e-03
GC_8_57 ref NI_8 NS_57 0 2.5860423127657439e-01
GC_8_58 ref NI_8 NS_58 0 4.5714740499021293e-02
GC_8_59 ref NI_8 NS_59 0 4.2756000047431244e-04
GC_8_60 ref NI_8 NS_60 0 5.5972968342466649e-05
GC_8_61 ref NI_8 NS_61 0 -3.7395910269394192e-02
GC_8_62 ref NI_8 NS_62 0 5.0063434709579890e-01
GC_8_63 ref NI_8 NS_63 0 3.8904275124940291e-01
GC_8_64 ref NI_8 NS_64 0 -1.3332240383409327e-01
GC_8_65 ref NI_8 NS_65 0 -1.7302545747873457e-04
GC_8_66 ref NI_8 NS_66 0 7.1525820878275127e-07
GC_8_67 ref NI_8 NS_67 0 -3.3270623131677529e-02
GC_8_68 ref NI_8 NS_68 0 2.8024549697184261e-02
GC_8_69 ref NI_8 NS_69 0 -4.5843158223439068e-03
GC_8_70 ref NI_8 NS_70 0 1.7434831899859901e-01
GC_8_71 ref NI_8 NS_71 0 2.6196889371534141e-03
GC_8_72 ref NI_8 NS_72 0 3.1815493449309164e-05
GC_8_73 ref NI_8 NS_73 0 3.5260249933526375e-02
GC_8_74 ref NI_8 NS_74 0 3.1156376785223806e-02
GC_8_75 ref NI_8 NS_75 0 6.4040015788566912e-02
GC_8_76 ref NI_8 NS_76 0 1.3732204929103725e-01
GC_8_77 ref NI_8 NS_77 0 1.6640282931719254e-03
GC_8_78 ref NI_8 NS_78 0 4.1359738239843600e-05
GC_8_79 ref NI_8 NS_79 0 -4.7877030210958967e-02
GC_8_80 ref NI_8 NS_80 0 2.7718151169581741e-02
GC_8_81 ref NI_8 NS_81 0 -1.1419689942871090e-01
GC_8_82 ref NI_8 NS_82 0 2.3085401183239179e-01
GC_8_83 ref NI_8 NS_83 0 3.5785994586687063e-03
GC_8_84 ref NI_8 NS_84 0 9.5519633410800608e-06
GC_8_85 ref NI_8 NS_85 0 -7.0963754516950611e-02
GC_8_86 ref NI_8 NS_86 0 7.4649201863385015e-02
GC_8_87 ref NI_8 NS_87 0 -1.8627001825989098e-01
GC_8_88 ref NI_8 NS_88 0 2.5523480640746371e-01
GC_8_89 ref NI_8 NS_89 0 4.2571951487710979e-03
GC_8_90 ref NI_8 NS_90 0 2.0068479142660706e-05
GD_8_1 ref NI_8 NA_1 0 1.0086116819132655e-02
GD_8_2 ref NI_8 NA_2 0 -6.6479802706189195e-02
GD_8_3 ref NI_8 NA_3 0 -1.3589339495302496e-02
GD_8_4 ref NI_8 NA_4 0 1.2356443000596337e-02
GD_8_5 ref NI_8 NA_5 0 -8.0080016650165994e-02
GD_8_6 ref NI_8 NA_6 0 3.5852363855125760e-02
GD_8_7 ref NI_8 NA_7 0 -1.0308533461752147e-02
GD_8_8 ref NI_8 NA_8 0 6.2016768193010208e+00
GD_8_9 ref NI_8 NA_9 0 -1.8552250475121185e-02
GD_8_10 ref NI_8 NA_10 0 3.0599998725332179e-03
GD_8_11 ref NI_8 NA_11 0 1.3953404262443689e-02
GD_8_12 ref NI_8 NA_12 0 3.3774671219078253e-03
GD_8_13 ref NI_8 NA_13 0 -9.9282382369195632e-04
GD_8_14 ref NI_8 NA_14 0 2.5639283050640834e-03
GD_8_15 ref NI_8 NA_15 0 6.5100815301814665e-03
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -5.3339823439971484e-02
GC_9_2 ref NI_9 NS_2 0 -9.4565275569891319e-02
GC_9_3 ref NI_9 NS_3 0 6.1291408647156809e-01
GC_9_4 ref NI_9 NS_4 0 -1.2059565972535530e-01
GC_9_5 ref NI_9 NS_5 0 -8.8787904055518589e-04
GC_9_6 ref NI_9 NS_6 0 2.2877273745405935e-04
GC_9_7 ref NI_9 NS_7 0 2.0665713694484361e-01
GC_9_8 ref NI_9 NS_8 0 6.4408042941771304e-01
GC_9_9 ref NI_9 NS_9 0 1.2203477160710502e-01
GC_9_10 ref NI_9 NS_10 0 -2.4015673873265538e-02
GC_9_11 ref NI_9 NS_11 0 4.0570581231902608e-04
GC_9_12 ref NI_9 NS_12 0 -1.4237365126664077e-05
GC_9_13 ref NI_9 NS_13 0 8.2812719061293200e-02
GC_9_14 ref NI_9 NS_14 0 -1.3692925923899704e-01
GC_9_15 ref NI_9 NS_15 0 7.0263885657774708e-02
GC_9_16 ref NI_9 NS_16 0 1.7792242791303145e-01
GC_9_17 ref NI_9 NS_17 0 9.8409892921593367e-04
GC_9_18 ref NI_9 NS_18 0 2.9685532393187873e-05
GC_9_19 ref NI_9 NS_19 0 7.7633435713465815e-01
GC_9_20 ref NI_9 NS_20 0 5.9632498379512313e+00
GC_9_21 ref NI_9 NS_21 0 -1.7548113263710412e+00
GC_9_22 ref NI_9 NS_22 0 -2.7317226485425683e-01
GC_9_23 ref NI_9 NS_23 0 -5.6639222293354743e-03
GC_9_24 ref NI_9 NS_24 0 -6.5647126099526983e-05
GC_9_25 ref NI_9 NS_25 0 -3.6778270845163430e-01
GC_9_26 ref NI_9 NS_26 0 2.1113736448310039e-02
GC_9_27 ref NI_9 NS_27 0 9.7562439666458345e-01
GC_9_28 ref NI_9 NS_28 0 -3.0879175443371459e-01
GC_9_29 ref NI_9 NS_29 0 7.2496948452894659e-04
GC_9_30 ref NI_9 NS_30 0 -7.3910244917566766e-05
GC_9_31 ref NI_9 NS_31 0 3.7956877969921782e-02
GC_9_32 ref NI_9 NS_32 0 -2.3503606447927175e-01
GC_9_33 ref NI_9 NS_33 0 6.7231977204389604e-01
GC_9_34 ref NI_9 NS_34 0 -1.0634634894755644e-01
GC_9_35 ref NI_9 NS_35 0 -9.5243405098457653e-04
GC_9_36 ref NI_9 NS_36 0 -1.5606791303065281e-05
GC_9_37 ref NI_9 NS_37 0 1.2349597739949546e-01
GC_9_38 ref NI_9 NS_38 0 -2.3774388615898995e-01
GC_9_39 ref NI_9 NS_39 0 3.2614091146130009e-01
GC_9_40 ref NI_9 NS_40 0 6.9416339218762835e-02
GC_9_41 ref NI_9 NS_41 0 -3.5443302643972403e-04
GC_9_42 ref NI_9 NS_42 0 2.7226073473739828e-05
GC_9_43 ref NI_9 NS_43 0 1.9641107618449194e-01
GC_9_44 ref NI_9 NS_44 0 4.8051570673818916e-01
GC_9_45 ref NI_9 NS_45 0 5.5586374206341782e-01
GC_9_46 ref NI_9 NS_46 0 -2.1293459788134694e-01
GC_9_47 ref NI_9 NS_47 0 -1.4677581267645698e-03
GC_9_48 ref NI_9 NS_48 0 -6.5366639110627699e-05
GC_9_49 ref NI_9 NS_49 0 3.4548722098633106e-02
GC_9_50 ref NI_9 NS_50 0 -6.4568983613155240e+00
GC_9_51 ref NI_9 NS_51 0 -1.3031910290802513e+00
GC_9_52 ref NI_9 NS_52 0 -4.2119270486540306e-01
GC_9_53 ref NI_9 NS_53 0 -7.4023113384236242e-03
GC_9_54 ref NI_9 NS_54 0 -2.4443154665471063e-04
GC_9_55 ref NI_9 NS_55 0 6.8872716790605928e-02
GC_9_56 ref NI_9 NS_56 0 -6.8816798773808960e-02
GC_9_57 ref NI_9 NS_57 0 7.5510701256441812e-02
GC_9_58 ref NI_9 NS_58 0 1.4852800545913908e-01
GC_9_59 ref NI_9 NS_59 0 2.1863745742512434e-03
GC_9_60 ref NI_9 NS_60 0 9.2975471271378201e-05
GC_9_61 ref NI_9 NS_61 0 1.9439197291810320e-01
GC_9_62 ref NI_9 NS_62 0 -2.1228083713950094e-01
GC_9_63 ref NI_9 NS_63 0 3.0384413632333601e-01
GC_9_64 ref NI_9 NS_64 0 7.4815579826789991e-02
GC_9_65 ref NI_9 NS_65 0 -1.2468296565565312e-03
GC_9_66 ref NI_9 NS_66 0 1.3584387392197547e-05
GC_9_67 ref NI_9 NS_67 0 -4.1095639132295504e-02
GC_9_68 ref NI_9 NS_68 0 2.5760961672339138e-02
GC_9_69 ref NI_9 NS_69 0 -9.3178490293213123e-02
GC_9_70 ref NI_9 NS_70 0 2.1953740503700889e-01
GC_9_71 ref NI_9 NS_71 0 3.2603080827401493e-03
GC_9_72 ref NI_9 NS_72 0 4.1155578715723903e-05
GC_9_73 ref NI_9 NS_73 0 2.3362025827677654e-02
GC_9_74 ref NI_9 NS_74 0 -2.9521503546432945e-02
GC_9_75 ref NI_9 NS_75 0 -3.3394345503424530e-02
GC_9_76 ref NI_9 NS_76 0 2.0325423654963634e-01
GC_9_77 ref NI_9 NS_77 0 2.1887051621100359e-03
GC_9_78 ref NI_9 NS_78 0 2.7512881738623162e-05
GC_9_79 ref NI_9 NS_79 0 -7.1997691892261170e-02
GC_9_80 ref NI_9 NS_80 0 5.2268771047808832e-02
GC_9_81 ref NI_9 NS_81 0 -1.8307225235847988e-01
GC_9_82 ref NI_9 NS_82 0 2.5972282699392257e-01
GC_9_83 ref NI_9 NS_83 0 4.3381498529863859e-03
GC_9_84 ref NI_9 NS_84 0 1.3316517162073251e-05
GC_9_85 ref NI_9 NS_85 0 -1.0444224983647495e-01
GC_9_86 ref NI_9 NS_86 0 9.6705592529231929e-02
GC_9_87 ref NI_9 NS_87 0 -2.5629730917970206e-01
GC_9_88 ref NI_9 NS_88 0 2.8511530511679367e-01
GC_9_89 ref NI_9 NS_89 0 5.2515064922513417e-03
GC_9_90 ref NI_9 NS_90 0 1.6640283108876118e-05
GD_9_1 ref NI_9 NA_1 0 2.2374376787886702e-02
GD_9_2 ref NI_9 NA_2 0 -6.0065389981327988e-02
GD_9_3 ref NI_9 NA_3 0 -1.3620823263566216e-02
GD_9_4 ref NI_9 NA_4 0 -6.2203831471273584e-02
GD_9_5 ref NI_9 NA_5 0 1.1519039721191405e-02
GD_9_6 ref NI_9 NA_6 0 -1.2732968887358150e-02
GD_9_7 ref NI_9 NA_7 0 -1.8296250500812180e-02
GD_9_8 ref NI_9 NA_8 0 -1.8552250475121788e-02
GD_9_9 ref NI_9 NA_9 0 6.2296994676549469e+00
GD_9_10 ref NI_9 NA_10 0 -6.1559589531722204e-03
GD_9_11 ref NI_9 NA_11 0 -1.7480885849597852e-02
GD_9_12 ref NI_9 NA_12 0 2.8802152236376195e-03
GD_9_13 ref NI_9 NA_13 0 -2.0447322357071240e-03
GD_9_14 ref NI_9 NA_14 0 4.5878331131174463e-03
GD_9_15 ref NI_9 NA_15 0 9.2482779080327211e-03
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -2.0354714861540041e-01
GC_10_2 ref NI_10 NS_2 0 1.5721839680742045e-01
GC_10_3 ref NI_10 NS_3 0 -2.7319983447570945e-01
GC_10_4 ref NI_10 NS_4 0 2.5358210748041299e-01
GC_10_5 ref NI_10 NS_5 0 9.2193184136463505e-03
GC_10_6 ref NI_10 NS_6 0 2.4078543294737384e-04
GC_10_7 ref NI_10 NS_7 0 4.7961030725404218e-02
GC_10_8 ref NI_10 NS_8 0 4.9667221613239304e-01
GC_10_9 ref NI_10 NS_9 0 1.5139063697189903e-01
GC_10_10 ref NI_10 NS_10 0 -8.1710680909105517e-03
GC_10_11 ref NI_10 NS_11 0 1.1780498027619171e-03
GC_10_12 ref NI_10 NS_12 0 5.4374272135064945e-06
GC_10_13 ref NI_10 NS_13 0 2.4186832222316098e-02
GC_10_14 ref NI_10 NS_14 0 -6.2277537708111209e-02
GC_10_15 ref NI_10 NS_15 0 5.9782840777502448e-02
GC_10_16 ref NI_10 NS_16 0 1.6237452491925711e-01
GC_10_17 ref NI_10 NS_17 0 2.1182573674078044e-03
GC_10_18 ref NI_10 NS_18 0 1.1513870670432471e-05
GC_10_19 ref NI_10 NS_19 0 1.0229690203219180e-01
GC_10_20 ref NI_10 NS_20 0 -1.3899659475830409e-01
GC_10_21 ref NI_10 NS_21 0 6.8990978704864397e-02
GC_10_22 ref NI_10 NS_22 0 1.6995164970513138e-01
GC_10_23 ref NI_10 NS_23 0 1.5807544516259322e-03
GC_10_24 ref NI_10 NS_24 0 8.9491918196322022e-05
GC_10_25 ref NI_10 NS_25 0 9.1513508563795906e-02
GC_10_26 ref NI_10 NS_26 0 -2.3316542753651892e-01
GC_10_27 ref NI_10 NS_27 0 2.6571214213547872e-01
GC_10_28 ref NI_10 NS_28 0 9.3617500798792663e-02
GC_10_29 ref NI_10 NS_29 0 5.1326754457618978e-04
GC_10_30 ref NI_10 NS_30 0 5.5710936584965582e-05
GC_10_31 ref NI_10 NS_31 0 1.1190541535986429e-01
GC_10_32 ref NI_10 NS_32 0 -3.2942744484496034e-01
GC_10_33 ref NI_10 NS_33 0 3.9405772933380628e-01
GC_10_34 ref NI_10 NS_34 0 5.1357715062863671e-02
GC_10_35 ref NI_10 NS_35 0 1.7735971500197902e-04
GC_10_36 ref NI_10 NS_36 0 2.7728322342984444e-05
GC_10_37 ref NI_10 NS_37 0 -3.1000417191459049e-02
GC_10_38 ref NI_10 NS_38 0 1.5229805596897755e-01
GC_10_39 ref NI_10 NS_39 0 2.1221836665261443e-01
GC_10_40 ref NI_10 NS_40 0 4.0903841119947694e-02
GC_10_41 ref NI_10 NS_41 0 1.2618388373343903e-03
GC_10_42 ref NI_10 NS_42 0 -3.2398384756089304e-05
GC_10_43 ref NI_10 NS_43 0 1.8500655395728080e-02
GC_10_44 ref NI_10 NS_44 0 3.4118925008271225e-03
GC_10_45 ref NI_10 NS_45 0 2.5860423127657767e-01
GC_10_46 ref NI_10 NS_46 0 4.5714740499020329e-02
GC_10_47 ref NI_10 NS_47 0 4.2756000047434908e-04
GC_10_48 ref NI_10 NS_48 0 5.5972968342467374e-05
GC_10_49 ref NI_10 NS_49 0 6.8872716790647451e-02
GC_10_50 ref NI_10 NS_50 0 -6.8816798773826793e-02
GC_10_51 ref NI_10 NS_51 0 7.5510701256451415e-02
GC_10_52 ref NI_10 NS_52 0 1.4852800545913619e-01
GC_10_53 ref NI_10 NS_53 0 2.1863745742513540e-03
GC_10_54 ref NI_10 NS_54 0 9.2975471271379475e-05
GC_10_55 ref NI_10 NS_55 0 1.2026723751402772e+00
GC_10_56 ref NI_10 NS_56 0 -1.2175283759129414e+00
GC_10_57 ref NI_10 NS_57 0 -2.1628016487620187e+00
GC_10_58 ref NI_10 NS_58 0 -1.0942426176060307e+00
GC_10_59 ref NI_10 NS_59 0 -2.9552100215757351e-02
GC_10_60 ref NI_10 NS_60 0 -7.9240154179770108e-04
GC_10_61 ref NI_10 NS_61 0 -5.4760447772355569e-01
GC_10_62 ref NI_10 NS_62 0 9.0264033377311137e-01
GC_10_63 ref NI_10 NS_63 0 7.1420256261080395e-01
GC_10_64 ref NI_10 NS_64 0 -3.8047348262347847e-01
GC_10_65 ref NI_10 NS_65 0 -1.3131876634010491e-03
GC_10_66 ref NI_10 NS_66 0 2.6720922002883540e-04
GC_10_67 ref NI_10 NS_67 0 -1.6637603650111712e-02
GC_10_68 ref NI_10 NS_68 0 -6.0287671887196886e-02
GC_10_69 ref NI_10 NS_69 0 1.4275878894857941e-01
GC_10_70 ref NI_10 NS_70 0 1.1641741695415998e-01
GC_10_71 ref NI_10 NS_71 0 2.5113767971893198e-03
GC_10_72 ref NI_10 NS_72 0 -1.3459452761991326e-05
GC_10_73 ref NI_10 NS_73 0 -1.1342947197467160e-01
GC_10_74 ref NI_10 NS_74 0 2.1006719262164439e-01
GC_10_75 ref NI_10 NS_75 0 4.0333483167083939e-01
GC_10_76 ref NI_10 NS_76 0 -7.1509807533874842e-02
GC_10_77 ref NI_10 NS_77 0 1.2587333301191312e-03
GC_10_78 ref NI_10 NS_78 0 -6.1120957513506889e-05
GC_10_79 ref NI_10 NS_79 0 -6.7430286590207056e-02
GC_10_80 ref NI_10 NS_80 0 3.0261707418252980e-02
GC_10_81 ref NI_10 NS_81 0 -1.1483398160110246e-01
GC_10_82 ref NI_10 NS_82 0 2.2283376326261045e-01
GC_10_83 ref NI_10 NS_83 0 4.3778625473764946e-03
GC_10_84 ref NI_10 NS_84 0 7.0300847906864188e-05
GC_10_85 ref NI_10 NS_85 0 -9.1815318425389730e-02
GC_10_86 ref NI_10 NS_86 0 6.3159717669038468e-02
GC_10_87 ref NI_10 NS_87 0 -1.4758915067439993e-01
GC_10_88 ref NI_10 NS_88 0 2.3391825866089641e-01
GC_10_89 ref NI_10 NS_89 0 5.1074696416862206e-03
GC_10_90 ref NI_10 NS_90 0 -8.5473248604935052e-07
GD_10_1 ref NI_10 NA_1 0 2.8418586545599322e-02
GD_10_2 ref NI_10 NA_2 0 -2.7331490197955475e-02
GD_10_3 ref NI_10 NA_3 0 -1.9426641591014575e-03
GD_10_4 ref NI_10 NA_4 0 -9.4542822469578340e-03
GD_10_5 ref NI_10 NA_5 0 -5.3660095696822863e-03
GD_10_6 ref NI_10 NA_6 0 -1.3233685801607937e-02
GD_10_7 ref NI_10 NA_7 0 5.6215368252913248e-03
GD_10_8 ref NI_10 NA_8 0 3.0599998725311418e-03
GD_10_9 ref NI_10 NA_9 0 -6.1559589531785556e-03
GD_10_10 ref NI_10 NA_10 0 6.0387764295997401e+00
GD_10_11 ref NI_10 NA_11 0 1.0248827768502038e-01
GD_10_12 ref NI_10 NA_12 0 9.2825966091882664e-03
GD_10_13 ref NI_10 NA_13 0 2.5787908377858288e-02
GD_10_14 ref NI_10 NA_14 0 8.8713529021827477e-03
GD_10_15 ref NI_10 NA_15 0 1.2777393683568941e-02
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -1.0761581536148643e-01
GC_11_2 ref NI_11 NS_2 0 3.3194725745720320e-02
GC_11_3 ref NI_11 NS_3 0 -1.8147681311713987e-01
GC_11_4 ref NI_11 NS_4 0 2.4479244200611702e-01
GC_11_5 ref NI_11 NS_5 0 6.1388395921931054e-03
GC_11_6 ref NI_11 NS_6 0 2.2420124716001280e-04
GC_11_7 ref NI_11 NS_7 0 -8.1050221651866698e-03
GC_11_8 ref NI_11 NS_8 0 3.3557693140379991e-01
GC_11_9 ref NI_11 NS_9 0 2.2695487308578374e-01
GC_11_10 ref NI_11 NS_10 0 -8.8838784794354857e-03
GC_11_11 ref NI_11 NS_11 0 1.1426270882693482e-03
GC_11_12 ref NI_11 NS_12 0 1.2516638467551338e-05
GC_11_13 ref NI_11 NS_13 0 8.8814443970083617e-02
GC_11_14 ref NI_11 NS_14 0 -1.5800019718703406e-01
GC_11_15 ref NI_11 NS_15 0 -9.9004423565435470e-03
GC_11_16 ref NI_11 NS_16 0 2.1338664392103301e-01
GC_11_17 ref NI_11 NS_17 0 2.7187858615332940e-03
GC_11_18 ref NI_11 NS_18 0 6.2766511087684789e-05
GC_11_19 ref NI_11 NS_19 0 1.9793576614835481e-01
GC_11_20 ref NI_11 NS_20 0 -3.6088097200322966e-01
GC_11_21 ref NI_11 NS_21 0 3.4788505413096521e-01
GC_11_22 ref NI_11 NS_22 0 8.5208988076172457e-02
GC_11_23 ref NI_11 NS_23 0 -1.1392398086228265e-03
GC_11_24 ref NI_11 NS_24 0 1.7828469423732737e-05
GC_11_25 ref NI_11 NS_25 0 -2.0414368380655076e-01
GC_11_26 ref NI_11 NS_26 0 -1.4219246348771403e-01
GC_11_27 ref NI_11 NS_27 0 6.5878840659923710e-01
GC_11_28 ref NI_11 NS_28 0 -1.2182004408440185e-01
GC_11_29 ref NI_11 NS_29 0 8.5679381581862479e-04
GC_11_30 ref NI_11 NS_30 0 -9.5383879037198983e-06
GC_11_31 ref NI_11 NS_31 0 -2.6582117013540618e-01
GC_11_32 ref NI_11 NS_32 0 8.5397442719768102e-01
GC_11_33 ref NI_11 NS_33 0 2.6984864064485320e-01
GC_11_34 ref NI_11 NS_34 0 -1.3719006916206783e-01
GC_11_35 ref NI_11 NS_35 0 7.3677529132954030e-04
GC_11_36 ref NI_11 NS_36 0 -1.1218343051462636e-04
GC_11_37 ref NI_11 NS_37 0 1.2515393537852182e-01
GC_11_38 ref NI_11 NS_38 0 -3.9650639414123551e-01
GC_11_39 ref NI_11 NS_39 0 3.3816245249562815e-01
GC_11_40 ref NI_11 NS_40 0 9.3225111042199549e-02
GC_11_41 ref NI_11 NS_41 0 7.6475029304760270e-04
GC_11_42 ref NI_11 NS_42 0 2.1187669956200833e-05
GC_11_43 ref NI_11 NS_43 0 -3.7395910269387753e-02
GC_11_44 ref NI_11 NS_44 0 5.0063434709579613e-01
GC_11_45 ref NI_11 NS_45 0 3.8904275124940446e-01
GC_11_46 ref NI_11 NS_46 0 -1.3332240383409369e-01
GC_11_47 ref NI_11 NS_47 0 -1.7302545747872785e-04
GC_11_48 ref NI_11 NS_48 0 7.1525820878858690e-07
GC_11_49 ref NI_11 NS_49 0 1.9439197291813889e-01
GC_11_50 ref NI_11 NS_50 0 -2.1228083713951601e-01
GC_11_51 ref NI_11 NS_51 0 3.0384413632334412e-01
GC_11_52 ref NI_11 NS_52 0 7.4815579826787562e-02
GC_11_53 ref NI_11 NS_53 0 -1.2468296565564276e-03
GC_11_54 ref NI_11 NS_54 0 1.3584387392193871e-05
GC_11_55 ref NI_11 NS_55 0 -5.4760447772356391e-01
GC_11_56 ref NI_11 NS_56 0 9.0264033377311492e-01
GC_11_57 ref NI_11 NS_57 0 7.1420256261080228e-01
GC_11_58 ref NI_11 NS_58 0 -3.8047348262347802e-01
GC_11_59 ref NI_11 NS_59 0 -1.3131876634010790e-03
GC_11_60 ref NI_11 NS_60 0 2.6720922002884320e-04
GC_11_61 ref NI_11 NS_61 0 1.2923757083291167e+00
GC_11_62 ref NI_11 NS_62 0 -1.5100534978637801e+00
GC_11_63 ref NI_11 NS_63 0 -2.6301282758385600e+00
GC_11_64 ref NI_11 NS_64 0 -8.1363552250758042e-01
GC_11_65 ref NI_11 NS_65 0 -2.4991311328860715e-02
GC_11_66 ref NI_11 NS_66 0 -5.7031759224419822e-04
GC_11_67 ref NI_11 NS_67 0 -4.0283338762061929e-02
GC_11_68 ref NI_11 NS_68 0 -1.9558795506779043e-02
GC_11_69 ref NI_11 NS_69 0 -4.0315780620964532e-02
GC_11_70 ref NI_11 NS_70 0 1.9912752594124747e-01
GC_11_71 ref NI_11 NS_71 0 3.5676735097760312e-03
GC_11_72 ref NI_11 NS_72 0 3.1678158784540106e-05
GC_11_73 ref NI_11 NS_73 0 1.2913079270738810e-03
GC_11_74 ref NI_11 NS_74 0 -7.6025226048032774e-02
GC_11_75 ref NI_11 NS_75 0 1.5116425865470984e-01
GC_11_76 ref NI_11 NS_76 0 1.1554808267828420e-01
GC_11_77 ref NI_11 NS_77 0 2.0227847374248882e-03
GC_11_78 ref NI_11 NS_78 0 1.5944001871325501e-05
GC_11_79 ref NI_11 NS_79 0 -9.6105133634638226e-02
GC_11_80 ref NI_11 NS_80 0 6.5184883809493555e-02
GC_11_81 ref NI_11 NS_81 0 -2.2621686469864638e-01
GC_11_82 ref NI_11 NS_82 0 2.7286561630779343e-01
GC_11_83 ref NI_11 NS_83 0 5.5856969688898818e-03
GC_11_84 ref NI_11 NS_84 0 1.9939834693359105e-05
GC_11_85 ref NI_11 NS_85 0 -1.3595708566003423e-01
GC_11_86 ref NI_11 NS_86 0 1.1668758534805025e-01
GC_11_87 ref NI_11 NS_87 0 -2.7493702756170363e-01
GC_11_88 ref NI_11 NS_88 0 2.8498167017673737e-01
GC_11_89 ref NI_11 NS_89 0 6.2710010167996892e-03
GC_11_90 ref NI_11 NS_90 0 2.2974321423906843e-05
GD_11_1 ref NI_11 NA_1 0 1.9852899866367065e-02
GD_11_2 ref NI_11 NA_2 0 -1.9755744015921804e-02
GD_11_3 ref NI_11 NA_3 0 -8.6729736336395215e-03
GD_11_4 ref NI_11 NA_4 0 -1.7955062167337676e-02
GD_11_5 ref NI_11 NA_5 0 2.1888759840425792e-02
GD_11_6 ref NI_11 NA_6 0 3.3433766281580381e-02
GD_11_7 ref NI_11 NA_7 0 -1.2306111455659838e-02
GD_11_8 ref NI_11 NA_8 0 1.3953404262442749e-02
GD_11_9 ref NI_11 NA_9 0 -1.7480885849603108e-02
GD_11_10 ref NI_11 NA_10 0 1.0248827768502118e-01
GD_11_11 ref NI_11 NA_11 0 6.0387431765976034e+00
GD_11_12 ref NI_11 NA_12 0 8.7994957010655919e-03
GD_11_13 ref NI_11 NA_13 0 7.8131837370007517e-03
GD_11_14 ref NI_11 NA_14 0 1.0671736413546400e-02
GD_11_15 ref NI_11 NA_15 0 1.5555979953217806e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -2.6630079186767341e-01
GC_12_2 ref NI_12 NS_2 0 2.1445928094826144e-01
GC_12_3 ref NI_12 NS_3 0 -3.3044180826656616e-01
GC_12_4 ref NI_12 NS_4 0 2.6213928842249290e-01
GC_12_5 ref NI_12 NS_5 0 1.1922566212528785e-02
GC_12_6 ref NI_12 NS_6 0 2.2179525456143587e-04
GC_12_7 ref NI_12 NS_7 0 1.1540871891141963e-02
GC_12_8 ref NI_12 NS_8 0 6.8622512687017134e-01
GC_12_9 ref NI_12 NS_9 0 1.4616692438438880e-01
GC_12_10 ref NI_12 NS_10 0 -4.6382374956076181e-02
GC_12_11 ref NI_12 NS_11 0 1.1805711600061486e-03
GC_12_12 ref NI_12 NS_12 0 -1.2345919484863441e-05
GC_12_13 ref NI_12 NS_13 0 2.0653576210135808e-02
GC_12_14 ref NI_12 NS_14 0 1.0516626293913471e-01
GC_12_15 ref NI_12 NS_15 0 3.9458101222955189e-01
GC_12_16 ref NI_12 NS_16 0 -3.9075999675184894e-02
GC_12_17 ref NI_12 NS_17 0 -4.8522836208121775e-04
GC_12_18 ref NI_12 NS_18 0 -4.4796244173582777e-05
GC_12_19 ref NI_12 NS_19 0 -1.3914497733263217e-02
GC_12_20 ref NI_12 NS_20 0 -1.7975806316111977e-02
GC_12_21 ref NI_12 NS_21 0 -1.0330878130815109e-01
GC_12_22 ref NI_12 NS_22 0 2.3359886326943355e-01
GC_12_23 ref NI_12 NS_23 0 3.3200642573074802e-03
GC_12_24 ref NI_12 NS_24 0 4.2465659831597510e-05
GC_12_25 ref NI_12 NS_25 0 6.7861311946239723e-03
GC_12_26 ref NI_12 NS_26 0 -7.8024132496395296e-02
GC_12_27 ref NI_12 NS_27 0 -1.2920017697528721e-02
GC_12_28 ref NI_12 NS_28 0 2.0063266769244717e-01
GC_12_29 ref NI_12 NS_29 0 2.8073154600143859e-03
GC_12_30 ref NI_12 NS_30 0 3.7135266920059653e-05
GC_12_31 ref NI_12 NS_31 0 6.5570085855503085e-02
GC_12_32 ref NI_12 NS_32 0 -7.3179878621419725e-02
GC_12_33 ref NI_12 NS_33 0 8.0447865081472669e-02
GC_12_34 ref NI_12 NS_34 0 1.4570269154832982e-01
GC_12_35 ref NI_12 NS_35 0 2.7110535582158448e-03
GC_12_36 ref NI_12 NS_36 0 6.5292669387365427e-05
GC_12_37 ref NI_12 NS_37 0 6.4833208127916986e-02
GC_12_38 ref NI_12 NS_38 0 -3.1590123607299564e-01
GC_12_39 ref NI_12 NS_39 0 4.8389874220582385e-01
GC_12_40 ref NI_12 NS_40 0 7.3720191850630654e-04
GC_12_41 ref NI_12 NS_41 0 9.1220646709101706e-04
GC_12_42 ref NI_12 NS_42 0 -3.1354872162369961e-06
GC_12_43 ref NI_12 NS_43 0 -3.3270623131684017e-02
GC_12_44 ref NI_12 NS_44 0 2.8024549697187623e-02
GC_12_45 ref NI_12 NS_45 0 -4.5843158223457196e-03
GC_12_46 ref NI_12 NS_46 0 1.7434831899859940e-01
GC_12_47 ref NI_12 NS_47 0 2.6196889371534206e-03
GC_12_48 ref NI_12 NS_48 0 3.1815493449300985e-05
GC_12_49 ref NI_12 NS_49 0 -4.1095639132261712e-02
GC_12_50 ref NI_12 NS_50 0 2.5760961672324639e-02
GC_12_51 ref NI_12 NS_51 0 -9.3178490293205449e-02
GC_12_52 ref NI_12 NS_52 0 2.1953740503700661e-01
GC_12_53 ref NI_12 NS_53 0 3.2603080827402261e-03
GC_12_54 ref NI_12 NS_54 0 4.1155578715726844e-05
GC_12_55 ref NI_12 NS_55 0 -1.6637603650129403e-02
GC_12_56 ref NI_12 NS_56 0 -6.0287671887188990e-02
GC_12_57 ref NI_12 NS_57 0 1.4275878894857524e-01
GC_12_58 ref NI_12 NS_58 0 1.1641741695416119e-01
GC_12_59 ref NI_12 NS_59 0 2.5113767971892621e-03
GC_12_60 ref NI_12 NS_60 0 -1.3459452761988672e-05
GC_12_61 ref NI_12 NS_61 0 -4.0283338762069035e-02
GC_12_62 ref NI_12 NS_62 0 -1.9558795506775757e-02
GC_12_63 ref NI_12 NS_63 0 -4.0315780620966420e-02
GC_12_64 ref NI_12 NS_64 0 1.9912752594124800e-01
GC_12_65 ref NI_12 NS_65 0 3.5676735097760238e-03
GC_12_66 ref NI_12 NS_66 0 3.1678158784535349e-05
GC_12_67 ref NI_12 NS_67 0 1.2277504331903890e+00
GC_12_68 ref NI_12 NS_68 0 -1.2511743151815569e+00
GC_12_69 ref NI_12 NS_69 0 -2.0868244620927352e+00
GC_12_70 ref NI_12 NS_70 0 -1.1363547304513086e+00
GC_12_71 ref NI_12 NS_71 0 -3.0224120289219985e-02
GC_12_72 ref NI_12 NS_72 0 -5.7203211738603372e-04
GC_12_73 ref NI_12 NS_73 0 -5.3745571728015196e-01
GC_12_74 ref NI_12 NS_74 0 8.9688703529827674e-01
GC_12_75 ref NI_12 NS_75 0 6.8755632562101876e-01
GC_12_76 ref NI_12 NS_76 0 -3.6854839162976588e-01
GC_12_77 ref NI_12 NS_77 0 -1.2795401118422223e-03
GC_12_78 ref NI_12 NS_78 0 3.0913519764406007e-04
GC_12_79 ref NI_12 NS_79 0 1.2899107395119977e-01
GC_12_80 ref NI_12 NS_80 0 -2.3864406537269062e-01
GC_12_81 ref NI_12 NS_81 0 3.3117515776597017e-01
GC_12_82 ref NI_12 NS_82 0 6.7985919634827502e-02
GC_12_83 ref NI_12 NS_83 0 -6.9800620341225420e-04
GC_12_84 ref NI_12 NS_84 0 -4.2553086188217239e-05
GC_12_85 ref NI_12 NS_85 0 4.1004173226117643e-02
GC_12_86 ref NI_12 NS_86 0 3.8435612436641077e-03
GC_12_87 ref NI_12 NS_87 0 4.5559136504716979e-01
GC_12_88 ref NI_12 NS_88 0 -4.6263485068234279e-02
GC_12_89 ref NI_12 NS_89 0 -1.0423604027554110e-03
GC_12_90 ref NI_12 NS_90 0 -7.5217888389378550e-05
GD_12_1 ref NI_12 NA_1 0 3.3253050395704642e-02
GD_12_2 ref NI_12 NA_2 0 -2.6330427883549355e-02
GD_12_3 ref NI_12 NA_3 0 1.4078778464126393e-03
GD_12_4 ref NI_12 NA_4 0 5.9638608450540047e-04
GD_12_5 ref NI_12 NA_5 0 2.0310766291602199e-04
GD_12_6 ref NI_12 NA_6 0 -5.0992054923496314e-03
GD_12_7 ref NI_12 NA_7 0 -7.7073742670747620e-03
GD_12_8 ref NI_12 NA_8 0 3.3774671219089676e-03
GD_12_9 ref NI_12 NA_9 0 2.8802152236326321e-03
GD_12_10 ref NI_12 NA_10 0 9.2825966091908130e-03
GD_12_11 ref NI_12 NA_11 0 8.7994957010667646e-03
GD_12_12 ref NI_12 NA_12 0 6.0352925887564721e+00
GD_12_13 ref NI_12 NA_13 0 1.0527225243807917e-01
GD_12_14 ref NI_12 NA_14 0 -5.8802789555809400e-03
GD_12_15 ref NI_12 NA_15 0 8.2017027543586588e-03
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -2.3136037423211478e-01
GC_13_2 ref NI_13 NS_2 0 1.6403105979157243e-01
GC_13_3 ref NI_13 NS_3 0 -3.0282039945696954e-01
GC_13_4 ref NI_13 NS_4 0 2.6328658902892721e-01
GC_13_5 ref NI_13 NS_5 0 1.0741074374666464e-02
GC_13_6 ref NI_13 NS_6 0 2.2173437617408764e-04
GC_13_7 ref NI_13 NS_7 0 -3.7150460451362867e-02
GC_13_8 ref NI_13 NS_8 0 5.4594155967986213e-01
GC_13_9 ref NI_13 NS_9 0 1.7544485026107856e-01
GC_13_10 ref NI_13 NS_10 0 -3.1473848873043657e-02
GC_13_11 ref NI_13 NS_11 0 1.5243602321498686e-03
GC_13_12 ref NI_13 NS_12 0 2.3914621000734195e-05
GC_13_13 ref NI_13 NS_13 0 8.4444930385568009e-02
GC_13_14 ref NI_13 NS_14 0 -4.2663865559049585e-01
GC_13_15 ref NI_13 NS_15 0 4.5553299263151775e-01
GC_13_16 ref NI_13 NS_16 0 3.8553295380537429e-02
GC_13_17 ref NI_13 NS_17 0 1.0832863694020733e-03
GC_13_18 ref NI_13 NS_18 0 1.2271080643121080e-06
GC_13_19 ref NI_13 NS_19 0 2.6546583111220969e-02
GC_13_20 ref NI_13 NS_20 0 -1.0881415361462535e-01
GC_13_21 ref NI_13 NS_21 0 -1.5709296096362582e-02
GC_13_22 ref NI_13 NS_22 0 2.1144601744592853e-01
GC_13_23 ref NI_13 NS_23 0 2.3331679690658247e-03
GC_13_24 ref NI_13 NS_24 0 3.1410517259483482e-05
GC_13_25 ref NI_13 NS_25 0 1.4670701583476662e-02
GC_13_26 ref NI_13 NS_26 0 -1.7828482985543612e-01
GC_13_27 ref NI_13 NS_27 0 1.2629763919436404e-01
GC_13_28 ref NI_13 NS_28 0 1.5294485963521121e-01
GC_13_29 ref NI_13 NS_29 0 2.0669071155091684e-03
GC_13_30 ref NI_13 NS_30 0 3.4710443622939359e-05
GC_13_31 ref NI_13 NS_31 0 7.4058152673058106e-04
GC_13_32 ref NI_13 NS_32 0 -1.7215189267109940e-01
GC_13_33 ref NI_13 NS_33 0 2.8330340201701121e-01
GC_13_34 ref NI_13 NS_34 0 6.8471645029443126e-02
GC_13_35 ref NI_13 NS_35 0 2.2703093309139203e-03
GC_13_36 ref NI_13 NS_36 0 1.0992822388232494e-05
GC_13_37 ref NI_13 NS_37 0 -4.2875135874667153e-01
GC_13_38 ref NI_13 NS_38 0 1.1091163677578455e+00
GC_13_39 ref NI_13 NS_39 0 1.8825485625133986e-01
GC_13_40 ref NI_13 NS_40 0 -1.5518013246942780e-01
GC_13_41 ref NI_13 NS_41 0 2.0530833026454697e-03
GC_13_42 ref NI_13 NS_42 0 -9.1319753398598659e-05
GC_13_43 ref NI_13 NS_43 0 3.5260249933509409e-02
GC_13_44 ref NI_13 NS_44 0 3.1156376785230856e-02
GC_13_45 ref NI_13 NS_45 0 6.4040015788563082e-02
GC_13_46 ref NI_13 NS_46 0 1.3732204929103842e-01
GC_13_47 ref NI_13 NS_47 0 1.6640282931718940e-03
GC_13_48 ref NI_13 NS_48 0 4.1359738239834696e-05
GC_13_49 ref NI_13 NS_49 0 2.3362025827713906e-02
GC_13_50 ref NI_13 NS_50 0 -2.9521503546448315e-02
GC_13_51 ref NI_13 NS_51 0 -3.3394345503416537e-02
GC_13_52 ref NI_13 NS_52 0 2.0325423654963395e-01
GC_13_53 ref NI_13 NS_53 0 2.1887051621101369e-03
GC_13_54 ref NI_13 NS_54 0 2.7512881738619632e-05
GC_13_55 ref NI_13 NS_55 0 -1.1342947197466273e-01
GC_13_56 ref NI_13 NS_56 0 2.1006719262164025e-01
GC_13_57 ref NI_13 NS_57 0 4.0333483167084150e-01
GC_13_58 ref NI_13 NS_58 0 -7.1509807533875522e-02
GC_13_59 ref NI_13 NS_59 0 1.2587333301191728e-03
GC_13_60 ref NI_13 NS_60 0 -6.1120957513515265e-05
GC_13_61 ref NI_13 NS_61 0 1.2913079270604087e-03
GC_13_62 ref NI_13 NS_62 0 -7.6025226048026862e-02
GC_13_63 ref NI_13 NS_63 0 1.5116425865470667e-01
GC_13_64 ref NI_13 NS_64 0 1.1554808267828511e-01
GC_13_65 ref NI_13 NS_65 0 2.0227847374248422e-03
GC_13_66 ref NI_13 NS_66 0 1.5944001871324796e-05
GC_13_67 ref NI_13 NS_67 0 -5.3745571728012664e-01
GC_13_68 ref NI_13 NS_68 0 8.9688703529826586e-01
GC_13_69 ref NI_13 NS_69 0 6.8755632562102409e-01
GC_13_70 ref NI_13 NS_70 0 -3.6854839162976766e-01
GC_13_71 ref NI_13 NS_71 0 -1.2795401118421543e-03
GC_13_72 ref NI_13 NS_72 0 3.0913519764405974e-04
GC_13_73 ref NI_13 NS_73 0 1.5232380913967642e+00
GC_13_74 ref NI_13 NS_74 0 -1.7961714624841121e+00
GC_13_75 ref NI_13 NS_75 0 -2.3069844950410570e+00
GC_13_76 ref NI_13 NS_76 0 -9.0020969829245112e-01
GC_13_77 ref NI_13 NS_77 0 -3.0635304121534694e-02
GC_13_78 ref NI_13 NS_78 0 -5.4645926503645893e-04
GC_13_79 ref NI_13 NS_79 0 7.0213351018175704e-02
GC_13_80 ref NI_13 NS_80 0 -1.3741216772662804e-01
GC_13_81 ref NI_13 NS_81 0 6.5087430246908523e-02
GC_13_82 ref NI_13 NS_82 0 1.7499867829743204e-01
GC_13_83 ref NI_13 NS_83 0 1.7421868227204872e-03
GC_13_84 ref NI_13 NS_84 0 5.6020747427538671e-06
GC_13_85 ref NI_13 NS_85 0 4.1683136884771411e-02
GC_13_86 ref NI_13 NS_86 0 -9.7547529008289738e-02
GC_13_87 ref NI_13 NS_87 0 9.6370975101456868e-02
GC_13_88 ref NI_13 NS_88 0 1.4901520501963963e-01
GC_13_89 ref NI_13 NS_89 0 1.9356837823587382e-03
GC_13_90 ref NI_13 NS_90 0 -6.2841255115704314e-06
GD_13_1 ref NI_13 NA_1 0 3.0449620543572645e-02
GD_13_2 ref NI_13 NA_2 0 -1.7941836240240417e-02
GD_13_3 ref NI_13 NA_3 0 -7.6983523845164147e-03
GD_13_4 ref NI_13 NA_4 0 -2.4344517932131174e-03
GD_13_5 ref NI_13 NA_5 0 5.6023465175549470e-05
GD_13_6 ref NI_13 NA_6 0 2.2585996328196630e-03
GD_13_7 ref NI_13 NA_7 0 5.6565506889570474e-02
GD_13_8 ref NI_13 NA_8 0 -9.9282382368920440e-04
GD_13_9 ref NI_13 NA_9 0 -2.0447322357125338e-03
GD_13_10 ref NI_13 NA_10 0 2.5787908377856886e-02
GD_13_11 ref NI_13 NA_11 0 7.8131837370027119e-03
GD_13_12 ref NI_13 NA_12 0 1.0527225243807542e-01
GD_13_13 ref NI_13 NA_13 0 5.9924687372762113e+00
GD_13_14 ref NI_13 NA_14 0 -2.1712275797125505e-03
GD_13_15 ref NI_13 NA_15 0 3.7104770674029099e-03
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 -2.8981917102680682e-01
GC_14_2 ref NI_14 NS_2 0 2.3475540595994093e-01
GC_14_3 ref NI_14 NS_3 0 -3.6377033616113147e-01
GC_14_4 ref NI_14 NS_4 0 2.7110386130334485e-01
GC_14_5 ref NI_14 NS_5 0 1.3193996793747899e-02
GC_14_6 ref NI_14 NS_6 0 2.1377171299780413e-04
GC_14_7 ref NI_14 NS_7 0 2.8538877472030582e-02
GC_14_8 ref NI_14 NS_8 0 6.7715443226913163e-01
GC_14_9 ref NI_14 NS_9 0 1.6048101698991743e-01
GC_14_10 ref NI_14 NS_10 0 -5.0160573144773020e-02
GC_14_11 ref NI_14 NS_11 0 1.0981987233878554e-03
GC_14_12 ref NI_14 NS_12 0 -2.3901063299633988e-05
GC_14_13 ref NI_14 NS_13 0 -3.4371441512165601e-01
GC_14_14 ref NI_14 NS_14 0 6.1306980202073580e-01
GC_14_15 ref NI_14 NS_15 0 9.2292915846197787e-01
GC_14_16 ref NI_14 NS_16 0 -4.2393637897404229e-01
GC_14_17 ref NI_14 NS_17 0 -1.8087252687354742e-03
GC_14_18 ref NI_14 NS_18 0 1.0120640737135847e-05
GC_14_19 ref NI_14 NS_19 0 -5.2724999574302336e-02
GC_14_20 ref NI_14 NS_20 0 2.4421707297831090e-02
GC_14_21 ref NI_14 NS_21 0 -1.8774173452005907e-01
GC_14_22 ref NI_14 NS_22 0 2.6715017988947104e-01
GC_14_23 ref NI_14 NS_23 0 4.4277308780159832e-03
GC_14_24 ref NI_14 NS_24 0 1.6612024078587488e-05
GC_14_25 ref NI_14 NS_25 0 -1.8123887753595802e-02
GC_14_26 ref NI_14 NS_26 0 -3.5560262580512397e-02
GC_14_27 ref NI_14 NS_27 0 -1.1263869049164037e-01
GC_14_28 ref NI_14 NS_28 0 2.4192153300959335e-01
GC_14_29 ref NI_14 NS_29 0 3.6675573399123514e-03
GC_14_30 ref NI_14 NS_30 0 2.6640195213427592e-05
GC_14_31 ref NI_14 NS_31 0 4.5169620033732531e-02
GC_14_32 ref NI_14 NS_32 0 -1.0675464113492525e-01
GC_14_33 ref NI_14 NS_33 0 6.1010694505432006e-02
GC_14_34 ref NI_14 NS_34 0 1.6490281276521571e-01
GC_14_35 ref NI_14 NS_35 0 2.8146720705261828e-03
GC_14_36 ref NI_14 NS_36 0 5.5477450925673236e-05
GC_14_37 ref NI_14 NS_37 0 6.1569310234525901e-02
GC_14_38 ref NI_14 NS_38 0 -2.0421671255523388e-01
GC_14_39 ref NI_14 NS_39 0 4.3803292434540769e-01
GC_14_40 ref NI_14 NS_40 0 -5.8136753516483154e-03
GC_14_41 ref NI_14 NS_41 0 7.7897258215690846e-04
GC_14_42 ref NI_14 NS_42 0 5.4163147204842116e-05
GC_14_43 ref NI_14 NS_43 0 -4.7877030210955518e-02
GC_14_44 ref NI_14 NS_44 0 2.7718151169579278e-02
GC_14_45 ref NI_14 NS_45 0 -1.1419689942870954e-01
GC_14_46 ref NI_14 NS_46 0 2.3085401183239149e-01
GC_14_47 ref NI_14 NS_47 0 3.5785994586687319e-03
GC_14_48 ref NI_14 NS_48 0 9.5519633410725832e-06
GC_14_49 ref NI_14 NS_49 0 -7.1997691892203369e-02
GC_14_50 ref NI_14 NS_50 0 5.2268771047784969e-02
GC_14_51 ref NI_14 NS_51 0 -1.8307225235846761e-01
GC_14_52 ref NI_14 NS_52 0 2.5972282699391891e-01
GC_14_53 ref NI_14 NS_53 0 4.3381498529865307e-03
GC_14_54 ref NI_14 NS_54 0 1.3316517162071823e-05
GC_14_55 ref NI_14 NS_55 0 -6.7430286590188376e-02
GC_14_56 ref NI_14 NS_56 0 3.0261707418245250e-02
GC_14_57 ref NI_14 NS_57 0 -1.1483398160109848e-01
GC_14_58 ref NI_14 NS_58 0 2.2283376326260931e-01
GC_14_59 ref NI_14 NS_59 0 4.3778625473765397e-03
GC_14_60 ref NI_14 NS_60 0 7.0300847906864893e-05
GC_14_61 ref NI_14 NS_61 0 -9.6105133634682399e-02
GC_14_62 ref NI_14 NS_62 0 6.5184883809512428e-02
GC_14_63 ref NI_14 NS_63 0 -2.2621686469865632e-01
GC_14_64 ref NI_14 NS_64 0 2.7286561630779654e-01
GC_14_65 ref NI_14 NS_65 0 5.5856969688897230e-03
GC_14_66 ref NI_14 NS_66 0 1.9939834693377164e-05
GC_14_67 ref NI_14 NS_67 0 1.2899107395119619e-01
GC_14_68 ref NI_14 NS_68 0 -2.3864406537268898e-01
GC_14_69 ref NI_14 NS_69 0 3.3117515776596934e-01
GC_14_70 ref NI_14 NS_70 0 6.7985919634827766e-02
GC_14_71 ref NI_14 NS_71 0 -6.9800620341226830e-04
GC_14_72 ref NI_14 NS_72 0 -4.2553086188217191e-05
GC_14_73 ref NI_14 NS_73 0 7.0213351018167378e-02
GC_14_74 ref NI_14 NS_74 0 -1.3741216772662412e-01
GC_14_75 ref NI_14 NS_75 0 6.5087430246906455e-02
GC_14_76 ref NI_14 NS_76 0 1.7499867829743262e-01
GC_14_77 ref NI_14 NS_77 0 1.7421868227204622e-03
GC_14_78 ref NI_14 NS_78 0 5.6020747427563879e-06
GC_14_79 ref NI_14 NS_79 0 1.5170324329039730e+00
GC_14_80 ref NI_14 NS_80 0 -1.6188844664788988e+00
GC_14_81 ref NI_14 NS_81 0 -2.0170503794606276e+00
GC_14_82 ref NI_14 NS_82 0 -1.0838419476443162e+00
GC_14_83 ref NI_14 NS_83 0 -3.2473395484562163e-02
GC_14_84 ref NI_14 NS_84 0 -6.9086420549467099e-04
GC_14_85 ref NI_14 NS_85 0 -2.9330237519724994e-01
GC_14_86 ref NI_14 NS_86 0 5.3421098041208925e-01
GC_14_87 ref NI_14 NS_87 0 1.3860832583103651e+00
GC_14_88 ref NI_14 NS_88 0 -6.2528534802349867e-01
GC_14_89 ref NI_14 NS_89 0 -9.5844145169968961e-03
GC_14_90 ref NI_14 NS_90 0 2.7913555977019912e-04
GD_14_1 ref NI_14 NA_1 0 3.4628072556283730e-02
GD_14_2 ref NI_14 NA_2 0 -3.2273633968247360e-02
GD_14_3 ref NI_14 NA_3 0 4.6223706625725593e-02
GD_14_4 ref NI_14 NA_4 0 3.5085994598520668e-03
GD_14_5 ref NI_14 NA_5 0 1.5322527904756415e-03
GD_14_6 ref NI_14 NA_6 0 -3.9357337833752859e-03
GD_14_7 ref NI_14 NA_7 0 -1.5106827211058516e-03
GD_14_8 ref NI_14 NA_8 0 2.5639283050635491e-03
GD_14_9 ref NI_14 NA_9 0 4.5878331131091405e-03
GD_14_10 ref NI_14 NA_10 0 8.8713529021801213e-03
GD_14_11 ref NI_14 NA_11 0 1.0671736413552959e-02
GD_14_12 ref NI_14 NA_12 0 -5.8802789555803241e-03
GD_14_13 ref NI_14 NA_13 0 -2.1712275797113587e-03
GD_14_14 ref NI_14 NA_14 0 6.0266015017602266e+00
GD_14_15 ref NI_14 NA_15 0 7.8061508529303061e-02
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -3.1919259634735120e-01
GC_15_2 ref NI_15 NS_2 0 2.6403977357452457e-01
GC_15_3 ref NI_15 NS_3 0 -4.0328225438680010e-01
GC_15_4 ref NI_15 NS_4 0 2.8030919187247150e-01
GC_15_5 ref NI_15 NS_5 0 1.4556930012423511e-02
GC_15_6 ref NI_15 NS_6 0 2.1341709137335832e-04
GC_15_7 ref NI_15 NS_7 0 -3.1451040061698902e-03
GC_15_8 ref NI_15 NS_8 0 3.5145909389381308e-01
GC_15_9 ref NI_15 NS_9 0 2.4847572957444389e-01
GC_15_10 ref NI_15 NS_10 0 -2.7320838193255866e-02
GC_15_11 ref NI_15 NS_11 0 1.5274914744614742e-03
GC_15_12 ref NI_15 NS_12 0 3.1948346289589736e-05
GC_15_13 ref NI_15 NS_13 0 -4.0523175680964590e-01
GC_15_14 ref NI_15 NS_14 0 8.8269096332289942e-01
GC_15_15 ref NI_15 NS_15 0 7.7527687797717626e-01
GC_15_16 ref NI_15 NS_16 0 -4.0475976864099217e-01
GC_15_17 ref NI_15 NS_17 0 -1.3572810778231944e-03
GC_15_18 ref NI_15 NS_18 0 -6.5084111776694199e-05
GC_15_19 ref NI_15 NS_19 0 -9.4877423570890004e-02
GC_15_20 ref NI_15 NS_20 0 6.5305996218661982e-02
GC_15_21 ref NI_15 NS_21 0 -2.5989076021811447e-01
GC_15_22 ref NI_15 NS_22 0 2.9300572358519839e-01
GC_15_23 ref NI_15 NS_23 0 5.4066780504002073e-03
GC_15_24 ref NI_15 NS_24 0 2.0914656320971414e-05
GC_15_25 ref NI_15 NS_25 0 -5.5867121831035281e-02
GC_15_26 ref NI_15 NS_26 0 -2.2341992057919582e-03
GC_15_27 ref NI_15 NS_27 0 -1.8214198294245204e-01
GC_15_28 ref NI_15 NS_28 0 2.6857516901722073e-01
GC_15_29 ref NI_15 NS_29 0 4.5256810426185122e-03
GC_15_30 ref NI_15 NS_30 0 3.0271329542421406e-05
GC_15_31 ref NI_15 NS_31 0 3.9652487600986740e-02
GC_15_32 ref NI_15 NS_32 0 -1.2283916374314904e-01
GC_15_33 ref NI_15 NS_33 0 -1.3755907180355753e-03
GC_15_34 ref NI_15 NS_34 0 1.9972101556700256e-01
GC_15_35 ref NI_15 NS_35 0 3.4572527272259393e-03
GC_15_36 ref NI_15 NS_36 0 4.2442789048773732e-05
GC_15_37 ref NI_15 NS_37 0 7.7736461648430871e-02
GC_15_38 ref NI_15 NS_38 0 -3.3753779005468343e-01
GC_15_39 ref NI_15 NS_39 0 4.2669656784023152e-01
GC_15_40 ref NI_15 NS_40 0 2.9662813423348360e-02
GC_15_41 ref NI_15 NS_41 0 1.2107162690109324e-03
GC_15_42 ref NI_15 NS_42 0 3.4475647825857721e-05
GC_15_43 ref NI_15 NS_43 0 -7.0963754516948890e-02
GC_15_44 ref NI_15 NS_44 0 7.4649201863384876e-02
GC_15_45 ref NI_15 NS_45 0 -1.8627001825989098e-01
GC_15_46 ref NI_15 NS_46 0 2.5523480640746360e-01
GC_15_47 ref NI_15 NS_47 0 4.2571951487711214e-03
GC_15_48 ref NI_15 NS_48 0 2.0068479142650748e-05
GC_15_49 ref NI_15 NS_49 0 -1.0444224983643707e-01
GC_15_50 ref NI_15 NS_50 0 9.6705592529216178e-02
GC_15_51 ref NI_15 NS_51 0 -2.5629730917969429e-01
GC_15_52 ref NI_15 NS_52 0 2.8511530511679145e-01
GC_15_53 ref NI_15 NS_53 0 5.2515064922514336e-03
GC_15_54 ref NI_15 NS_54 0 1.6640283108877338e-05
GC_15_55 ref NI_15 NS_55 0 -9.1815318425395698e-02
GC_15_56 ref NI_15 NS_56 0 6.3159717669041535e-02
GC_15_57 ref NI_15 NS_57 0 -1.4758915067440165e-01
GC_15_58 ref NI_15 NS_58 0 2.3391825866089691e-01
GC_15_59 ref NI_15 NS_59 0 5.1074696416862006e-03
GC_15_60 ref NI_15 NS_60 0 -8.5473248604720964e-07
GC_15_61 ref NI_15 NS_61 0 -1.3595708566006179e-01
GC_15_62 ref NI_15 NS_62 0 1.1668758534806176e-01
GC_15_63 ref NI_15 NS_63 0 -2.7493702756171001e-01
GC_15_64 ref NI_15 NS_64 0 2.8498167017673920e-01
GC_15_65 ref NI_15 NS_65 0 6.2710010167996372e-03
GC_15_66 ref NI_15 NS_66 0 2.2974321423894161e-05
GC_15_67 ref NI_15 NS_67 0 4.1004173226111176e-02
GC_15_68 ref NI_15 NS_68 0 3.8435612436669370e-03
GC_15_69 ref NI_15 NS_69 0 4.5559136504716802e-01
GC_15_70 ref NI_15 NS_70 0 -4.6263485068233780e-02
GC_15_71 ref NI_15 NS_71 0 -1.0423604027554208e-03
GC_15_72 ref NI_15 NS_72 0 -7.5217888389383347e-05
GC_15_73 ref NI_15 NS_73 0 4.1683136884767796e-02
GC_15_74 ref NI_15 NS_74 0 -9.7547529008288739e-02
GC_15_75 ref NI_15 NS_75 0 9.6370975101456424e-02
GC_15_76 ref NI_15 NS_76 0 1.4901520501963980e-01
GC_15_77 ref NI_15 NS_77 0 1.9356837823587382e-03
GC_15_78 ref NI_15 NS_78 0 -6.2841255115763327e-06
GC_15_79 ref NI_15 NS_79 0 -2.9330237519723401e-01
GC_15_80 ref NI_15 NS_80 0 5.3421098041208293e-01
GC_15_81 ref NI_15 NS_81 0 1.3860832583103682e+00
GC_15_82 ref NI_15 NS_82 0 -6.2528534802349955e-01
GC_15_83 ref NI_15 NS_83 0 -9.5844145169968458e-03
GC_15_84 ref NI_15 NS_84 0 2.7913555977019072e-04
GC_15_85 ref NI_15 NS_85 0 1.7506012975962935e+00
GC_15_86 ref NI_15 NS_86 0 -1.9421427349748788e+00
GC_15_87 ref NI_15 NS_87 0 -1.6484058698169592e+00
GC_15_88 ref NI_15 NS_88 0 -1.1847684517431656e+00
GC_15_89 ref NI_15 NS_89 0 -4.0639183662411975e-02
GC_15_90 ref NI_15 NS_90 0 -5.4522634592991091e-04
GD_15_1 ref NI_15 NA_1 0 3.7646898533982058e-02
GD_15_2 ref NI_15 NA_2 0 -1.9136658706435234e-02
GD_15_3 ref NI_15 NA_3 0 6.4462565923684878e-02
GD_15_4 ref NI_15 NA_4 0 8.7812591843265449e-03
GD_15_5 ref NI_15 NA_5 0 6.1551014558968208e-03
GD_15_6 ref NI_15 NA_6 0 -1.9352643691730662e-03
GD_15_7 ref NI_15 NA_7 0 -1.7700368393979125e-03
GD_15_8 ref NI_15 NA_8 0 6.5100815301813034e-03
GD_15_9 ref NI_15 NA_9 0 9.2482779080271891e-03
GD_15_10 ref NI_15 NA_10 0 1.2777393683569961e-02
GD_15_11 ref NI_15 NA_11 0 1.5555979953221954e-02
GD_15_12 ref NI_15 NA_12 0 8.2017027543596598e-03
GD_15_13 ref NI_15 NA_13 0 3.7104770674033405e-03
GD_15_14 ref NI_15 NA_14 0 7.8061508529301202e-02
GD_15_15 ref NI_15 NA_15 0 5.9846365169266669e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 1.1955091810266268e-01
GS_1_1 0 NS_1 NA_1 0 2.5028494115551925e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 4.0675278134726406e-01
GS_2_1 0 NS_2 NA_1 0 2.5028494115551925e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 9.2700715669969747e-01
GS_3_1 0 NS_3 NA_1 0 2.5028494115551925e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 1.7246232574671516e+00
GS_4_1 0 NS_4 NA_1 0 2.5028494115551925e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 7.9138482483183976e+00
GS_5_1 0 NS_5 NA_1 0 2.5028494115551925e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 9.5125210955522533e+01
GS_6_1 0 NS_6 NA_1 0 2.5028494115551925e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 1.1955091810266268e-01
GS_7_2 0 NS_7 NA_2 0 2.5028494115551925e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 4.0675278134726406e-01
GS_8_2 0 NS_8 NA_2 0 2.5028494115551925e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 9.2700715669969747e-01
GS_9_2 0 NS_9 NA_2 0 2.5028494115551925e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 1.7246232574671516e+00
GS_10_2 0 NS_10 NA_2 0 2.5028494115551925e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 7.9138482483183976e+00
GS_11_2 0 NS_11 NA_2 0 2.5028494115551925e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 9.5125210955522533e+01
GS_12_2 0 NS_12 NA_2 0 2.5028494115551925e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 1.1955091810266268e-01
GS_13_3 0 NS_13 NA_3 0 2.5028494115551925e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 4.0675278134726406e-01
GS_14_3 0 NS_14 NA_3 0 2.5028494115551925e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 9.2700715669969747e-01
GS_15_3 0 NS_15 NA_3 0 2.5028494115551925e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 1.7246232574671516e+00
GS_16_3 0 NS_16 NA_3 0 2.5028494115551925e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 7.9138482483183976e+00
GS_17_3 0 NS_17 NA_3 0 2.5028494115551925e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 9.5125210955522533e+01
GS_18_3 0 NS_18 NA_3 0 2.5028494115551925e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 1.1955091810266268e-01
GS_19_4 0 NS_19 NA_4 0 2.5028494115551925e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 4.0675278134726406e-01
GS_20_4 0 NS_20 NA_4 0 2.5028494115551925e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 9.2700715669969747e-01
GS_21_4 0 NS_21 NA_4 0 2.5028494115551925e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 1.7246232574671516e+00
GS_22_4 0 NS_22 NA_4 0 2.5028494115551925e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 7.9138482483183976e+00
GS_23_4 0 NS_23 NA_4 0 2.5028494115551925e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 9.5125210955522533e+01
GS_24_4 0 NS_24 NA_4 0 2.5028494115551925e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 1.1955091810266268e-01
GS_25_5 0 NS_25 NA_5 0 2.5028494115551925e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 4.0675278134726406e-01
GS_26_5 0 NS_26 NA_5 0 2.5028494115551925e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 9.2700715669969747e-01
GS_27_5 0 NS_27 NA_5 0 2.5028494115551925e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 1.7246232574671516e+00
GS_28_5 0 NS_28 NA_5 0 2.5028494115551925e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 7.9138482483183976e+00
GS_29_5 0 NS_29 NA_5 0 2.5028494115551925e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 9.5125210955522533e+01
GS_30_5 0 NS_30 NA_5 0 2.5028494115551925e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 1.1955091810266268e-01
GS_31_6 0 NS_31 NA_6 0 2.5028494115551925e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 4.0675278134726406e-01
GS_32_6 0 NS_32 NA_6 0 2.5028494115551925e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 9.2700715669969747e-01
GS_33_6 0 NS_33 NA_6 0 2.5028494115551925e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 1.7246232574671516e+00
GS_34_6 0 NS_34 NA_6 0 2.5028494115551925e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 7.9138482483183976e+00
GS_35_6 0 NS_35 NA_6 0 2.5028494115551925e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 9.5125210955522533e+01
GS_36_6 0 NS_36 NA_6 0 2.5028494115551925e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 1.1955091810266268e-01
GS_37_7 0 NS_37 NA_7 0 2.5028494115551925e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 4.0675278134726406e-01
GS_38_7 0 NS_38 NA_7 0 2.5028494115551925e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 9.2700715669969747e-01
GS_39_7 0 NS_39 NA_7 0 2.5028494115551925e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 1.7246232574671516e+00
GS_40_7 0 NS_40 NA_7 0 2.5028494115551925e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 7.9138482483183976e+00
GS_41_7 0 NS_41 NA_7 0 2.5028494115551925e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 9.5125210955522533e+01
GS_42_7 0 NS_42 NA_7 0 2.5028494115551925e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 1.1955091810266268e-01
GS_43_8 0 NS_43 NA_8 0 2.5028494115551925e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 4.0675278134726406e-01
GS_44_8 0 NS_44 NA_8 0 2.5028494115551925e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 9.2700715669969747e-01
GS_45_8 0 NS_45 NA_8 0 2.5028494115551925e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 1.7246232574671516e+00
GS_46_8 0 NS_46 NA_8 0 2.5028494115551925e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 7.9138482483183976e+00
GS_47_8 0 NS_47 NA_8 0 2.5028494115551925e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 9.5125210955522533e+01
GS_48_8 0 NS_48 NA_8 0 2.5028494115551925e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 1.1955091810266268e-01
GS_49_9 0 NS_49 NA_9 0 2.5028494115551925e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 4.0675278134726406e-01
GS_50_9 0 NS_50 NA_9 0 2.5028494115551925e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 9.2700715669969747e-01
GS_51_9 0 NS_51 NA_9 0 2.5028494115551925e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 1.7246232574671516e+00
GS_52_9 0 NS_52 NA_9 0 2.5028494115551925e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 7.9138482483183976e+00
GS_53_9 0 NS_53 NA_9 0 2.5028494115551925e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 9.5125210955522533e+01
GS_54_9 0 NS_54 NA_9 0 2.5028494115551925e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 1.1955091810266268e-01
GS_55_10 0 NS_55 NA_10 0 2.5028494115551925e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 4.0675278134726406e-01
GS_56_10 0 NS_56 NA_10 0 2.5028494115551925e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 9.2700715669969747e-01
GS_57_10 0 NS_57 NA_10 0 2.5028494115551925e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 1.7246232574671516e+00
GS_58_10 0 NS_58 NA_10 0 2.5028494115551925e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 7.9138482483183976e+00
GS_59_10 0 NS_59 NA_10 0 2.5028494115551925e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 9.5125210955522533e+01
GS_60_10 0 NS_60 NA_10 0 2.5028494115551925e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 1.1955091810266268e-01
GS_61_11 0 NS_61 NA_11 0 2.5028494115551925e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 4.0675278134726406e-01
GS_62_11 0 NS_62 NA_11 0 2.5028494115551925e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 9.2700715669969747e-01
GS_63_11 0 NS_63 NA_11 0 2.5028494115551925e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 1.7246232574671516e+00
GS_64_11 0 NS_64 NA_11 0 2.5028494115551925e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 7.9138482483183976e+00
GS_65_11 0 NS_65 NA_11 0 2.5028494115551925e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 9.5125210955522533e+01
GS_66_11 0 NS_66 NA_11 0 2.5028494115551925e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 1.1955091810266268e-01
GS_67_12 0 NS_67 NA_12 0 2.5028494115551925e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 4.0675278134726406e-01
GS_68_12 0 NS_68 NA_12 0 2.5028494115551925e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 9.2700715669969747e-01
GS_69_12 0 NS_69 NA_12 0 2.5028494115551925e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 1.7246232574671516e+00
GS_70_12 0 NS_70 NA_12 0 2.5028494115551925e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 7.9138482483183976e+00
GS_71_12 0 NS_71 NA_12 0 2.5028494115551925e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 9.5125210955522533e+01
GS_72_12 0 NS_72 NA_12 0 2.5028494115551925e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 1.1955091810266268e-01
GS_73_13 0 NS_73 NA_13 0 2.5028494115551925e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 4.0675278134726406e-01
GS_74_13 0 NS_74 NA_13 0 2.5028494115551925e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 9.2700715669969747e-01
GS_75_13 0 NS_75 NA_13 0 2.5028494115551925e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 1.7246232574671516e+00
GS_76_13 0 NS_76 NA_13 0 2.5028494115551925e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 7.9138482483183976e+00
GS_77_13 0 NS_77 NA_13 0 2.5028494115551925e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 9.5125210955522533e+01
GS_78_13 0 NS_78 NA_13 0 2.5028494115551925e+00
*
* Real pole n. 79
CS_79 NS_79 0 1.0000000000000001e-09
RS_79 NS_79 0 1.1955091810266268e-01
GS_79_14 0 NS_79 NA_14 0 2.5028494115551925e+00
*
* Real pole n. 80
CS_80 NS_80 0 1.0000000000000001e-09
RS_80 NS_80 0 4.0675278134726406e-01
GS_80_14 0 NS_80 NA_14 0 2.5028494115551925e+00
*
* Real pole n. 81
CS_81 NS_81 0 1.0000000000000001e-09
RS_81 NS_81 0 9.2700715669969747e-01
GS_81_14 0 NS_81 NA_14 0 2.5028494115551925e+00
*
* Real pole n. 82
CS_82 NS_82 0 1.0000000000000001e-09
RS_82 NS_82 0 1.7246232574671516e+00
GS_82_14 0 NS_82 NA_14 0 2.5028494115551925e+00
*
* Real pole n. 83
CS_83 NS_83 0 1.0000000000000001e-09
RS_83 NS_83 0 7.9138482483183976e+00
GS_83_14 0 NS_83 NA_14 0 2.5028494115551925e+00
*
* Real pole n. 84
CS_84 NS_84 0 1.0000000000000001e-09
RS_84 NS_84 0 9.5125210955522533e+01
GS_84_14 0 NS_84 NA_14 0 2.5028494115551925e+00
*
* Real pole n. 85
CS_85 NS_85 0 1.0000000000000001e-09
RS_85 NS_85 0 1.1955091810266268e-01
GS_85_15 0 NS_85 NA_15 0 2.5028494115551925e+00
*
* Real pole n. 86
CS_86 NS_86 0 1.0000000000000001e-09
RS_86 NS_86 0 4.0675278134726406e-01
GS_86_15 0 NS_86 NA_15 0 2.5028494115551925e+00
*
* Real pole n. 87
CS_87 NS_87 0 1.0000000000000001e-09
RS_87 NS_87 0 9.2700715669969747e-01
GS_87_15 0 NS_87 NA_15 0 2.5028494115551925e+00
*
* Real pole n. 88
CS_88 NS_88 0 1.0000000000000001e-09
RS_88 NS_88 0 1.7246232574671516e+00
GS_88_15 0 NS_88 NA_15 0 2.5028494115551925e+00
*
* Real pole n. 89
CS_89 NS_89 0 1.0000000000000001e-09
RS_89 NS_89 0 7.9138482483183976e+00
GS_89_15 0 NS_89 NA_15 0 2.5028494115551925e+00
*
* Real pole n. 90
CS_90 NS_90 0 1.0000000000000001e-09
RS_90 NS_90 0 9.5125210955522533e+01
GS_90_15 0 NS_90 NA_15 0 2.5028494115551925e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
