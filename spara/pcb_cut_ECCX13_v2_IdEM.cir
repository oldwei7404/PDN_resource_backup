**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 30-May-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Fri May 30 19:16:52 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Fri May 30 19:16:52 2025
**
**  Modal data exported
**  Port[1] = PORT_1_L38_PWR_VECMX1_Group_U51_GND_Group
**  Port[2] = PORT_2_U1_PWR_VECMX1_Group_U1_GRP_0_1_GND
**  Port[3] = PWR_VECMX1_C513_1
**  Port[4] = PWR_VECMX1_C514_1
**  Port[5] = PWR_VECMX1_C515_1
**  Port[6] = PWR_VECMX1_C516_1
**  Port[7] = PWR_VECMX1_C517_1
**  Port[8] = PWR_VECMX1_C518_1
**  Port[9] = PWR_VECMX1_C519_1
**  Port[10] = PWR_VECMX1_C643_1
**  Port[11] = PWR_VECMX1_C659_1
**  Port[12] = PWR_VECMX1_C659_3
**  Port[13] = PWR_VECMX1_C661_1
**  Port[14] = PWR_VECMX1_C661_3
**  Port[15] = PWR_VECMX1_C663_1
**  Port[16] = PWR_VECMX1_C663_3
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 8]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_ECCX13_v2_IdEM
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 a_16 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 1.8273431358765595e+01
GC_1_2 ref NI_1 NS_2 0 -5.1154704008752705e-01
GC_1_3 ref NI_1 NS_3 0 -1.0375320110200917e-01
GC_1_4 ref NI_1 NS_4 0 -2.6922836393964250e-01
GC_1_5 ref NI_1 NS_5 0 -1.7383089794063478e-01
GC_1_6 ref NI_1 NS_6 0 -2.7786499043392015e-02
GC_1_7 ref NI_1 NS_7 0 -5.2398373957076761e-06
GC_1_8 ref NI_1 NS_8 0 -1.0077656516636621e-03
GC_1_9 ref NI_1 NS_9 0 -4.2250961653080388e-01
GC_1_10 ref NI_1 NS_10 0 2.3856962136658003e-02
GC_1_11 ref NI_1 NS_11 0 -1.6367306454605823e-02
GC_1_12 ref NI_1 NS_12 0 1.3154808300010055e-02
GC_1_13 ref NI_1 NS_13 0 2.2321948392954157e-02
GC_1_14 ref NI_1 NS_14 0 1.8967841050438014e-03
GC_1_15 ref NI_1 NS_15 0 1.1685558071646495e-06
GC_1_16 ref NI_1 NS_16 0 6.2839919688728601e-05
GC_1_17 ref NI_1 NS_17 0 -4.3574363285838669e-01
GC_1_18 ref NI_1 NS_18 0 -1.2985186860629681e-04
GC_1_19 ref NI_1 NS_19 0 1.0290337661522547e-02
GC_1_20 ref NI_1 NS_20 0 -3.2805729740340003e-02
GC_1_21 ref NI_1 NS_21 0 3.7061754932091705e-02
GC_1_22 ref NI_1 NS_22 0 2.9665577325844257e-03
GC_1_23 ref NI_1 NS_23 0 9.4407005280011303e-07
GC_1_24 ref NI_1 NS_24 0 6.1705438536320558e-05
GC_1_25 ref NI_1 NS_25 0 -1.2665979893150709e+00
GC_1_26 ref NI_1 NS_26 0 6.7400924223441919e-02
GC_1_27 ref NI_1 NS_27 0 -7.6685176313064901e-02
GC_1_28 ref NI_1 NS_28 0 1.2388302668452708e-01
GC_1_29 ref NI_1 NS_29 0 -1.4264067166508633e-02
GC_1_30 ref NI_1 NS_30 0 -1.0685646899751055e-04
GC_1_31 ref NI_1 NS_31 0 2.3729332805302801e-08
GC_1_32 ref NI_1 NS_32 0 6.6708783399729296e-05
GC_1_33 ref NI_1 NS_33 0 -9.4729531293282732e-01
GC_1_34 ref NI_1 NS_34 0 4.7502764887270184e-02
GC_1_35 ref NI_1 NS_35 0 -8.2375248496974807e-02
GC_1_36 ref NI_1 NS_36 0 7.8967022823377614e-02
GC_1_37 ref NI_1 NS_37 0 1.0043601948603596e-02
GC_1_38 ref NI_1 NS_38 0 5.5075609551383242e-04
GC_1_39 ref NI_1 NS_39 0 2.7152532236656639e-07
GC_1_40 ref NI_1 NS_40 0 6.7335070329660219e-05
GC_1_41 ref NI_1 NS_41 0 -8.2277731561994460e-01
GC_1_42 ref NI_1 NS_42 0 3.1074745834920363e-02
GC_1_43 ref NI_1 NS_43 0 -4.5894254413968279e-02
GC_1_44 ref NI_1 NS_44 0 4.9087532107276732e-02
GC_1_45 ref NI_1 NS_45 0 1.4856887557815755e-02
GC_1_46 ref NI_1 NS_46 0 1.0546528875275919e-03
GC_1_47 ref NI_1 NS_47 0 2.1010185973617910e-07
GC_1_48 ref NI_1 NS_48 0 6.7539476557989392e-05
GC_1_49 ref NI_1 NS_49 0 -6.2423469091496409e-01
GC_1_50 ref NI_1 NS_50 0 1.4969175114962856e-02
GC_1_51 ref NI_1 NS_51 0 -1.8737504685438999e-02
GC_1_52 ref NI_1 NS_52 0 7.3012534990685865e-03
GC_1_53 ref NI_1 NS_53 0 2.6498453291696811e-02
GC_1_54 ref NI_1 NS_54 0 2.0652279128023365e-03
GC_1_55 ref NI_1 NS_55 0 6.5306889967316110e-07
GC_1_56 ref NI_1 NS_56 0 6.4916122368831119e-05
GC_1_57 ref NI_1 NS_57 0 -8.8057298588311372e-01
GC_1_58 ref NI_1 NS_58 0 3.3531646345538985e-02
GC_1_59 ref NI_1 NS_59 0 -7.9746125138093926e-02
GC_1_60 ref NI_1 NS_60 0 6.8124537022233658e-02
GC_1_61 ref NI_1 NS_61 0 1.5990753629480707e-02
GC_1_62 ref NI_1 NS_62 0 8.0158570266319949e-04
GC_1_63 ref NI_1 NS_63 0 2.2196995912615635e-07
GC_1_64 ref NI_1 NS_64 0 6.6551317743390525e-05
GC_1_65 ref NI_1 NS_65 0 -1.2274061800917182e+00
GC_1_66 ref NI_1 NS_66 0 4.7600976130966276e-02
GC_1_67 ref NI_1 NS_67 0 -8.0643027738061202e-02
GC_1_68 ref NI_1 NS_68 0 1.2011261215371520e-01
GC_1_69 ref NI_1 NS_69 0 -8.7631195642192405e-03
GC_1_70 ref NI_1 NS_70 0 1.1029054645496379e-04
GC_1_71 ref NI_1 NS_71 0 1.3691739054815980e-07
GC_1_72 ref NI_1 NS_72 0 6.7801293545112476e-05
GC_1_73 ref NI_1 NS_73 0 -5.5968645383647324e+00
GC_1_74 ref NI_1 NS_74 0 2.3656727813100667e-01
GC_1_75 ref NI_1 NS_75 0 3.9501392096453625e-01
GC_1_76 ref NI_1 NS_76 0 1.4031907914106603e-01
GC_1_77 ref NI_1 NS_77 0 -1.7324580798994096e-01
GC_1_78 ref NI_1 NS_78 0 -4.1520609019441183e-03
GC_1_79 ref NI_1 NS_79 0 -1.3102598743377926e-06
GC_1_80 ref NI_1 NS_80 0 6.4971248018572922e-05
GC_1_81 ref NI_1 NS_81 0 -5.9932060333405790e-01
GC_1_82 ref NI_1 NS_82 0 1.0980594472522682e-02
GC_1_83 ref NI_1 NS_83 0 -1.0303838024446818e-03
GC_1_84 ref NI_1 NS_84 0 -3.5851820621961530e-02
GC_1_85 ref NI_1 NS_85 0 3.9606461485374216e-02
GC_1_86 ref NI_1 NS_86 0 2.9752988294388222e-03
GC_1_87 ref NI_1 NS_87 0 8.0926830255819273e-07
GC_1_88 ref NI_1 NS_88 0 6.9360650706319231e-05
GC_1_89 ref NI_1 NS_89 0 -7.7838928244931838e-01
GC_1_90 ref NI_1 NS_90 0 2.7124814248607448e-02
GC_1_91 ref NI_1 NS_91 0 -4.0988948848440045e-02
GC_1_92 ref NI_1 NS_92 0 -5.2470987666336380e-03
GC_1_93 ref NI_1 NS_93 0 3.6117304113640301e-02
GC_1_94 ref NI_1 NS_94 0 2.2846589684400479e-03
GC_1_95 ref NI_1 NS_95 0 -2.8748412882142859e-08
GC_1_96 ref NI_1 NS_96 0 7.5485168698225040e-05
GC_1_97 ref NI_1 NS_97 0 -4.2738442331280851e-01
GC_1_98 ref NI_1 NS_98 0 -5.0547603798987316e-03
GC_1_99 ref NI_1 NS_99 0 2.8901713829545261e-02
GC_1_100 ref NI_1 NS_100 0 -5.7468660695483398e-02
GC_1_101 ref NI_1 NS_101 0 4.1109842958261235e-02
GC_1_102 ref NI_1 NS_102 0 3.9373267065332829e-03
GC_1_103 ref NI_1 NS_103 0 6.2740991190325928e-07
GC_1_104 ref NI_1 NS_104 0 6.8616334111439397e-05
GC_1_105 ref NI_1 NS_105 0 -5.4002022967733487e-01
GC_1_106 ref NI_1 NS_106 0 1.7981858914725552e-03
GC_1_107 ref NI_1 NS_107 0 1.3708167528862163e-02
GC_1_108 ref NI_1 NS_108 0 -4.8071044673837257e-02
GC_1_109 ref NI_1 NS_109 0 4.0756079089861924e-02
GC_1_110 ref NI_1 NS_110 0 3.6802920749209609e-03
GC_1_111 ref NI_1 NS_111 0 4.1964790944885167e-07
GC_1_112 ref NI_1 NS_112 0 6.9925013883146306e-05
GC_1_113 ref NI_1 NS_113 0 -3.2958197528892025e-01
GC_1_114 ref NI_1 NS_114 0 -1.5204812506243741e-02
GC_1_115 ref NI_1 NS_115 0 4.8362460078548733e-02
GC_1_116 ref NI_1 NS_116 0 -7.3061822605321139e-02
GC_1_117 ref NI_1 NS_117 0 4.2786607528564849e-02
GC_1_118 ref NI_1 NS_118 0 4.6169129275336488e-03
GC_1_119 ref NI_1 NS_119 0 5.7364357790002142e-07
GC_1_120 ref NI_1 NS_120 0 6.4458570733001832e-05
GC_1_121 ref NI_1 NS_121 0 -3.0466470402090479e-01
GC_1_122 ref NI_1 NS_122 0 -1.8691887489031757e-02
GC_1_123 ref NI_1 NS_123 0 5.7468193944308417e-02
GC_1_124 ref NI_1 NS_124 0 -8.2090529207360804e-02
GC_1_125 ref NI_1 NS_125 0 4.3557931351147890e-02
GC_1_126 ref NI_1 NS_126 0 5.0781894470924155e-03
GC_1_127 ref NI_1 NS_127 0 6.4292370009400437e-07
GC_1_128 ref NI_1 NS_128 0 6.8134851406888359e-05
GD_1_1 ref NI_1 NA_1 0 3.2172519854173025e+00
GD_1_2 ref NI_1 NA_2 0 6.6789449435360526e-02
GD_1_3 ref NI_1 NA_3 0 7.4449968067869229e-02
GD_1_4 ref NI_1 NA_4 0 2.1090212097596558e-01
GD_1_5 ref NI_1 NA_5 0 1.5567357981140384e-01
GD_1_6 ref NI_1 NA_6 0 1.3618926717589769e-01
GD_1_7 ref NI_1 NA_7 0 1.0431434150870431e-01
GD_1_8 ref NI_1 NA_8 0 1.4378328762743953e-01
GD_1_9 ref NI_1 NA_9 0 2.0300181342889292e-01
GD_1_10 ref NI_1 NA_10 0 9.6948779715625300e-01
GD_1_11 ref NI_1 NA_11 0 1.0002578764709137e-01
GD_1_12 ref NI_1 NA_12 0 1.2761622441726989e-01
GD_1_13 ref NI_1 NA_13 0 7.3702991652065800e-02
GD_1_14 ref NI_1 NA_14 0 9.1671173427164368e-02
GD_1_15 ref NI_1 NA_15 0 5.9046785344118051e-02
GD_1_16 ref NI_1 NA_16 0 5.5501379891744904e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -4.2250961653080388e-01
GC_2_2 ref NI_2 NS_2 0 2.3856962136657993e-02
GC_2_3 ref NI_2 NS_3 0 -1.6367306454605809e-02
GC_2_4 ref NI_2 NS_4 0 1.3154808300010038e-02
GC_2_5 ref NI_2 NS_5 0 2.2321948392954167e-02
GC_2_6 ref NI_2 NS_6 0 1.8967841050437993e-03
GC_2_7 ref NI_2 NS_7 0 1.1685558071640942e-06
GC_2_8 ref NI_2 NS_8 0 6.2839919688729347e-05
GC_2_9 ref NI_2 NS_9 0 4.9160013089879016e+01
GC_2_10 ref NI_2 NS_10 0 -8.8650357589173123e-01
GC_2_11 ref NI_2 NS_11 0 -1.4438885809776711e+00
GC_2_12 ref NI_2 NS_12 0 8.4434699030565205e-02
GC_2_13 ref NI_2 NS_13 0 -1.7131077180008326e-02
GC_2_14 ref NI_2 NS_14 0 -2.1516945706526714e-03
GC_2_15 ref NI_2 NS_15 0 4.1798836255023386e-08
GC_2_16 ref NI_2 NS_16 0 -9.1056610452012240e-05
GC_2_17 ref NI_2 NS_17 0 1.2464760921976434e+00
GC_2_18 ref NI_2 NS_18 0 4.1205538254518836e-02
GC_2_19 ref NI_2 NS_19 0 1.3331082388836304e-01
GC_2_20 ref NI_2 NS_20 0 -9.5621874088822438e-03
GC_2_21 ref NI_2 NS_21 0 -4.0907223078278550e-03
GC_2_22 ref NI_2 NS_22 0 -2.5129154352323391e-04
GC_2_23 ref NI_2 NS_23 0 -1.9341543253372018e-08
GC_2_24 ref NI_2 NS_24 0 -2.6457149105708244e-06
GC_2_25 ref NI_2 NS_25 0 1.1246626453602089e+00
GC_2_26 ref NI_2 NS_26 0 -2.4729093056069917e-02
GC_2_27 ref NI_2 NS_27 0 1.6759694027942904e-01
GC_2_28 ref NI_2 NS_28 0 -2.4443545079758440e-02
GC_2_29 ref NI_2 NS_29 0 3.0972385122903742e-03
GC_2_30 ref NI_2 NS_30 0 -4.2439739155195402e-05
GC_2_31 ref NI_2 NS_31 0 7.0602320012711829e-08
GC_2_32 ref NI_2 NS_32 0 -4.3329415642386029e-07
GC_2_33 ref NI_2 NS_33 0 8.2663596049463295e-01
GC_2_34 ref NI_2 NS_34 0 -5.9631816866104699e-02
GC_2_35 ref NI_2 NS_35 0 2.2360092105749921e-01
GC_2_36 ref NI_2 NS_36 0 -4.3309899301866787e-02
GC_2_37 ref NI_2 NS_37 0 2.4825017432796499e-03
GC_2_38 ref NI_2 NS_38 0 -2.2824423429331457e-04
GC_2_39 ref NI_2 NS_39 0 1.4731670119383389e-09
GC_2_40 ref NI_2 NS_40 0 1.4423998625985265e-06
GC_2_41 ref NI_2 NS_41 0 1.5272354698667385e+00
GC_2_42 ref NI_2 NS_42 0 4.9219372641461888e-02
GC_2_43 ref NI_2 NS_43 0 1.0566849914585082e-01
GC_2_44 ref NI_2 NS_44 0 -2.9146340908179505e-03
GC_2_45 ref NI_2 NS_45 0 -1.6273076467576966e-03
GC_2_46 ref NI_2 NS_46 0 -6.2046706795533120e-05
GC_2_47 ref NI_2 NS_47 0 5.1197154614260976e-08
GC_2_48 ref NI_2 NS_48 0 -3.1149774932785801e-06
GC_2_49 ref NI_2 NS_49 0 1.3224472720712122e+00
GC_2_50 ref NI_2 NS_50 0 3.2402311835452162e-02
GC_2_51 ref NI_2 NS_51 0 1.2521508287969019e-01
GC_2_52 ref NI_2 NS_52 0 -5.1223000798798907e-03
GC_2_53 ref NI_2 NS_53 0 -3.0689559736968202e-03
GC_2_54 ref NI_2 NS_54 0 -1.3992664294412073e-04
GC_2_55 ref NI_2 NS_55 0 -6.4846706174533346e-09
GC_2_56 ref NI_2 NS_56 0 -6.6496645433206514e-07
GC_2_57 ref NI_2 NS_57 0 1.4391717610247776e+00
GC_2_58 ref NI_2 NS_58 0 1.9978332818913663e-01
GC_2_59 ref NI_2 NS_59 0 4.9398549599492560e-02
GC_2_60 ref NI_2 NS_60 0 -2.1412421648951217e-02
GC_2_61 ref NI_2 NS_61 0 -1.0123109402674719e-03
GC_2_62 ref NI_2 NS_62 0 -9.7992184510272911e-05
GC_2_63 ref NI_2 NS_63 0 -9.4688777786512331e-08
GC_2_64 ref NI_2 NS_64 0 -1.4048695187533890e-07
GC_2_65 ref NI_2 NS_65 0 1.2752218877400114e+00
GC_2_66 ref NI_2 NS_66 0 1.0955456558364991e-01
GC_2_67 ref NI_2 NS_67 0 8.7827831219271152e-02
GC_2_68 ref NI_2 NS_68 0 -1.9572135308477814e-02
GC_2_69 ref NI_2 NS_69 0 1.7348853231962788e-03
GC_2_70 ref NI_2 NS_70 0 -2.8645453585635473e-05
GC_2_71 ref NI_2 NS_71 0 -2.0136594906581289e-08
GC_2_72 ref NI_2 NS_72 0 3.6320946995324680e-08
GC_2_73 ref NI_2 NS_73 0 8.8526633380495567e-01
GC_2_74 ref NI_2 NS_74 0 1.3474140043657582e-02
GC_2_75 ref NI_2 NS_75 0 1.9125279422863815e-02
GC_2_76 ref NI_2 NS_76 0 9.2062541743264618e-03
GC_2_77 ref NI_2 NS_77 0 2.2001459329248175e-02
GC_2_78 ref NI_2 NS_78 0 3.5201124276559062e-04
GC_2_79 ref NI_2 NS_79 0 3.4307516586394858e-07
GC_2_80 ref NI_2 NS_80 0 -1.6107315473657192e-07
GC_2_81 ref NI_2 NS_81 0 6.7709106732389279e-01
GC_2_82 ref NI_2 NS_82 0 6.7421498231590063e-02
GC_2_83 ref NI_2 NS_83 0 9.3479500985539754e-02
GC_2_84 ref NI_2 NS_84 0 -2.0924040032965882e-03
GC_2_85 ref NI_2 NS_85 0 -1.8130898296946200e-03
GC_2_86 ref NI_2 NS_86 0 3.9778902482799000e-05
GC_2_87 ref NI_2 NS_87 0 -3.2630052194767776e-07
GC_2_88 ref NI_2 NS_88 0 5.5885432172528558e-06
GC_2_89 ref NI_2 NS_89 0 3.7980255456175260e-01
GC_2_90 ref NI_2 NS_90 0 3.2787245158799695e-02
GC_2_91 ref NI_2 NS_91 0 7.9655044789074453e-02
GC_2_92 ref NI_2 NS_92 0 1.7752630975539384e-02
GC_2_93 ref NI_2 NS_93 0 -2.1265723283854735e-03
GC_2_94 ref NI_2 NS_94 0 1.7496571148651328e-04
GC_2_95 ref NI_2 NS_95 0 -2.4149232483661029e-08
GC_2_96 ref NI_2 NS_96 0 2.6288372596665225e-06
GC_2_97 ref NI_2 NS_97 0 7.0234491506117147e-01
GC_2_98 ref NI_2 NS_98 0 9.3838955929799781e-02
GC_2_99 ref NI_2 NS_99 0 1.3093904298029790e-01
GC_2_100 ref NI_2 NS_100 0 -2.8265423116799516e-02
GC_2_101 ref NI_2 NS_101 0 -4.4046659125179704e-03
GC_2_102 ref NI_2 NS_102 0 6.3170138818196636e-05
GC_2_103 ref NI_2 NS_103 0 -5.0264225944458403e-07
GC_2_104 ref NI_2 NS_104 0 1.1051401840432648e-05
GC_2_105 ref NI_2 NS_105 0 2.9757807544770620e-01
GC_2_106 ref NI_2 NS_106 0 7.3801296677346667e-02
GC_2_107 ref NI_2 NS_107 0 9.3376225707967317e-02
GC_2_108 ref NI_2 NS_108 0 -1.1642901075079024e-03
GC_2_109 ref NI_2 NS_109 0 -3.4451713528198050e-03
GC_2_110 ref NI_2 NS_110 0 6.2410589013565549e-05
GC_2_111 ref NI_2 NS_111 0 -1.7971467602323087e-08
GC_2_112 ref NI_2 NS_112 0 5.9607901627410389e-06
GC_2_113 ref NI_2 NS_113 0 6.9360036491765176e-01
GC_2_114 ref NI_2 NS_114 0 9.7617345589559396e-02
GC_2_115 ref NI_2 NS_115 0 1.0878873862124040e-01
GC_2_116 ref NI_2 NS_116 0 -1.6215142905300010e-02
GC_2_117 ref NI_2 NS_117 0 -3.2807481686263967e-03
GC_2_118 ref NI_2 NS_118 0 -1.4529164168757518e-04
GC_2_119 ref NI_2 NS_119 0 -5.8099954221265001e-07
GC_2_120 ref NI_2 NS_120 0 -3.1742486269751535e-06
GC_2_121 ref NI_2 NS_121 0 3.0317581864650056e-01
GC_2_122 ref NI_2 NS_122 0 4.4914113065591579e-02
GC_2_123 ref NI_2 NS_123 0 6.5688122783947048e-02
GC_2_124 ref NI_2 NS_124 0 2.9571706518738364e-02
GC_2_125 ref NI_2 NS_125 0 -6.4823526755213795e-03
GC_2_126 ref NI_2 NS_126 0 3.5561835244142639e-04
GC_2_127 ref NI_2 NS_127 0 -5.0089143629281815e-10
GC_2_128 ref NI_2 NS_128 0 1.3824664639345010e-05
GD_2_1 ref NI_2 NA_1 0 6.6789449435360526e-02
GD_2_2 ref NI_2 NA_2 0 -1.7661889119752661e+00
GD_2_3 ref NI_2 NA_3 0 -2.2939126378589644e-01
GD_2_4 ref NI_2 NA_4 0 -2.0401891756154464e-01
GD_2_5 ref NI_2 NA_5 0 -1.5901521966794072e-01
GD_2_6 ref NI_2 NA_6 0 -2.7136831789994548e-01
GD_2_7 ref NI_2 NA_7 0 -2.3907162725515485e-01
GD_2_8 ref NI_2 NA_8 0 -2.6290006585644737e-01
GD_2_9 ref NI_2 NA_9 0 -2.3299565534028921e-01
GD_2_10 ref NI_2 NA_10 0 -1.5856707774783496e-01
GD_2_11 ref NI_2 NA_11 0 -1.3044973544527758e-01
GD_2_12 ref NI_2 NA_12 0 -7.5854476387458153e-02
GD_2_13 ref NI_2 NA_13 0 -1.3790266419073263e-01
GD_2_14 ref NI_2 NA_14 0 -6.3815160766587151e-02
GD_2_15 ref NI_2 NA_15 0 -1.3523149465809742e-01
GD_2_16 ref NI_2 NA_16 0 -6.4108673680550496e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 -4.3574363285838669e-01
GC_3_2 ref NI_3 NS_2 0 -1.2985186860630068e-04
GC_3_3 ref NI_3 NS_3 0 1.0290337661522557e-02
GC_3_4 ref NI_3 NS_4 0 -3.2805729740340017e-02
GC_3_5 ref NI_3 NS_5 0 3.7061754932091712e-02
GC_3_6 ref NI_3 NS_6 0 2.9665577325844244e-03
GC_3_7 ref NI_3 NS_7 0 9.4407005279983647e-07
GC_3_8 ref NI_3 NS_8 0 6.1705438536320924e-05
GC_3_9 ref NI_3 NS_9 0 1.2464760921976434e+00
GC_3_10 ref NI_3 NS_10 0 4.1205538254518843e-02
GC_3_11 ref NI_3 NS_11 0 1.3331082388836302e-01
GC_3_12 ref NI_3 NS_12 0 -9.5621874088822265e-03
GC_3_13 ref NI_3 NS_13 0 -4.0907223078278637e-03
GC_3_14 ref NI_3 NS_14 0 -2.5129154352323163e-04
GC_3_15 ref NI_3 NS_15 0 -1.9341543252844085e-08
GC_3_16 ref NI_3 NS_16 0 -2.6457149105715283e-06
GC_3_17 ref NI_3 NS_17 0 5.0851871204210211e+00
GC_3_18 ref NI_3 NS_18 0 -2.5669381147309717e-01
GC_3_19 ref NI_3 NS_19 0 -1.0180652676660387e+00
GC_3_20 ref NI_3 NS_20 0 -3.0854998534073563e-01
GC_3_21 ref NI_3 NS_21 0 -2.8447070369227268e-02
GC_3_22 ref NI_3 NS_22 0 -3.8843150189702175e-03
GC_3_23 ref NI_3 NS_23 0 8.3244345604898990e-07
GC_3_24 ref NI_3 NS_24 0 -6.4860460784313997e-05
GC_3_25 ref NI_3 NS_25 0 1.1748509718051312e-01
GC_3_26 ref NI_3 NS_26 0 1.0704844038199315e-02
GC_3_27 ref NI_3 NS_27 0 -4.3771610519517494e-02
GC_3_28 ref NI_3 NS_28 0 5.8311894325161991e-02
GC_3_29 ref NI_3 NS_29 0 1.7378241072262983e-02
GC_3_30 ref NI_3 NS_30 0 1.1829396300104703e-04
GC_3_31 ref NI_3 NS_31 0 1.5857249940981652e-07
GC_3_32 ref NI_3 NS_32 0 5.3662990412864761e-07
GC_3_33 ref NI_3 NS_33 0 1.7355441445846606e-01
GC_3_34 ref NI_3 NS_34 0 -5.5101270857634112e-03
GC_3_35 ref NI_3 NS_35 0 -1.8909239496880455e-02
GC_3_36 ref NI_3 NS_36 0 6.5074065224206099e-02
GC_3_37 ref NI_3 NS_37 0 9.6186238600156054e-03
GC_3_38 ref NI_3 NS_38 0 9.1524718398889896e-05
GC_3_39 ref NI_3 NS_39 0 1.4213343341126655e-07
GC_3_40 ref NI_3 NS_40 0 5.0661830565069512e-07
GC_3_41 ref NI_3 NS_41 0 3.0445014832252715e-01
GC_3_42 ref NI_3 NS_42 0 -4.7565553576476190e-02
GC_3_43 ref NI_3 NS_43 0 1.8140542499105483e-01
GC_3_44 ref NI_3 NS_44 0 -2.8846365914499475e-02
GC_3_45 ref NI_3 NS_45 0 4.6600899446703533e-03
GC_3_46 ref NI_3 NS_46 0 -1.5390292499680800e-04
GC_3_47 ref NI_3 NS_47 0 2.0828427050760084e-07
GC_3_48 ref NI_3 NS_48 0 -5.2305380531857298e-06
GC_3_49 ref NI_3 NS_49 0 -2.2092234997230370e-01
GC_3_50 ref NI_3 NS_50 0 2.0964443978192973e-01
GC_3_51 ref NI_3 NS_51 0 4.0535543817844000e-01
GC_3_52 ref NI_3 NS_52 0 -2.3717603498999001e-01
GC_3_53 ref NI_3 NS_53 0 2.5479120828821359e-03
GC_3_54 ref NI_3 NS_54 0 -1.4764724608442338e-03
GC_3_55 ref NI_3 NS_55 0 -4.4514479963670338e-08
GC_3_56 ref NI_3 NS_56 0 -1.0079318632784504e-05
GC_3_57 ref NI_3 NS_57 0 1.3155088019810754e-01
GC_3_58 ref NI_3 NS_58 0 -1.3259583794184456e-02
GC_3_59 ref NI_3 NS_59 0 -4.1555104035488385e-02
GC_3_60 ref NI_3 NS_60 0 8.3129250178778175e-02
GC_3_61 ref NI_3 NS_61 0 8.8157014172977315e-03
GC_3_62 ref NI_3 NS_62 0 8.7817367845244027e-05
GC_3_63 ref NI_3 NS_63 0 9.1946396450595378e-08
GC_3_64 ref NI_3 NS_64 0 1.5977464755759639e-08
GC_3_65 ref NI_3 NS_65 0 7.4649630397658762e-02
GC_3_66 ref NI_3 NS_66 0 1.1292168702560260e-03
GC_3_67 ref NI_3 NS_67 0 -5.2282051612226238e-02
GC_3_68 ref NI_3 NS_68 0 6.8710764795656853e-02
GC_3_69 ref NI_3 NS_69 0 1.6432265748472952e-02
GC_3_70 ref NI_3 NS_70 0 1.1944634482183502e-04
GC_3_71 ref NI_3 NS_71 0 1.4156301722551587e-07
GC_3_72 ref NI_3 NS_72 0 9.7379585989903422e-07
GC_3_73 ref NI_3 NS_73 0 3.1013764500296603e-01
GC_3_74 ref NI_3 NS_74 0 -1.4993433647969153e-02
GC_3_75 ref NI_3 NS_75 0 2.3307958384056023e-02
GC_3_76 ref NI_3 NS_76 0 -2.5727613483203928e-02
GC_3_77 ref NI_3 NS_77 0 3.9170764858555668e-02
GC_3_78 ref NI_3 NS_78 0 1.2059525481777757e-03
GC_3_79 ref NI_3 NS_79 0 4.9202249306337508e-07
GC_3_80 ref NI_3 NS_80 0 -1.8814249149793025e-06
GC_3_81 ref NI_3 NS_81 0 -1.6172371804222135e-01
GC_3_82 ref NI_3 NS_82 0 1.3882237397429331e-02
GC_3_83 ref NI_3 NS_83 0 -6.0281191690551565e-02
GC_3_84 ref NI_3 NS_84 0 8.3405883989121021e-02
GC_3_85 ref NI_3 NS_85 0 9.8390509952248888e-03
GC_3_86 ref NI_3 NS_86 0 -6.3901039676081448e-07
GC_3_87 ref NI_3 NS_87 0 -1.0702011256268557e-06
GC_3_88 ref NI_3 NS_88 0 1.5741951311420149e-05
GC_3_89 ref NI_3 NS_89 0 -2.7909361113455639e-01
GC_3_90 ref NI_3 NS_90 0 2.6230631607895169e-02
GC_3_91 ref NI_3 NS_91 0 -1.1228692591197069e-01
GC_3_92 ref NI_3 NS_92 0 9.6718856590231606e-02
GC_3_93 ref NI_3 NS_93 0 1.5775517829208750e-02
GC_3_94 ref NI_3 NS_94 0 1.1010740275089429e-04
GC_3_95 ref NI_3 NS_95 0 1.0179029976533772e-07
GC_3_96 ref NI_3 NS_96 0 1.3157578379935557e-05
GC_3_97 ref NI_3 NS_97 0 -1.3098527176304943e-02
GC_3_98 ref NI_3 NS_98 0 1.9135451748830037e-02
GC_3_99 ref NI_3 NS_99 0 4.0061379344482402e-02
GC_3_100 ref NI_3 NS_100 0 7.8869086621142809e-02
GC_3_101 ref NI_3 NS_101 0 -1.6558363183867778e-02
GC_3_102 ref NI_3 NS_102 0 -1.1464170191657268e-04
GC_3_103 ref NI_3 NS_103 0 -1.5339750977191003e-06
GC_3_104 ref NI_3 NS_104 0 7.1880293815103130e-06
GC_3_105 ref NI_3 NS_105 0 -6.1865891039159140e-02
GC_3_106 ref NI_3 NS_106 0 -7.2505409620118894e-02
GC_3_107 ref NI_3 NS_107 0 -1.8380264887583649e-02
GC_3_108 ref NI_3 NS_108 0 1.2471767384538997e-01
GC_3_109 ref NI_3 NS_109 0 -8.8542153668686140e-03
GC_3_110 ref NI_3 NS_110 0 3.9540250970423736e-04
GC_3_111 ref NI_3 NS_111 0 -1.1061560359619655e-06
GC_3_112 ref NI_3 NS_112 0 9.9879125712943860e-06
GC_3_113 ref NI_3 NS_113 0 -5.4946208741815794e-01
GC_3_114 ref NI_3 NS_114 0 6.1472281989414070e-03
GC_3_115 ref NI_3 NS_115 0 3.0411892625253351e-01
GC_3_116 ref NI_3 NS_116 0 -4.2695351387909645e-03
GC_3_117 ref NI_3 NS_117 0 -5.2336158914660445e-02
GC_3_118 ref NI_3 NS_118 0 4.0808574343941472e-04
GC_3_119 ref NI_3 NS_119 0 8.8910034496591812e-07
GC_3_120 ref NI_3 NS_120 0 -1.6547009996403864e-05
GC_3_121 ref NI_3 NS_121 0 -1.1074932310817220e+00
GC_3_122 ref NI_3 NS_122 0 7.9497309672401442e-02
GC_3_123 ref NI_3 NS_123 0 2.7344518312414640e-01
GC_3_124 ref NI_3 NS_124 0 -1.3413221839757154e-02
GC_3_125 ref NI_3 NS_125 0 -5.0843376289518537e-02
GC_3_126 ref NI_3 NS_126 0 3.7229598021403128e-04
GC_3_127 ref NI_3 NS_127 0 -9.8165727799442318e-08
GC_3_128 ref NI_3 NS_128 0 -9.7262012664687856e-06
GD_3_1 ref NI_3 NA_1 0 7.4449968067869229e-02
GD_3_2 ref NI_3 NA_2 0 -2.2939126378589644e-01
GD_3_3 ref NI_3 NA_3 0 5.4504730873252516e+00
GD_3_4 ref NI_3 NA_4 0 -2.2859023430895135e-02
GD_3_5 ref NI_3 NA_5 0 -2.9857994586663775e-02
GD_3_6 ref NI_3 NA_6 0 -5.0741423212216530e-02
GD_3_7 ref NI_3 NA_7 0 2.1677553302512313e-02
GD_3_8 ref NI_3 NA_8 0 -2.4430496279180095e-02
GD_3_9 ref NI_3 NA_9 0 -1.6215758774349390e-02
GD_3_10 ref NI_3 NA_10 0 -5.1893094414425391e-02
GD_3_11 ref NI_3 NA_11 0 2.3154747685995122e-02
GD_3_12 ref NI_3 NA_12 0 4.2012012905218075e-02
GD_3_13 ref NI_3 NA_13 0 1.6579777670613267e-03
GD_3_14 ref NI_3 NA_14 0 1.2131062892830075e-02
GD_3_15 ref NI_3 NA_15 0 1.0273571913500749e-01
GD_3_16 ref NI_3 NA_16 0 2.0178297254970573e-01
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -1.2665979893150709e+00
GC_4_2 ref NI_4 NS_2 0 6.7400924223441919e-02
GC_4_3 ref NI_4 NS_3 0 -7.6685176313064901e-02
GC_4_4 ref NI_4 NS_4 0 1.2388302668452708e-01
GC_4_5 ref NI_4 NS_5 0 -1.4264067166508637e-02
GC_4_6 ref NI_4 NS_6 0 -1.0685646899751000e-04
GC_4_7 ref NI_4 NS_7 0 2.3729332805441294e-08
GC_4_8 ref NI_4 NS_8 0 6.6708783399729106e-05
GC_4_9 ref NI_4 NS_9 0 1.1246626453602089e+00
GC_4_10 ref NI_4 NS_10 0 -2.4729093056069906e-02
GC_4_11 ref NI_4 NS_11 0 1.6759694027942904e-01
GC_4_12 ref NI_4 NS_12 0 -2.4443545079758409e-02
GC_4_13 ref NI_4 NS_13 0 3.0972385122903646e-03
GC_4_14 ref NI_4 NS_14 0 -4.2439739155192617e-05
GC_4_15 ref NI_4 NS_15 0 7.0602320013377888e-08
GC_4_16 ref NI_4 NS_16 0 -4.3329415642474062e-07
GC_4_17 ref NI_4 NS_17 0 1.1748509718051312e-01
GC_4_18 ref NI_4 NS_18 0 1.0704844038199320e-02
GC_4_19 ref NI_4 NS_19 0 -4.3771610519517501e-02
GC_4_20 ref NI_4 NS_20 0 5.8311894325161998e-02
GC_4_21 ref NI_4 NS_21 0 1.7378241072262976e-02
GC_4_22 ref NI_4 NS_22 0 1.1829396300104859e-04
GC_4_23 ref NI_4 NS_23 0 1.5857249941020396e-07
GC_4_24 ref NI_4 NS_24 0 5.3662990412814680e-07
GC_4_25 ref NI_4 NS_25 0 3.2153654229867175e+00
GC_4_26 ref NI_4 NS_26 0 -1.6394698363377078e+00
GC_4_27 ref NI_4 NS_27 0 -1.7780008939306691e-01
GC_4_28 ref NI_4 NS_28 0 -3.6418457270998533e-01
GC_4_29 ref NI_4 NS_29 0 -2.0735803896111224e-02
GC_4_30 ref NI_4 NS_30 0 -2.4771952565600728e-03
GC_4_31 ref NI_4 NS_31 0 -6.4264167485165973e-07
GC_4_32 ref NI_4 NS_32 0 -3.4488642035762567e-05
GC_4_33 ref NI_4 NS_33 0 1.5809379394021386e+00
GC_4_34 ref NI_4 NS_34 0 5.5464602625605958e-02
GC_4_35 ref NI_4 NS_35 0 1.5583729538837321e-01
GC_4_36 ref NI_4 NS_36 0 1.6752674723897909e-02
GC_4_37 ref NI_4 NS_37 0 -2.8703442200466209e-02
GC_4_38 ref NI_4 NS_38 0 5.1949931868519139e-04
GC_4_39 ref NI_4 NS_39 0 2.0661441788734804e-07
GC_4_40 ref NI_4 NS_40 0 -1.5445490010444085e-05
GC_4_41 ref NI_4 NS_41 0 6.1814412744257163e-01
GC_4_42 ref NI_4 NS_42 0 3.1554497365561825e-02
GC_4_43 ref NI_4 NS_43 0 7.8513032687321543e-02
GC_4_44 ref NI_4 NS_44 0 4.1312174402720205e-02
GC_4_45 ref NI_4 NS_45 0 -1.2854291825121197e-02
GC_4_46 ref NI_4 NS_46 0 1.5892256932380154e-04
GC_4_47 ref NI_4 NS_47 0 6.1147242450928606e-08
GC_4_48 ref NI_4 NS_48 0 -9.6757812712319923e-06
GC_4_49 ref NI_4 NS_49 0 3.1375779936491499e-01
GC_4_50 ref NI_4 NS_50 0 1.7014806106133446e-02
GC_4_51 ref NI_4 NS_51 0 -4.5043497334443664e-03
GC_4_52 ref NI_4 NS_52 0 6.2493297012807682e-02
GC_4_53 ref NI_4 NS_53 0 3.2629886758633246e-03
GC_4_54 ref NI_4 NS_54 0 1.0067056727384426e-04
GC_4_55 ref NI_4 NS_55 0 2.2481722005726374e-07
GC_4_56 ref NI_4 NS_56 0 -5.4732531290163921e-06
GC_4_57 ref NI_4 NS_57 0 1.0243687680422559e-01
GC_4_58 ref NI_4 NS_58 0 -1.9114855102359690e-01
GC_4_59 ref NI_4 NS_59 0 3.9250357937987651e-01
GC_4_60 ref NI_4 NS_60 0 -5.9995941053337234e-02
GC_4_61 ref NI_4 NS_61 0 -1.6100306048040282e-02
GC_4_62 ref NI_4 NS_62 0 -1.3946961125065765e-04
GC_4_63 ref NI_4 NS_63 0 -6.6646255139696886e-10
GC_4_64 ref NI_4 NS_64 0 -1.4062920256828723e-05
GC_4_65 ref NI_4 NS_65 0 1.0902394432201072e+00
GC_4_66 ref NI_4 NS_66 0 1.5667645992677188e+00
GC_4_67 ref NI_4 NS_67 0 -9.2728706485579918e-02
GC_4_68 ref NI_4 NS_68 0 -3.6176231574290701e-01
GC_4_69 ref NI_4 NS_69 0 -1.9218501085820554e-02
GC_4_70 ref NI_4 NS_70 0 -1.1412762273453191e-03
GC_4_71 ref NI_4 NS_71 0 2.0143468912647975e-08
GC_4_72 ref NI_4 NS_72 0 -3.3026487339341244e-05
GC_4_73 ref NI_4 NS_73 0 5.8143603391165088e-01
GC_4_74 ref NI_4 NS_74 0 2.5584928889946765e-02
GC_4_75 ref NI_4 NS_75 0 8.2453487056929117e-03
GC_4_76 ref NI_4 NS_76 0 1.1304725683950984e-01
GC_4_77 ref NI_4 NS_77 0 -2.2771926878379825e-02
GC_4_78 ref NI_4 NS_78 0 -8.5647060365804111e-04
GC_4_79 ref NI_4 NS_79 0 1.0753532305726308e-07
GC_4_80 ref NI_4 NS_80 0 -9.1230006580911240e-06
GC_4_81 ref NI_4 NS_81 0 -2.2175074933858618e-01
GC_4_82 ref NI_4 NS_82 0 2.3666832154758725e-02
GC_4_83 ref NI_4 NS_83 0 -8.8783145687455933e-02
GC_4_84 ref NI_4 NS_84 0 9.3817418677799580e-02
GC_4_85 ref NI_4 NS_85 0 1.0212072112238178e-02
GC_4_86 ref NI_4 NS_86 0 3.2798567333147373e-04
GC_4_87 ref NI_4 NS_87 0 5.1099538634371321e-07
GC_4_88 ref NI_4 NS_88 0 1.0369876476219421e-05
GC_4_89 ref NI_4 NS_89 0 -1.1898115603289083e-01
GC_4_90 ref NI_4 NS_90 0 -1.2602057543818929e-02
GC_4_91 ref NI_4 NS_91 0 -7.3992760553165657e-02
GC_4_92 ref NI_4 NS_92 0 1.3005308990536660e-01
GC_4_93 ref NI_4 NS_93 0 -5.7761613933515719e-03
GC_4_94 ref NI_4 NS_94 0 6.1145138808211066e-04
GC_4_95 ref NI_4 NS_95 0 -3.8224330803036671e-07
GC_4_96 ref NI_4 NS_96 0 5.0721840003582847e-06
GC_4_97 ref NI_4 NS_97 0 -1.7121772334422974e-01
GC_4_98 ref NI_4 NS_98 0 1.5614347770946030e-02
GC_4_99 ref NI_4 NS_99 0 -6.0672510124944200e-02
GC_4_100 ref NI_4 NS_100 0 5.1716414769619225e-02
GC_4_101 ref NI_4 NS_101 0 2.2809499898954411e-02
GC_4_102 ref NI_4 NS_102 0 5.9621890014038077e-04
GC_4_103 ref NI_4 NS_103 0 6.8134027294511409e-08
GC_4_104 ref NI_4 NS_104 0 1.0024158738482919e-05
GC_4_105 ref NI_4 NS_105 0 -3.1298846503243810e-01
GC_4_106 ref NI_4 NS_106 0 1.2092362880442784e-02
GC_4_107 ref NI_4 NS_107 0 -7.1557186691537045e-02
GC_4_108 ref NI_4 NS_108 0 6.9547232016267876e-02
GC_4_109 ref NI_4 NS_109 0 1.8274460264608994e-02
GC_4_110 ref NI_4 NS_110 0 5.8361412846571667e-04
GC_4_111 ref NI_4 NS_111 0 -9.0041860630926720e-08
GC_4_112 ref NI_4 NS_112 0 7.7550954962175954e-06
GC_4_113 ref NI_4 NS_113 0 -1.8191741753388402e-01
GC_4_114 ref NI_4 NS_114 0 1.3225692591871863e-02
GC_4_115 ref NI_4 NS_115 0 -4.8259659056555708e-02
GC_4_116 ref NI_4 NS_116 0 2.6734066945462456e-02
GC_4_117 ref NI_4 NS_117 0 3.1213494450236134e-02
GC_4_118 ref NI_4 NS_118 0 7.6462826013042788e-04
GC_4_119 ref NI_4 NS_119 0 -1.6531181818926482e-07
GC_4_120 ref NI_4 NS_120 0 7.4279750078276922e-06
GC_4_121 ref NI_4 NS_121 0 -2.8701144752669777e-01
GC_4_122 ref NI_4 NS_122 0 1.8055395383222844e-02
GC_4_123 ref NI_4 NS_123 0 -5.2559544040867323e-02
GC_4_124 ref NI_4 NS_124 0 1.8927390843519042e-02
GC_4_125 ref NI_4 NS_125 0 3.4659104556069520e-02
GC_4_126 ref NI_4 NS_126 0 9.5525927124610877e-04
GC_4_127 ref NI_4 NS_127 0 -3.8559929673843280e-08
GC_4_128 ref NI_4 NS_128 0 1.2622176474676705e-05
GD_4_1 ref NI_4 NA_1 0 2.1090212097596558e-01
GD_4_2 ref NI_4 NA_2 0 -2.0401891756154464e-01
GD_4_3 ref NI_4 NA_3 0 -2.2859023430895135e-02
GD_4_4 ref NI_4 NA_4 0 5.7573931910011735e+00
GD_4_5 ref NI_4 NA_5 0 -2.4216362665055879e-01
GD_4_6 ref NI_4 NA_6 0 -1.0209461355858700e-01
GD_4_7 ref NI_4 NA_7 0 -5.4193327460060434e-02
GD_4_8 ref NI_4 NA_8 0 -2.6797112535628234e-02
GD_4_9 ref NI_4 NA_9 0 -1.6793147302621678e-01
GD_4_10 ref NI_4 NA_10 0 -1.0251072781727390e-01
GD_4_11 ref NI_4 NA_11 0 3.2608858060876579e-02
GD_4_12 ref NI_4 NA_12 0 1.9690659209348774e-02
GD_4_13 ref NI_4 NA_13 0 2.4676790511190448e-02
GD_4_14 ref NI_4 NA_14 0 4.8654995188906383e-02
GD_4_15 ref NI_4 NA_15 0 2.7066317446559178e-02
GD_4_16 ref NI_4 NA_16 0 4.4247886549703956e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -9.4729531293282732e-01
GC_5_2 ref NI_5 NS_2 0 4.7502764887270184e-02
GC_5_3 ref NI_5 NS_3 0 -8.2375248496974807e-02
GC_5_4 ref NI_5 NS_4 0 7.8967022823377600e-02
GC_5_5 ref NI_5 NS_5 0 1.0043601948603599e-02
GC_5_6 ref NI_5 NS_6 0 5.5075609551383188e-04
GC_5_7 ref NI_5 NS_7 0 2.7152532236642684e-07
GC_5_8 ref NI_5 NS_8 0 6.7335070329660408e-05
GC_5_9 ref NI_5 NS_9 0 8.2663596049463295e-01
GC_5_10 ref NI_5 NS_10 0 -5.9631816866104699e-02
GC_5_11 ref NI_5 NS_11 0 2.2360092105749921e-01
GC_5_12 ref NI_5 NS_12 0 -4.3309899301866780e-02
GC_5_13 ref NI_5 NS_13 0 2.4825017432796451e-03
GC_5_14 ref NI_5 NS_14 0 -2.2824423429331335e-04
GC_5_15 ref NI_5 NS_15 0 1.4731670122432935e-09
GC_5_16 ref NI_5 NS_16 0 1.4423998625981267e-06
GC_5_17 ref NI_5 NS_17 0 1.7355441445846606e-01
GC_5_18 ref NI_5 NS_18 0 -5.5101270857634129e-03
GC_5_19 ref NI_5 NS_19 0 -1.8909239496880451e-02
GC_5_20 ref NI_5 NS_20 0 6.5074065224206099e-02
GC_5_21 ref NI_5 NS_21 0 9.6186238600156054e-03
GC_5_22 ref NI_5 NS_22 0 9.1524718398889611e-05
GC_5_23 ref NI_5 NS_23 0 1.4213343341120975e-07
GC_5_24 ref NI_5 NS_24 0 5.0661830565078331e-07
GC_5_25 ref NI_5 NS_25 0 1.5809379394021386e+00
GC_5_26 ref NI_5 NS_26 0 5.5464602625605958e-02
GC_5_27 ref NI_5 NS_27 0 1.5583729538837321e-01
GC_5_28 ref NI_5 NS_28 0 1.6752674723897909e-02
GC_5_29 ref NI_5 NS_29 0 -2.8703442200466209e-02
GC_5_30 ref NI_5 NS_30 0 5.1949931868519128e-04
GC_5_31 ref NI_5 NS_31 0 2.0661441788731932e-07
GC_5_32 ref NI_5 NS_32 0 -1.5445490010444034e-05
GC_5_33 ref NI_5 NS_33 0 2.4640014064124749e+00
GC_5_34 ref NI_5 NS_34 0 -1.6562870665567311e+00
GC_5_35 ref NI_5 NS_35 0 -3.3177888702893887e-01
GC_5_36 ref NI_5 NS_36 0 -2.9149796523053684e-01
GC_5_37 ref NI_5 NS_37 0 -6.3688544341370954e-03
GC_5_38 ref NI_5 NS_38 0 -2.9197068506176893e-03
GC_5_39 ref NI_5 NS_39 0 -4.9252336007927972e-07
GC_5_40 ref NI_5 NS_40 0 -3.5893258808247203e-05
GC_5_41 ref NI_5 NS_41 0 4.0694186098534768e-01
GC_5_42 ref NI_5 NS_42 0 2.6450398397116653e-01
GC_5_43 ref NI_5 NS_43 0 1.7256245728153652e-01
GC_5_44 ref NI_5 NS_44 0 -1.0085195009418442e-01
GC_5_45 ref NI_5 NS_45 0 -8.8746514408841876e-03
GC_5_46 ref NI_5 NS_46 0 -2.3668419182340354e-04
GC_5_47 ref NI_5 NS_47 0 -3.7433743421599450e-08
GC_5_48 ref NI_5 NS_48 0 -1.2871115234146699e-05
GC_5_49 ref NI_5 NS_49 0 3.5030934265474650e-01
GC_5_50 ref NI_5 NS_50 0 -2.0165973830973834e-03
GC_5_51 ref NI_5 NS_51 0 8.4773624516455093e-02
GC_5_52 ref NI_5 NS_52 0 2.5678620659411823e-02
GC_5_53 ref NI_5 NS_53 0 -1.6171228542129728e-03
GC_5_54 ref NI_5 NS_54 0 7.0000243006686490e-05
GC_5_55 ref NI_5 NS_55 0 2.2708161928348302e-07
GC_5_56 ref NI_5 NS_56 0 -8.1486501149853921e-06
GC_5_57 ref NI_5 NS_57 0 1.4738110308208763e+00
GC_5_58 ref NI_5 NS_58 0 1.6486264251250342e+00
GC_5_59 ref NI_5 NS_59 0 -4.2859297803718793e-01
GC_5_60 ref NI_5 NS_60 0 -2.0341065531358643e-01
GC_5_61 ref NI_5 NS_61 0 -1.2285651338979065e-02
GC_5_62 ref NI_5 NS_62 0 -1.2150063606179409e-03
GC_5_63 ref NI_5 NS_63 0 2.9608143420469023e-07
GC_5_64 ref NI_5 NS_64 0 -3.4195671974002613e-05
GC_5_65 ref NI_5 NS_65 0 1.4205784237238370e-01
GC_5_66 ref NI_5 NS_66 0 -2.1377366623995697e-01
GC_5_67 ref NI_5 NS_67 0 4.0142450334937929e-01
GC_5_68 ref NI_5 NS_68 0 -5.1168791895100943e-02
GC_5_69 ref NI_5 NS_69 0 -1.9570175489277676e-02
GC_5_70 ref NI_5 NS_70 0 -3.1733953360045980e-05
GC_5_71 ref NI_5 NS_71 0 4.9301185981489656e-08
GC_5_72 ref NI_5 NS_72 0 -1.1899110118690341e-05
GC_5_73 ref NI_5 NS_73 0 3.5914333458454589e-01
GC_5_74 ref NI_5 NS_74 0 2.5044028256023719e-02
GC_5_75 ref NI_5 NS_75 0 -3.9929761670221026e-02
GC_5_76 ref NI_5 NS_76 0 8.4803049151369186e-02
GC_5_77 ref NI_5 NS_77 0 3.7978157453323188e-03
GC_5_78 ref NI_5 NS_78 0 -6.0717350475181079e-04
GC_5_79 ref NI_5 NS_79 0 1.4736818903474952e-07
GC_5_80 ref NI_5 NS_80 0 -4.2789011254489440e-06
GC_5_81 ref NI_5 NS_81 0 -1.7990886858430666e-01
GC_5_82 ref NI_5 NS_82 0 -1.7665205589214698e-02
GC_5_83 ref NI_5 NS_83 0 -4.6255490153260047e-02
GC_5_84 ref NI_5 NS_84 0 1.1138029629515198e-01
GC_5_85 ref NI_5 NS_85 0 -4.5358586760232255e-03
GC_5_86 ref NI_5 NS_86 0 7.2982843867381382e-04
GC_5_87 ref NI_5 NS_87 0 4.3681907948702659e-07
GC_5_88 ref NI_5 NS_88 0 3.2673964521112007e-06
GC_5_89 ref NI_5 NS_89 0 -3.0756717388601545e-01
GC_5_90 ref NI_5 NS_90 0 -1.2379822119847199e-01
GC_5_91 ref NI_5 NS_91 0 1.7500204563492031e-01
GC_5_92 ref NI_5 NS_92 0 4.3926865288676870e-02
GC_5_93 ref NI_5 NS_93 0 -1.9015254662610417e-02
GC_5_94 ref NI_5 NS_94 0 1.0265397389965796e-03
GC_5_95 ref NI_5 NS_95 0 -4.7306712460951007e-07
GC_5_96 ref NI_5 NS_96 0 4.5785474640938687e-06
GC_5_97 ref NI_5 NS_97 0 -2.2966758888116073e-01
GC_5_98 ref NI_5 NS_98 0 8.3376915191800231e-03
GC_5_99 ref NI_5 NS_99 0 -6.5755935851682892e-02
GC_5_100 ref NI_5 NS_100 0 7.4855027248672573e-02
GC_5_101 ref NI_5 NS_101 0 1.4699516387370810e-02
GC_5_102 ref NI_5 NS_102 0 5.0676994655674478e-04
GC_5_103 ref NI_5 NS_103 0 -1.2130922645237069e-07
GC_5_104 ref NI_5 NS_104 0 1.1870657215863328e-05
GC_5_105 ref NI_5 NS_105 0 -3.4968775957209325e-01
GC_5_106 ref NI_5 NS_106 0 -1.4690431067133984e-02
GC_5_107 ref NI_5 NS_107 0 -4.9491065385736666e-02
GC_5_108 ref NI_5 NS_108 0 8.6274781367449940e-02
GC_5_109 ref NI_5 NS_109 0 8.4207667527710431e-03
GC_5_110 ref NI_5 NS_110 0 5.5599531170091138e-04
GC_5_111 ref NI_5 NS_111 0 -1.3632110286992226e-07
GC_5_112 ref NI_5 NS_112 0 7.8415450281962386e-06
GC_5_113 ref NI_5 NS_113 0 -2.5050879242480673e-01
GC_5_114 ref NI_5 NS_114 0 1.4046791581950886e-02
GC_5_115 ref NI_5 NS_115 0 -6.5148671672430755e-02
GC_5_116 ref NI_5 NS_116 0 5.2245606277351309e-02
GC_5_117 ref NI_5 NS_117 0 2.4430768230670238e-02
GC_5_118 ref NI_5 NS_118 0 5.1803911789427798e-04
GC_5_119 ref NI_5 NS_119 0 -2.4141702024465730e-07
GC_5_120 ref NI_5 NS_120 0 9.1981480709523456e-06
GC_5_121 ref NI_5 NS_121 0 -3.7413487074439428e-01
GC_5_122 ref NI_5 NS_122 0 2.0335363707146108e-02
GC_5_123 ref NI_5 NS_123 0 -7.3777862238534941e-02
GC_5_124 ref NI_5 NS_124 0 4.6910034873808203e-02
GC_5_125 ref NI_5 NS_125 0 2.7871700600878943e-02
GC_5_126 ref NI_5 NS_126 0 6.4751523574892633e-04
GC_5_127 ref NI_5 NS_127 0 -1.5104640088098675e-07
GC_5_128 ref NI_5 NS_128 0 1.5626550940194222e-05
GD_5_1 ref NI_5 NA_1 0 1.5567357981140384e-01
GD_5_2 ref NI_5 NA_2 0 -1.5901521966794072e-01
GD_5_3 ref NI_5 NA_3 0 -2.9857994586663775e-02
GD_5_4 ref NI_5 NA_4 0 -2.4216362665055879e-01
GD_5_5 ref NI_5 NA_5 0 5.8696414458608048e+00
GD_5_6 ref NI_5 NA_6 0 -6.6442367032635646e-02
GD_5_7 ref NI_5 NA_7 0 -5.7714624636920855e-02
GD_5_8 ref NI_5 NA_8 0 -2.2392710278517095e-01
GD_5_9 ref NI_5 NA_9 0 -3.1773420996836291e-02
GD_5_10 ref NI_5 NA_10 0 -6.5285158501088431e-02
GD_5_11 ref NI_5 NA_11 0 2.9112130475685744e-02
GD_5_12 ref NI_5 NA_12 0 5.3947537868054327e-02
GD_5_13 ref NI_5 NA_13 0 3.4605900838272606e-02
GD_5_14 ref NI_5 NA_14 0 5.5787201539263080e-02
GD_5_15 ref NI_5 NA_15 0 3.8220420667578976e-02
GD_5_16 ref NI_5 NA_16 0 5.7990194260042614e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -8.2277731561994460e-01
GC_6_2 ref NI_6 NS_2 0 3.1074745834920359e-02
GC_6_3 ref NI_6 NS_3 0 -4.5894254413968272e-02
GC_6_4 ref NI_6 NS_4 0 4.9087532107276725e-02
GC_6_5 ref NI_6 NS_5 0 1.4856887557815758e-02
GC_6_6 ref NI_6 NS_6 0 1.0546528875275910e-03
GC_6_7 ref NI_6 NS_7 0 2.1010185973591615e-07
GC_6_8 ref NI_6 NS_8 0 6.7539476557989744e-05
GC_6_9 ref NI_6 NS_9 0 1.5272354698667385e+00
GC_6_10 ref NI_6 NS_10 0 4.9219372641461895e-02
GC_6_11 ref NI_6 NS_11 0 1.0566849914585082e-01
GC_6_12 ref NI_6 NS_12 0 -2.9146340908179375e-03
GC_6_13 ref NI_6 NS_13 0 -1.6273076467577020e-03
GC_6_14 ref NI_6 NS_14 0 -6.2046706795531467e-05
GC_6_15 ref NI_6 NS_15 0 5.1197154614650240e-08
GC_6_16 ref NI_6 NS_16 0 -3.1149774932791010e-06
GC_6_17 ref NI_6 NS_17 0 3.0445014832252715e-01
GC_6_18 ref NI_6 NS_18 0 -4.7565553576476176e-02
GC_6_19 ref NI_6 NS_19 0 1.8140542499105483e-01
GC_6_20 ref NI_6 NS_20 0 -2.8846365914499451e-02
GC_6_21 ref NI_6 NS_21 0 4.6600899446703429e-03
GC_6_22 ref NI_6 NS_22 0 -1.5390292499680491e-04
GC_6_23 ref NI_6 NS_23 0 2.0828427050836240e-07
GC_6_24 ref NI_6 NS_24 0 -5.2305380531867191e-06
GC_6_25 ref NI_6 NS_25 0 6.1814412744257163e-01
GC_6_26 ref NI_6 NS_26 0 3.1554497365561818e-02
GC_6_27 ref NI_6 NS_27 0 7.8513032687321557e-02
GC_6_28 ref NI_6 NS_28 0 4.1312174402720198e-02
GC_6_29 ref NI_6 NS_29 0 -1.2854291825121194e-02
GC_6_30 ref NI_6 NS_30 0 1.5892256932380046e-04
GC_6_31 ref NI_6 NS_31 0 6.1147242450665642e-08
GC_6_32 ref NI_6 NS_32 0 -9.6757812712316535e-06
GC_6_33 ref NI_6 NS_33 0 4.0694186098534768e-01
GC_6_34 ref NI_6 NS_34 0 2.6450398397116653e-01
GC_6_35 ref NI_6 NS_35 0 1.7256245728153652e-01
GC_6_36 ref NI_6 NS_36 0 -1.0085195009418441e-01
GC_6_37 ref NI_6 NS_37 0 -8.8746514408841910e-03
GC_6_38 ref NI_6 NS_38 0 -2.3668419182340186e-04
GC_6_39 ref NI_6 NS_39 0 -3.7433743421210437e-08
GC_6_40 ref NI_6 NS_40 0 -1.2871115234147217e-05
GC_6_41 ref NI_6 NS_41 0 4.6650137651367318e+00
GC_6_42 ref NI_6 NS_42 0 -3.6569636423598278e-01
GC_6_43 ref NI_6 NS_43 0 -1.3219411340964289e+00
GC_6_44 ref NI_6 NS_44 0 -1.3608100431752784e-01
GC_6_45 ref NI_6 NS_45 0 -1.0708517777733861e-02
GC_6_46 ref NI_6 NS_46 0 -2.6750646050131095e-03
GC_6_47 ref NI_6 NS_47 0 2.6423428247613707e-07
GC_6_48 ref NI_6 NS_48 0 -2.1200176267018885e-05
GC_6_49 ref NI_6 NS_49 0 -3.8209858312795858e-01
GC_6_50 ref NI_6 NS_50 0 2.4737580647285815e-01
GC_6_51 ref NI_6 NS_51 0 2.8990742473488806e-01
GC_6_52 ref NI_6 NS_52 0 -1.9979679096329717e-01
GC_6_53 ref NI_6 NS_53 0 1.0853230325380228e-02
GC_6_54 ref NI_6 NS_54 0 -1.1867451188525726e-03
GC_6_55 ref NI_6 NS_55 0 1.1913641722165419e-07
GC_6_56 ref NI_6 NS_56 0 -5.9312983817276134e-06
GC_6_57 ref NI_6 NS_57 0 -1.6656373457722525e-02
GC_6_58 ref NI_6 NS_58 0 -1.9875909009728709e-01
GC_6_59 ref NI_6 NS_59 0 4.1087195020812411e-01
GC_6_60 ref NI_6 NS_60 0 -8.8412702927414252e-02
GC_6_61 ref NI_6 NS_61 0 -7.1429671133569584e-03
GC_6_62 ref NI_6 NS_62 0 -1.8261938648078945e-04
GC_6_63 ref NI_6 NS_63 0 -2.1167570769051524e-08
GC_6_64 ref NI_6 NS_64 0 -7.7938666544997211e-06
GC_6_65 ref NI_6 NS_65 0 6.0928811096025826e-01
GC_6_66 ref NI_6 NS_66 0 -9.6125947608470139e-02
GC_6_67 ref NI_6 NS_67 0 1.2321119988085487e-01
GC_6_68 ref NI_6 NS_68 0 6.0427559042433354e-02
GC_6_69 ref NI_6 NS_69 0 -1.4551857089761347e-02
GC_6_70 ref NI_6 NS_70 0 3.4197688504183248e-04
GC_6_71 ref NI_6 NS_71 0 3.1809542328404386e-08
GC_6_72 ref NI_6 NS_72 0 -9.8311489869782157e-06
GC_6_73 ref NI_6 NS_73 0 4.0304545702777617e-01
GC_6_74 ref NI_6 NS_74 0 7.0739766659967370e-03
GC_6_75 ref NI_6 NS_75 0 1.3782210467913321e-02
GC_6_76 ref NI_6 NS_76 0 4.0083031697108328e-02
GC_6_77 ref NI_6 NS_77 0 1.1566889898935319e-02
GC_6_78 ref NI_6 NS_78 0 -2.8010609846600859e-04
GC_6_79 ref NI_6 NS_79 0 1.1249126194017543e-07
GC_6_80 ref NI_6 NS_80 0 -3.1287842215166090e-06
GC_6_81 ref NI_6 NS_81 0 2.0082878112365435e-01
GC_6_82 ref NI_6 NS_82 0 -5.2619029533411181e-02
GC_6_83 ref NI_6 NS_83 0 -1.0552098560557584e-02
GC_6_84 ref NI_6 NS_84 0 1.1372065429644232e-01
GC_6_85 ref NI_6 NS_85 0 -1.0069825432896074e-02
GC_6_86 ref NI_6 NS_86 0 8.4863634032053244e-04
GC_6_87 ref NI_6 NS_87 0 1.2119780890283329e-06
GC_6_88 ref NI_6 NS_88 0 -1.9090664382863898e-05
GC_6_89 ref NI_6 NS_89 0 -4.0892746314662015e-01
GC_6_90 ref NI_6 NS_90 0 1.1768391286080566e-01
GC_6_91 ref NI_6 NS_91 0 1.9596182843550511e-01
GC_6_92 ref NI_6 NS_92 0 -6.2679614937728625e-02
GC_6_93 ref NI_6 NS_93 0 -1.0191033268576767e-02
GC_6_94 ref NI_6 NS_94 0 -1.9980007021108126e-06
GC_6_95 ref NI_6 NS_95 0 -1.5016594597895645e-06
GC_6_96 ref NI_6 NS_96 0 1.3477673595135396e-07
GC_6_97 ref NI_6 NS_97 0 -1.4034789339525230e-01
GC_6_98 ref NI_6 NS_98 0 2.1100134276348458e-02
GC_6_99 ref NI_6 NS_99 0 -6.2538074642218569e-02
GC_6_100 ref NI_6 NS_100 0 8.5618038102964727e-02
GC_6_101 ref NI_6 NS_101 0 6.7597599738333583e-03
GC_6_102 ref NI_6 NS_102 0 4.3879515009613546e-04
GC_6_103 ref NI_6 NS_103 0 9.2787651093478425e-08
GC_6_104 ref NI_6 NS_104 0 8.2694142603648607e-06
GC_6_105 ref NI_6 NS_105 0 -1.7022257845345554e-01
GC_6_106 ref NI_6 NS_106 0 -3.9961704502572359e-02
GC_6_107 ref NI_6 NS_107 0 1.3168263195712617e-02
GC_6_108 ref NI_6 NS_108 0 7.4218469668084097e-02
GC_6_109 ref NI_6 NS_109 0 -1.2733884062075951e-05
GC_6_110 ref NI_6 NS_110 0 6.8282937222889238e-04
GC_6_111 ref NI_6 NS_111 0 -3.1378419678579895e-07
GC_6_112 ref NI_6 NS_112 0 3.4494933571242772e-06
GC_6_113 ref NI_6 NS_113 0 -1.9219195069502343e-01
GC_6_114 ref NI_6 NS_114 0 8.9162331717119771e-03
GC_6_115 ref NI_6 NS_115 0 -5.5275857709998558e-02
GC_6_116 ref NI_6 NS_116 0 7.2869098075769301e-02
GC_6_117 ref NI_6 NS_117 0 1.2584885220396856e-02
GC_6_118 ref NI_6 NS_118 0 5.3152223400028940e-04
GC_6_119 ref NI_6 NS_119 0 -2.2467038597440484e-07
GC_6_120 ref NI_6 NS_120 0 6.6138116734142749e-06
GC_6_121 ref NI_6 NS_121 0 -3.0318400119751449e-01
GC_6_122 ref NI_6 NS_122 0 1.5119239064506823e-02
GC_6_123 ref NI_6 NS_123 0 -8.0817696735031253e-02
GC_6_124 ref NI_6 NS_124 0 7.9575600054321211e-02
GC_6_125 ref NI_6 NS_125 0 1.5095656877057311e-02
GC_6_126 ref NI_6 NS_126 0 7.0362968184909758e-04
GC_6_127 ref NI_6 NS_127 0 -1.3759165223142506e-07
GC_6_128 ref NI_6 NS_128 0 1.0802489658458902e-05
GD_6_1 ref NI_6 NA_1 0 1.3618926717589769e-01
GD_6_2 ref NI_6 NA_2 0 -2.7136831789994548e-01
GD_6_3 ref NI_6 NA_3 0 -5.0741423212216530e-02
GD_6_4 ref NI_6 NA_4 0 -1.0209461355858700e-01
GD_6_5 ref NI_6 NA_5 0 -6.6442367032635646e-02
GD_6_6 ref NI_6 NA_6 0 5.5335182339974907e+00
GD_6_7 ref NI_6 NA_7 0 4.5983671505584439e-02
GD_6_8 ref NI_6 NA_8 0 -4.8147544743491043e-03
GD_6_9 ref NI_6 NA_9 0 -9.7728048741030041e-02
GD_6_10 ref NI_6 NA_10 0 -7.2401358346941100e-02
GD_6_11 ref NI_6 NA_11 0 -3.4048170351395131e-02
GD_6_12 ref NI_6 NA_12 0 7.5610690034893777e-02
GD_6_13 ref NI_6 NA_13 0 2.0648243601595121e-02
GD_6_14 ref NI_6 NA_14 0 3.0557645885233391e-02
GD_6_15 ref NI_6 NA_15 0 3.0086452297480148e-02
GD_6_16 ref NI_6 NA_16 0 4.8136920152113682e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -6.2423469091496409e-01
GC_7_2 ref NI_7 NS_2 0 1.4969175114962855e-02
GC_7_3 ref NI_7 NS_3 0 -1.8737504685438999e-02
GC_7_4 ref NI_7 NS_4 0 7.3012534990685848e-03
GC_7_5 ref NI_7 NS_5 0 2.6498453291696811e-02
GC_7_6 ref NI_7 NS_6 0 2.0652279128023361e-03
GC_7_7 ref NI_7 NS_7 0 6.5306889967309133e-07
GC_7_8 ref NI_7 NS_8 0 6.4916122368831200e-05
GC_7_9 ref NI_7 NS_9 0 1.3224472720712122e+00
GC_7_10 ref NI_7 NS_10 0 3.2402311835452162e-02
GC_7_11 ref NI_7 NS_11 0 1.2521508287969019e-01
GC_7_12 ref NI_7 NS_12 0 -5.1223000798798863e-03
GC_7_13 ref NI_7 NS_13 0 -3.0689559736968219e-03
GC_7_14 ref NI_7 NS_14 0 -1.3992664294412008e-04
GC_7_15 ref NI_7 NS_15 0 -6.4846706173002442e-09
GC_7_16 ref NI_7 NS_16 0 -6.6496645433227203e-07
GC_7_17 ref NI_7 NS_17 0 -2.2092234997230370e-01
GC_7_18 ref NI_7 NS_18 0 2.0964443978192973e-01
GC_7_19 ref NI_7 NS_19 0 4.0535543817844000e-01
GC_7_20 ref NI_7 NS_20 0 -2.3717603498999001e-01
GC_7_21 ref NI_7 NS_21 0 2.5479120828821376e-03
GC_7_22 ref NI_7 NS_22 0 -1.4764724608442345e-03
GC_7_23 ref NI_7 NS_23 0 -4.4514479963795884e-08
GC_7_24 ref NI_7 NS_24 0 -1.0079318632784333e-05
GC_7_25 ref NI_7 NS_25 0 3.1375779936491499e-01
GC_7_26 ref NI_7 NS_26 0 1.7014806106133457e-02
GC_7_27 ref NI_7 NS_27 0 -4.5043497334443820e-03
GC_7_28 ref NI_7 NS_28 0 6.2493297012807696e-02
GC_7_29 ref NI_7 NS_29 0 3.2629886758633185e-03
GC_7_30 ref NI_7 NS_30 0 1.0067056727384604e-04
GC_7_31 ref NI_7 NS_31 0 2.2481722005772029e-07
GC_7_32 ref NI_7 NS_32 0 -5.4732531290169816e-06
GC_7_33 ref NI_7 NS_33 0 3.5030934265474650e-01
GC_7_34 ref NI_7 NS_34 0 -2.0165973830973800e-03
GC_7_35 ref NI_7 NS_35 0 8.4773624516455093e-02
GC_7_36 ref NI_7 NS_36 0 2.5678620659411833e-02
GC_7_37 ref NI_7 NS_37 0 -1.6171228542129761e-03
GC_7_38 ref NI_7 NS_38 0 7.0000243006687412e-05
GC_7_39 ref NI_7 NS_39 0 2.2708161928370510e-07
GC_7_40 ref NI_7 NS_40 0 -8.1486501149856885e-06
GC_7_41 ref NI_7 NS_41 0 -3.8209858312795858e-01
GC_7_42 ref NI_7 NS_42 0 2.4737580647285815e-01
GC_7_43 ref NI_7 NS_43 0 2.8990742473488801e-01
GC_7_44 ref NI_7 NS_44 0 -1.9979679096329717e-01
GC_7_45 ref NI_7 NS_45 0 1.0853230325380225e-02
GC_7_46 ref NI_7 NS_46 0 -1.1867451188525711e-03
GC_7_47 ref NI_7 NS_47 0 1.1913641722201356e-07
GC_7_48 ref NI_7 NS_48 0 -5.9312983817280733e-06
GC_7_49 ref NI_7 NS_49 0 4.9469841537488950e+00
GC_7_50 ref NI_7 NS_50 0 -4.0820651364966720e-01
GC_7_51 ref NI_7 NS_51 0 -1.1963922671085447e+00
GC_7_52 ref NI_7 NS_52 0 -1.9576577821194108e-01
GC_7_53 ref NI_7 NS_53 0 -1.0139194435739157e-02
GC_7_54 ref NI_7 NS_54 0 -2.9907681422810606e-03
GC_7_55 ref NI_7 NS_55 0 1.2943034762789004e-06
GC_7_56 ref NI_7 NS_56 0 -4.6742281715883003e-05
GC_7_57 ref NI_7 NS_57 0 3.6497724208923948e-01
GC_7_58 ref NI_7 NS_58 0 -8.4268181548692728e-02
GC_7_59 ref NI_7 NS_59 0 6.8846324073760512e-02
GC_7_60 ref NI_7 NS_60 0 6.7237391804730720e-02
GC_7_61 ref NI_7 NS_61 0 -4.1286341472554040e-03
GC_7_62 ref NI_7 NS_62 0 2.6662095211937376e-04
GC_7_63 ref NI_7 NS_63 0 2.4912897902734933e-07
GC_7_64 ref NI_7 NS_64 0 -7.1861799730822571e-06
GC_7_65 ref NI_7 NS_65 0 2.6289797596786751e-01
GC_7_66 ref NI_7 NS_66 0 -3.2103346724319859e-02
GC_7_67 ref NI_7 NS_67 0 -3.1230813075973974e-03
GC_7_68 ref NI_7 NS_68 0 8.0940411195311202e-02
GC_7_69 ref NI_7 NS_69 0 1.7791263744329582e-03
GC_7_70 ref NI_7 NS_70 0 1.9476083284184850e-04
GC_7_71 ref NI_7 NS_71 0 2.5856623191652586e-07
GC_7_72 ref NI_7 NS_72 0 -4.7706579133282897e-06
GC_7_73 ref NI_7 NS_73 0 3.4588073972131100e-01
GC_7_74 ref NI_7 NS_74 0 -4.8527806495949231e-03
GC_7_75 ref NI_7 NS_75 0 1.6972126433230584e-02
GC_7_76 ref NI_7 NS_76 0 6.8992086329712383e-03
GC_7_77 ref NI_7 NS_77 0 2.5746458748323698e-02
GC_7_78 ref NI_7 NS_78 0 5.3350017236829998e-04
GC_7_79 ref NI_7 NS_79 0 3.5525236829099364e-07
GC_7_80 ref NI_7 NS_80 0 1.0222103280228270e-06
GC_7_81 ref NI_7 NS_81 0 -9.2643393310175431e-02
GC_7_82 ref NI_7 NS_82 0 2.8308693715844529e-02
GC_7_83 ref NI_7 NS_83 0 3.7220321457293586e-02
GC_7_84 ref NI_7 NS_84 0 4.6872382155872465e-02
GC_7_85 ref NI_7 NS_85 0 -3.0649285471947211e-03
GC_7_86 ref NI_7 NS_86 0 1.9901863912514145e-04
GC_7_87 ref NI_7 NS_87 0 -1.2023130405481838e-06
GC_7_88 ref NI_7 NS_88 0 8.8169735486792321e-06
GC_7_89 ref NI_7 NS_89 0 -7.1391844189165653e-04
GC_7_90 ref NI_7 NS_90 0 -5.6084763466572929e-02
GC_7_91 ref NI_7 NS_91 0 -3.6682959490647780e-02
GC_7_92 ref NI_7 NS_92 0 1.1758415676935083e-01
GC_7_93 ref NI_7 NS_93 0 -3.4777321161010327e-03
GC_7_94 ref NI_7 NS_94 0 6.1726594833947767e-04
GC_7_95 ref NI_7 NS_95 0 3.1926515956230863e-07
GC_7_96 ref NI_7 NS_96 0 -4.2197109445481052e-06
GC_7_97 ref NI_7 NS_97 0 1.9610444324521412e-01
GC_7_98 ref NI_7 NS_98 0 -6.7540896856215379e-02
GC_7_99 ref NI_7 NS_99 0 3.6203163106837681e-02
GC_7_100 ref NI_7 NS_100 0 9.9648695629294515e-02
GC_7_101 ref NI_7 NS_101 0 -1.3537838852067991e-02
GC_7_102 ref NI_7 NS_102 0 5.4384397238351108e-04
GC_7_103 ref NI_7 NS_103 0 -6.5100698399150915e-07
GC_7_104 ref NI_7 NS_104 0 3.0089287336796792e-06
GC_7_105 ref NI_7 NS_105 0 -9.5081896799772425e-01
GC_7_106 ref NI_7 NS_106 0 1.6626675957845519e-01
GC_7_107 ref NI_7 NS_107 0 2.1181869037949383e-01
GC_7_108 ref NI_7 NS_108 0 -9.3063824790169641e-02
GC_7_109 ref NI_7 NS_109 0 -8.8088494164676231e-03
GC_7_110 ref NI_7 NS_110 0 1.3703344438272392e-04
GC_7_111 ref NI_7 NS_111 0 -7.0390057042290354e-07
GC_7_112 ref NI_7 NS_112 0 -2.4275312609251790e-07
GC_7_113 ref NI_7 NS_113 0 -1.6032304692446966e-01
GC_7_114 ref NI_7 NS_114 0 -2.5331182569910238e-02
GC_7_115 ref NI_7 NS_115 0 1.1078987778011723e-02
GC_7_116 ref NI_7 NS_116 0 9.6426962040294287e-02
GC_7_117 ref NI_7 NS_117 0 -1.1797174612991634e-02
GC_7_118 ref NI_7 NS_118 0 4.4656901240215722e-04
GC_7_119 ref NI_7 NS_119 0 -2.5282943156768944e-07
GC_7_120 ref NI_7 NS_120 0 2.8354326531275680e-06
GC_7_121 ref NI_7 NS_121 0 -2.6963715738730870e-01
GC_7_122 ref NI_7 NS_122 0 -4.0968111119635851e-02
GC_7_123 ref NI_7 NS_123 0 -2.0743524138065701e-02
GC_7_124 ref NI_7 NS_124 0 1.1765839574799368e-01
GC_7_125 ref NI_7 NS_125 0 -1.0759223110257910e-02
GC_7_126 ref NI_7 NS_126 0 6.0426958349184766e-04
GC_7_127 ref NI_7 NS_127 0 -7.1341625876098194e-07
GC_7_128 ref NI_7 NS_128 0 1.1760729218203693e-05
GD_7_1 ref NI_7 NA_1 0 1.0431434150870431e-01
GD_7_2 ref NI_7 NA_2 0 -2.3907162725515485e-01
GD_7_3 ref NI_7 NA_3 0 2.1677553302512313e-02
GD_7_4 ref NI_7 NA_4 0 -5.4193327460060434e-02
GD_7_5 ref NI_7 NA_5 0 -5.7714624636920855e-02
GD_7_6 ref NI_7 NA_6 0 4.5983671505584439e-02
GD_7_7 ref NI_7 NA_7 0 5.4872953933833548e+00
GD_7_8 ref NI_7 NA_8 0 -5.8903756078237182e-02
GD_7_9 ref NI_7 NA_9 0 -4.5037554950411604e-02
GD_7_10 ref NI_7 NA_10 0 -6.0348913126581916e-02
GD_7_11 ref NI_7 NA_11 0 1.3862025531422850e-02
GD_7_12 ref NI_7 NA_12 0 1.0592689734926241e-03
GD_7_13 ref NI_7 NA_13 0 -3.2509935924240646e-02
GD_7_14 ref NI_7 NA_14 0 1.6788966023065063e-01
GD_7_15 ref NI_7 NA_15 0 3.0060199325836930e-02
GD_7_16 ref NI_7 NA_16 0 4.8140067064881865e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -8.8057298588311372e-01
GC_8_2 ref NI_8 NS_2 0 3.3531646345538985e-02
GC_8_3 ref NI_8 NS_3 0 -7.9746125138093926e-02
GC_8_4 ref NI_8 NS_4 0 6.8124537022233658e-02
GC_8_5 ref NI_8 NS_5 0 1.5990753629480707e-02
GC_8_6 ref NI_8 NS_6 0 8.0158570266319971e-04
GC_8_7 ref NI_8 NS_7 0 2.2196995912618436e-07
GC_8_8 ref NI_8 NS_8 0 6.6551317743390485e-05
GC_8_9 ref NI_8 NS_9 0 1.4391717610247776e+00
GC_8_10 ref NI_8 NS_10 0 1.9978332818913663e-01
GC_8_11 ref NI_8 NS_11 0 4.9398549599492546e-02
GC_8_12 ref NI_8 NS_12 0 -2.1412421648951217e-02
GC_8_13 ref NI_8 NS_13 0 -1.0123109402674745e-03
GC_8_14 ref NI_8 NS_14 0 -9.7992184510272193e-05
GC_8_15 ref NI_8 NS_15 0 -9.4688777786344579e-08
GC_8_16 ref NI_8 NS_16 0 -1.4048695187557281e-07
GC_8_17 ref NI_8 NS_17 0 1.3155088019810754e-01
GC_8_18 ref NI_8 NS_18 0 -1.3259583794184456e-02
GC_8_19 ref NI_8 NS_19 0 -4.1555104035488392e-02
GC_8_20 ref NI_8 NS_20 0 8.3129250178778175e-02
GC_8_21 ref NI_8 NS_21 0 8.8157014172977298e-03
GC_8_22 ref NI_8 NS_22 0 8.7817367845244380e-05
GC_8_23 ref NI_8 NS_23 0 9.1946396450678347e-08
GC_8_24 ref NI_8 NS_24 0 1.5977464755652810e-08
GC_8_25 ref NI_8 NS_25 0 1.0243687680422559e-01
GC_8_26 ref NI_8 NS_26 0 -1.9114855102359690e-01
GC_8_27 ref NI_8 NS_27 0 3.9250357937987651e-01
GC_8_28 ref NI_8 NS_28 0 -5.9995941053337234e-02
GC_8_29 ref NI_8 NS_29 0 -1.6100306048040282e-02
GC_8_30 ref NI_8 NS_30 0 -1.3946961125065751e-04
GC_8_31 ref NI_8 NS_31 0 -6.6646255136900860e-10
GC_8_32 ref NI_8 NS_32 0 -1.4062920256828760e-05
GC_8_33 ref NI_8 NS_33 0 1.4738110308208763e+00
GC_8_34 ref NI_8 NS_34 0 1.6486264251250342e+00
GC_8_35 ref NI_8 NS_35 0 -4.2859297803718793e-01
GC_8_36 ref NI_8 NS_36 0 -2.0341065531358637e-01
GC_8_37 ref NI_8 NS_37 0 -1.2285651338979076e-02
GC_8_38 ref NI_8 NS_38 0 -1.2150063606179381e-03
GC_8_39 ref NI_8 NS_39 0 2.9608143420538400e-07
GC_8_40 ref NI_8 NS_40 0 -3.4195671974003534e-05
GC_8_41 ref NI_8 NS_41 0 -1.6656373457722525e-02
GC_8_42 ref NI_8 NS_42 0 -1.9875909009728709e-01
GC_8_43 ref NI_8 NS_43 0 4.1087195020812411e-01
GC_8_44 ref NI_8 NS_44 0 -8.8412702927414252e-02
GC_8_45 ref NI_8 NS_45 0 -7.1429671133569567e-03
GC_8_46 ref NI_8 NS_46 0 -1.8261938648078961e-04
GC_8_47 ref NI_8 NS_47 0 -2.1167570769093022e-08
GC_8_48 ref NI_8 NS_48 0 -7.7938666544996685e-06
GC_8_49 ref NI_8 NS_49 0 3.6497724208923948e-01
GC_8_50 ref NI_8 NS_50 0 -8.4268181548692728e-02
GC_8_51 ref NI_8 NS_51 0 6.8846324073760512e-02
GC_8_52 ref NI_8 NS_52 0 6.7237391804730720e-02
GC_8_53 ref NI_8 NS_53 0 -4.1286341472554031e-03
GC_8_54 ref NI_8 NS_54 0 2.6662095211937360e-04
GC_8_55 ref NI_8 NS_55 0 2.4912897902729475e-07
GC_8_56 ref NI_8 NS_56 0 -7.1861799730821927e-06
GC_8_57 ref NI_8 NS_57 0 2.7057046497653316e+00
GC_8_58 ref NI_8 NS_58 0 -1.7698328999201451e+00
GC_8_59 ref NI_8 NS_59 0 -3.0412640762781340e-01
GC_8_60 ref NI_8 NS_60 0 -2.6961283099672789e-01
GC_8_61 ref NI_8 NS_61 0 -3.6691076293664015e-03
GC_8_62 ref NI_8 NS_62 0 -3.4875711451754906e-03
GC_8_63 ref NI_8 NS_63 0 5.6909650384709341e-07
GC_8_64 ref NI_8 NS_64 0 -3.7831392122423478e-05
GC_8_65 ref NI_8 NS_65 0 1.5428282440265855e+00
GC_8_66 ref NI_8 NS_66 0 1.0703270032916889e-01
GC_8_67 ref NI_8 NS_67 0 1.3066462746471405e-01
GC_8_68 ref NI_8 NS_68 0 9.5096894172907124e-03
GC_8_69 ref NI_8 NS_69 0 -2.6093479592600229e-02
GC_8_70 ref NI_8 NS_70 0 4.5360599352299336e-04
GC_8_71 ref NI_8 NS_71 0 5.1934571124860399e-08
GC_8_72 ref NI_8 NS_72 0 -2.1586204734887172e-05
GC_8_73 ref NI_8 NS_73 0 2.4252989874687567e-01
GC_8_74 ref NI_8 NS_74 0 -8.6142407836822168e-03
GC_8_75 ref NI_8 NS_75 0 -4.4018397323836937e-02
GC_8_76 ref NI_8 NS_76 0 8.4501027752923813e-02
GC_8_77 ref NI_8 NS_77 0 1.0012413426664733e-02
GC_8_78 ref NI_8 NS_78 0 -4.1361520829125825e-04
GC_8_79 ref NI_8 NS_79 0 1.5805594479419099e-07
GC_8_80 ref NI_8 NS_80 0 -4.8304592311146719e-06
GC_8_81 ref NI_8 NS_81 0 -3.0948305301422163e-01
GC_8_82 ref NI_8 NS_82 0 3.3633550729990518e-02
GC_8_83 ref NI_8 NS_83 0 -1.2353232879981033e-02
GC_8_84 ref NI_8 NS_84 0 8.0208867747467882e-02
GC_8_85 ref NI_8 NS_85 0 -7.8602049027295499e-03
GC_8_86 ref NI_8 NS_86 0 7.4786754327950899e-04
GC_8_87 ref NI_8 NS_87 0 3.0033287204034591e-07
GC_8_88 ref NI_8 NS_88 0 7.3260086885358678e-06
GC_8_89 ref NI_8 NS_89 0 -2.1112421151597366e-01
GC_8_90 ref NI_8 NS_90 0 1.0980883298790368e-01
GC_8_91 ref NI_8 NS_91 0 8.0709120325298644e-02
GC_8_92 ref NI_8 NS_92 0 3.0236297285118088e-02
GC_8_93 ref NI_8 NS_93 0 -2.5577888764231050e-02
GC_8_94 ref NI_8 NS_94 0 1.4735169168155773e-03
GC_8_95 ref NI_8 NS_95 0 -6.5336918280119129e-07
GC_8_96 ref NI_8 NS_96 0 1.2784786119316463e-05
GC_8_97 ref NI_8 NS_97 0 -2.5169846182605243e-01
GC_8_98 ref NI_8 NS_98 0 2.6249657873069245e-02
GC_8_99 ref NI_8 NS_99 0 -4.2293076452667999e-02
GC_8_100 ref NI_8 NS_100 0 5.9415928764359020e-02
GC_8_101 ref NI_8 NS_101 0 1.2629554938611785e-02
GC_8_102 ref NI_8 NS_102 0 4.3111395582889542e-04
GC_8_103 ref NI_8 NS_103 0 -2.6426279514655447e-07
GC_8_104 ref NI_8 NS_104 0 1.2593180928697784e-05
GC_8_105 ref NI_8 NS_105 0 -3.2993800517255351e-01
GC_8_106 ref NI_8 NS_106 0 5.1279473481124674e-02
GC_8_107 ref NI_8 NS_107 0 -6.0419348001617197e-02
GC_8_108 ref NI_8 NS_108 0 7.5674779810551693e-02
GC_8_109 ref NI_8 NS_109 0 6.0718187215869964e-03
GC_8_110 ref NI_8 NS_110 0 4.4739866113515156e-04
GC_8_111 ref NI_8 NS_111 0 -1.8385081388159685e-07
GC_8_112 ref NI_8 NS_112 0 5.3079106086769241e-06
GC_8_113 ref NI_8 NS_113 0 -2.3899775667231557e-01
GC_8_114 ref NI_8 NS_114 0 2.2116953423189423e-02
GC_8_115 ref NI_8 NS_115 0 -5.1448143877407690e-02
GC_8_116 ref NI_8 NS_116 0 4.3571482358310328e-02
GC_8_117 ref NI_8 NS_117 0 2.3860636119852747e-02
GC_8_118 ref NI_8 NS_118 0 3.5557135414270003e-04
GC_8_119 ref NI_8 NS_119 0 -3.5992907188067878e-07
GC_8_120 ref NI_8 NS_120 0 7.4152124723705685e-06
GC_8_121 ref NI_8 NS_121 0 -3.4358851907291166e-01
GC_8_122 ref NI_8 NS_122 0 3.4037796325676273e-02
GC_8_123 ref NI_8 NS_123 0 -6.3110958193577912e-02
GC_8_124 ref NI_8 NS_124 0 3.9386928651994016e-02
GC_8_125 ref NI_8 NS_125 0 2.6659443822726107e-02
GC_8_126 ref NI_8 NS_126 0 4.6614604258734507e-04
GC_8_127 ref NI_8 NS_127 0 -2.2328749105114794e-07
GC_8_128 ref NI_8 NS_128 0 1.4358343010026644e-05
GD_8_1 ref NI_8 NA_1 0 1.4378328762743953e-01
GD_8_2 ref NI_8 NA_2 0 -2.6290006585644737e-01
GD_8_3 ref NI_8 NA_3 0 -2.4430496279180095e-02
GD_8_4 ref NI_8 NA_4 0 -2.6797112535628234e-02
GD_8_5 ref NI_8 NA_5 0 -2.2392710278517095e-01
GD_8_6 ref NI_8 NA_6 0 -4.8147544743491043e-03
GD_8_7 ref NI_8 NA_7 0 -5.8903756078237182e-02
GD_8_8 ref NI_8 NA_8 0 5.8237453678472111e+00
GD_8_9 ref NI_8 NA_9 0 -2.3697188816945547e-01
GD_8_10 ref NI_8 NA_10 0 -4.5319044239719629e-02
GD_8_11 ref NI_8 NA_11 0 5.0835115012352189e-02
GD_8_12 ref NI_8 NA_12 0 4.6424528093197276e-02
GD_8_13 ref NI_8 NA_13 0 3.7394665826142398e-02
GD_8_14 ref NI_8 NA_14 0 5.3847963486686079e-02
GD_8_15 ref NI_8 NA_15 0 3.4744237646540894e-02
GD_8_16 ref NI_8 NA_16 0 5.2354928548402437e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -1.2274061800917182e+00
GC_9_2 ref NI_9 NS_2 0 4.7600976130966276e-02
GC_9_3 ref NI_9 NS_3 0 -8.0643027738061215e-02
GC_9_4 ref NI_9 NS_4 0 1.2011261215371520e-01
GC_9_5 ref NI_9 NS_5 0 -8.7631195642192423e-03
GC_9_6 ref NI_9 NS_6 0 1.1029054645496460e-04
GC_9_7 ref NI_9 NS_7 0 1.3691739054835377e-07
GC_9_8 ref NI_9 NS_8 0 6.7801293545112232e-05
GC_9_9 ref NI_9 NS_9 0 1.2752218877400114e+00
GC_9_10 ref NI_9 NS_10 0 1.0955456558364994e-01
GC_9_11 ref NI_9 NS_11 0 8.7827831219271138e-02
GC_9_12 ref NI_9 NS_12 0 -1.9572135308477793e-02
GC_9_13 ref NI_9 NS_13 0 1.7348853231962710e-03
GC_9_14 ref NI_9 NS_14 0 -2.8645453585633139e-05
GC_9_15 ref NI_9 NS_15 0 -2.0136594906025983e-08
GC_9_16 ref NI_9 NS_16 0 3.6320946994587927e-08
GC_9_17 ref NI_9 NS_17 0 7.4649630397658762e-02
GC_9_18 ref NI_9 NS_18 0 1.1292168702560286e-03
GC_9_19 ref NI_9 NS_19 0 -5.2282051612226252e-02
GC_9_20 ref NI_9 NS_20 0 6.8710764795656853e-02
GC_9_21 ref NI_9 NS_21 0 1.6432265748472948e-02
GC_9_22 ref NI_9 NS_22 0 1.1944634482183582e-04
GC_9_23 ref NI_9 NS_23 0 1.4156301722570947e-07
GC_9_24 ref NI_9 NS_24 0 9.7379585989878519e-07
GC_9_25 ref NI_9 NS_25 0 1.0902394432201072e+00
GC_9_26 ref NI_9 NS_26 0 1.5667645992677188e+00
GC_9_27 ref NI_9 NS_27 0 -9.2728706485579890e-02
GC_9_28 ref NI_9 NS_28 0 -3.6176231574290701e-01
GC_9_29 ref NI_9 NS_29 0 -1.9218501085820548e-02
GC_9_30 ref NI_9 NS_30 0 -1.1412762273453224e-03
GC_9_31 ref NI_9 NS_31 0 2.0143468911927845e-08
GC_9_32 ref NI_9 NS_32 0 -3.3026487339340309e-05
GC_9_33 ref NI_9 NS_33 0 1.4205784237238370e-01
GC_9_34 ref NI_9 NS_34 0 -2.1377366623995697e-01
GC_9_35 ref NI_9 NS_35 0 4.0142450334937929e-01
GC_9_36 ref NI_9 NS_36 0 -5.1168791895100943e-02
GC_9_37 ref NI_9 NS_37 0 -1.9570175489277676e-02
GC_9_38 ref NI_9 NS_38 0 -3.1733953360045594e-05
GC_9_39 ref NI_9 NS_39 0 4.9301185981573816e-08
GC_9_40 ref NI_9 NS_40 0 -1.1899110118690463e-05
GC_9_41 ref NI_9 NS_41 0 6.0928811096025826e-01
GC_9_42 ref NI_9 NS_42 0 -9.6125947608470139e-02
GC_9_43 ref NI_9 NS_43 0 1.2321119988085487e-01
GC_9_44 ref NI_9 NS_44 0 6.0427559042433361e-02
GC_9_45 ref NI_9 NS_45 0 -1.4551857089761353e-02
GC_9_46 ref NI_9 NS_46 0 3.4197688504183400e-04
GC_9_47 ref NI_9 NS_47 0 3.1809542328764329e-08
GC_9_48 ref NI_9 NS_48 0 -9.8311489869786816e-06
GC_9_49 ref NI_9 NS_49 0 2.6289797596786751e-01
GC_9_50 ref NI_9 NS_50 0 -3.2103346724319859e-02
GC_9_51 ref NI_9 NS_51 0 -3.1230813075973974e-03
GC_9_52 ref NI_9 NS_52 0 8.0940411195311202e-02
GC_9_53 ref NI_9 NS_53 0 1.7791263744329582e-03
GC_9_54 ref NI_9 NS_54 0 1.9476083284184840e-04
GC_9_55 ref NI_9 NS_55 0 2.5856623191649871e-07
GC_9_56 ref NI_9 NS_56 0 -4.7706579133282600e-06
GC_9_57 ref NI_9 NS_57 0 1.5428282440265855e+00
GC_9_58 ref NI_9 NS_58 0 1.0703270032916889e-01
GC_9_59 ref NI_9 NS_59 0 1.3066462746471405e-01
GC_9_60 ref NI_9 NS_60 0 9.5096894172907315e-03
GC_9_61 ref NI_9 NS_61 0 -2.6093479592600239e-02
GC_9_62 ref NI_9 NS_62 0 4.5360599352299547e-04
GC_9_63 ref NI_9 NS_63 0 5.1934571125386499e-08
GC_9_64 ref NI_9 NS_64 0 -2.1586204734887856e-05
GC_9_65 ref NI_9 NS_65 0 3.2478544144445154e+00
GC_9_66 ref NI_9 NS_66 0 -1.6090482209194144e+00
GC_9_67 ref NI_9 NS_67 0 -1.5885364893322618e-01
GC_9_68 ref NI_9 NS_68 0 -3.8757600614437998e-01
GC_9_69 ref NI_9 NS_69 0 -1.9126482392842526e-02
GC_9_70 ref NI_9 NS_70 0 -2.6658866633991539e-03
GC_9_71 ref NI_9 NS_71 0 -3.9015893044238660e-07
GC_9_72 ref NI_9 NS_72 0 -3.5624691512690618e-05
GC_9_73 ref NI_9 NS_73 0 4.1056663378355968e-01
GC_9_74 ref NI_9 NS_74 0 -2.8262697829535530e-02
GC_9_75 ref NI_9 NS_75 0 4.6199651805791673e-03
GC_9_76 ref NI_9 NS_76 0 1.2153962413656094e-01
GC_9_77 ref NI_9 NS_77 0 -1.7568296415024522e-02
GC_9_78 ref NI_9 NS_78 0 -6.7685698259115957e-04
GC_9_79 ref NI_9 NS_79 0 1.4385674181453161e-07
GC_9_80 ref NI_9 NS_80 0 -6.4775597468435888e-06
GC_9_81 ref NI_9 NS_81 0 -2.7054993244582987e-01
GC_9_82 ref NI_9 NS_82 0 3.0419653735749529e-02
GC_9_83 ref NI_9 NS_83 0 -7.0842034675944313e-02
GC_9_84 ref NI_9 NS_84 0 8.3830958894214214e-02
GC_9_85 ref NI_9 NS_85 0 8.9412940156796492e-03
GC_9_86 ref NI_9 NS_86 0 2.4348457674005632e-04
GC_9_87 ref NI_9 NS_87 0 5.1388272468339960e-07
GC_9_88 ref NI_9 NS_88 0 1.2400295330288875e-05
GC_9_89 ref NI_9 NS_89 0 -1.7332746247201336e-01
GC_9_90 ref NI_9 NS_90 0 2.3826953861149681e-02
GC_9_91 ref NI_9 NS_91 0 -7.2901142905659494e-02
GC_9_92 ref NI_9 NS_92 0 1.1976381583879520e-01
GC_9_93 ref NI_9 NS_93 0 -6.8359037052785933e-03
GC_9_94 ref NI_9 NS_94 0 5.3347344625927586e-04
GC_9_95 ref NI_9 NS_95 0 -4.4990396951189591e-07
GC_9_96 ref NI_9 NS_96 0 4.7713020161959772e-06
GC_9_97 ref NI_9 NS_97 0 -2.0138753917324156e-01
GC_9_98 ref NI_9 NS_98 0 1.8649690786292920e-02
GC_9_99 ref NI_9 NS_99 0 -4.7140544496277727e-02
GC_9_100 ref NI_9 NS_100 0 4.5398118497072815e-02
GC_9_101 ref NI_9 NS_101 0 2.1714712404776050e-02
GC_9_102 ref NI_9 NS_102 0 5.1766025891027937e-04
GC_9_103 ref NI_9 NS_103 0 5.4799822336146511e-08
GC_9_104 ref NI_9 NS_104 0 9.7466189380956333e-06
GC_9_105 ref NI_9 NS_105 0 -3.3560714668578501e-01
GC_9_106 ref NI_9 NS_106 0 3.2299653065847929e-02
GC_9_107 ref NI_9 NS_107 0 -7.1776545999450311e-02
GC_9_108 ref NI_9 NS_108 0 6.5781800131549273e-02
GC_9_109 ref NI_9 NS_109 0 1.7095038586673088e-02
GC_9_110 ref NI_9 NS_110 0 5.0214728994773660e-04
GC_9_111 ref NI_9 NS_111 0 -1.0867671500714298e-07
GC_9_112 ref NI_9 NS_112 0 6.9164782642697831e-06
GC_9_113 ref NI_9 NS_113 0 -1.9503978961183627e-01
GC_9_114 ref NI_9 NS_114 0 1.5018843377262749e-02
GC_9_115 ref NI_9 NS_115 0 -4.1333524404792620e-02
GC_9_116 ref NI_9 NS_116 0 2.3985171263574204e-02
GC_9_117 ref NI_9 NS_117 0 3.0595709778515688e-02
GC_9_118 ref NI_9 NS_118 0 6.6226798394939692e-04
GC_9_119 ref NI_9 NS_119 0 -2.3756406264051039e-07
GC_9_120 ref NI_9 NS_120 0 7.2861526191338668e-06
GC_9_121 ref NI_9 NS_121 0 -2.9156719579740670e-01
GC_9_122 ref NI_9 NS_122 0 2.2844748980710143e-02
GC_9_123 ref NI_9 NS_123 0 -4.8167860100224537e-02
GC_9_124 ref NI_9 NS_124 0 1.7220815069518926e-02
GC_9_125 ref NI_9 NS_125 0 3.3765796097267584e-02
GC_9_126 ref NI_9 NS_126 0 8.4735050022315594e-04
GC_9_127 ref NI_9 NS_127 0 -6.3101352390778329e-08
GC_9_128 ref NI_9 NS_128 0 1.2099653592731883e-05
GD_9_1 ref NI_9 NA_1 0 2.0300181342889292e-01
GD_9_2 ref NI_9 NA_2 0 -2.3299565534028921e-01
GD_9_3 ref NI_9 NA_3 0 -1.6215758774349390e-02
GD_9_4 ref NI_9 NA_4 0 -1.6793147302621678e-01
GD_9_5 ref NI_9 NA_5 0 -3.1773420996836291e-02
GD_9_6 ref NI_9 NA_6 0 -9.7728048741030041e-02
GD_9_7 ref NI_9 NA_7 0 -4.5037554950411604e-02
GD_9_8 ref NI_9 NA_8 0 -2.3697188816945547e-01
GD_9_9 ref NI_9 NA_9 0 5.7494138262259922e+00
GD_9_10 ref NI_9 NA_10 0 -7.3318373172250553e-02
GD_9_11 ref NI_9 NA_11 0 4.0004045797367029e-02
GD_9_12 ref NI_9 NA_12 0 2.7788663733114782e-02
GD_9_13 ref NI_9 NA_13 0 2.8943649787663898e-02
GD_9_14 ref NI_9 NA_14 0 5.2082545156365970e-02
GD_9_15 ref NI_9 NA_15 0 2.8332610196078346e-02
GD_9_16 ref NI_9 NA_16 0 4.4470654161844973e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -5.5968645383647324e+00
GC_10_2 ref NI_10 NS_2 0 2.3656727813100667e-01
GC_10_3 ref NI_10 NS_3 0 3.9501392096453625e-01
GC_10_4 ref NI_10 NS_4 0 1.4031907914106603e-01
GC_10_5 ref NI_10 NS_5 0 -1.7324580798994096e-01
GC_10_6 ref NI_10 NS_6 0 -4.1520609019441200e-03
GC_10_7 ref NI_10 NS_7 0 -1.3102598743380152e-06
GC_10_8 ref NI_10 NS_8 0 6.4971248018573220e-05
GC_10_9 ref NI_10 NS_9 0 8.8526633380495567e-01
GC_10_10 ref NI_10 NS_10 0 1.3474140043657590e-02
GC_10_11 ref NI_10 NS_11 0 1.9125279422863791e-02
GC_10_12 ref NI_10 NS_12 0 9.2062541743264826e-03
GC_10_13 ref NI_10 NS_13 0 2.2001459329248164e-02
GC_10_14 ref NI_10 NS_14 0 3.5201124276559311e-04
GC_10_15 ref NI_10 NS_15 0 3.4307516586454467e-07
GC_10_16 ref NI_10 NS_16 0 -1.6107315473735513e-07
GC_10_17 ref NI_10 NS_17 0 3.1013764500296603e-01
GC_10_18 ref NI_10 NS_18 0 -1.4993433647969151e-02
GC_10_19 ref NI_10 NS_19 0 2.3307958384056023e-02
GC_10_20 ref NI_10 NS_20 0 -2.5727613483203921e-02
GC_10_21 ref NI_10 NS_21 0 3.9170764858555668e-02
GC_10_22 ref NI_10 NS_22 0 1.2059525481777768e-03
GC_10_23 ref NI_10 NS_23 0 4.9202249306358186e-07
GC_10_24 ref NI_10 NS_24 0 -1.8814249149795621e-06
GC_10_25 ref NI_10 NS_25 0 5.8143603391165088e-01
GC_10_26 ref NI_10 NS_26 0 2.5584928889946765e-02
GC_10_27 ref NI_10 NS_27 0 8.2453487056929030e-03
GC_10_28 ref NI_10 NS_28 0 1.1304725683950985e-01
GC_10_29 ref NI_10 NS_29 0 -2.2771926878379832e-02
GC_10_30 ref NI_10 NS_30 0 -8.5647060365804002e-04
GC_10_31 ref NI_10 NS_31 0 1.0753532305749792e-07
GC_10_32 ref NI_10 NS_32 0 -9.1230006580914256e-06
GC_10_33 ref NI_10 NS_33 0 3.5914333458454589e-01
GC_10_34 ref NI_10 NS_34 0 2.5044028256023726e-02
GC_10_35 ref NI_10 NS_35 0 -3.9929761670221026e-02
GC_10_36 ref NI_10 NS_36 0 8.4803049151369214e-02
GC_10_37 ref NI_10 NS_37 0 3.7978157453323154e-03
GC_10_38 ref NI_10 NS_38 0 -6.0717350475180982e-04
GC_10_39 ref NI_10 NS_39 0 1.4736818903499924e-07
GC_10_40 ref NI_10 NS_40 0 -4.2789011254492726e-06
GC_10_41 ref NI_10 NS_41 0 4.0304545702777617e-01
GC_10_42 ref NI_10 NS_42 0 7.0739766659967370e-03
GC_10_43 ref NI_10 NS_43 0 1.3782210467913321e-02
GC_10_44 ref NI_10 NS_44 0 4.0083031697108328e-02
GC_10_45 ref NI_10 NS_45 0 1.1566889898935319e-02
GC_10_46 ref NI_10 NS_46 0 -2.8010609846600859e-04
GC_10_47 ref NI_10 NS_47 0 1.1249126194017461e-07
GC_10_48 ref NI_10 NS_48 0 -3.1287842215165997e-06
GC_10_49 ref NI_10 NS_49 0 3.4588073972131100e-01
GC_10_50 ref NI_10 NS_50 0 -4.8527806495949222e-03
GC_10_51 ref NI_10 NS_51 0 1.6972126433230580e-02
GC_10_52 ref NI_10 NS_52 0 6.8992086329712392e-03
GC_10_53 ref NI_10 NS_53 0 2.5746458748323698e-02
GC_10_54 ref NI_10 NS_54 0 5.3350017236830031e-04
GC_10_55 ref NI_10 NS_55 0 3.5525236829103509e-07
GC_10_56 ref NI_10 NS_56 0 1.0222103280227739e-06
GC_10_57 ref NI_10 NS_57 0 2.4252989874687567e-01
GC_10_58 ref NI_10 NS_58 0 -8.6142407836822133e-03
GC_10_59 ref NI_10 NS_59 0 -4.4018397323836937e-02
GC_10_60 ref NI_10 NS_60 0 8.4501027752923827e-02
GC_10_61 ref NI_10 NS_61 0 1.0012413426664726e-02
GC_10_62 ref NI_10 NS_62 0 -4.1361520829125679e-04
GC_10_63 ref NI_10 NS_63 0 1.5805594479457790e-07
GC_10_64 ref NI_10 NS_64 0 -4.8304592311151675e-06
GC_10_65 ref NI_10 NS_65 0 4.1056663378355968e-01
GC_10_66 ref NI_10 NS_66 0 -2.8262697829535527e-02
GC_10_67 ref NI_10 NS_67 0 4.6199651805791629e-03
GC_10_68 ref NI_10 NS_68 0 1.2153962413656094e-01
GC_10_69 ref NI_10 NS_69 0 -1.7568296415024522e-02
GC_10_70 ref NI_10 NS_70 0 -6.7685698259115903e-04
GC_10_71 ref NI_10 NS_71 0 1.4385674181468328e-07
GC_10_72 ref NI_10 NS_72 0 -6.4775597468437794e-06
GC_10_73 ref NI_10 NS_73 0 6.9700367838386788e+00
GC_10_74 ref NI_10 NS_74 0 -2.2618505787213333e-01
GC_10_75 ref NI_10 NS_75 0 -4.4867633667025969e-01
GC_10_76 ref NI_10 NS_76 0 -3.5383462391334680e-01
GC_10_77 ref NI_10 NS_77 0 -1.6577252090829886e-01
GC_10_78 ref NI_10 NS_78 0 -6.7656908051706164e-03
GC_10_79 ref NI_10 NS_79 0 -1.9762786463001794e-06
GC_10_80 ref NI_10 NS_80 0 -6.6946647257820318e-05
GC_10_81 ref NI_10 NS_81 0 -1.2979340980804610e-02
GC_10_82 ref NI_10 NS_82 0 7.3867848198952415e-03
GC_10_83 ref NI_10 NS_83 0 -1.0619758146908947e-02
GC_10_84 ref NI_10 NS_84 0 -1.9724209010614214e-02
GC_10_85 ref NI_10 NS_85 0 4.2127713083809061e-02
GC_10_86 ref NI_10 NS_86 0 1.1771322877352499e-03
GC_10_87 ref NI_10 NS_87 0 6.4660335127495787e-07
GC_10_88 ref NI_10 NS_88 0 5.1519519625266055e-06
GC_10_89 ref NI_10 NS_89 0 -1.5529394870233593e-01
GC_10_90 ref NI_10 NS_90 0 2.0100241757724999e-02
GC_10_91 ref NI_10 NS_91 0 -5.7412073402911622e-02
GC_10_92 ref NI_10 NS_92 0 2.1758293861604255e-02
GC_10_93 ref NI_10 NS_93 0 3.5498707276942383e-02
GC_10_94 ref NI_10 NS_94 0 6.6966143302665186e-04
GC_10_95 ref NI_10 NS_95 0 -2.4953727393389004e-07
GC_10_96 ref NI_10 NS_96 0 9.2262862123853293e-06
GC_10_97 ref NI_10 NS_97 0 1.1517381885941823e-01
GC_10_98 ref NI_10 NS_98 0 -1.0369669230421433e-02
GC_10_99 ref NI_10 NS_99 0 2.4476936494397653e-02
GC_10_100 ref NI_10 NS_100 0 -4.8012990226669702e-02
GC_10_101 ref NI_10 NS_101 0 4.5821706148258937e-02
GC_10_102 ref NI_10 NS_102 0 2.0740050578134674e-03
GC_10_103 ref NI_10 NS_103 0 4.0042719425339968e-07
GC_10_104 ref NI_10 NS_104 0 4.4969804528407125e-06
GC_10_105 ref NI_10 NS_105 0 -2.1290737951665910e-02
GC_10_106 ref NI_10 NS_106 0 -4.4548035097955289e-03
GC_10_107 ref NI_10 NS_107 0 4.4096298751358691e-03
GC_10_108 ref NI_10 NS_108 0 -3.3231945894351279e-02
GC_10_109 ref NI_10 NS_109 0 4.4278512787498496e-02
GC_10_110 ref NI_10 NS_110 0 1.8828119516688957e-03
GC_10_111 ref NI_10 NS_111 0 1.3656975450080542e-07
GC_10_112 ref NI_10 NS_112 0 5.7599643704318547e-06
GC_10_113 ref NI_10 NS_113 0 1.6109554018099420e-01
GC_10_114 ref NI_10 NS_114 0 -2.0983958124639521e-02
GC_10_115 ref NI_10 NS_115 0 4.4970843509862454e-02
GC_10_116 ref NI_10 NS_116 0 -6.6818463943191395e-02
GC_10_117 ref NI_10 NS_117 0 4.8986381762885715e-02
GC_10_118 ref NI_10 NS_118 0 2.7034070570161289e-03
GC_10_119 ref NI_10 NS_119 0 2.5419928344834368e-07
GC_10_120 ref NI_10 NS_120 0 5.6137410351696592e-07
GC_10_121 ref NI_10 NS_121 0 1.2716838002837499e-01
GC_10_122 ref NI_10 NS_122 0 -2.2634760592027139e-02
GC_10_123 ref NI_10 NS_123 0 5.1447063298528738e-02
GC_10_124 ref NI_10 NS_124 0 -7.6913988865300070e-02
GC_10_125 ref NI_10 NS_125 0 5.0791609593526882e-02
GC_10_126 ref NI_10 NS_126 0 3.1375472404510216e-03
GC_10_127 ref NI_10 NS_127 0 3.6985192700637990e-07
GC_10_128 ref NI_10 NS_128 0 4.4947043133747200e-06
GD_10_1 ref NI_10 NA_1 0 9.6948779715625300e-01
GD_10_2 ref NI_10 NA_2 0 -1.5856707774783496e-01
GD_10_3 ref NI_10 NA_3 0 -5.1893094414425391e-02
GD_10_4 ref NI_10 NA_4 0 -1.0251072781727390e-01
GD_10_5 ref NI_10 NA_5 0 -6.5285158501088431e-02
GD_10_6 ref NI_10 NA_6 0 -7.2401358346941100e-02
GD_10_7 ref NI_10 NA_7 0 -6.0348913126581916e-02
GD_10_8 ref NI_10 NA_8 0 -4.5319044239719629e-02
GD_10_9 ref NI_10 NA_9 0 -7.3318373172250553e-02
GD_10_10 ref NI_10 NA_10 0 5.1256242146746400e+00
GD_10_11 ref NI_10 NA_11 0 -3.2475172056359704e-04
GD_10_12 ref NI_10 NA_12 0 2.1702764641194590e-02
GD_10_13 ref NI_10 NA_13 0 -1.8871611418406761e-02
GD_10_14 ref NI_10 NA_14 0 3.4391870702005938e-03
GD_10_15 ref NI_10 NA_15 0 -2.4428290543256109e-02
GD_10_16 ref NI_10 NA_16 0 -1.8013308795973258e-02
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -5.9932060333405790e-01
GC_11_2 ref NI_11 NS_2 0 1.0980594472522682e-02
GC_11_3 ref NI_11 NS_3 0 -1.0303838024446784e-03
GC_11_4 ref NI_11 NS_4 0 -3.5851820621961530e-02
GC_11_5 ref NI_11 NS_5 0 3.9606461485374216e-02
GC_11_6 ref NI_11 NS_6 0 2.9752988294388222e-03
GC_11_7 ref NI_11 NS_7 0 8.0926830255809543e-07
GC_11_8 ref NI_11 NS_8 0 6.9360650706319367e-05
GC_11_9 ref NI_11 NS_9 0 6.7709106732389279e-01
GC_11_10 ref NI_11 NS_10 0 6.7421498231590077e-02
GC_11_11 ref NI_11 NS_11 0 9.3479500985539726e-02
GC_11_12 ref NI_11 NS_12 0 -2.0924040032965809e-03
GC_11_13 ref NI_11 NS_13 0 -1.8130898296946231e-03
GC_11_14 ref NI_11 NS_14 0 3.9778902482800010e-05
GC_11_15 ref NI_11 NS_15 0 -3.2630052194744139e-07
GC_11_16 ref NI_11 NS_16 0 5.5885432172525373e-06
GC_11_17 ref NI_11 NS_17 0 -1.6172371804222135e-01
GC_11_18 ref NI_11 NS_18 0 1.3882237397429328e-02
GC_11_19 ref NI_11 NS_19 0 -6.0281191690551551e-02
GC_11_20 ref NI_11 NS_20 0 8.3405883989120994e-02
GC_11_21 ref NI_11 NS_21 0 9.8390509952248906e-03
GC_11_22 ref NI_11 NS_22 0 -6.3901039676157903e-07
GC_11_23 ref NI_11 NS_23 0 -1.0702011256270364e-06
GC_11_24 ref NI_11 NS_24 0 1.5741951311420390e-05
GC_11_25 ref NI_11 NS_25 0 -2.2175074933858618e-01
GC_11_26 ref NI_11 NS_26 0 2.3666832154758725e-02
GC_11_27 ref NI_11 NS_27 0 -8.8783145687455933e-02
GC_11_28 ref NI_11 NS_28 0 9.3817418677799580e-02
GC_11_29 ref NI_11 NS_29 0 1.0212072112238180e-02
GC_11_30 ref NI_11 NS_30 0 3.2798567333147352e-04
GC_11_31 ref NI_11 NS_31 0 5.1099538634365752e-07
GC_11_32 ref NI_11 NS_32 0 1.0369876476219497e-05
GC_11_33 ref NI_11 NS_33 0 -1.7990886858430666e-01
GC_11_34 ref NI_11 NS_34 0 -1.7665205589214701e-02
GC_11_35 ref NI_11 NS_35 0 -4.6255490153260040e-02
GC_11_36 ref NI_11 NS_36 0 1.1138029629515196e-01
GC_11_37 ref NI_11 NS_37 0 -4.5358586760232220e-03
GC_11_38 ref NI_11 NS_38 0 7.2982843867381263e-04
GC_11_39 ref NI_11 NS_39 0 4.3681907948669487e-07
GC_11_40 ref NI_11 NS_40 0 3.2673964521116238e-06
GC_11_41 ref NI_11 NS_41 0 2.0082878112365435e-01
GC_11_42 ref NI_11 NS_42 0 -5.2619029533411181e-02
GC_11_43 ref NI_11 NS_43 0 -1.0552098560557584e-02
GC_11_44 ref NI_11 NS_44 0 1.1372065429644232e-01
GC_11_45 ref NI_11 NS_45 0 -1.0069825432896074e-02
GC_11_46 ref NI_11 NS_46 0 8.4863634032053266e-04
GC_11_47 ref NI_11 NS_47 0 1.2119780890283462e-06
GC_11_48 ref NI_11 NS_48 0 -1.9090664382863915e-05
GC_11_49 ref NI_11 NS_49 0 -9.2643393310175431e-02
GC_11_50 ref NI_11 NS_50 0 2.8308693715844522e-02
GC_11_51 ref NI_11 NS_51 0 3.7220321457293599e-02
GC_11_52 ref NI_11 NS_52 0 4.6872382155872458e-02
GC_11_53 ref NI_11 NS_53 0 -3.0649285471947177e-03
GC_11_54 ref NI_11 NS_54 0 1.9901863912514023e-04
GC_11_55 ref NI_11 NS_55 0 -1.2023130405484881e-06
GC_11_56 ref NI_11 NS_56 0 8.8169735486796268e-06
GC_11_57 ref NI_11 NS_57 0 -3.0948305301422163e-01
GC_11_58 ref NI_11 NS_58 0 3.3633550729990518e-02
GC_11_59 ref NI_11 NS_59 0 -1.2353232879981029e-02
GC_11_60 ref NI_11 NS_60 0 8.0208867747467882e-02
GC_11_61 ref NI_11 NS_61 0 -7.8602049027295499e-03
GC_11_62 ref NI_11 NS_62 0 7.4786754327950877e-04
GC_11_63 ref NI_11 NS_63 0 3.0033287204027618e-07
GC_11_64 ref NI_11 NS_64 0 7.3260086885359643e-06
GC_11_65 ref NI_11 NS_65 0 -2.7054993244582987e-01
GC_11_66 ref NI_11 NS_66 0 3.0419653735749529e-02
GC_11_67 ref NI_11 NS_67 0 -7.0842034675944313e-02
GC_11_68 ref NI_11 NS_68 0 8.3830958894214214e-02
GC_11_69 ref NI_11 NS_69 0 8.9412940156796475e-03
GC_11_70 ref NI_11 NS_70 0 2.4348457674005692e-04
GC_11_71 ref NI_11 NS_71 0 5.1388272468353767e-07
GC_11_72 ref NI_11 NS_72 0 1.2400295330288695e-05
GC_11_73 ref NI_11 NS_73 0 -1.2979340980804610e-02
GC_11_74 ref NI_11 NS_74 0 7.3867848198952380e-03
GC_11_75 ref NI_11 NS_75 0 -1.0619758146908940e-02
GC_11_76 ref NI_11 NS_76 0 -1.9724209010614217e-02
GC_11_77 ref NI_11 NS_77 0 4.2127713083809075e-02
GC_11_78 ref NI_11 NS_78 0 1.1771322877352490e-03
GC_11_79 ref NI_11 NS_79 0 6.4660335127476432e-07
GC_11_80 ref NI_11 NS_80 0 5.1519519625268536e-06
GC_11_81 ref NI_11 NS_81 0 7.5982305882442622e+00
GC_11_82 ref NI_11 NS_82 0 -2.7118008799334192e-01
GC_11_83 ref NI_11 NS_83 0 -5.8080672910887109e-02
GC_11_84 ref NI_11 NS_84 0 -7.5810504371884635e-01
GC_11_85 ref NI_11 NS_85 0 -6.6922471057308114e-02
GC_11_86 ref NI_11 NS_86 0 -9.2927990863418929e-03
GC_11_87 ref NI_11 NS_87 0 6.3274294465773593e-07
GC_11_88 ref NI_11 NS_88 0 -2.5006605907998295e-04
GC_11_89 ref NI_11 NS_89 0 -1.2662717980131029e+00
GC_11_90 ref NI_11 NS_90 0 3.8204556173769173e-02
GC_11_91 ref NI_11 NS_91 0 3.1107330839441433e-01
GC_11_92 ref NI_11 NS_92 0 -3.9958875827462936e-02
GC_11_93 ref NI_11 NS_93 0 -4.3459273017650832e-02
GC_11_94 ref NI_11 NS_94 0 7.6390029361707117e-04
GC_11_95 ref NI_11 NS_95 0 8.2412796991031554e-06
GC_11_96 ref NI_11 NS_96 0 -1.6914806860280958e-05
GC_11_97 ref NI_11 NS_97 0 -4.2380291258406877e-01
GC_11_98 ref NI_11 NS_98 0 9.9091257314833404e-03
GC_11_99 ref NI_11 NS_99 0 -3.8325986399242118e-02
GC_11_100 ref NI_11 NS_100 0 8.9661145093391750e-02
GC_11_101 ref NI_11 NS_101 0 -1.9576662993166024e-04
GC_11_102 ref NI_11 NS_102 0 4.1093435660508965e-04
GC_11_103 ref NI_11 NS_103 0 -3.3485215804022353e-06
GC_11_104 ref NI_11 NS_104 0 4.0447365720139828e-05
GC_11_105 ref NI_11 NS_105 0 -4.5312907015716586e-01
GC_11_106 ref NI_11 NS_106 0 1.4159449819195638e-02
GC_11_107 ref NI_11 NS_107 0 9.8797283665697649e-02
GC_11_108 ref NI_11 NS_108 0 4.2825940868498377e-02
GC_11_109 ref NI_11 NS_109 0 -1.6987696905533520e-02
GC_11_110 ref NI_11 NS_110 0 3.2507546651570652e-04
GC_11_111 ref NI_11 NS_111 0 -3.6568596907208329e-06
GC_11_112 ref NI_11 NS_112 0 3.2808499252399094e-05
GC_11_113 ref NI_11 NS_113 0 -4.2587718957065640e-01
GC_11_114 ref NI_11 NS_114 0 2.7916337272193493e-02
GC_11_115 ref NI_11 NS_115 0 -6.8638318435283840e-02
GC_11_116 ref NI_11 NS_116 0 5.6330818874327157e-02
GC_11_117 ref NI_11 NS_117 0 2.1512852159597366e-02
GC_11_118 ref NI_11 NS_118 0 1.9697093734070585e-04
GC_11_119 ref NI_11 NS_119 0 -1.2121573318585538e-06
GC_11_120 ref NI_11 NS_120 0 3.7101325130761015e-05
GC_11_121 ref NI_11 NS_121 0 -5.0911656351871626e-01
GC_11_122 ref NI_11 NS_122 0 3.3025242397346881e-02
GC_11_123 ref NI_11 NS_123 0 -6.9613197470353758e-02
GC_11_124 ref NI_11 NS_124 0 5.2476709184869637e-02
GC_11_125 ref NI_11 NS_125 0 2.2875479115752176e-02
GC_11_126 ref NI_11 NS_126 0 2.9960144727962868e-04
GC_11_127 ref NI_11 NS_127 0 -2.3625103984819309e-06
GC_11_128 ref NI_11 NS_128 0 3.6537255983586446e-05
GD_11_1 ref NI_11 NA_1 0 1.0002578764709137e-01
GD_11_2 ref NI_11 NA_2 0 -1.3044973544527758e-01
GD_11_3 ref NI_11 NA_3 0 2.3154747685995122e-02
GD_11_4 ref NI_11 NA_4 0 3.2608858060876579e-02
GD_11_5 ref NI_11 NA_5 0 2.9112130475685744e-02
GD_11_6 ref NI_11 NA_6 0 -3.4048170351395131e-02
GD_11_7 ref NI_11 NA_7 0 1.3862025531422850e-02
GD_11_8 ref NI_11 NA_8 0 5.0835115012352189e-02
GD_11_9 ref NI_11 NA_9 0 4.0004045797367029e-02
GD_11_10 ref NI_11 NA_10 0 -3.2475172056359704e-04
GD_11_11 ref NI_11 NA_11 0 5.0244356126926526e+00
GD_11_12 ref NI_11 NA_12 0 2.3808083969377689e-01
GD_11_13 ref NI_11 NA_13 0 6.9998095816068820e-02
GD_11_14 ref NI_11 NA_14 0 8.5305562421920653e-02
GD_11_15 ref NI_11 NA_15 0 6.6121497066974344e-02
GD_11_16 ref NI_11 NA_16 0 8.0632535666696245e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -7.7838928244931838e-01
GC_12_2 ref NI_12 NS_2 0 2.7124814248607448e-02
GC_12_3 ref NI_12 NS_3 0 -4.0988948848440052e-02
GC_12_4 ref NI_12 NS_4 0 -5.2470987666336346e-03
GC_12_5 ref NI_12 NS_5 0 3.6117304113640301e-02
GC_12_6 ref NI_12 NS_6 0 2.2846589684400484e-03
GC_12_7 ref NI_12 NS_7 0 -2.8748412882060651e-08
GC_12_8 ref NI_12 NS_8 0 7.5485168698224958e-05
GC_12_9 ref NI_12 NS_9 0 3.7980255456175260e-01
GC_12_10 ref NI_12 NS_10 0 3.2787245158799702e-02
GC_12_11 ref NI_12 NS_11 0 7.9655044789074439e-02
GC_12_12 ref NI_12 NS_12 0 1.7752630975539401e-02
GC_12_13 ref NI_12 NS_13 0 -2.1265723283854800e-03
GC_12_14 ref NI_12 NS_14 0 1.7496571148651523e-04
GC_12_15 ref NI_12 NS_15 0 -2.4149232483189738e-08
GC_12_16 ref NI_12 NS_16 0 2.6288372596659041e-06
GC_12_17 ref NI_12 NS_17 0 -2.7909361113455639e-01
GC_12_18 ref NI_12 NS_18 0 2.6230631607895172e-02
GC_12_19 ref NI_12 NS_19 0 -1.1228692591197069e-01
GC_12_20 ref NI_12 NS_20 0 9.6718856590231606e-02
GC_12_21 ref NI_12 NS_21 0 1.5775517829208746e-02
GC_12_22 ref NI_12 NS_22 0 1.1010740275089533e-04
GC_12_23 ref NI_12 NS_23 0 1.0179029976559962e-07
GC_12_24 ref NI_12 NS_24 0 1.3157578379935226e-05
GC_12_25 ref NI_12 NS_25 0 -1.1898115603289083e-01
GC_12_26 ref NI_12 NS_26 0 -1.2602057543818925e-02
GC_12_27 ref NI_12 NS_27 0 -7.3992760553165657e-02
GC_12_28 ref NI_12 NS_28 0 1.3005308990536660e-01
GC_12_29 ref NI_12 NS_29 0 -5.7761613933515745e-03
GC_12_30 ref NI_12 NS_30 0 6.1145138808211142e-04
GC_12_31 ref NI_12 NS_31 0 -3.8224330803020159e-07
GC_12_32 ref NI_12 NS_32 0 5.0721840003580780e-06
GC_12_33 ref NI_12 NS_33 0 -3.0756717388601545e-01
GC_12_34 ref NI_12 NS_34 0 -1.2379822119847199e-01
GC_12_35 ref NI_12 NS_35 0 1.7500204563492031e-01
GC_12_36 ref NI_12 NS_36 0 4.3926865288676877e-02
GC_12_37 ref NI_12 NS_37 0 -1.9015254662610420e-02
GC_12_38 ref NI_12 NS_38 0 1.0265397389965806e-03
GC_12_39 ref NI_12 NS_39 0 -4.7306712460928836e-07
GC_12_40 ref NI_12 NS_40 0 4.5785474640935773e-06
GC_12_41 ref NI_12 NS_41 0 -4.0892746314662015e-01
GC_12_42 ref NI_12 NS_42 0 1.1768391286080566e-01
GC_12_43 ref NI_12 NS_43 0 1.9596182843550511e-01
GC_12_44 ref NI_12 NS_44 0 -6.2679614937728625e-02
GC_12_45 ref NI_12 NS_45 0 -1.0191033268576767e-02
GC_12_46 ref NI_12 NS_46 0 -1.9980007021106318e-06
GC_12_47 ref NI_12 NS_47 0 -1.5016594597895101e-06
GC_12_48 ref NI_12 NS_48 0 1.3477673595129427e-07
GC_12_49 ref NI_12 NS_49 0 -7.1391844189165621e-04
GC_12_50 ref NI_12 NS_50 0 -5.6084763466572943e-02
GC_12_51 ref NI_12 NS_51 0 -3.6682959490647780e-02
GC_12_52 ref NI_12 NS_52 0 1.1758415676935083e-01
GC_12_53 ref NI_12 NS_53 0 -3.4777321161010314e-03
GC_12_54 ref NI_12 NS_54 0 6.1726594833947746e-04
GC_12_55 ref NI_12 NS_55 0 3.1926515956225294e-07
GC_12_56 ref NI_12 NS_56 0 -4.2197109445480298e-06
GC_12_57 ref NI_12 NS_57 0 -2.1112421151597366e-01
GC_12_58 ref NI_12 NS_58 0 1.0980883298790368e-01
GC_12_59 ref NI_12 NS_59 0 8.0709120325298644e-02
GC_12_60 ref NI_12 NS_60 0 3.0236297285118084e-02
GC_12_61 ref NI_12 NS_61 0 -2.5577888764231050e-02
GC_12_62 ref NI_12 NS_62 0 1.4735169168155770e-03
GC_12_63 ref NI_12 NS_63 0 -6.5336918280127546e-07
GC_12_64 ref NI_12 NS_64 0 1.2784786119316578e-05
GC_12_65 ref NI_12 NS_65 0 -1.7332746247201336e-01
GC_12_66 ref NI_12 NS_66 0 2.3826953861149681e-02
GC_12_67 ref NI_12 NS_67 0 -7.2901142905659494e-02
GC_12_68 ref NI_12 NS_68 0 1.1976381583879520e-01
GC_12_69 ref NI_12 NS_69 0 -6.8359037052785933e-03
GC_12_70 ref NI_12 NS_70 0 5.3347344625927554e-04
GC_12_71 ref NI_12 NS_71 0 -4.4990396951195235e-07
GC_12_72 ref NI_12 NS_72 0 4.7713020161960602e-06
GC_12_73 ref NI_12 NS_73 0 -1.5529394870233593e-01
GC_12_74 ref NI_12 NS_74 0 2.0100241757724999e-02
GC_12_75 ref NI_12 NS_75 0 -5.7412073402911622e-02
GC_12_76 ref NI_12 NS_76 0 2.1758293861604255e-02
GC_12_77 ref NI_12 NS_77 0 3.5498707276942383e-02
GC_12_78 ref NI_12 NS_78 0 6.6966143302665197e-04
GC_12_79 ref NI_12 NS_79 0 -2.4953727393384875e-07
GC_12_80 ref NI_12 NS_80 0 9.2262862123852785e-06
GC_12_81 ref NI_12 NS_81 0 -1.2662717980131029e+00
GC_12_82 ref NI_12 NS_82 0 3.8204556173769173e-02
GC_12_83 ref NI_12 NS_83 0 3.1107330839441433e-01
GC_12_84 ref NI_12 NS_84 0 -3.9958875827462943e-02
GC_12_85 ref NI_12 NS_85 0 -4.3459273017650832e-02
GC_12_86 ref NI_12 NS_86 0 7.6390029361706998e-04
GC_12_87 ref NI_12 NS_87 0 8.2412796991028776e-06
GC_12_88 ref NI_12 NS_88 0 -1.6914806860280596e-05
GC_12_89 ref NI_12 NS_89 0 8.4902626850328264e+00
GC_12_90 ref NI_12 NS_90 0 -3.3652898811903031e-01
GC_12_91 ref NI_12 NS_91 0 -1.5512942624825532e-01
GC_12_92 ref NI_12 NS_92 0 -7.1281916580710625e-01
GC_12_93 ref NI_12 NS_93 0 -4.7416644593278920e-02
GC_12_94 ref NI_12 NS_94 0 -1.0452773361335611e-02
GC_12_95 ref NI_12 NS_95 0 -1.0088035576339557e-06
GC_12_96 ref NI_12 NS_96 0 -1.9469623721727608e-04
GC_12_97 ref NI_12 NS_97 0 -5.7432226992558366e-01
GC_12_98 ref NI_12 NS_98 0 3.0199600311652721e-02
GC_12_99 ref NI_12 NS_99 0 -7.7853807383350349e-02
GC_12_100 ref NI_12 NS_100 0 7.7186712069705107e-02
GC_12_101 ref NI_12 NS_101 0 1.3446986483400597e-02
GC_12_102 ref NI_12 NS_102 0 4.8132825665502460e-04
GC_12_103 ref NI_12 NS_103 0 -1.4305692001984916e-06
GC_12_104 ref NI_12 NS_104 0 2.9272404844826910e-05
GC_12_105 ref NI_12 NS_105 0 -7.0730379408850785e-01
GC_12_106 ref NI_12 NS_106 0 3.1144267317538610e-02
GC_12_107 ref NI_12 NS_107 0 -6.8553205706912063e-02
GC_12_108 ref NI_12 NS_108 0 9.9545979449672237e-02
GC_12_109 ref NI_12 NS_109 0 -1.8035223481420166e-04
GC_12_110 ref NI_12 NS_110 0 6.2461206549508817e-04
GC_12_111 ref NI_12 NS_111 0 -1.0516040075311598e-06
GC_12_112 ref NI_12 NS_112 0 1.6140205010487446e-05
GC_12_113 ref NI_12 NS_113 0 -4.9765793768972610e-01
GC_12_114 ref NI_12 NS_114 0 3.2489884122490369e-02
GC_12_115 ref NI_12 NS_115 0 -7.2647491999757535e-02
GC_12_116 ref NI_12 NS_116 0 3.7417056932703488e-02
GC_12_117 ref NI_12 NS_117 0 3.0520915294840776e-02
GC_12_118 ref NI_12 NS_118 0 4.9397389435634699e-04
GC_12_119 ref NI_12 NS_119 0 -8.4154789695421841e-07
GC_12_120 ref NI_12 NS_120 0 1.9917377430362852e-05
GC_12_121 ref NI_12 NS_121 0 -5.7312199030667799e-01
GC_12_122 ref NI_12 NS_122 0 3.7024816252336723e-02
GC_12_123 ref NI_12 NS_123 0 -6.9686415057572074e-02
GC_12_124 ref NI_12 NS_124 0 2.8339798894298694e-02
GC_12_125 ref NI_12 NS_125 0 3.2805733561731117e-02
GC_12_126 ref NI_12 NS_126 0 5.8706077728153529e-04
GC_12_127 ref NI_12 NS_127 0 -4.4158324441987495e-07
GC_12_128 ref NI_12 NS_128 0 2.1344270040190991e-05
GD_12_1 ref NI_12 NA_1 0 1.2761622441726989e-01
GD_12_2 ref NI_12 NA_2 0 -7.5854476387458153e-02
GD_12_3 ref NI_12 NA_3 0 4.2012012905218075e-02
GD_12_4 ref NI_12 NA_4 0 1.9690659209348774e-02
GD_12_5 ref NI_12 NA_5 0 5.3947537868054327e-02
GD_12_6 ref NI_12 NA_6 0 7.5610690034893777e-02
GD_12_7 ref NI_12 NA_7 0 1.0592689734926241e-03
GD_12_8 ref NI_12 NA_8 0 4.6424528093197276e-02
GD_12_9 ref NI_12 NA_9 0 2.7788663733114782e-02
GD_12_10 ref NI_12 NA_10 0 2.1702764641194590e-02
GD_12_11 ref NI_12 NA_11 0 2.3808083969377689e-01
GD_12_12 ref NI_12 NA_12 0 4.8596412222849352e+00
GD_12_13 ref NI_12 NA_13 0 9.1998473344403128e-02
GD_12_14 ref NI_12 NA_14 0 1.1816163838470277e-01
GD_12_15 ref NI_12 NA_15 0 7.7738992047452937e-02
GD_12_16 ref NI_12 NA_16 0 9.0463787799791501e-02
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -4.2738442331280851e-01
GC_13_2 ref NI_13 NS_2 0 -5.0547603798987307e-03
GC_13_3 ref NI_13 NS_3 0 2.8901713829545254e-02
GC_13_4 ref NI_13 NS_4 0 -5.7468660695483398e-02
GC_13_5 ref NI_13 NS_5 0 4.1109842958261235e-02
GC_13_6 ref NI_13 NS_6 0 3.9373267065332829e-03
GC_13_7 ref NI_13 NS_7 0 6.2740991190331424e-07
GC_13_8 ref NI_13 NS_8 0 6.8616334111439316e-05
GC_13_9 ref NI_13 NS_9 0 7.0234491506117147e-01
GC_13_10 ref NI_13 NS_10 0 9.3838955929799781e-02
GC_13_11 ref NI_13 NS_11 0 1.3093904298029788e-01
GC_13_12 ref NI_13 NS_12 0 -2.8265423116799498e-02
GC_13_13 ref NI_13 NS_13 0 -4.4046659125179756e-03
GC_13_14 ref NI_13 NS_14 0 6.3170138818198317e-05
GC_13_15 ref NI_13 NS_15 0 -5.0264225944418169e-07
GC_13_16 ref NI_13 NS_16 0 1.1051401840432118e-05
GC_13_17 ref NI_13 NS_17 0 -1.3098527176304943e-02
GC_13_18 ref NI_13 NS_18 0 1.9135451748830037e-02
GC_13_19 ref NI_13 NS_19 0 4.0061379344482402e-02
GC_13_20 ref NI_13 NS_20 0 7.8869086621142809e-02
GC_13_21 ref NI_13 NS_21 0 -1.6558363183867778e-02
GC_13_22 ref NI_13 NS_22 0 -1.1464170191657227e-04
GC_13_23 ref NI_13 NS_23 0 -1.5339750977189904e-06
GC_13_24 ref NI_13 NS_24 0 7.1880293815101800e-06
GC_13_25 ref NI_13 NS_25 0 -1.7121772334422974e-01
GC_13_26 ref NI_13 NS_26 0 1.5614347770946030e-02
GC_13_27 ref NI_13 NS_27 0 -6.0672510124944200e-02
GC_13_28 ref NI_13 NS_28 0 5.1716414769619225e-02
GC_13_29 ref NI_13 NS_29 0 2.2809499898954411e-02
GC_13_30 ref NI_13 NS_30 0 5.9621890014038175e-04
GC_13_31 ref NI_13 NS_31 0 6.8134027294718588e-08
GC_13_32 ref NI_13 NS_32 0 1.0024158738482656e-05
GC_13_33 ref NI_13 NS_33 0 -2.2966758888116073e-01
GC_13_34 ref NI_13 NS_34 0 8.3376915191800283e-03
GC_13_35 ref NI_13 NS_35 0 -6.5755935851682906e-02
GC_13_36 ref NI_13 NS_36 0 7.4855027248672587e-02
GC_13_37 ref NI_13 NS_37 0 1.4699516387370808e-02
GC_13_38 ref NI_13 NS_38 0 5.0676994655674587e-04
GC_13_39 ref NI_13 NS_39 0 -1.2130922645212095e-07
GC_13_40 ref NI_13 NS_40 0 1.1870657215862998e-05
GC_13_41 ref NI_13 NS_41 0 -1.4034789339525230e-01
GC_13_42 ref NI_13 NS_42 0 2.1100134276348454e-02
GC_13_43 ref NI_13 NS_43 0 -6.2538074642218555e-02
GC_13_44 ref NI_13 NS_44 0 8.5618038102964727e-02
GC_13_45 ref NI_13 NS_45 0 6.7597599738333609e-03
GC_13_46 ref NI_13 NS_46 0 4.3879515009613443e-04
GC_13_47 ref NI_13 NS_47 0 9.2787651093269883e-08
GC_13_48 ref NI_13 NS_48 0 8.2694142603651403e-06
GC_13_49 ref NI_13 NS_49 0 1.9610444324521412e-01
GC_13_50 ref NI_13 NS_50 0 -6.7540896856215393e-02
GC_13_51 ref NI_13 NS_51 0 3.6203163106837695e-02
GC_13_52 ref NI_13 NS_52 0 9.9648695629294515e-02
GC_13_53 ref NI_13 NS_53 0 -1.3537838852067986e-02
GC_13_54 ref NI_13 NS_54 0 5.4384397238350988e-04
GC_13_55 ref NI_13 NS_55 0 -6.5100698399174452e-07
GC_13_56 ref NI_13 NS_56 0 3.0089287336799858e-06
GC_13_57 ref NI_13 NS_57 0 -2.5169846182605243e-01
GC_13_58 ref NI_13 NS_58 0 2.6249657873069238e-02
GC_13_59 ref NI_13 NS_59 0 -4.2293076452667999e-02
GC_13_60 ref NI_13 NS_60 0 5.9415928764359013e-02
GC_13_61 ref NI_13 NS_61 0 1.2629554938611787e-02
GC_13_62 ref NI_13 NS_62 0 4.3111395582889455e-04
GC_13_63 ref NI_13 NS_63 0 -2.6426279514673532e-07
GC_13_64 ref NI_13 NS_64 0 1.2593180928698028e-05
GC_13_65 ref NI_13 NS_65 0 -2.0138753917324156e-01
GC_13_66 ref NI_13 NS_66 0 1.8649690786292916e-02
GC_13_67 ref NI_13 NS_67 0 -4.7140544496277727e-02
GC_13_68 ref NI_13 NS_68 0 4.5398118497072815e-02
GC_13_69 ref NI_13 NS_69 0 2.1714712404776057e-02
GC_13_70 ref NI_13 NS_70 0 5.1766025891027861e-04
GC_13_71 ref NI_13 NS_71 0 5.4799822335965822e-08
GC_13_72 ref NI_13 NS_72 0 9.7466189380958738e-06
GC_13_73 ref NI_13 NS_73 0 1.1517381885941823e-01
GC_13_74 ref NI_13 NS_74 0 -1.0369669230421437e-02
GC_13_75 ref NI_13 NS_75 0 2.4476936494397659e-02
GC_13_76 ref NI_13 NS_76 0 -4.8012990226669702e-02
GC_13_77 ref NI_13 NS_77 0 4.5821706148258937e-02
GC_13_78 ref NI_13 NS_78 0 2.0740050578134661e-03
GC_13_79 ref NI_13 NS_79 0 4.0042719425317818e-07
GC_13_80 ref NI_13 NS_80 0 4.4969804528410005e-06
GC_13_81 ref NI_13 NS_81 0 -4.2380291258406877e-01
GC_13_82 ref NI_13 NS_82 0 9.9091257314833352e-03
GC_13_83 ref NI_13 NS_83 0 -3.8325986399242118e-02
GC_13_84 ref NI_13 NS_84 0 8.9661145093391736e-02
GC_13_85 ref NI_13 NS_85 0 -1.9576662993165696e-04
GC_13_86 ref NI_13 NS_86 0 4.1093435660508873e-04
GC_13_87 ref NI_13 NS_87 0 -3.3485215804024721e-06
GC_13_88 ref NI_13 NS_88 0 4.0447365720140147e-05
GC_13_89 ref NI_13 NS_89 0 -5.7432226992558366e-01
GC_13_90 ref NI_13 NS_90 0 3.0199600311652721e-02
GC_13_91 ref NI_13 NS_91 0 -7.7853807383350349e-02
GC_13_92 ref NI_13 NS_92 0 7.7186712069705135e-02
GC_13_93 ref NI_13 NS_93 0 1.3446986483400595e-02
GC_13_94 ref NI_13 NS_94 0 4.8132825665502492e-04
GC_13_95 ref NI_13 NS_95 0 -1.4305692001984219e-06
GC_13_96 ref NI_13 NS_96 0 2.9272404844826825e-05
GC_13_97 ref NI_13 NS_97 0 7.6760132001219397e+00
GC_13_98 ref NI_13 NS_98 0 -2.7705911370994296e-01
GC_13_99 ref NI_13 NS_99 0 -4.0731718550612230e-02
GC_13_100 ref NI_13 NS_100 0 -7.6210130675731014e-01
GC_13_101 ref NI_13 NS_101 0 -6.7409921092920697e-02
GC_13_102 ref NI_13 NS_102 0 -1.0249679886610043e-02
GC_13_103 ref NI_13 NS_103 0 3.9144362776982376e-06
GC_13_104 ref NI_13 NS_104 0 -2.4566454323603535e-04
GC_13_105 ref NI_13 NS_105 0 -1.5504334347812307e+00
GC_13_106 ref NI_13 NS_106 0 6.3086983811414463e-02
GC_13_107 ref NI_13 NS_107 0 2.6730527121914932e-01
GC_13_108 ref NI_13 NS_108 0 -2.1119627833723464e-02
GC_13_109 ref NI_13 NS_109 0 -4.4431587462819409e-02
GC_13_110 ref NI_13 NS_110 0 8.1206738134023226e-04
GC_13_111 ref NI_13 NS_111 0 9.2912118162676215e-06
GC_13_112 ref NI_13 NS_112 0 -1.2900841688717898e-05
GC_13_113 ref NI_13 NS_113 0 -5.0996345500322904e-01
GC_13_114 ref NI_13 NS_114 0 2.3193076539425986e-02
GC_13_115 ref NI_13 NS_115 0 -9.3889510477176391e-02
GC_13_116 ref NI_13 NS_116 0 1.4833424950417834e-01
GC_13_117 ref NI_13 NS_117 0 -1.2271198453838436e-02
GC_13_118 ref NI_13 NS_118 0 -3.3749011601344470e-05
GC_13_119 ref NI_13 NS_119 0 -1.8791563041403843e-06
GC_13_120 ref NI_13 NS_120 0 7.8576684337010895e-06
GC_13_121 ref NI_13 NS_121 0 -4.7555325236786256e-01
GC_13_122 ref NI_13 NS_122 0 2.9451664328107481e-02
GC_13_123 ref NI_13 NS_123 0 6.7199026755137524e-03
GC_13_124 ref NI_13 NS_124 0 1.0488233862105760e-01
GC_13_125 ref NI_13 NS_125 0 -2.0010636670002292e-02
GC_13_126 ref NI_13 NS_126 0 -4.2166027250432994e-04
GC_13_127 ref NI_13 NS_127 0 -4.5863325094820207e-06
GC_13_128 ref NI_13 NS_128 0 3.2940068858338695e-05
GD_13_1 ref NI_13 NA_1 0 7.3702991652065800e-02
GD_13_2 ref NI_13 NA_2 0 -1.3790266419073263e-01
GD_13_3 ref NI_13 NA_3 0 1.6579777670613267e-03
GD_13_4 ref NI_13 NA_4 0 2.4676790511190448e-02
GD_13_5 ref NI_13 NA_5 0 3.4605900838272606e-02
GD_13_6 ref NI_13 NA_6 0 2.0648243601595121e-02
GD_13_7 ref NI_13 NA_7 0 -3.2509935924240646e-02
GD_13_8 ref NI_13 NA_8 0 3.7394665826142398e-02
GD_13_9 ref NI_13 NA_9 0 2.8943649787663898e-02
GD_13_10 ref NI_13 NA_10 0 -1.8871611418406761e-02
GD_13_11 ref NI_13 NA_11 0 6.9998095816068820e-02
GD_13_12 ref NI_13 NA_12 0 9.1998473344403128e-02
GD_13_13 ref NI_13 NA_13 0 5.0117548297850920e+00
GD_13_14 ref NI_13 NA_14 0 2.8542544446145757e-01
GD_13_15 ref NI_13 NA_15 0 8.1493976474405483e-02
GD_13_16 ref NI_13 NA_16 0 8.2905821300920501e-02
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 -5.4002022967733487e-01
GC_14_2 ref NI_14 NS_2 0 1.7981858914725593e-03
GC_14_3 ref NI_14 NS_3 0 1.3708167528862157e-02
GC_14_4 ref NI_14 NS_4 0 -4.8071044673837243e-02
GC_14_5 ref NI_14 NS_5 0 4.0756079089861917e-02
GC_14_6 ref NI_14 NS_6 0 3.6802920749209622e-03
GC_14_7 ref NI_14 NS_7 0 4.1964790944908772e-07
GC_14_8 ref NI_14 NS_8 0 6.9925013883145981e-05
GC_14_9 ref NI_14 NS_9 0 2.9757807544770620e-01
GC_14_10 ref NI_14 NS_10 0 7.3801296677346667e-02
GC_14_11 ref NI_14 NS_11 0 9.3376225707967289e-02
GC_14_12 ref NI_14 NS_12 0 -1.1642901075078786e-03
GC_14_13 ref NI_14 NS_13 0 -3.4451713528198145e-03
GC_14_14 ref NI_14 NS_14 0 6.2410589013568639e-05
GC_14_15 ref NI_14 NS_15 0 -1.7971467601587190e-08
GC_14_16 ref NI_14 NS_16 0 5.9607901627400623e-06
GC_14_17 ref NI_14 NS_17 0 -6.1865891039159140e-02
GC_14_18 ref NI_14 NS_18 0 -7.2505409620118894e-02
GC_14_19 ref NI_14 NS_19 0 -1.8380264887583656e-02
GC_14_20 ref NI_14 NS_20 0 1.2471767384538998e-01
GC_14_21 ref NI_14 NS_21 0 -8.8542153668686192e-03
GC_14_22 ref NI_14 NS_22 0 3.9540250970423812e-04
GC_14_23 ref NI_14 NS_23 0 -1.1061560359617434e-06
GC_14_24 ref NI_14 NS_24 0 9.9879125712940929e-06
GC_14_25 ref NI_14 NS_25 0 -3.1298846503243810e-01
GC_14_26 ref NI_14 NS_26 0 1.2092362880442780e-02
GC_14_27 ref NI_14 NS_27 0 -7.1557186691537045e-02
GC_14_28 ref NI_14 NS_28 0 6.9547232016267863e-02
GC_14_29 ref NI_14 NS_29 0 1.8274460264608994e-02
GC_14_30 ref NI_14 NS_30 0 5.8361412846571548e-04
GC_14_31 ref NI_14 NS_31 0 -9.0041860631230871e-08
GC_14_32 ref NI_14 NS_32 0 7.7550954962179850e-06
GC_14_33 ref NI_14 NS_33 0 -3.4968775957209325e-01
GC_14_34 ref NI_14 NS_34 0 -1.4690431067133986e-02
GC_14_35 ref NI_14 NS_35 0 -4.9491065385736666e-02
GC_14_36 ref NI_14 NS_36 0 8.6274781367449940e-02
GC_14_37 ref NI_14 NS_37 0 8.4207667527710448e-03
GC_14_38 ref NI_14 NS_38 0 5.5599531170091063e-04
GC_14_39 ref NI_14 NS_39 0 -1.3632110287008685e-07
GC_14_40 ref NI_14 NS_40 0 7.8415450281964351e-06
GC_14_41 ref NI_14 NS_41 0 -1.7022257845345554e-01
GC_14_42 ref NI_14 NS_42 0 -3.9961704502572346e-02
GC_14_43 ref NI_14 NS_43 0 1.3168263195712597e-02
GC_14_44 ref NI_14 NS_44 0 7.4218469668084125e-02
GC_14_45 ref NI_14 NS_45 0 -1.2733884062084279e-05
GC_14_46 ref NI_14 NS_46 0 6.8282937222889487e-04
GC_14_47 ref NI_14 NS_47 0 -3.1378419678520301e-07
GC_14_48 ref NI_14 NS_48 0 3.4494933571234971e-06
GC_14_49 ref NI_14 NS_49 0 -9.5081896799772425e-01
GC_14_50 ref NI_14 NS_50 0 1.6626675957845519e-01
GC_14_51 ref NI_14 NS_51 0 2.1181869037949383e-01
GC_14_52 ref NI_14 NS_52 0 -9.3063824790169627e-02
GC_14_53 ref NI_14 NS_53 0 -8.8088494164676248e-03
GC_14_54 ref NI_14 NS_54 0 1.3703344438272466e-04
GC_14_55 ref NI_14 NS_55 0 -7.0390057042273614e-07
GC_14_56 ref NI_14 NS_56 0 -2.4275312609274707e-07
GC_14_57 ref NI_14 NS_57 0 -3.2993800517255351e-01
GC_14_58 ref NI_14 NS_58 0 5.1279473481124674e-02
GC_14_59 ref NI_14 NS_59 0 -6.0419348001617197e-02
GC_14_60 ref NI_14 NS_60 0 7.5674779810551693e-02
GC_14_61 ref NI_14 NS_61 0 6.0718187215869964e-03
GC_14_62 ref NI_14 NS_62 0 4.4739866113515129e-04
GC_14_63 ref NI_14 NS_63 0 -1.8385081388165190e-07
GC_14_64 ref NI_14 NS_64 0 5.3079106086769902e-06
GC_14_65 ref NI_14 NS_65 0 -3.3560714668578501e-01
GC_14_66 ref NI_14 NS_66 0 3.2299653065847936e-02
GC_14_67 ref NI_14 NS_67 0 -7.1776545999450339e-02
GC_14_68 ref NI_14 NS_68 0 6.5781800131549287e-02
GC_14_69 ref NI_14 NS_69 0 1.7095038586673078e-02
GC_14_70 ref NI_14 NS_70 0 5.0214728994773877e-04
GC_14_71 ref NI_14 NS_71 0 -1.0867671500663002e-07
GC_14_72 ref NI_14 NS_72 0 6.9164782642691114e-06
GC_14_73 ref NI_14 NS_73 0 -2.1290737951665910e-02
GC_14_74 ref NI_14 NS_74 0 -4.4548035097955281e-03
GC_14_75 ref NI_14 NS_75 0 4.4096298751358639e-03
GC_14_76 ref NI_14 NS_76 0 -3.3231945894351279e-02
GC_14_77 ref NI_14 NS_77 0 4.4278512787498496e-02
GC_14_78 ref NI_14 NS_78 0 1.8828119516688965e-03
GC_14_79 ref NI_14 NS_79 0 1.3656975450090354e-07
GC_14_80 ref NI_14 NS_80 0 5.7599643704317133e-06
GC_14_81 ref NI_14 NS_81 0 -4.5312907015716586e-01
GC_14_82 ref NI_14 NS_82 0 1.4159449819195643e-02
GC_14_83 ref NI_14 NS_83 0 9.8797283665697649e-02
GC_14_84 ref NI_14 NS_84 0 4.2825940868498391e-02
GC_14_85 ref NI_14 NS_85 0 -1.6987696905533520e-02
GC_14_86 ref NI_14 NS_86 0 3.2507546651570787e-04
GC_14_87 ref NI_14 NS_87 0 -3.6568596907205275e-06
GC_14_88 ref NI_14 NS_88 0 3.2808499252398688e-05
GC_14_89 ref NI_14 NS_89 0 -7.0730379408850785e-01
GC_14_90 ref NI_14 NS_90 0 3.1144267317538610e-02
GC_14_91 ref NI_14 NS_91 0 -6.8553205706912063e-02
GC_14_92 ref NI_14 NS_92 0 9.9545979449672237e-02
GC_14_93 ref NI_14 NS_93 0 -1.8035223481420231e-04
GC_14_94 ref NI_14 NS_94 0 6.2461206549508839e-04
GC_14_95 ref NI_14 NS_95 0 -1.0516040075311306e-06
GC_14_96 ref NI_14 NS_96 0 1.6140205010487395e-05
GC_14_97 ref NI_14 NS_97 0 -1.5504334347812307e+00
GC_14_98 ref NI_14 NS_98 0 6.3086983811414490e-02
GC_14_99 ref NI_14 NS_99 0 2.6730527121914932e-01
GC_14_100 ref NI_14 NS_100 0 -2.1119627833723439e-02
GC_14_101 ref NI_14 NS_101 0 -4.4431587462819423e-02
GC_14_102 ref NI_14 NS_102 0 8.1206738134023562e-04
GC_14_103 ref NI_14 NS_103 0 9.2912118162684550e-06
GC_14_104 ref NI_14 NS_104 0 -1.2900841688718990e-05
GC_14_105 ref NI_14 NS_105 0 9.9390981587543532e+00
GC_14_106 ref NI_14 NS_106 0 -4.1082556659595387e-01
GC_14_107 ref NI_14 NS_107 0 -1.3160690825908924e-01
GC_14_108 ref NI_14 NS_108 0 -6.6498814142011653e-01
GC_14_109 ref NI_14 NS_109 0 -6.4468026716678117e-02
GC_14_110 ref NI_14 NS_110 0 -1.0658599621324129e-02
GC_14_111 ref NI_14 NS_111 0 4.5362413392258258e-06
GC_14_112 ref NI_14 NS_112 0 -2.4342569109431813e-04
GC_14_113 ref NI_14 NS_113 0 -6.7496444788964027e-01
GC_14_114 ref NI_14 NS_114 0 4.4194188933107420e-02
GC_14_115 ref NI_14 NS_115 0 -1.1768907345595576e-01
GC_14_116 ref NI_14 NS_116 0 1.1177879736213622e-01
GC_14_117 ref NI_14 NS_117 0 7.8746343334681525e-03
GC_14_118 ref NI_14 NS_118 0 -3.2517675614823541e-05
GC_14_119 ref NI_14 NS_119 0 -2.9509755306660302e-06
GC_14_120 ref NI_14 NS_120 0 3.6162220305081154e-05
GC_14_121 ref NI_14 NS_121 0 -8.1742673244185626e-01
GC_14_122 ref NI_14 NS_122 0 5.0703498253673727e-02
GC_14_123 ref NI_14 NS_123 0 -1.0823514031055759e-01
GC_14_124 ref NI_14 NS_124 0 1.1039378132927735e-01
GC_14_125 ref NI_14 NS_125 0 4.5451945565632805e-03
GC_14_126 ref NI_14 NS_126 0 -4.8586055734710165e-06
GC_14_127 ref NI_14 NS_127 0 -3.9388734686534652e-06
GC_14_128 ref NI_14 NS_128 0 4.7277475882031292e-05
GD_14_1 ref NI_14 NA_1 0 9.1671173427164368e-02
GD_14_2 ref NI_14 NA_2 0 -6.3815160766587151e-02
GD_14_3 ref NI_14 NA_3 0 1.2131062892830075e-02
GD_14_4 ref NI_14 NA_4 0 4.8654995188906383e-02
GD_14_5 ref NI_14 NA_5 0 5.5787201539263080e-02
GD_14_6 ref NI_14 NA_6 0 3.0557645885233391e-02
GD_14_7 ref NI_14 NA_7 0 1.6788966023065063e-01
GD_14_8 ref NI_14 NA_8 0 5.3847963486686079e-02
GD_14_9 ref NI_14 NA_9 0 5.2082545156365970e-02
GD_14_10 ref NI_14 NA_10 0 3.4391870702005938e-03
GD_14_11 ref NI_14 NA_11 0 8.5305562421920653e-02
GD_14_12 ref NI_14 NA_12 0 1.1816163838470277e-01
GD_14_13 ref NI_14 NA_13 0 2.8542544446145757e-01
GD_14_14 ref NI_14 NA_14 0 4.6069548957604951e+00
GD_14_15 ref NI_14 NA_15 0 1.0743845964219553e-01
GD_14_16 ref NI_14 NA_16 0 1.3336214563764243e-01
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -3.2958197528892025e-01
GC_15_2 ref NI_15 NS_2 0 -1.5204812506243741e-02
GC_15_3 ref NI_15 NS_3 0 4.8362460078548733e-02
GC_15_4 ref NI_15 NS_4 0 -7.3061822605321139e-02
GC_15_5 ref NI_15 NS_5 0 4.2786607528564849e-02
GC_15_6 ref NI_15 NS_6 0 4.6169129275336479e-03
GC_15_7 ref NI_15 NS_7 0 5.7364357790004821e-07
GC_15_8 ref NI_15 NS_8 0 6.4458570733001819e-05
GC_15_9 ref NI_15 NS_9 0 6.9360036491765176e-01
GC_15_10 ref NI_15 NS_10 0 9.7617345589559396e-02
GC_15_11 ref NI_15 NS_11 0 1.0878873862124040e-01
GC_15_12 ref NI_15 NS_12 0 -1.6215142905300007e-02
GC_15_13 ref NI_15 NS_13 0 -3.2807481686263976e-03
GC_15_14 ref NI_15 NS_14 0 -1.4529164168757507e-04
GC_15_15 ref NI_15 NS_15 0 -5.8099954221262195e-07
GC_15_16 ref NI_15 NS_16 0 -3.1742486269751950e-06
GC_15_17 ref NI_15 NS_17 0 -5.4946208741815794e-01
GC_15_18 ref NI_15 NS_18 0 6.1472281989414087e-03
GC_15_19 ref NI_15 NS_19 0 3.0411892625253351e-01
GC_15_20 ref NI_15 NS_20 0 -4.2695351387909627e-03
GC_15_21 ref NI_15 NS_21 0 -5.2336158914660445e-02
GC_15_22 ref NI_15 NS_22 0 4.0808574343941494e-04
GC_15_23 ref NI_15 NS_23 0 8.8910034496597211e-07
GC_15_24 ref NI_15 NS_24 0 -1.6547009996403925e-05
GC_15_25 ref NI_15 NS_25 0 -1.8191741753388402e-01
GC_15_26 ref NI_15 NS_26 0 1.3225692591871863e-02
GC_15_27 ref NI_15 NS_27 0 -4.8259659056555708e-02
GC_15_28 ref NI_15 NS_28 0 2.6734066945462456e-02
GC_15_29 ref NI_15 NS_29 0 3.1213494450236134e-02
GC_15_30 ref NI_15 NS_30 0 7.6462826013042778e-04
GC_15_31 ref NI_15 NS_31 0 -1.6531181818930720e-07
GC_15_32 ref NI_15 NS_32 0 7.4279750078277548e-06
GC_15_33 ref NI_15 NS_33 0 -2.5050879242480673e-01
GC_15_34 ref NI_15 NS_34 0 1.4046791581950886e-02
GC_15_35 ref NI_15 NS_35 0 -6.5148671672430755e-02
GC_15_36 ref NI_15 NS_36 0 5.2245606277351316e-02
GC_15_37 ref NI_15 NS_37 0 2.4430768230670238e-02
GC_15_38 ref NI_15 NS_38 0 5.1803911789427852e-04
GC_15_39 ref NI_15 NS_39 0 -2.4141702024453247e-07
GC_15_40 ref NI_15 NS_40 0 9.1981480709521812e-06
GC_15_41 ref NI_15 NS_41 0 -1.9219195069502343e-01
GC_15_42 ref NI_15 NS_42 0 8.9162331717119771e-03
GC_15_43 ref NI_15 NS_43 0 -5.5275857709998558e-02
GC_15_44 ref NI_15 NS_44 0 7.2869098075769301e-02
GC_15_45 ref NI_15 NS_45 0 1.2584885220396854e-02
GC_15_46 ref NI_15 NS_46 0 5.3152223400028940e-04
GC_15_47 ref NI_15 NS_47 0 -2.2467038597437814e-07
GC_15_48 ref NI_15 NS_48 0 6.6138116734142520e-06
GC_15_49 ref NI_15 NS_49 0 -1.6032304692446966e-01
GC_15_50 ref NI_15 NS_50 0 -2.5331182569910238e-02
GC_15_51 ref NI_15 NS_51 0 1.1078987778011730e-02
GC_15_52 ref NI_15 NS_52 0 9.6426962040294287e-02
GC_15_53 ref NI_15 NS_53 0 -1.1797174612991630e-02
GC_15_54 ref NI_15 NS_54 0 4.4656901240215652e-04
GC_15_55 ref NI_15 NS_55 0 -2.5282943156784212e-07
GC_15_56 ref NI_15 NS_56 0 2.8354326531277692e-06
GC_15_57 ref NI_15 NS_57 0 -2.3899775667231557e-01
GC_15_58 ref NI_15 NS_58 0 2.2116953423189416e-02
GC_15_59 ref NI_15 NS_59 0 -5.1448143877407690e-02
GC_15_60 ref NI_15 NS_60 0 4.3571482358310321e-02
GC_15_61 ref NI_15 NS_61 0 2.3860636119852747e-02
GC_15_62 ref NI_15 NS_62 0 3.5557135414269905e-04
GC_15_63 ref NI_15 NS_63 0 -3.5992907188090144e-07
GC_15_64 ref NI_15 NS_64 0 7.4152124723708718e-06
GC_15_65 ref NI_15 NS_65 0 -1.9503978961183627e-01
GC_15_66 ref NI_15 NS_66 0 1.5018843377262741e-02
GC_15_67 ref NI_15 NS_67 0 -4.1333524404792620e-02
GC_15_68 ref NI_15 NS_68 0 2.3985171263574197e-02
GC_15_69 ref NI_15 NS_69 0 3.0595709778515695e-02
GC_15_70 ref NI_15 NS_70 0 6.6226798394939572e-04
GC_15_71 ref NI_15 NS_71 0 -2.3756406264080211e-07
GC_15_72 ref NI_15 NS_72 0 7.2861526191342564e-06
GC_15_73 ref NI_15 NS_73 0 1.6109554018099420e-01
GC_15_74 ref NI_15 NS_74 0 -2.0983958124639525e-02
GC_15_75 ref NI_15 NS_75 0 4.4970843509862468e-02
GC_15_76 ref NI_15 NS_76 0 -6.6818463943191395e-02
GC_15_77 ref NI_15 NS_77 0 4.8986381762885722e-02
GC_15_78 ref NI_15 NS_78 0 2.7034070570161272e-03
GC_15_79 ref NI_15 NS_79 0 2.5419928344794181e-07
GC_15_80 ref NI_15 NS_80 0 5.6137410351749151e-07
GC_15_81 ref NI_15 NS_81 0 -4.2587718957065640e-01
GC_15_82 ref NI_15 NS_82 0 2.7916337272193486e-02
GC_15_83 ref NI_15 NS_83 0 -6.8638318435283840e-02
GC_15_84 ref NI_15 NS_84 0 5.6330818874327143e-02
GC_15_85 ref NI_15 NS_85 0 2.1512852159597369e-02
GC_15_86 ref NI_15 NS_86 0 1.9697093734070476e-04
GC_15_87 ref NI_15 NS_87 0 -1.2121573318588035e-06
GC_15_88 ref NI_15 NS_88 0 3.7101325130761340e-05
GC_15_89 ref NI_15 NS_89 0 -4.9765793768972610e-01
GC_15_90 ref NI_15 NS_90 0 3.2489884122490362e-02
GC_15_91 ref NI_15 NS_91 0 -7.2647491999757521e-02
GC_15_92 ref NI_15 NS_92 0 3.7417056932703474e-02
GC_15_93 ref NI_15 NS_93 0 3.0520915294840783e-02
GC_15_94 ref NI_15 NS_94 0 4.9397389435634612e-04
GC_15_95 ref NI_15 NS_95 0 -8.4154789695445399e-07
GC_15_96 ref NI_15 NS_96 0 1.9917377430363160e-05
GC_15_97 ref NI_15 NS_97 0 -5.0996345500322904e-01
GC_15_98 ref NI_15 NS_98 0 2.3193076539425986e-02
GC_15_99 ref NI_15 NS_99 0 -9.3889510477176391e-02
GC_15_100 ref NI_15 NS_100 0 1.4833424950417831e-01
GC_15_101 ref NI_15 NS_101 0 -1.2271198453838436e-02
GC_15_102 ref NI_15 NS_102 0 -3.3749011601344700e-05
GC_15_103 ref NI_15 NS_103 0 -1.8791563041404398e-06
GC_15_104 ref NI_15 NS_104 0 7.8576684337011674e-06
GC_15_105 ref NI_15 NS_105 0 -6.7496444788964027e-01
GC_15_106 ref NI_15 NS_106 0 4.4194188933107413e-02
GC_15_107 ref NI_15 NS_107 0 -1.1768907345595576e-01
GC_15_108 ref NI_15 NS_108 0 1.1177879736213622e-01
GC_15_109 ref NI_15 NS_109 0 7.8746343334681560e-03
GC_15_110 ref NI_15 NS_110 0 -3.2517675614824401e-05
GC_15_111 ref NI_15 NS_111 0 -2.9509755306662246e-06
GC_15_112 ref NI_15 NS_112 0 3.6162220305081419e-05
GC_15_113 ref NI_15 NS_113 0 8.4834388245963694e+00
GC_15_114 ref NI_15 NS_114 0 -3.0038940370506800e-01
GC_15_115 ref NI_15 NS_115 0 -1.5106572356556255e-01
GC_15_116 ref NI_15 NS_116 0 -6.0926999586676056e-01
GC_15_117 ref NI_15 NS_117 0 -1.0310571222193755e-01
GC_15_118 ref NI_15 NS_118 0 -1.0838312052380627e-02
GC_15_119 ref NI_15 NS_119 0 -1.0007436935247265e-06
GC_15_120 ref NI_15 NS_120 0 -1.7287607614168793e-04
GC_15_121 ref NI_15 NS_121 0 -1.7026882532794760e+00
GC_15_122 ref NI_15 NS_122 0 5.5461820069300234e-02
GC_15_123 ref NI_15 NS_123 0 2.5373303742714015e-01
GC_15_124 ref NI_15 NS_124 0 9.8402019219003004e-02
GC_15_125 ref NI_15 NS_125 0 -9.1339846369028088e-02
GC_15_126 ref NI_15 NS_126 0 -6.5819778341661382e-04
GC_15_127 ref NI_15 NS_127 0 8.3591152055300191e-06
GC_15_128 ref NI_15 NS_128 0 -1.5426025086077273e-05
GD_15_1 ref NI_15 NA_1 0 5.9046785344118051e-02
GD_15_2 ref NI_15 NA_2 0 -1.3523149465809742e-01
GD_15_3 ref NI_15 NA_3 0 1.0273571913500749e-01
GD_15_4 ref NI_15 NA_4 0 2.7066317446559178e-02
GD_15_5 ref NI_15 NA_5 0 3.8220420667578976e-02
GD_15_6 ref NI_15 NA_6 0 3.0086452297480148e-02
GD_15_7 ref NI_15 NA_7 0 3.0060199325836930e-02
GD_15_8 ref NI_15 NA_8 0 3.4744237646540894e-02
GD_15_9 ref NI_15 NA_9 0 2.8332610196078346e-02
GD_15_10 ref NI_15 NA_10 0 -2.4428290543256109e-02
GD_15_11 ref NI_15 NA_11 0 6.6121497066974344e-02
GD_15_12 ref NI_15 NA_12 0 7.7738992047452937e-02
GD_15_13 ref NI_15 NA_13 0 8.1493976474405483e-02
GD_15_14 ref NI_15 NA_14 0 1.0743845964219553e-01
GD_15_15 ref NI_15 NA_15 0 4.8684713945157592e+00
GD_15_16 ref NI_15 NA_16 0 3.1498232527268877e-01
*
* Port 16
VI_16 a_16 NI_16 0
RI_16 NI_16 ref 1.0000000000000001e-01
GC_16_1 ref NI_16 NS_1 0 -3.0466470402090479e-01
GC_16_2 ref NI_16 NS_2 0 -1.8691887489031757e-02
GC_16_3 ref NI_16 NS_3 0 5.7468193944308396e-02
GC_16_4 ref NI_16 NS_4 0 -8.2090529207360791e-02
GC_16_5 ref NI_16 NS_5 0 4.3557931351147883e-02
GC_16_6 ref NI_16 NS_6 0 5.0781894470924172e-03
GC_16_7 ref NI_16 NS_7 0 6.4292370009429532e-07
GC_16_8 ref NI_16 NS_8 0 6.8134851406887980e-05
GC_16_9 ref NI_16 NS_9 0 3.0317581864650056e-01
GC_16_10 ref NI_16 NS_10 0 4.4914113065591586e-02
GC_16_11 ref NI_16 NS_11 0 6.5688122783947034e-02
GC_16_12 ref NI_16 NS_12 0 2.9571706518738389e-02
GC_16_13 ref NI_16 NS_13 0 -6.4823526755213882e-03
GC_16_14 ref NI_16 NS_14 0 3.5561835244142862e-04
GC_16_15 ref NI_16 NS_15 0 -5.0089143576526821e-10
GC_16_16 ref NI_16 NS_16 0 1.3824664639344312e-05
GC_16_17 ref NI_16 NS_17 0 -1.1074932310817220e+00
GC_16_18 ref NI_16 NS_18 0 7.9497309672401442e-02
GC_16_19 ref NI_16 NS_19 0 2.7344518312414640e-01
GC_16_20 ref NI_16 NS_20 0 -1.3413221839757154e-02
GC_16_21 ref NI_16 NS_21 0 -5.0843376289518537e-02
GC_16_22 ref NI_16 NS_22 0 3.7229598021403095e-04
GC_16_23 ref NI_16 NS_23 0 -9.8165727799525817e-08
GC_16_24 ref NI_16 NS_24 0 -9.7262012664686721e-06
GC_16_25 ref NI_16 NS_25 0 -2.8701144752669777e-01
GC_16_26 ref NI_16 NS_26 0 1.8055395383222844e-02
GC_16_27 ref NI_16 NS_27 0 -5.2559544040867316e-02
GC_16_28 ref NI_16 NS_28 0 1.8927390843519035e-02
GC_16_29 ref NI_16 NS_29 0 3.4659104556069520e-02
GC_16_30 ref NI_16 NS_30 0 9.5525927124610823e-04
GC_16_31 ref NI_16 NS_31 0 -3.8559929673940226e-08
GC_16_32 ref NI_16 NS_32 0 1.2622176474676832e-05
GC_16_33 ref NI_16 NS_33 0 -3.7413487074439428e-01
GC_16_34 ref NI_16 NS_34 0 2.0335363707146115e-02
GC_16_35 ref NI_16 NS_35 0 -7.3777862238534941e-02
GC_16_36 ref NI_16 NS_36 0 4.6910034873808210e-02
GC_16_37 ref NI_16 NS_37 0 2.7871700600878943e-02
GC_16_38 ref NI_16 NS_38 0 6.4751523574892774e-04
GC_16_39 ref NI_16 NS_39 0 -1.5104640088066718e-07
GC_16_40 ref NI_16 NS_40 0 1.5626550940193799e-05
GC_16_41 ref NI_16 NS_41 0 -3.0318400119751449e-01
GC_16_42 ref NI_16 NS_42 0 1.5119239064506823e-02
GC_16_43 ref NI_16 NS_43 0 -8.0817696735031266e-02
GC_16_44 ref NI_16 NS_44 0 7.9575600054321224e-02
GC_16_45 ref NI_16 NS_45 0 1.5095656877057311e-02
GC_16_46 ref NI_16 NS_46 0 7.0362968184909877e-04
GC_16_47 ref NI_16 NS_47 0 -1.3759165223118982e-07
GC_16_48 ref NI_16 NS_48 0 1.0802489658458597e-05
GC_16_49 ref NI_16 NS_49 0 -2.6963715738730870e-01
GC_16_50 ref NI_16 NS_50 0 -4.0968111119635851e-02
GC_16_51 ref NI_16 NS_51 0 -2.0743524138065701e-02
GC_16_52 ref NI_16 NS_52 0 1.1765839574799368e-01
GC_16_53 ref NI_16 NS_53 0 -1.0759223110257909e-02
GC_16_54 ref NI_16 NS_54 0 6.0426958349184756e-04
GC_16_55 ref NI_16 NS_55 0 -7.1341625876100936e-07
GC_16_56 ref NI_16 NS_56 0 1.1760729218203724e-05
GC_16_57 ref NI_16 NS_57 0 -3.4358851907291166e-01
GC_16_58 ref NI_16 NS_58 0 3.4037796325676280e-02
GC_16_59 ref NI_16 NS_59 0 -6.3110958193577926e-02
GC_16_60 ref NI_16 NS_60 0 3.9386928651994016e-02
GC_16_61 ref NI_16 NS_61 0 2.6659443822726107e-02
GC_16_62 ref NI_16 NS_62 0 4.6614604258734567e-04
GC_16_63 ref NI_16 NS_63 0 -2.2328749105099587e-07
GC_16_64 ref NI_16 NS_64 0 1.4358343010026446e-05
GC_16_65 ref NI_16 NS_65 0 -2.9156719579740670e-01
GC_16_66 ref NI_16 NS_66 0 2.2844748980710150e-02
GC_16_67 ref NI_16 NS_67 0 -4.8167860100224558e-02
GC_16_68 ref NI_16 NS_68 0 1.7220815069518940e-02
GC_16_69 ref NI_16 NS_69 0 3.3765796097267577e-02
GC_16_70 ref NI_16 NS_70 0 8.4735050022315779e-04
GC_16_71 ref NI_16 NS_71 0 -6.3101352390376743e-08
GC_16_72 ref NI_16 NS_72 0 1.2099653592731361e-05
GC_16_73 ref NI_16 NS_73 0 1.2716838002837499e-01
GC_16_74 ref NI_16 NS_74 0 -2.2634760592027139e-02
GC_16_75 ref NI_16 NS_75 0 5.1447063298528738e-02
GC_16_76 ref NI_16 NS_76 0 -7.6913988865300070e-02
GC_16_77 ref NI_16 NS_77 0 5.0791609593526882e-02
GC_16_78 ref NI_16 NS_78 0 3.1375472404510212e-03
GC_16_79 ref NI_16 NS_79 0 3.6985192700631134e-07
GC_16_80 ref NI_16 NS_80 0 4.4947043133748038e-06
GC_16_81 ref NI_16 NS_81 0 -5.0911656351871626e-01
GC_16_82 ref NI_16 NS_82 0 3.3025242397346881e-02
GC_16_83 ref NI_16 NS_83 0 -6.9613197470353771e-02
GC_16_84 ref NI_16 NS_84 0 5.2476709184869651e-02
GC_16_85 ref NI_16 NS_85 0 2.2875479115752169e-02
GC_16_86 ref NI_16 NS_86 0 2.9960144727963025e-04
GC_16_87 ref NI_16 NS_87 0 -2.3625103984815565e-06
GC_16_88 ref NI_16 NS_88 0 3.6537255983585958e-05
GC_16_89 ref NI_16 NS_89 0 -5.7312199030667799e-01
GC_16_90 ref NI_16 NS_90 0 3.7024816252336730e-02
GC_16_91 ref NI_16 NS_91 0 -6.9686415057572088e-02
GC_16_92 ref NI_16 NS_92 0 2.8339798894298704e-02
GC_16_93 ref NI_16 NS_93 0 3.2805733561731110e-02
GC_16_94 ref NI_16 NS_94 0 5.8706077728153659e-04
GC_16_95 ref NI_16 NS_95 0 -4.4158324441956944e-07
GC_16_96 ref NI_16 NS_96 0 2.1344270040190588e-05
GC_16_97 ref NI_16 NS_97 0 -4.7555325236786256e-01
GC_16_98 ref NI_16 NS_98 0 2.9451664328107488e-02
GC_16_99 ref NI_16 NS_99 0 6.7199026755137411e-03
GC_16_100 ref NI_16 NS_100 0 1.0488233862105761e-01
GC_16_101 ref NI_16 NS_101 0 -2.0010636670002295e-02
GC_16_102 ref NI_16 NS_102 0 -4.2166027250432864e-04
GC_16_103 ref NI_16 NS_103 0 -4.5863325094816878e-06
GC_16_104 ref NI_16 NS_104 0 3.2940068858338254e-05
GC_16_105 ref NI_16 NS_105 0 -8.1742673244185626e-01
GC_16_106 ref NI_16 NS_106 0 5.0703498253673727e-02
GC_16_107 ref NI_16 NS_107 0 -1.0823514031055759e-01
GC_16_108 ref NI_16 NS_108 0 1.1039378132927735e-01
GC_16_109 ref NI_16 NS_109 0 4.5451945565632796e-03
GC_16_110 ref NI_16 NS_110 0 -4.8586055734709276e-06
GC_16_111 ref NI_16 NS_111 0 -3.9388734686534372e-06
GC_16_112 ref NI_16 NS_112 0 4.7277475882031259e-05
GC_16_113 ref NI_16 NS_113 0 -1.7026882532794760e+00
GC_16_114 ref NI_16 NS_114 0 5.5461820069300248e-02
GC_16_115 ref NI_16 NS_115 0 2.5373303742714015e-01
GC_16_116 ref NI_16 NS_116 0 9.8402019219003045e-02
GC_16_117 ref NI_16 NS_117 0 -9.1339846369028088e-02
GC_16_118 ref NI_16 NS_118 0 -6.5819778341661003e-04
GC_16_119 ref NI_16 NS_119 0 8.3591152055309610e-06
GC_16_120 ref NI_16 NS_120 0 -1.5426025086078510e-05
GC_16_121 ref NI_16 NS_121 0 9.3206630987373202e+00
GC_16_122 ref NI_16 NS_122 0 -3.5929877033389401e-01
GC_16_123 ref NI_16 NS_123 0 -1.1884350844432921e-01
GC_16_124 ref NI_16 NS_124 0 -5.7121238415233999e-01
GC_16_125 ref NI_16 NS_125 0 -1.1315267369062754e-01
GC_16_126 ref NI_16 NS_126 0 -1.2966555154787415e-02
GC_16_127 ref NI_16 NS_127 0 3.5139294866371568e-06
GC_16_128 ref NI_16 NS_128 0 -2.7804573788625626e-04
GD_16_1 ref NI_16 NA_1 0 5.5501379891744904e-02
GD_16_2 ref NI_16 NA_2 0 -6.4108673680550496e-02
GD_16_3 ref NI_16 NA_3 0 2.0178297254970573e-01
GD_16_4 ref NI_16 NA_4 0 4.4247886549703956e-02
GD_16_5 ref NI_16 NA_5 0 5.7990194260042614e-02
GD_16_6 ref NI_16 NA_6 0 4.8136920152113682e-02
GD_16_7 ref NI_16 NA_7 0 4.8140067064881865e-02
GD_16_8 ref NI_16 NA_8 0 5.2354928548402437e-02
GD_16_9 ref NI_16 NA_9 0 4.4470654161844973e-02
GD_16_10 ref NI_16 NA_10 0 -1.8013308795973258e-02
GD_16_11 ref NI_16 NA_11 0 8.0632535666696245e-02
GD_16_12 ref NI_16 NA_12 0 9.0463787799791501e-02
GD_16_13 ref NI_16 NA_13 0 8.2905821300920501e-02
GD_16_14 ref NI_16 NA_14 0 1.3336214563764243e-01
GD_16_15 ref NI_16 NA_15 0 3.1498232527268877e-01
GD_16_16 ref NI_16 NA_16 0 4.7169424778945901e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
* Impinging wave, port 16
RA_16 NA_16 0 1.5811388300841897e-01
FA_16 0 NA_16 VI_16 1.0
GA_16 0 NA_16 a_16 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 1.7730407554537825e-02
GS_1_1 0 NS_1 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 3.7522380818405299e-01
GS_2_1 0 NS_2 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 6.5564245977207458e-01
GS_3_1 0 NS_3 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 1.0885964058211799e+00
GS_4_1 0 NS_4 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 2.2749165713500892e+00
GS_5_1 0 NS_5 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 6.3185103247837020e+00
GS_6_1 0 NS_6 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 7.2761079693302304e+02
GS_7_1 0 NS_7 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 7.3569671455008603e+01
GS_8_1 0 NS_8 NA_1 0 9.8478438040782823e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 1.7730407554537825e-02
GS_9_2 0 NS_9 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 3.7522380818405299e-01
GS_10_2 0 NS_10 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 6.5564245977207458e-01
GS_11_2 0 NS_11 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 1.0885964058211799e+00
GS_12_2 0 NS_12 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 2.2749165713500892e+00
GS_13_2 0 NS_13 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 6.3185103247837020e+00
GS_14_2 0 NS_14 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 7.2761079693302304e+02
GS_15_2 0 NS_15 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 7.3569671455008603e+01
GS_16_2 0 NS_16 NA_2 0 9.8478438040782823e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 1.7730407554537825e-02
GS_17_3 0 NS_17 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 3.7522380818405299e-01
GS_18_3 0 NS_18 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 6.5564245977207458e-01
GS_19_3 0 NS_19 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 1.0885964058211799e+00
GS_20_3 0 NS_20 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 2.2749165713500892e+00
GS_21_3 0 NS_21 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 6.3185103247837020e+00
GS_22_3 0 NS_22 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 7.2761079693302304e+02
GS_23_3 0 NS_23 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 7.3569671455008603e+01
GS_24_3 0 NS_24 NA_3 0 9.8478438040782823e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 1.7730407554537825e-02
GS_25_4 0 NS_25 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 3.7522380818405299e-01
GS_26_4 0 NS_26 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 6.5564245977207458e-01
GS_27_4 0 NS_27 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 1.0885964058211799e+00
GS_28_4 0 NS_28 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 2.2749165713500892e+00
GS_29_4 0 NS_29 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 6.3185103247837020e+00
GS_30_4 0 NS_30 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 7.2761079693302304e+02
GS_31_4 0 NS_31 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 7.3569671455008603e+01
GS_32_4 0 NS_32 NA_4 0 9.8478438040782823e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 1.7730407554537825e-02
GS_33_5 0 NS_33 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 3.7522380818405299e-01
GS_34_5 0 NS_34 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 6.5564245977207458e-01
GS_35_5 0 NS_35 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 1.0885964058211799e+00
GS_36_5 0 NS_36 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 2.2749165713500892e+00
GS_37_5 0 NS_37 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 6.3185103247837020e+00
GS_38_5 0 NS_38 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 7.2761079693302304e+02
GS_39_5 0 NS_39 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 7.3569671455008603e+01
GS_40_5 0 NS_40 NA_5 0 9.8478438040782823e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 1.7730407554537825e-02
GS_41_6 0 NS_41 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 3.7522380818405299e-01
GS_42_6 0 NS_42 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 6.5564245977207458e-01
GS_43_6 0 NS_43 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 1.0885964058211799e+00
GS_44_6 0 NS_44 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 2.2749165713500892e+00
GS_45_6 0 NS_45 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 6.3185103247837020e+00
GS_46_6 0 NS_46 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 7.2761079693302304e+02
GS_47_6 0 NS_47 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 7.3569671455008603e+01
GS_48_6 0 NS_48 NA_6 0 9.8478438040782823e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 1.7730407554537825e-02
GS_49_7 0 NS_49 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 3.7522380818405299e-01
GS_50_7 0 NS_50 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 6.5564245977207458e-01
GS_51_7 0 NS_51 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 1.0885964058211799e+00
GS_52_7 0 NS_52 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 2.2749165713500892e+00
GS_53_7 0 NS_53 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 6.3185103247837020e+00
GS_54_7 0 NS_54 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 7.2761079693302304e+02
GS_55_7 0 NS_55 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 7.3569671455008603e+01
GS_56_7 0 NS_56 NA_7 0 9.8478438040782823e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 1.7730407554537825e-02
GS_57_8 0 NS_57 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 3.7522380818405299e-01
GS_58_8 0 NS_58 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 6.5564245977207458e-01
GS_59_8 0 NS_59 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 1.0885964058211799e+00
GS_60_8 0 NS_60 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 2.2749165713500892e+00
GS_61_8 0 NS_61 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 6.3185103247837020e+00
GS_62_8 0 NS_62 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 7.2761079693302304e+02
GS_63_8 0 NS_63 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 7.3569671455008603e+01
GS_64_8 0 NS_64 NA_8 0 9.8478438040782823e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 1.7730407554537825e-02
GS_65_9 0 NS_65 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 3.7522380818405299e-01
GS_66_9 0 NS_66 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 6.5564245977207458e-01
GS_67_9 0 NS_67 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 1.0885964058211799e+00
GS_68_9 0 NS_68 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 2.2749165713500892e+00
GS_69_9 0 NS_69 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 6.3185103247837020e+00
GS_70_9 0 NS_70 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 7.2761079693302304e+02
GS_71_9 0 NS_71 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 7.3569671455008603e+01
GS_72_9 0 NS_72 NA_9 0 9.8478438040782823e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 1.7730407554537825e-02
GS_73_10 0 NS_73 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 3.7522380818405299e-01
GS_74_10 0 NS_74 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 6.5564245977207458e-01
GS_75_10 0 NS_75 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 1.0885964058211799e+00
GS_76_10 0 NS_76 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 2.2749165713500892e+00
GS_77_10 0 NS_77 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 6.3185103247837020e+00
GS_78_10 0 NS_78 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 79
CS_79 NS_79 0 1.0000000000000001e-09
RS_79 NS_79 0 7.2761079693302304e+02
GS_79_10 0 NS_79 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 80
CS_80 NS_80 0 1.0000000000000001e-09
RS_80 NS_80 0 7.3569671455008603e+01
GS_80_10 0 NS_80 NA_10 0 9.8478438040782823e+00
*
* Real pole n. 81
CS_81 NS_81 0 1.0000000000000001e-09
RS_81 NS_81 0 1.7730407554537825e-02
GS_81_11 0 NS_81 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 82
CS_82 NS_82 0 1.0000000000000001e-09
RS_82 NS_82 0 3.7522380818405299e-01
GS_82_11 0 NS_82 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 83
CS_83 NS_83 0 1.0000000000000001e-09
RS_83 NS_83 0 6.5564245977207458e-01
GS_83_11 0 NS_83 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 84
CS_84 NS_84 0 1.0000000000000001e-09
RS_84 NS_84 0 1.0885964058211799e+00
GS_84_11 0 NS_84 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 85
CS_85 NS_85 0 1.0000000000000001e-09
RS_85 NS_85 0 2.2749165713500892e+00
GS_85_11 0 NS_85 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 86
CS_86 NS_86 0 1.0000000000000001e-09
RS_86 NS_86 0 6.3185103247837020e+00
GS_86_11 0 NS_86 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 87
CS_87 NS_87 0 1.0000000000000001e-09
RS_87 NS_87 0 7.2761079693302304e+02
GS_87_11 0 NS_87 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 88
CS_88 NS_88 0 1.0000000000000001e-09
RS_88 NS_88 0 7.3569671455008603e+01
GS_88_11 0 NS_88 NA_11 0 9.8478438040782823e+00
*
* Real pole n. 89
CS_89 NS_89 0 1.0000000000000001e-09
RS_89 NS_89 0 1.7730407554537825e-02
GS_89_12 0 NS_89 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 90
CS_90 NS_90 0 1.0000000000000001e-09
RS_90 NS_90 0 3.7522380818405299e-01
GS_90_12 0 NS_90 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 91
CS_91 NS_91 0 1.0000000000000001e-09
RS_91 NS_91 0 6.5564245977207458e-01
GS_91_12 0 NS_91 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 92
CS_92 NS_92 0 1.0000000000000001e-09
RS_92 NS_92 0 1.0885964058211799e+00
GS_92_12 0 NS_92 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 93
CS_93 NS_93 0 1.0000000000000001e-09
RS_93 NS_93 0 2.2749165713500892e+00
GS_93_12 0 NS_93 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 94
CS_94 NS_94 0 1.0000000000000001e-09
RS_94 NS_94 0 6.3185103247837020e+00
GS_94_12 0 NS_94 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 95
CS_95 NS_95 0 1.0000000000000001e-09
RS_95 NS_95 0 7.2761079693302304e+02
GS_95_12 0 NS_95 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 96
CS_96 NS_96 0 1.0000000000000001e-09
RS_96 NS_96 0 7.3569671455008603e+01
GS_96_12 0 NS_96 NA_12 0 9.8478438040782823e+00
*
* Real pole n. 97
CS_97 NS_97 0 1.0000000000000001e-09
RS_97 NS_97 0 1.7730407554537825e-02
GS_97_13 0 NS_97 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 98
CS_98 NS_98 0 1.0000000000000001e-09
RS_98 NS_98 0 3.7522380818405299e-01
GS_98_13 0 NS_98 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 99
CS_99 NS_99 0 1.0000000000000001e-09
RS_99 NS_99 0 6.5564245977207458e-01
GS_99_13 0 NS_99 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 100
CS_100 NS_100 0 1.0000000000000001e-09
RS_100 NS_100 0 1.0885964058211799e+00
GS_100_13 0 NS_100 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 101
CS_101 NS_101 0 1.0000000000000001e-09
RS_101 NS_101 0 2.2749165713500892e+00
GS_101_13 0 NS_101 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 102
CS_102 NS_102 0 1.0000000000000001e-09
RS_102 NS_102 0 6.3185103247837020e+00
GS_102_13 0 NS_102 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 103
CS_103 NS_103 0 1.0000000000000001e-09
RS_103 NS_103 0 7.2761079693302304e+02
GS_103_13 0 NS_103 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 104
CS_104 NS_104 0 1.0000000000000001e-09
RS_104 NS_104 0 7.3569671455008603e+01
GS_104_13 0 NS_104 NA_13 0 9.8478438040782823e+00
*
* Real pole n. 105
CS_105 NS_105 0 1.0000000000000001e-09
RS_105 NS_105 0 1.7730407554537825e-02
GS_105_14 0 NS_105 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 106
CS_106 NS_106 0 1.0000000000000001e-09
RS_106 NS_106 0 3.7522380818405299e-01
GS_106_14 0 NS_106 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 107
CS_107 NS_107 0 1.0000000000000001e-09
RS_107 NS_107 0 6.5564245977207458e-01
GS_107_14 0 NS_107 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 108
CS_108 NS_108 0 1.0000000000000001e-09
RS_108 NS_108 0 1.0885964058211799e+00
GS_108_14 0 NS_108 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 109
CS_109 NS_109 0 1.0000000000000001e-09
RS_109 NS_109 0 2.2749165713500892e+00
GS_109_14 0 NS_109 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 110
CS_110 NS_110 0 1.0000000000000001e-09
RS_110 NS_110 0 6.3185103247837020e+00
GS_110_14 0 NS_110 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 111
CS_111 NS_111 0 1.0000000000000001e-09
RS_111 NS_111 0 7.2761079693302304e+02
GS_111_14 0 NS_111 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 112
CS_112 NS_112 0 1.0000000000000001e-09
RS_112 NS_112 0 7.3569671455008603e+01
GS_112_14 0 NS_112 NA_14 0 9.8478438040782823e+00
*
* Real pole n. 113
CS_113 NS_113 0 1.0000000000000001e-09
RS_113 NS_113 0 1.7730407554537825e-02
GS_113_15 0 NS_113 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 114
CS_114 NS_114 0 1.0000000000000001e-09
RS_114 NS_114 0 3.7522380818405299e-01
GS_114_15 0 NS_114 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 115
CS_115 NS_115 0 1.0000000000000001e-09
RS_115 NS_115 0 6.5564245977207458e-01
GS_115_15 0 NS_115 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 116
CS_116 NS_116 0 1.0000000000000001e-09
RS_116 NS_116 0 1.0885964058211799e+00
GS_116_15 0 NS_116 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 117
CS_117 NS_117 0 1.0000000000000001e-09
RS_117 NS_117 0 2.2749165713500892e+00
GS_117_15 0 NS_117 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 118
CS_118 NS_118 0 1.0000000000000001e-09
RS_118 NS_118 0 6.3185103247837020e+00
GS_118_15 0 NS_118 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 119
CS_119 NS_119 0 1.0000000000000001e-09
RS_119 NS_119 0 7.2761079693302304e+02
GS_119_15 0 NS_119 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 120
CS_120 NS_120 0 1.0000000000000001e-09
RS_120 NS_120 0 7.3569671455008603e+01
GS_120_15 0 NS_120 NA_15 0 9.8478438040782823e+00
*
* Real pole n. 121
CS_121 NS_121 0 1.0000000000000001e-09
RS_121 NS_121 0 1.7730407554537825e-02
GS_121_16 0 NS_121 NA_16 0 9.8478438040782823e+00
*
* Real pole n. 122
CS_122 NS_122 0 1.0000000000000001e-09
RS_122 NS_122 0 3.7522380818405299e-01
GS_122_16 0 NS_122 NA_16 0 9.8478438040782823e+00
*
* Real pole n. 123
CS_123 NS_123 0 1.0000000000000001e-09
RS_123 NS_123 0 6.5564245977207458e-01
GS_123_16 0 NS_123 NA_16 0 9.8478438040782823e+00
*
* Real pole n. 124
CS_124 NS_124 0 1.0000000000000001e-09
RS_124 NS_124 0 1.0885964058211799e+00
GS_124_16 0 NS_124 NA_16 0 9.8478438040782823e+00
*
* Real pole n. 125
CS_125 NS_125 0 1.0000000000000001e-09
RS_125 NS_125 0 2.2749165713500892e+00
GS_125_16 0 NS_125 NA_16 0 9.8478438040782823e+00
*
* Real pole n. 126
CS_126 NS_126 0 1.0000000000000001e-09
RS_126 NS_126 0 6.3185103247837020e+00
GS_126_16 0 NS_126 NA_16 0 9.8478438040782823e+00
*
* Real pole n. 127
CS_127 NS_127 0 1.0000000000000001e-09
RS_127 NS_127 0 7.2761079693302304e+02
GS_127_16 0 NS_127 NA_16 0 9.8478438040782823e+00
*
* Real pole n. 128
CS_128 NS_128 0 1.0000000000000001e-09
RS_128 NS_128 0 7.3569671455008603e+01
GS_128_16 0 NS_128 NA_16 0 9.8478438040782823e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
