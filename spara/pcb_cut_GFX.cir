**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 22-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Tue Apr 22 09:41:47 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Tue Apr 22 09:41:47 2025
**
**  Modal data exported
**  Port[1] = PORT_3_L27_SOC_VGPU_Group_U41_GND_Group
**  Port[2] = PORT_4_U1_SOC_VGPU_Group_U1_GRP_1_0_GND
**  Port[3] = SOC_VGPU_C458_1
**  Port[4] = SOC_VGPU_C459_1
**  Port[5] = SOC_VGPU_C460_1
**  Port[6] = SOC_VGPU_C461_1
**  Port[7] = SOC_VGPU_C462_1
**  Port[8] = SOC_VGPU_C463_1
**  Port[9] = SOC_VGPU_C551_1
**  Port[10] = SOC_VGPU_C551_3
**  Port[11] = SOC_VGPU_C552_1
**  Port[12] = SOC_VGPU_C552_3
**  Port[13] = SOC_VGPU_C553_1
**  Port[14] = SOC_VGPU_C553_3
**  Port[15] = SOC_VGPU_C645_1
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_GFX
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 1.9325665813565744e+00
GC_1_2 ref NI_1 NS_2 0 -1.6772772416733501e+00
GC_1_3 ref NI_1 NS_3 0 -2.5098055440876726e-01
GC_1_4 ref NI_1 NS_4 0 -1.1337363341601239e+00
GC_1_5 ref NI_1 NS_5 0 -8.8326113079446406e-02
GC_1_6 ref NI_1 NS_6 0 -2.9325894053188794e-03
GC_1_7 ref NI_1 NS_7 0 1.7778316317141180e-02
GC_1_8 ref NI_1 NS_8 0 1.6938799658635179e-01
GC_1_9 ref NI_1 NS_9 0 6.5526820135602428e-04
GC_1_10 ref NI_1 NS_10 0 7.6377817155971556e-02
GC_1_11 ref NI_1 NS_11 0 4.9021303652586482e-03
GC_1_12 ref NI_1 NS_12 0 2.5599255127961720e-04
GC_1_13 ref NI_1 NS_13 0 -1.3066175557064047e-01
GC_1_14 ref NI_1 NS_14 0 1.6625885715914190e-01
GC_1_15 ref NI_1 NS_15 0 -6.1578722959885449e-04
GC_1_16 ref NI_1 NS_16 0 8.2919616976444663e-02
GC_1_17 ref NI_1 NS_17 0 6.0473603714442502e-03
GC_1_18 ref NI_1 NS_18 0 2.1824055300184866e-04
GC_1_19 ref NI_1 NS_19 0 -1.0389187347274483e-01
GC_1_20 ref NI_1 NS_20 0 1.1087669111692995e-01
GC_1_21 ref NI_1 NS_21 0 3.0523101891080449e-02
GC_1_22 ref NI_1 NS_22 0 7.9510070673027483e-02
GC_1_23 ref NI_1 NS_23 0 5.5265349543400779e-03
GC_1_24 ref NI_1 NS_24 0 2.1245271173945702e-04
GC_1_25 ref NI_1 NS_25 0 -1.1432007762687625e-01
GC_1_26 ref NI_1 NS_26 0 1.7060427394829158e-01
GC_1_27 ref NI_1 NS_27 0 6.4426681153718190e-02
GC_1_28 ref NI_1 NS_28 0 5.5551600608667304e-02
GC_1_29 ref NI_1 NS_29 0 4.5515231209217553e-03
GC_1_30 ref NI_1 NS_30 0 2.0760683170007141e-04
GC_1_31 ref NI_1 NS_31 0 -2.8329609306760067e-02
GC_1_32 ref NI_1 NS_32 0 1.2968164689489917e-01
GC_1_33 ref NI_1 NS_33 0 8.2986202668081321e-02
GC_1_34 ref NI_1 NS_34 0 5.0383523566139322e-02
GC_1_35 ref NI_1 NS_35 0 3.7375074247105360e-03
GC_1_36 ref NI_1 NS_36 0 2.0765640250880197e-04
GC_1_37 ref NI_1 NS_37 0 -1.1628281021090951e-01
GC_1_38 ref NI_1 NS_38 0 -2.7819977866944415e-02
GC_1_39 ref NI_1 NS_39 0 1.1334857894957548e-01
GC_1_40 ref NI_1 NS_40 0 7.0074455789281592e-02
GC_1_41 ref NI_1 NS_41 0 4.7503893002222939e-03
GC_1_42 ref NI_1 NS_42 0 2.2105771254076576e-04
GC_1_43 ref NI_1 NS_43 0 -8.7039669490003649e-02
GC_1_44 ref NI_1 NS_44 0 1.1249862920751579e-01
GC_1_45 ref NI_1 NS_45 0 1.0080540766626349e-01
GC_1_46 ref NI_1 NS_46 0 4.8703556263942856e-02
GC_1_47 ref NI_1 NS_47 0 3.9960795581225218e-03
GC_1_48 ref NI_1 NS_48 0 2.0211851401545240e-04
GC_1_49 ref NI_1 NS_49 0 -8.8903899014473459e-02
GC_1_50 ref NI_1 NS_50 0 6.8973760201082007e-02
GC_1_51 ref NI_1 NS_51 0 -8.7251642426201148e-02
GC_1_52 ref NI_1 NS_52 0 1.3936409993771662e-01
GC_1_53 ref NI_1 NS_53 0 6.7004550996687118e-03
GC_1_54 ref NI_1 NS_54 0 2.0684674194552767e-04
GC_1_55 ref NI_1 NS_55 0 -1.1405020586468156e-01
GC_1_56 ref NI_1 NS_56 0 7.4656507621983170e-02
GC_1_57 ref NI_1 NS_57 0 -1.5316699383989002e-01
GC_1_58 ref NI_1 NS_58 0 1.6387346122659183e-01
GC_1_59 ref NI_1 NS_59 0 8.8813586060150010e-03
GC_1_60 ref NI_1 NS_60 0 2.1636870436846008e-04
GC_1_61 ref NI_1 NS_61 0 -1.4204171831315493e-01
GC_1_62 ref NI_1 NS_62 0 1.3308308847152953e-01
GC_1_63 ref NI_1 NS_63 0 -1.6709136437793365e-01
GC_1_64 ref NI_1 NS_64 0 1.5902686556367182e-01
GC_1_65 ref NI_1 NS_65 0 9.3750638652343125e-03
GC_1_66 ref NI_1 NS_66 0 2.1892956389263037e-04
GC_1_67 ref NI_1 NS_67 0 -1.4218906460072553e-01
GC_1_68 ref NI_1 NS_68 0 1.1384611229556865e-01
GC_1_69 ref NI_1 NS_69 0 -1.7511748933460924e-01
GC_1_70 ref NI_1 NS_70 0 1.6468039173238164e-01
GC_1_71 ref NI_1 NS_71 0 9.8042215362501503e-03
GC_1_72 ref NI_1 NS_72 0 2.2314011211065345e-04
GC_1_73 ref NI_1 NS_73 0 -1.6468133022701398e-01
GC_1_74 ref NI_1 NS_74 0 1.6243086020251182e-01
GC_1_75 ref NI_1 NS_75 0 -1.8628585600505734e-01
GC_1_76 ref NI_1 NS_76 0 1.6013361524833339e-01
GC_1_77 ref NI_1 NS_77 0 1.0387552861638824e-02
GC_1_78 ref NI_1 NS_78 0 2.1836600214517757e-04
GC_1_79 ref NI_1 NS_79 0 -1.6428218653948440e-01
GC_1_80 ref NI_1 NS_80 0 1.4042105480275438e-01
GC_1_81 ref NI_1 NS_81 0 -2.0433904925410015e-01
GC_1_82 ref NI_1 NS_82 0 1.7160560332369557e-01
GC_1_83 ref NI_1 NS_83 0 1.0926717819319098e-02
GC_1_84 ref NI_1 NS_84 0 2.1410440704556157e-04
GC_1_85 ref NI_1 NS_85 0 -1.5452966404309539e-02
GC_1_86 ref NI_1 NS_86 0 -2.9099740996109156e-02
GC_1_87 ref NI_1 NS_87 0 8.6158621575472538e-01
GC_1_88 ref NI_1 NS_88 0 -2.8483142968428538e-01
GC_1_89 ref NI_1 NS_89 0 -6.6278001745307983e-03
GC_1_90 ref NI_1 NS_90 0 5.3618020764131206e-04
GD_1_1 ref NI_1 NA_1 0 5.8821286324309767e+00
GD_1_2 ref NI_1 NA_2 0 -3.7461759006322116e-03
GD_1_3 ref NI_1 NA_3 0 2.0541483788929570e-02
GD_1_4 ref NI_1 NA_4 0 1.6826153039675371e-02
GD_1_5 ref NI_1 NA_5 0 2.0368799818057687e-02
GD_1_6 ref NI_1 NA_6 0 1.8014581271787667e-02
GD_1_7 ref NI_1 NA_7 0 1.6887625949362741e-02
GD_1_8 ref NI_1 NA_8 0 2.0104896014060149e-02
GD_1_9 ref NI_1 NA_9 0 1.6371365073705069e-02
GD_1_10 ref NI_1 NA_10 0 1.7168938566001820e-02
GD_1_11 ref NI_1 NA_11 0 1.9999689043709724e-02
GD_1_12 ref NI_1 NA_12 0 1.9527718619251580e-02
GD_1_13 ref NI_1 NA_13 0 2.1898767838031411e-02
GD_1_14 ref NI_1 NA_14 0 2.0729527681449183e-02
GD_1_15 ref NI_1 NA_15 0 5.8750286923879957e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 1.7778316317140622e-02
GC_2_2 ref NI_2 NS_2 0 1.6938799658635265e-01
GC_2_3 ref NI_2 NS_3 0 6.5526820135519497e-04
GC_2_4 ref NI_2 NS_4 0 7.6377817155972055e-02
GC_2_5 ref NI_2 NS_5 0 4.9021303652585294e-03
GC_2_6 ref NI_2 NS_6 0 2.5599255127962582e-04
GC_2_7 ref NI_2 NS_7 0 6.5716423339677421e+00
GC_2_8 ref NI_2 NS_8 0 -1.1319865007116945e+01
GC_2_9 ref NI_2 NS_9 0 9.8646442406547102e-02
GC_2_10 ref NI_2 NS_10 0 -1.5511775810033718e-01
GC_2_11 ref NI_2 NS_11 0 -1.5545715083312591e-03
GC_2_12 ref NI_2 NS_12 0 -2.3020178176385363e-04
GC_2_13 ref NI_2 NS_13 0 2.3025890267792123e-01
GC_2_14 ref NI_2 NS_14 0 5.6023053527891031e-01
GC_2_15 ref NI_2 NS_15 0 5.7187823880401813e-02
GC_2_16 ref NI_2 NS_16 0 -8.9216321918088367e-03
GC_2_17 ref NI_2 NS_17 0 -4.8551222212420782e-04
GC_2_18 ref NI_2 NS_18 0 4.0259699082015260e-05
GC_2_19 ref NI_2 NS_19 0 1.8799044650479910e-01
GC_2_20 ref NI_2 NS_20 0 5.5942460196597676e-01
GC_2_21 ref NI_2 NS_21 0 1.0503805953947352e-01
GC_2_22 ref NI_2 NS_22 0 -2.9174611246288656e-02
GC_2_23 ref NI_2 NS_23 0 -2.1692377344558435e-04
GC_2_24 ref NI_2 NS_24 0 3.3900498259880380e-05
GC_2_25 ref NI_2 NS_25 0 2.4617770241254852e-01
GC_2_26 ref NI_2 NS_26 0 5.2959323048121543e-01
GC_2_27 ref NI_2 NS_27 0 1.2206839236605005e-01
GC_2_28 ref NI_2 NS_28 0 -3.5689298516880401e-02
GC_2_29 ref NI_2 NS_29 0 -2.4811028004613099e-04
GC_2_30 ref NI_2 NS_30 0 3.2454341123514748e-05
GC_2_31 ref NI_2 NS_31 0 -1.9480898925439694e-01
GC_2_32 ref NI_2 NS_32 0 7.3662716022463481e-01
GC_2_33 ref NI_2 NS_33 0 1.9591611062548431e-01
GC_2_34 ref NI_2 NS_34 0 -8.4304456897278099e-02
GC_2_35 ref NI_2 NS_35 0 9.2712819448691186e-04
GC_2_36 ref NI_2 NS_36 0 1.0208939663618142e-05
GC_2_37 ref NI_2 NS_37 0 3.7827101386208295e-01
GC_2_38 ref NI_2 NS_38 0 9.0282310928511000e-01
GC_2_39 ref NI_2 NS_39 0 -1.5221597605096896e-02
GC_2_40 ref NI_2 NS_40 0 -5.2218373537168197e-02
GC_2_41 ref NI_2 NS_41 0 -3.1424663245939157e-04
GC_2_42 ref NI_2 NS_42 0 2.9781928421437709e-05
GC_2_43 ref NI_2 NS_43 0 2.2769291524562746e-01
GC_2_44 ref NI_2 NS_44 0 1.2017565168031257e+00
GC_2_45 ref NI_2 NS_45 0 -1.2102567927175294e-01
GC_2_46 ref NI_2 NS_46 0 -4.4619584963026267e-02
GC_2_47 ref NI_2 NS_47 0 -7.8148711230032278e-04
GC_2_48 ref NI_2 NS_48 0 2.2097773164787881e-05
GC_2_49 ref NI_2 NS_49 0 1.0848862850130223e-01
GC_2_50 ref NI_2 NS_50 0 3.9702898195166453e-01
GC_2_51 ref NI_2 NS_51 0 1.5583799948695609e-01
GC_2_52 ref NI_2 NS_52 0 -1.9957242698467301e-02
GC_2_53 ref NI_2 NS_53 0 -4.5668614716000742e-04
GC_2_54 ref NI_2 NS_54 0 3.7799244833710782e-05
GC_2_55 ref NI_2 NS_55 0 1.1730085376544087e-01
GC_2_56 ref NI_2 NS_56 0 4.2826981201479969e-01
GC_2_57 ref NI_2 NS_57 0 9.6711045638116777e-02
GC_2_58 ref NI_2 NS_58 0 3.6668758371900703e-04
GC_2_59 ref NI_2 NS_59 0 -3.0258513530112162e-04
GC_2_60 ref NI_2 NS_60 0 5.0709744436642727e-05
GC_2_61 ref NI_2 NS_61 0 1.4623270295319082e-01
GC_2_62 ref NI_2 NS_62 0 5.2447691992288992e-01
GC_2_63 ref NI_2 NS_63 0 6.4678881869545790e-02
GC_2_64 ref NI_2 NS_64 0 -3.6716204282309117e-03
GC_2_65 ref NI_2 NS_65 0 -3.9533907939561815e-04
GC_2_66 ref NI_2 NS_66 0 4.1266681446493900e-05
GC_2_67 ref NI_2 NS_67 0 5.6085882655045743e-02
GC_2_68 ref NI_2 NS_68 0 5.4060376867980819e-01
GC_2_69 ref NI_2 NS_69 0 6.1128729578981786e-02
GC_2_70 ref NI_2 NS_70 0 1.1219283055728638e-03
GC_2_71 ref NI_2 NS_71 0 -4.9013921685779811e-04
GC_2_72 ref NI_2 NS_72 0 4.7185488590358957e-05
GC_2_73 ref NI_2 NS_73 0 1.5480973724393896e-01
GC_2_74 ref NI_2 NS_74 0 5.8309433133151600e-01
GC_2_75 ref NI_2 NS_75 0 7.1930268854511724e-03
GC_2_76 ref NI_2 NS_76 0 1.2013149680040970e-02
GC_2_77 ref NI_2 NS_77 0 -3.7115722699805962e-04
GC_2_78 ref NI_2 NS_78 0 4.4050680083234980e-05
GC_2_79 ref NI_2 NS_79 0 3.2047957076935373e-03
GC_2_80 ref NI_2 NS_80 0 3.3505998652353597e-01
GC_2_81 ref NI_2 NS_81 0 1.0209673400879106e-01
GC_2_82 ref NI_2 NS_82 0 2.4645687037024723e-02
GC_2_83 ref NI_2 NS_83 0 -1.3314483435451858e-04
GC_2_84 ref NI_2 NS_84 0 4.7021707574519012e-05
GC_2_85 ref NI_2 NS_85 0 2.3119230762867182e-01
GC_2_86 ref NI_2 NS_86 0 1.4178368912917566e-01
GC_2_87 ref NI_2 NS_87 0 6.9256606495111978e-02
GC_2_88 ref NI_2 NS_88 0 7.0000092678766404e-02
GC_2_89 ref NI_2 NS_89 0 -5.1535492005265308e-04
GC_2_90 ref NI_2 NS_90 0 3.7107344705526515e-05
GD_2_1 ref NI_2 NA_1 0 -3.7461759006322116e-03
GD_2_2 ref NI_2 NA_2 0 5.3598083652651081e+00
GD_2_3 ref NI_2 NA_3 0 -6.4811905557816851e-02
GD_2_4 ref NI_2 NA_4 0 -6.7660096489288044e-02
GD_2_5 ref NI_2 NA_5 0 -7.2522884226015188e-02
GD_2_6 ref NI_2 NA_6 0 -4.1035891745530566e-02
GD_2_7 ref NI_2 NA_7 0 -8.0033841809753051e-02
GD_2_8 ref NI_2 NA_8 0 -7.7951972613773304e-02
GD_2_9 ref NI_2 NA_9 0 -3.6770733464139220e-02
GD_2_10 ref NI_2 NA_10 0 -3.2111577907632208e-02
GD_2_11 ref NI_2 NA_11 0 -3.7813775352277326e-02
GD_2_12 ref NI_2 NA_12 0 -2.8194506199163624e-02
GD_2_13 ref NI_2 NA_13 0 -3.6002737806601390e-02
GD_2_14 ref NI_2 NA_14 0 -2.0840314381378872e-02
GD_2_15 ref NI_2 NA_15 0 -6.1778840755860071e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 -1.3066175557064083e-01
GC_3_2 ref NI_3 NS_2 0 1.6625885715914238e-01
GC_3_3 ref NI_3 NS_3 0 -6.1578722959912977e-04
GC_3_4 ref NI_3 NS_4 0 8.2919616976444760e-02
GC_3_5 ref NI_3 NS_5 0 6.0473603714442156e-03
GC_3_6 ref NI_3 NS_6 0 2.1824055300185381e-04
GC_3_7 ref NI_3 NS_7 0 2.3025890267792137e-01
GC_3_8 ref NI_3 NS_8 0 5.6023053527891054e-01
GC_3_9 ref NI_3 NS_9 0 5.7187823880401042e-02
GC_3_10 ref NI_3 NS_10 0 -8.9216321918082105e-03
GC_3_11 ref NI_3 NS_11 0 -4.8551222212435592e-04
GC_3_12 ref NI_3 NS_12 0 4.0259699082021447e-05
GC_3_13 ref NI_3 NS_13 0 1.5804233941576213e+00
GC_3_14 ref NI_3 NS_14 0 -2.9446447722932083e+00
GC_3_15 ref NI_3 NS_15 0 -2.7827983191434353e+00
GC_3_16 ref NI_3 NS_16 0 -3.8036697034767954e-02
GC_3_17 ref NI_3 NS_17 0 -1.3849786621124289e-02
GC_3_18 ref NI_3 NS_18 0 -1.6367982068328846e-04
GC_3_19 ref NI_3 NS_19 0 -6.6255219077270622e-01
GC_3_20 ref NI_3 NS_20 0 1.7127486835971331e+00
GC_3_21 ref NI_3 NS_21 0 5.4937444547677065e-02
GC_3_22 ref NI_3 NS_22 0 -1.8644232135911776e-01
GC_3_23 ref NI_3 NS_23 0 2.1913982355495102e-03
GC_3_24 ref NI_3 NS_24 0 -2.4211333890562404e-05
GC_3_25 ref NI_3 NS_25 0 -1.3454504337364964e-01
GC_3_26 ref NI_3 NS_26 0 1.9899189181721222e-01
GC_3_27 ref NI_3 NS_27 0 2.6196589450926333e-01
GC_3_28 ref NI_3 NS_28 0 -2.3030204707936059e-02
GC_3_29 ref NI_3 NS_29 0 9.5829108496104298e-04
GC_3_30 ref NI_3 NS_30 0 2.8793654241565901e-05
GC_3_31 ref NI_3 NS_31 0 9.0604956488662028e-02
GC_3_32 ref NI_3 NS_32 0 -7.8325353876821630e-02
GC_3_33 ref NI_3 NS_33 0 1.6329806966153315e-01
GC_3_34 ref NI_3 NS_34 0 6.7498216632998168e-02
GC_3_35 ref NI_3 NS_35 0 -1.5078548863618144e-04
GC_3_36 ref NI_3 NS_36 0 6.0822487794234741e-05
GC_3_37 ref NI_3 NS_37 0 3.6055616059036129e-02
GC_3_38 ref NI_3 NS_38 0 -1.5540515499181243e-01
GC_3_39 ref NI_3 NS_39 0 2.0137275006900332e-01
GC_3_40 ref NI_3 NS_40 0 6.8992433378048987e-02
GC_3_41 ref NI_3 NS_41 0 -1.9539499795546178e-04
GC_3_42 ref NI_3 NS_42 0 5.6565374814872652e-05
GC_3_43 ref NI_3 NS_43 0 5.5028735757179266e-02
GC_3_44 ref NI_3 NS_44 0 -1.3295021955976918e-01
GC_3_45 ref NI_3 NS_45 0 1.9647278372774923e-01
GC_3_46 ref NI_3 NS_46 0 6.5701469078287694e-02
GC_3_47 ref NI_3 NS_47 0 -2.9021916038318886e-04
GC_3_48 ref NI_3 NS_48 0 5.5909389974467103e-05
GC_3_49 ref NI_3 NS_49 0 4.4437352189331876e-02
GC_3_50 ref NI_3 NS_50 0 -8.4258858884177931e-02
GC_3_51 ref NI_3 NS_51 0 3.3767713081063792e-02
GC_3_52 ref NI_3 NS_52 0 1.3320674379764880e-01
GC_3_53 ref NI_3 NS_53 0 2.6276106577948172e-04
GC_3_54 ref NI_3 NS_54 0 6.2182809440240768e-05
GC_3_55 ref NI_3 NS_55 0 4.4796007209814220e-02
GC_3_56 ref NI_3 NS_56 0 -1.2253638266607469e-01
GC_3_57 ref NI_3 NS_57 0 7.7473914566130869e-02
GC_3_58 ref NI_3 NS_58 0 1.1771620593282930e-01
GC_3_59 ref NI_3 NS_59 0 7.9818765311623807e-04
GC_3_60 ref NI_3 NS_60 0 4.3755878369297555e-05
GC_3_61 ref NI_3 NS_61 0 6.6835269452294538e-02
GC_3_62 ref NI_3 NS_62 0 -1.0589900651813221e-01
GC_3_63 ref NI_3 NS_63 0 1.5574538979703589e-01
GC_3_64 ref NI_3 NS_64 0 7.8125888099153593e-02
GC_3_65 ref NI_3 NS_65 0 -4.9532973777172953e-04
GC_3_66 ref NI_3 NS_66 0 7.1490751448051375e-05
GC_3_67 ref NI_3 NS_67 0 -1.7599528761120004e-03
GC_3_68 ref NI_3 NS_68 0 -1.5180817221215107e-01
GC_3_69 ref NI_3 NS_69 0 3.6715497417449799e-01
GC_3_70 ref NI_3 NS_70 0 -1.3784128381280089e-02
GC_3_71 ref NI_3 NS_71 0 2.2228326685121784e-04
GC_3_72 ref NI_3 NS_72 0 2.0898143236105474e-05
GC_3_73 ref NI_3 NS_73 0 1.5932882337242057e-01
GC_3_74 ref NI_3 NS_74 0 -4.3308938368885513e-01
GC_3_75 ref NI_3 NS_75 0 5.9231521845553181e-01
GC_3_76 ref NI_3 NS_76 0 -7.2047705854834374e-02
GC_3_77 ref NI_3 NS_77 0 -1.7863603677127876e-03
GC_3_78 ref NI_3 NS_78 0 4.2017955132020642e-05
GC_3_79 ref NI_3 NS_79 0 -5.8841355966368514e-01
GC_3_80 ref NI_3 NS_80 0 1.3028911656056181e+00
GC_3_81 ref NI_3 NS_81 0 6.3416150153847217e-01
GC_3_82 ref NI_3 NS_82 0 -3.8915266776928698e-01
GC_3_83 ref NI_3 NS_83 0 3.1811008202436595e-04
GC_3_84 ref NI_3 NS_84 0 -1.1854020138221277e-04
GC_3_85 ref NI_3 NS_85 0 2.6705197221461800e-02
GC_3_86 ref NI_3 NS_86 0 -4.3631313139618037e-03
GC_3_87 ref NI_3 NS_87 0 4.5488139899349883e-02
GC_3_88 ref NI_3 NS_88 0 1.1364220738244751e-01
GC_3_89 ref NI_3 NS_89 0 9.5089273969445863e-04
GC_3_90 ref NI_3 NS_90 0 5.4265346440089550e-05
GD_3_1 ref NI_3 NA_1 0 2.0541483788929570e-02
GD_3_2 ref NI_3 NA_2 0 -6.4811905557816851e-02
GD_3_3 ref NI_3 NA_3 0 6.1091137467924019e+00
GD_3_4 ref NI_3 NA_4 0 3.5468481212770124e-02
GD_3_5 ref NI_3 NA_5 0 9.5760721874096932e-04
GD_3_6 ref NI_3 NA_6 0 -1.3956512391937657e-02
GD_3_7 ref NI_3 NA_7 0 -1.1454497049119319e-02
GD_3_8 ref NI_3 NA_8 0 -1.3137542481508769e-02
GD_3_9 ref NI_3 NA_9 0 -5.9716208492877594e-03
GD_3_10 ref NI_3 NA_10 0 -3.8516233713632585e-03
GD_3_11 ref NI_3 NA_11 0 -5.2009778954253162e-03
GD_3_12 ref NI_3 NA_12 0 3.1629939182118857e-03
GD_3_13 ref NI_3 NA_13 0 -1.3728095042594613e-02
GD_3_14 ref NI_3 NA_14 0 6.0614817556697002e-02
GD_3_15 ref NI_3 NA_15 0 -1.3746448091772069e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -1.0389187347274406e-01
GC_4_2 ref NI_4 NS_2 0 1.1087669111692879e-01
GC_4_3 ref NI_4 NS_3 0 3.0523101891081553e-02
GC_4_4 ref NI_4 NS_4 0 7.9510070673026845e-02
GC_4_5 ref NI_4 NS_5 0 5.5265349543401890e-03
GC_4_6 ref NI_4 NS_6 0 2.1245271173945076e-04
GC_4_7 ref NI_4 NS_7 0 1.8799044650479974e-01
GC_4_8 ref NI_4 NS_8 0 5.5942460196597588e-01
GC_4_9 ref NI_4 NS_9 0 1.0503805953947437e-01
GC_4_10 ref NI_4 NS_10 0 -2.9174611246289131e-02
GC_4_11 ref NI_4 NS_11 0 -2.1692377344547823e-04
GC_4_12 ref NI_4 NS_12 0 3.3900498259879235e-05
GC_4_13 ref NI_4 NS_13 0 -6.6255219077270688e-01
GC_4_14 ref NI_4 NS_14 0 1.7127486835971342e+00
GC_4_15 ref NI_4 NS_15 0 5.4937444547676129e-02
GC_4_16 ref NI_4 NS_16 0 -1.8644232135911731e-01
GC_4_17 ref NI_4 NS_17 0 2.1913982355494682e-03
GC_4_18 ref NI_4 NS_18 0 -2.4211333890557928e-05
GC_4_19 ref NI_4 NS_19 0 1.7905131666514080e+00
GC_4_20 ref NI_4 NS_20 0 -3.5497214606541760e+00
GC_4_21 ref NI_4 NS_21 0 -2.8731669254181047e+00
GC_4_22 ref NI_4 NS_22 0 1.0366309627886722e-01
GC_4_23 ref NI_4 NS_23 0 -1.3833905244198487e-02
GC_4_24 ref NI_4 NS_24 0 -7.4074534951155892e-05
GC_4_25 ref NI_4 NS_25 0 -4.3514645512630712e-01
GC_4_26 ref NI_4 NS_26 0 1.1967493829057796e+00
GC_4_27 ref NI_4 NS_27 0 3.8932265489889102e-02
GC_4_28 ref NI_4 NS_28 0 -8.6801295631795672e-02
GC_4_29 ref NI_4 NS_29 0 1.1070044826051969e-03
GC_4_30 ref NI_4 NS_30 0 -3.3591167855512466e-05
GC_4_31 ref NI_4 NS_31 0 7.1876766936159742e-02
GC_4_32 ref NI_4 NS_32 0 -4.4589646902507891e-02
GC_4_33 ref NI_4 NS_33 0 2.4563114995812066e-01
GC_4_34 ref NI_4 NS_34 0 2.3759923789058727e-02
GC_4_35 ref NI_4 NS_35 0 -3.9420454888138148e-04
GC_4_36 ref NI_4 NS_36 0 3.7353635016419988e-05
GC_4_37 ref NI_4 NS_37 0 4.0401384510730110e-02
GC_4_38 ref NI_4 NS_38 0 -2.0762773261615874e-01
GC_4_39 ref NI_4 NS_39 0 3.1426036580442801e-01
GC_4_40 ref NI_4 NS_40 0 2.4729518399007000e-02
GC_4_41 ref NI_4 NS_41 0 -3.5359161407261383e-04
GC_4_42 ref NI_4 NS_42 0 4.1257088985344255e-05
GC_4_43 ref NI_4 NS_43 0 8.1307632931478760e-02
GC_4_44 ref NI_4 NS_44 0 -2.0245435931931374e-01
GC_4_45 ref NI_4 NS_45 0 3.0147334800896369e-01
GC_4_46 ref NI_4 NS_46 0 2.7115992327963190e-02
GC_4_47 ref NI_4 NS_47 0 -5.0475377159534408e-04
GC_4_48 ref NI_4 NS_48 0 4.6863271430811775e-05
GC_4_49 ref NI_4 NS_49 0 9.3621461048105148e-02
GC_4_50 ref NI_4 NS_50 0 -1.4860219553406268e-01
GC_4_51 ref NI_4 NS_51 0 1.3940811987842994e-01
GC_4_52 ref NI_4 NS_52 0 9.3437812634262596e-02
GC_4_53 ref NI_4 NS_53 0 -6.7131433295204224e-04
GC_4_54 ref NI_4 NS_54 0 8.0259666642330238e-05
GC_4_55 ref NI_4 NS_55 0 1.9374405515037604e-02
GC_4_56 ref NI_4 NS_56 0 -1.4966908722213679e-01
GC_4_57 ref NI_4 NS_57 0 2.2837814653575403e-01
GC_4_58 ref NI_4 NS_58 0 5.1704741719242372e-02
GC_4_59 ref NI_4 NS_59 0 5.4111193211579128e-04
GC_4_60 ref NI_4 NS_60 0 3.4481379631493007e-05
GC_4_61 ref NI_4 NS_61 0 3.3241926527289543e-02
GC_4_62 ref NI_4 NS_62 0 -2.2725841487520590e-01
GC_4_63 ref NI_4 NS_63 0 3.9636558456274890e-01
GC_4_64 ref NI_4 NS_64 0 -1.4534198677824675e-02
GC_4_65 ref NI_4 NS_65 0 2.4434590298121750e-04
GC_4_66 ref NI_4 NS_66 0 3.5604774685496944e-05
GC_4_67 ref NI_4 NS_67 0 -4.6196955147838398e-01
GC_4_68 ref NI_4 NS_68 0 1.1151341180349206e+00
GC_4_69 ref NI_4 NS_69 0 1.8875658450098814e-01
GC_4_70 ref NI_4 NS_70 0 -1.5215356345070141e-01
GC_4_71 ref NI_4 NS_71 0 2.1783433964863933e-03
GC_4_72 ref NI_4 NS_72 0 -3.8299974054458416e-05
GC_4_73 ref NI_4 NS_73 0 -2.7629122773046182e-02
GC_4_74 ref NI_4 NS_74 0 1.3223544350781627e-01
GC_4_75 ref NI_4 NS_75 0 2.9531485842489247e-01
GC_4_76 ref NI_4 NS_76 0 -2.9434503491973588e-02
GC_4_77 ref NI_4 NS_77 0 -2.7974578916608954e-04
GC_4_78 ref NI_4 NS_78 0 2.2093027422803876e-05
GC_4_79 ref NI_4 NS_79 0 1.7125361735288180e-01
GC_4_80 ref NI_4 NS_80 0 -5.4134129798197206e-01
GC_4_81 ref NI_4 NS_81 0 5.1151486138231139e-01
GC_4_82 ref NI_4 NS_82 0 -1.4380174425299418e-02
GC_4_83 ref NI_4 NS_83 0 -1.0779999370415154e-03
GC_4_84 ref NI_4 NS_84 0 3.7686175875628912e-05
GC_4_85 ref NI_4 NS_85 0 6.1157478887504294e-02
GC_4_86 ref NI_4 NS_86 0 -4.5973114422979515e-02
GC_4_87 ref NI_4 NS_87 0 8.7317498891180068e-02
GC_4_88 ref NI_4 NS_88 0 1.0326990883514334e-01
GC_4_89 ref NI_4 NS_89 0 1.6470739796368896e-04
GC_4_90 ref NI_4 NS_90 0 3.4106283706229721e-05
GD_4_1 ref NI_4 NA_1 0 1.6826153039675371e-02
GD_4_2 ref NI_4 NA_2 0 -6.7660096489288044e-02
GD_4_3 ref NI_4 NA_3 0 3.5468481212770124e-02
GD_4_4 ref NI_4 NA_4 0 6.1058759011364492e+00
GD_4_5 ref NI_4 NA_5 0 1.9137026656360405e-02
GD_4_6 ref NI_4 NA_6 0 -1.3882449409737109e-02
GD_4_7 ref NI_4 NA_7 0 -1.2402795108233947e-02
GD_4_8 ref NI_4 NA_8 0 -1.5698269652004417e-02
GD_4_9 ref NI_4 NA_9 0 -9.9967370486201447e-03
GD_4_10 ref NI_4 NA_10 0 -8.1856992333746942e-04
GD_4_11 ref NI_4 NA_11 0 -6.6472509043282195e-03
GD_4_12 ref NI_4 NA_12 0 5.2937930395157998e-02
GD_4_13 ref NI_4 NA_13 0 3.2780272807221519e-03
GD_4_14 ref NI_4 NA_14 0 -1.4747316016503705e-02
GD_4_15 ref NI_4 NA_15 0 -1.8551964706635234e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -1.1432007762687652e-01
GC_5_2 ref NI_5 NS_2 0 1.7060427394829211e-01
GC_5_3 ref NI_5 NS_3 0 6.4426681153717608e-02
GC_5_4 ref NI_5 NS_4 0 5.5551600608667706e-02
GC_5_5 ref NI_5 NS_5 0 4.5515231209216512e-03
GC_5_6 ref NI_5 NS_6 0 2.0760683170007932e-04
GC_5_7 ref NI_5 NS_7 0 2.4617770241254835e-01
GC_5_8 ref NI_5 NS_8 0 5.2959323048121565e-01
GC_5_9 ref NI_5 NS_9 0 1.2206839236604974e-01
GC_5_10 ref NI_5 NS_10 0 -3.5689298516880137e-02
GC_5_11 ref NI_5 NS_11 0 -2.4811028004623859e-04
GC_5_12 ref NI_5 NS_12 0 3.2454341123522663e-05
GC_5_13 ref NI_5 NS_13 0 -1.3454504337364970e-01
GC_5_14 ref NI_5 NS_14 0 1.9899189181721244e-01
GC_5_15 ref NI_5 NS_15 0 2.6196589450926305e-01
GC_5_16 ref NI_5 NS_16 0 -2.3030204707935868e-02
GC_5_17 ref NI_5 NS_17 0 9.5829108496100666e-04
GC_5_18 ref NI_5 NS_18 0 2.8793654241567467e-05
GC_5_19 ref NI_5 NS_19 0 -4.3514645512630828e-01
GC_5_20 ref NI_5 NS_20 0 1.1967493829057809e+00
GC_5_21 ref NI_5 NS_21 0 3.8932265489887811e-02
GC_5_22 ref NI_5 NS_22 0 -8.6801295631795006e-02
GC_5_23 ref NI_5 NS_23 0 1.1070044826051143e-03
GC_5_24 ref NI_5 NS_24 0 -3.3591167855516085e-05
GC_5_25 ref NI_5 NS_25 0 1.8510397931438705e+00
GC_5_26 ref NI_5 NS_26 0 -3.5457116153445423e+00
GC_5_27 ref NI_5 NS_27 0 -2.8731238479233934e+00
GC_5_28 ref NI_5 NS_28 0 1.0636841356756509e-01
GC_5_29 ref NI_5 NS_29 0 -1.4700959729290414e-02
GC_5_30 ref NI_5 NS_30 0 -1.2761496178842423e-04
GC_5_31 ref NI_5 NS_31 0 5.2785490230988649e-02
GC_5_32 ref NI_5 NS_32 0 6.6316456513753264e-01
GC_5_33 ref NI_5 NS_33 0 1.2556134082166912e-01
GC_5_34 ref NI_5 NS_34 0 -5.8576421202388131e-02
GC_5_35 ref NI_5 NS_35 0 -3.4497974625486886e-04
GC_5_36 ref NI_5 NS_36 0 3.4684120047352547e-05
GC_5_37 ref NI_5 NS_37 0 -3.6398351756516600e-01
GC_5_38 ref NI_5 NS_38 0 1.6541607656638246e-01
GC_5_39 ref NI_5 NS_39 0 4.5739023277966084e-01
GC_5_40 ref NI_5 NS_40 0 -9.5141090689027374e-02
GC_5_41 ref NI_5 NS_41 0 1.1106865101994166e-03
GC_5_42 ref NI_5 NS_42 0 1.7505023344773661e-05
GC_5_43 ref NI_5 NS_43 0 -6.9212825386713250e-02
GC_5_44 ref NI_5 NS_44 0 5.1644029705144916e-02
GC_5_45 ref NI_5 NS_45 0 4.1526231007985454e-01
GC_5_46 ref NI_5 NS_46 0 -7.2897686851150154e-02
GC_5_47 ref NI_5 NS_47 0 5.2735049127665857e-04
GC_5_48 ref NI_5 NS_48 0 2.9528663787121605e-05
GC_5_49 ref NI_5 NS_49 0 7.1360471503157955e-02
GC_5_50 ref NI_5 NS_50 0 -2.7870033414099804e-01
GC_5_51 ref NI_5 NS_51 0 4.5118947044909657e-01
GC_5_52 ref NI_5 NS_52 0 -3.5845294567911162e-02
GC_5_53 ref NI_5 NS_53 0 -3.0455459883023514e-04
GC_5_54 ref NI_5 NS_54 0 1.0694632514747557e-04
GC_5_55 ref NI_5 NS_55 0 -3.8331644030713075e-01
GC_5_56 ref NI_5 NS_56 0 9.8217714242908727e-01
GC_5_57 ref NI_5 NS_57 0 1.8599482132509179e-01
GC_5_58 ref NI_5 NS_58 0 -1.2705633956594606e-01
GC_5_59 ref NI_5 NS_59 0 1.3605486321583238e-03
GC_5_60 ref NI_5 NS_60 0 -2.0228717773779361e-05
GC_5_61 ref NI_5 NS_61 0 -4.3715610037840268e-02
GC_5_62 ref NI_5 NS_62 0 1.5457830656626448e-01
GC_5_63 ref NI_5 NS_63 0 2.2756448450304922e-01
GC_5_64 ref NI_5 NS_64 0 -7.7250234857303025e-04
GC_5_65 ref NI_5 NS_65 0 2.6201347067082828e-04
GC_5_66 ref NI_5 NS_66 0 1.4115108743839137e-05
GC_5_67 ref NI_5 NS_67 0 5.4152201663332074e-02
GC_5_68 ref NI_5 NS_68 0 -2.9738687548534309e-01
GC_5_69 ref NI_5 NS_69 0 3.0001210163982484e-01
GC_5_70 ref NI_5 NS_70 0 4.4097436332906324e-02
GC_5_71 ref NI_5 NS_71 0 4.8795556225505148e-04
GC_5_72 ref NI_5 NS_72 0 2.9945026260882180e-05
GC_5_73 ref NI_5 NS_73 0 3.0380742040479351e-02
GC_5_74 ref NI_5 NS_74 0 -6.8693560263387785e-02
GC_5_75 ref NI_5 NS_75 0 1.0143317536179074e-01
GC_5_76 ref NI_5 NS_76 0 9.8558067531617749e-02
GC_5_77 ref NI_5 NS_77 0 5.3674023433235968e-04
GC_5_78 ref NI_5 NS_78 0 3.1166988198586009e-05
GC_5_79 ref NI_5 NS_79 0 9.8427180003274120e-02
GC_5_80 ref NI_5 NS_80 0 -2.0018500543447840e-01
GC_5_81 ref NI_5 NS_81 0 5.4535035225376796e-02
GC_5_82 ref NI_5 NS_82 0 1.4310657174177807e-01
GC_5_83 ref NI_5 NS_83 0 2.5976475341248312e-04
GC_5_84 ref NI_5 NS_84 0 5.8281384175232242e-05
GC_5_85 ref NI_5 NS_85 0 7.9023296270678209e-02
GC_5_86 ref NI_5 NS_86 0 -4.7739375384652886e-02
GC_5_87 ref NI_5 NS_87 0 1.4211480773320304e-01
GC_5_88 ref NI_5 NS_88 0 7.9588993474062869e-02
GC_5_89 ref NI_5 NS_89 0 -8.7624721328355296e-04
GC_5_90 ref NI_5 NS_90 0 3.6025452488546532e-05
GD_5_1 ref NI_5 NA_1 0 2.0368799818057687e-02
GD_5_2 ref NI_5 NA_2 0 -7.2522884226015188e-02
GD_5_3 ref NI_5 NA_3 0 9.5760721874096932e-04
GD_5_4 ref NI_5 NA_4 0 1.9137026656360405e-02
GD_5_5 ref NI_5 NA_5 0 6.0838535326333387e+00
GD_5_6 ref NI_5 NA_6 0 -4.0790547708300911e-03
GD_5_7 ref NI_5 NA_7 0 1.4132748069580585e-02
GD_5_8 ref NI_5 NA_8 0 -2.6086618482116406e-03
GD_5_9 ref NI_5 NA_9 0 -9.0262947338557407e-03
GD_5_10 ref NI_5 NA_10 0 4.4535667981603987e-02
GD_5_11 ref NI_5 NA_11 0 3.5874533397585876e-03
GD_5_12 ref NI_5 NA_12 0 -6.0577653854758462e-03
GD_5_13 ref NI_5 NA_13 0 -4.4889550180056796e-03
GD_5_14 ref NI_5 NA_14 0 -9.3537887473684259e-03
GD_5_15 ref NI_5 NA_15 0 -2.1107948781254722e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -2.8329609306760536e-02
GC_6_2 ref NI_6 NS_2 0 1.2968164689489964e-01
GC_6_3 ref NI_6 NS_3 0 8.2986202668081072e-02
GC_6_4 ref NI_6 NS_4 0 5.0383523566139420e-02
GC_6_5 ref NI_6 NS_5 0 3.7375074247104961e-03
GC_6_6 ref NI_6 NS_6 0 2.0765640250880823e-04
GC_6_7 ref NI_6 NS_7 0 -1.9480898925439824e-01
GC_6_8 ref NI_6 NS_8 0 7.3662716022463659e-01
GC_6_9 ref NI_6 NS_9 0 1.9591611062548273e-01
GC_6_10 ref NI_6 NS_10 0 -8.4304456897277225e-02
GC_6_11 ref NI_6 NS_11 0 9.2712819448672506e-04
GC_6_12 ref NI_6 NS_12 0 1.0208939663628289e-05
GC_6_13 ref NI_6 NS_13 0 9.0604956488661265e-02
GC_6_14 ref NI_6 NS_14 0 -7.8325353876820603e-02
GC_6_15 ref NI_6 NS_15 0 1.6329806966153221e-01
GC_6_16 ref NI_6 NS_16 0 6.7498216632998681e-02
GC_6_17 ref NI_6 NS_17 0 -1.5078548863627406e-04
GC_6_18 ref NI_6 NS_18 0 6.0822487794234199e-05
GC_6_19 ref NI_6 NS_19 0 7.1876766936160463e-02
GC_6_20 ref NI_6 NS_20 0 -4.4589646902508953e-02
GC_6_21 ref NI_6 NS_21 0 2.4563114995812135e-01
GC_6_22 ref NI_6 NS_22 0 2.3759923789058481e-02
GC_6_23 ref NI_6 NS_23 0 -3.9420454888141189e-04
GC_6_24 ref NI_6 NS_24 0 3.7353635016429908e-05
GC_6_25 ref NI_6 NS_25 0 5.2785490230988989e-02
GC_6_26 ref NI_6 NS_26 0 6.6316456513753197e-01
GC_6_27 ref NI_6 NS_27 0 1.2556134082166967e-01
GC_6_28 ref NI_6 NS_28 0 -5.8576421202388394e-02
GC_6_29 ref NI_6 NS_29 0 -3.4497974625486100e-04
GC_6_30 ref NI_6 NS_30 0 3.4684120047352445e-05
GC_6_31 ref NI_6 NS_31 0 -2.6507221782394402e-01
GC_6_32 ref NI_6 NS_32 0 -6.2367152724661903e+00
GC_6_33 ref NI_6 NS_33 0 -9.3798523855642291e-01
GC_6_34 ref NI_6 NS_34 0 -1.8569487693130574e-01
GC_6_35 ref NI_6 NS_35 0 -6.2201901539445641e-03
GC_6_36 ref NI_6 NS_36 0 -7.5416636670037828e-05
GC_6_37 ref NI_6 NS_37 0 1.5953424469769246e+00
GC_6_38 ref NI_6 NS_38 0 3.7562254119978515e+00
GC_6_39 ref NI_6 NS_39 0 -1.3132052240829033e+00
GC_6_40 ref NI_6 NS_40 0 -6.1852926804959477e-02
GC_6_41 ref NI_6 NS_41 0 -5.7512596312741691e-03
GC_6_42 ref NI_6 NS_42 0 -4.1766131869032078e-05
GC_6_43 ref NI_6 NS_43 0 -9.4819785151175739e-01
GC_6_44 ref NI_6 NS_44 0 1.6854963474236337e+00
GC_6_45 ref NI_6 NS_45 0 2.9724930581002013e-01
GC_6_46 ref NI_6 NS_46 0 -2.8934202513211726e-01
GC_6_47 ref NI_6 NS_47 0 4.4123907351889084e-03
GC_6_48 ref NI_6 NS_48 0 -3.9825398791615601e-05
GC_6_49 ref NI_6 NS_49 0 -2.9094897439540454e-02
GC_6_50 ref NI_6 NS_50 0 2.1996572769513076e-01
GC_6_51 ref NI_6 NS_51 0 4.4552391619231735e-01
GC_6_52 ref NI_6 NS_52 0 -1.1697801798132611e-01
GC_6_53 ref NI_6 NS_53 0 -5.8372776115270925e-04
GC_6_54 ref NI_6 NS_54 0 -4.6033396024510566e-05
GC_6_55 ref NI_6 NS_55 0 7.4371743912537980e-02
GC_6_56 ref NI_6 NS_56 0 -4.2157936494316267e-01
GC_6_57 ref NI_6 NS_57 0 3.9186059958581992e-01
GC_6_58 ref NI_6 NS_58 0 2.6453407622746266e-02
GC_6_59 ref NI_6 NS_59 0 -6.1575674042556848e-04
GC_6_60 ref NI_6 NS_60 0 3.0671115593421579e-05
GC_6_61 ref NI_6 NS_61 0 7.4657830512006557e-02
GC_6_62 ref NI_6 NS_62 0 -1.7009160939360862e-01
GC_6_63 ref NI_6 NS_63 0 1.6292724863445898e-01
GC_6_64 ref NI_6 NS_64 0 8.8032707089327242e-02
GC_6_65 ref NI_6 NS_65 0 -2.8755205024789542e-04
GC_6_66 ref NI_6 NS_66 0 3.4847519153554334e-05
GC_6_67 ref NI_6 NS_67 0 7.3550899664256875e-02
GC_6_68 ref NI_6 NS_68 0 -2.0270514519133168e-01
GC_6_69 ref NI_6 NS_69 0 1.0149597777249289e-01
GC_6_70 ref NI_6 NS_70 0 1.2269573276119711e-01
GC_6_71 ref NI_6 NS_71 0 -2.1102800132422893e-04
GC_6_72 ref NI_6 NS_72 0 7.3346314526150200e-05
GC_6_73 ref NI_6 NS_73 0 2.8754049015220277e-02
GC_6_74 ref NI_6 NS_74 0 -9.2252553835920736e-02
GC_6_75 ref NI_6 NS_75 0 2.5067288122809176e-02
GC_6_76 ref NI_6 NS_76 0 1.3872304951822223e-01
GC_6_77 ref NI_6 NS_77 0 9.7408051926768039e-04
GC_6_78 ref NI_6 NS_78 0 3.9671008732555166e-05
GC_6_79 ref NI_6 NS_79 0 2.4180268558174178e-02
GC_6_80 ref NI_6 NS_80 0 -8.7447132386338972e-02
GC_6_81 ref NI_6 NS_81 0 -7.0381409180392568e-02
GC_6_82 ref NI_6 NS_82 0 1.8335956755487171e-01
GC_6_83 ref NI_6 NS_83 0 1.1000093296608593e-03
GC_6_84 ref NI_6 NS_84 0 7.7320104972886420e-05
GC_6_85 ref NI_6 NS_85 0 1.6253734312194476e-01
GC_6_86 ref NI_6 NS_86 0 -1.2509043111764398e-01
GC_6_87 ref NI_6 NS_87 0 1.4703949591586496e-01
GC_6_88 ref NI_6 NS_88 0 9.0608988028175130e-02
GC_6_89 ref NI_6 NS_89 0 -1.9911467713986772e-03
GC_6_90 ref NI_6 NS_90 0 4.2342890765011349e-05
GD_6_1 ref NI_6 NA_1 0 1.8014581271787667e-02
GD_6_2 ref NI_6 NA_2 0 -4.1035891745530566e-02
GD_6_3 ref NI_6 NA_3 0 -1.3956512391937657e-02
GD_6_4 ref NI_6 NA_4 0 -1.3882449409737109e-02
GD_6_5 ref NI_6 NA_5 0 -4.0790547708300911e-03
GD_6_6 ref NI_6 NA_6 0 6.2204299095339390e+00
GD_6_7 ref NI_6 NA_7 0 -8.3238976970021500e-02
GD_6_8 ref NI_6 NA_8 0 6.3821127405104219e-02
GD_6_9 ref NI_6 NA_9 0 -1.2548895980242284e-03
GD_6_10 ref NI_6 NA_10 0 -8.6036206167567075e-03
GD_6_11 ref NI_6 NA_11 0 -7.3918823159972932e-03
GD_6_12 ref NI_6 NA_12 0 -6.8009738184829638e-03
GD_6_13 ref NI_6 NA_13 0 -3.8113355622217673e-03
GD_6_14 ref NI_6 NA_14 0 -3.0763196222196288e-03
GD_6_15 ref NI_6 NA_15 0 -2.6129482000444376e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -1.1628281021090954e-01
GC_7_2 ref NI_7 NS_2 0 -2.7819977866944349e-02
GC_7_3 ref NI_7 NS_3 0 1.1334857894957513e-01
GC_7_4 ref NI_7 NS_4 0 7.0074455789281967e-02
GC_7_5 ref NI_7 NS_5 0 4.7503893002221560e-03
GC_7_6 ref NI_7 NS_6 0 2.2105771254077590e-04
GC_7_7 ref NI_7 NS_7 0 3.7827101386208245e-01
GC_7_8 ref NI_7 NS_8 0 9.0282310928511078e-01
GC_7_9 ref NI_7 NS_9 0 -1.5221597605097521e-02
GC_7_10 ref NI_7 NS_10 0 -5.2218373537167732e-02
GC_7_11 ref NI_7 NS_11 0 -3.1424663245953826e-04
GC_7_12 ref NI_7 NS_12 0 2.9781928421450442e-05
GC_7_13 ref NI_7 NS_13 0 3.6055616059035421e-02
GC_7_14 ref NI_7 NS_14 0 -1.5540515499181140e-01
GC_7_15 ref NI_7 NS_15 0 2.0137275006900252e-01
GC_7_16 ref NI_7 NS_16 0 6.8992433378049417e-02
GC_7_17 ref NI_7 NS_17 0 -1.9539499795553591e-04
GC_7_18 ref NI_7 NS_18 0 5.6565374814876630e-05
GC_7_19 ref NI_7 NS_19 0 4.0401384510729797e-02
GC_7_20 ref NI_7 NS_20 0 -2.0762773261615808e-01
GC_7_21 ref NI_7 NS_21 0 3.1426036580442712e-01
GC_7_22 ref NI_7 NS_22 0 2.4729518399007683e-02
GC_7_23 ref NI_7 NS_23 0 -3.5359161407279283e-04
GC_7_24 ref NI_7 NS_24 0 4.1257088985358614e-05
GC_7_25 ref NI_7 NS_25 0 -3.6398351756516562e-01
GC_7_26 ref NI_7 NS_26 0 1.6541607656638202e-01
GC_7_27 ref NI_7 NS_27 0 4.5739023277966129e-01
GC_7_28 ref NI_7 NS_28 0 -9.5141090689027596e-02
GC_7_29 ref NI_7 NS_29 0 1.1106865101994394e-03
GC_7_30 ref NI_7 NS_30 0 1.7505023344779512e-05
GC_7_31 ref NI_7 NS_31 0 1.5953424469769257e+00
GC_7_32 ref NI_7 NS_32 0 3.7562254119978493e+00
GC_7_33 ref NI_7 NS_33 0 -1.3132052240829024e+00
GC_7_34 ref NI_7 NS_34 0 -6.1852926804959914e-02
GC_7_35 ref NI_7 NS_35 0 -5.7512596312741509e-03
GC_7_36 ref NI_7 NS_36 0 -4.1766131869025254e-05
GC_7_37 ref NI_7 NS_37 0 -6.0025675018960367e-01
GC_7_38 ref NI_7 NS_38 0 -6.2441088947294920e+00
GC_7_39 ref NI_7 NS_39 0 -8.4191401226071305e-01
GC_7_40 ref NI_7 NS_40 0 -2.1107492687943244e-01
GC_7_41 ref NI_7 NS_41 0 -5.4724191988802682e-03
GC_7_42 ref NI_7 NS_42 0 -1.2645679547392682e-04
GC_7_43 ref NI_7 NS_43 0 -6.6511064768029393e-01
GC_7_44 ref NI_7 NS_44 0 2.1800455815898001e+00
GC_7_45 ref NI_7 NS_45 0 1.6847232296388171e-02
GC_7_46 ref NI_7 NS_46 0 -2.6534203551507130e-01
GC_7_47 ref NI_7 NS_47 0 2.9769688722406538e-03
GC_7_48 ref NI_7 NS_48 0 -3.5104861319256221e-05
GC_7_49 ref NI_7 NS_49 0 -1.1666913192718290e-01
GC_7_50 ref NI_7 NS_50 0 1.9079569491782877e-01
GC_7_51 ref NI_7 NS_51 0 4.8400421479127820e-01
GC_7_52 ref NI_7 NS_52 0 -1.2530248458108625e-01
GC_7_53 ref NI_7 NS_53 0 -3.3827238272704247e-04
GC_7_54 ref NI_7 NS_54 0 -1.8402258878190739e-05
GC_7_55 ref NI_7 NS_55 0 2.0315227145811404e-01
GC_7_56 ref NI_7 NS_56 0 -2.4531290122036742e-01
GC_7_57 ref NI_7 NS_57 0 2.9724041504848298e-01
GC_7_58 ref NI_7 NS_58 0 2.9752404145807359e-02
GC_7_59 ref NI_7 NS_59 0 -1.1946399137421322e-03
GC_7_60 ref NI_7 NS_60 0 3.1739091324454220e-05
GC_7_61 ref NI_7 NS_61 0 6.1961984069639625e-02
GC_7_62 ref NI_7 NS_62 0 -8.9812843465290726e-02
GC_7_63 ref NI_7 NS_63 0 1.5884049490865801e-01
GC_7_64 ref NI_7 NS_64 0 7.6105057582315533e-02
GC_7_65 ref NI_7 NS_65 0 -4.5762214672971727e-04
GC_7_66 ref NI_7 NS_66 0 2.8783047928883266e-05
GC_7_67 ref NI_7 NS_67 0 6.3684076881170032e-02
GC_7_68 ref NI_7 NS_68 0 -1.1073038710766535e-01
GC_7_69 ref NI_7 NS_69 0 8.4925211242732404e-02
GC_7_70 ref NI_7 NS_70 0 1.1439715864826284e-01
GC_7_71 ref NI_7 NS_71 0 -4.2848589372931152e-04
GC_7_72 ref NI_7 NS_72 0 6.9315208545761168e-05
GC_7_73 ref NI_7 NS_73 0 -2.7809276296457109e-03
GC_7_74 ref NI_7 NS_74 0 -3.6469038136897877e-02
GC_7_75 ref NI_7 NS_75 0 2.9489303583328862e-02
GC_7_76 ref NI_7 NS_76 0 1.2863280467630378e-01
GC_7_77 ref NI_7 NS_77 0 8.5699644387390536e-04
GC_7_78 ref NI_7 NS_78 0 3.5893844076785941e-05
GC_7_79 ref NI_7 NS_79 0 1.3693588730061303e-02
GC_7_80 ref NI_7 NS_80 0 -5.0117786702574073e-02
GC_7_81 ref NI_7 NS_81 0 -7.1152015408175728e-02
GC_7_82 ref NI_7 NS_82 0 1.7791652528033952e-01
GC_7_83 ref NI_7 NS_83 0 9.1119042622083270e-04
GC_7_84 ref NI_7 NS_84 0 7.9939346040336069e-05
GC_7_85 ref NI_7 NS_85 0 1.0604812802944293e-01
GC_7_86 ref NI_7 NS_86 0 -1.9993675582033182e-01
GC_7_87 ref NI_7 NS_87 0 1.1844153846416008e-01
GC_7_88 ref NI_7 NS_88 0 1.2171948392344541e-01
GC_7_89 ref NI_7 NS_89 0 -1.4975289168735416e-03
GC_7_90 ref NI_7 NS_90 0 4.6146800349896486e-05
GD_7_1 ref NI_7 NA_1 0 1.6887625949362741e-02
GD_7_2 ref NI_7 NA_2 0 -8.0033841809753051e-02
GD_7_3 ref NI_7 NA_3 0 -1.1454497049119319e-02
GD_7_4 ref NI_7 NA_4 0 -1.2402795108233947e-02
GD_7_5 ref NI_7 NA_5 0 1.4132748069580585e-02
GD_7_6 ref NI_7 NA_6 0 -8.3238976970021500e-02
GD_7_7 ref NI_7 NA_7 0 6.2511022745647047e+00
GD_7_8 ref NI_7 NA_8 0 4.8709966126277052e-02
GD_7_9 ref NI_7 NA_9 0 6.7091554151602261e-03
GD_7_10 ref NI_7 NA_10 0 -1.1864020847628259e-02
GD_7_11 ref NI_7 NA_11 0 -6.8932572634914941e-03
GD_7_12 ref NI_7 NA_12 0 -6.1983703789898039e-03
GD_7_13 ref NI_7 NA_13 0 -2.4629870343301323e-03
GD_7_14 ref NI_7 NA_14 0 -2.7981699937172943e-03
GD_7_15 ref NI_7 NA_15 0 -1.9812754202640424e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -8.7039669490004093e-02
GC_8_2 ref NI_8 NS_2 0 1.1249862920751670e-01
GC_8_3 ref NI_8 NS_3 0 1.0080540766626221e-01
GC_8_4 ref NI_8 NS_4 0 4.8703556263943772e-02
GC_8_5 ref NI_8 NS_5 0 3.9960795581222824e-03
GC_8_6 ref NI_8 NS_6 0 2.0211851401547034e-04
GC_8_7 ref NI_8 NS_7 0 2.2769291524562843e-01
GC_8_8 ref NI_8 NS_8 0 1.2017565168031241e+00
GC_8_9 ref NI_8 NS_9 0 -1.2102567927175233e-01
GC_8_10 ref NI_8 NS_10 0 -4.4619584963026461e-02
GC_8_11 ref NI_8 NS_11 0 -7.8148711230035584e-04
GC_8_12 ref NI_8 NS_12 0 2.2097773164791784e-05
GC_8_13 ref NI_8 NS_13 0 5.5028735757178676e-02
GC_8_14 ref NI_8 NS_14 0 -1.3295021955976827e-01
GC_8_15 ref NI_8 NS_15 0 1.9647278372774837e-01
GC_8_16 ref NI_8 NS_16 0 6.5701469078288124e-02
GC_8_17 ref NI_8 NS_17 0 -2.9021916038326107e-04
GC_8_18 ref NI_8 NS_18 0 5.5909389974471840e-05
GC_8_19 ref NI_8 NS_19 0 8.1307632931477622e-02
GC_8_20 ref NI_8 NS_20 0 -2.0245435931931216e-01
GC_8_21 ref NI_8 NS_21 0 3.0147334800896258e-01
GC_8_22 ref NI_8 NS_22 0 2.7115992327963721e-02
GC_8_23 ref NI_8 NS_23 0 -5.0475377159545781e-04
GC_8_24 ref NI_8 NS_24 0 4.6863271430826798e-05
GC_8_25 ref NI_8 NS_25 0 -6.9212825386711974e-02
GC_8_26 ref NI_8 NS_26 0 5.1644029705143160e-02
GC_8_27 ref NI_8 NS_27 0 4.1526231007985587e-01
GC_8_28 ref NI_8 NS_28 0 -7.2897686851150764e-02
GC_8_29 ref NI_8 NS_29 0 5.2735049127674227e-04
GC_8_30 ref NI_8 NS_30 0 2.9528663787115439e-05
GC_8_31 ref NI_8 NS_31 0 -9.4819785151175739e-01
GC_8_32 ref NI_8 NS_32 0 1.6854963474236335e+00
GC_8_33 ref NI_8 NS_33 0 2.9724930581002029e-01
GC_8_34 ref NI_8 NS_34 0 -2.8934202513211732e-01
GC_8_35 ref NI_8 NS_35 0 4.4123907351889119e-03
GC_8_36 ref NI_8 NS_36 0 -3.9825398791610431e-05
GC_8_37 ref NI_8 NS_37 0 -6.6511064768029371e-01
GC_8_38 ref NI_8 NS_38 0 2.1800455815897997e+00
GC_8_39 ref NI_8 NS_39 0 1.6847232296388792e-02
GC_8_40 ref NI_8 NS_40 0 -2.6534203551507152e-01
GC_8_41 ref NI_8 NS_41 0 2.9769688722407015e-03
GC_8_42 ref NI_8 NS_42 0 -3.5104861319263059e-05
GC_8_43 ref NI_8 NS_43 0 1.8526730846837900e+00
GC_8_44 ref NI_8 NS_44 0 -4.1944107040234497e+00
GC_8_45 ref NI_8 NS_45 0 -2.3771020786443167e+00
GC_8_46 ref NI_8 NS_46 0 -1.3561490513084567e-02
GC_8_47 ref NI_8 NS_47 0 -1.2735833006312534e-02
GC_8_48 ref NI_8 NS_48 0 -1.4584248645683112e-04
GC_8_49 ref NI_8 NS_49 0 2.2595040626406670e-02
GC_8_50 ref NI_8 NS_50 0 -1.4584414833723455e-01
GC_8_51 ref NI_8 NS_51 0 5.0686093033320412e-01
GC_8_52 ref NI_8 NS_52 0 -8.1478732276890606e-02
GC_8_53 ref NI_8 NS_53 0 -8.8046195347980468e-04
GC_8_54 ref NI_8 NS_54 0 2.2235562385168006e-05
GC_8_55 ref NI_8 NS_55 0 1.2812745472612039e-01
GC_8_56 ref NI_8 NS_56 0 -2.6774692344033590e-01
GC_8_57 ref NI_8 NS_57 0 2.8420538156330927e-01
GC_8_58 ref NI_8 NS_58 0 4.5803501346678564e-02
GC_8_59 ref NI_8 NS_59 0 -1.1103130072360893e-03
GC_8_60 ref NI_8 NS_60 0 4.4084833274374658e-05
GC_8_61 ref NI_8 NS_61 0 4.3006014800357616e-02
GC_8_62 ref NI_8 NS_62 0 -1.2796869892585225e-01
GC_8_63 ref NI_8 NS_63 0 1.7022883975313971e-01
GC_8_64 ref NI_8 NS_64 0 7.8712332558377368e-02
GC_8_65 ref NI_8 NS_65 0 -3.9129179220216237e-04
GC_8_66 ref NI_8 NS_66 0 3.4286170078397787e-05
GC_8_67 ref NI_8 NS_67 0 3.5966461047908814e-02
GC_8_68 ref NI_8 NS_68 0 -1.2606822225885120e-01
GC_8_69 ref NI_8 NS_69 0 1.0117616520972214e-01
GC_8_70 ref NI_8 NS_70 0 1.1074446352942763e-01
GC_8_71 ref NI_8 NS_71 0 -3.2135214085712767e-04
GC_8_72 ref NI_8 NS_72 0 7.1522187658143172e-05
GC_8_73 ref NI_8 NS_73 0 -1.6780300854482316e-02
GC_8_74 ref NI_8 NS_74 0 -5.1552485132513391e-02
GC_8_75 ref NI_8 NS_75 0 4.6424548764616699e-02
GC_8_76 ref NI_8 NS_76 0 1.2418440336650438e-01
GC_8_77 ref NI_8 NS_77 0 8.1142970865773385e-04
GC_8_78 ref NI_8 NS_78 0 3.6811769271419051e-05
GC_8_79 ref NI_8 NS_79 0 3.5698936042850805e-03
GC_8_80 ref NI_8 NS_80 0 -6.3098634541793625e-02
GC_8_81 ref NI_8 NS_81 0 -5.0716744166955000e-02
GC_8_82 ref NI_8 NS_82 0 1.7146304353728728e-01
GC_8_83 ref NI_8 NS_83 0 9.4173999738690541e-04
GC_8_84 ref NI_8 NS_84 0 6.5070398125153096e-05
GC_8_85 ref NI_8 NS_85 0 1.3342458511737756e-01
GC_8_86 ref NI_8 NS_86 0 -1.5915963972173208e-01
GC_8_87 ref NI_8 NS_87 0 1.6698116611497160e-01
GC_8_88 ref NI_8 NS_88 0 9.0495244747908501e-02
GC_8_89 ref NI_8 NS_89 0 -1.9738717249353889e-03
GC_8_90 ref NI_8 NS_90 0 3.1233993425783466e-05
GD_8_1 ref NI_8 NA_1 0 2.0104896014060149e-02
GD_8_2 ref NI_8 NA_2 0 -7.7951972613773304e-02
GD_8_3 ref NI_8 NA_3 0 -1.3137542481508769e-02
GD_8_4 ref NI_8 NA_4 0 -1.5698269652004417e-02
GD_8_5 ref NI_8 NA_5 0 -2.6086618482116406e-03
GD_8_6 ref NI_8 NA_6 0 6.3821127405104219e-02
GD_8_7 ref NI_8 NA_7 0 4.8709966126277052e-02
GD_8_8 ref NI_8 NA_8 0 6.0939411266428198e+00
GD_8_9 ref NI_8 NA_9 0 -2.3293735811228144e-03
GD_8_10 ref NI_8 NA_10 0 -9.9767752982454841e-03
GD_8_11 ref NI_8 NA_11 0 -5.9260674732797411e-03
GD_8_12 ref NI_8 NA_12 0 -4.6007527147581074e-03
GD_8_13 ref NI_8 NA_13 0 -1.5304528967563802e-03
GD_8_14 ref NI_8 NA_14 0 -2.1467382504071889e-03
GD_8_15 ref NI_8 NA_15 0 -2.4972823865023586e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -8.8903899014474430e-02
GC_9_2 ref NI_9 NS_2 0 6.8973760201083395e-02
GC_9_3 ref NI_9 NS_3 0 -8.7251642426202411e-02
GC_9_4 ref NI_9 NS_4 0 1.3936409993771742e-01
GC_9_5 ref NI_9 NS_5 0 6.7004550996685539e-03
GC_9_6 ref NI_9 NS_6 0 2.0684674194554301e-04
GC_9_7 ref NI_9 NS_7 0 1.0848862850130248e-01
GC_9_8 ref NI_9 NS_8 0 3.9702898195166431e-01
GC_9_9 ref NI_9 NS_9 0 1.5583799948695590e-01
GC_9_10 ref NI_9 NS_10 0 -1.9957242698467104e-02
GC_9_11 ref NI_9 NS_11 0 -4.5668614716006277e-04
GC_9_12 ref NI_9 NS_12 0 3.7799244833718290e-05
GC_9_13 ref NI_9 NS_13 0 4.4437352189330578e-02
GC_9_14 ref NI_9 NS_14 0 -8.4258858884176252e-02
GC_9_15 ref NI_9 NS_15 0 3.3767713081062634e-02
GC_9_16 ref NI_9 NS_16 0 1.3320674379764930e-01
GC_9_17 ref NI_9 NS_17 0 2.6276106577944914e-04
GC_9_18 ref NI_9 NS_18 0 6.2182809440227310e-05
GC_9_19 ref NI_9 NS_19 0 9.3621461048105648e-02
GC_9_20 ref NI_9 NS_20 0 -1.4860219553406320e-01
GC_9_21 ref NI_9 NS_21 0 1.3940811987843019e-01
GC_9_22 ref NI_9 NS_22 0 9.3437812634262610e-02
GC_9_23 ref NI_9 NS_23 0 -6.7131433295210556e-04
GC_9_24 ref NI_9 NS_24 0 8.0259666642352017e-05
GC_9_25 ref NI_9 NS_25 0 7.1360471503157205e-02
GC_9_26 ref NI_9 NS_26 0 -2.7870033414099699e-01
GC_9_27 ref NI_9 NS_27 0 4.5118947044909574e-01
GC_9_28 ref NI_9 NS_28 0 -3.5845294567910892e-02
GC_9_29 ref NI_9 NS_29 0 -3.0455459883023118e-04
GC_9_30 ref NI_9 NS_30 0 1.0694632514747622e-04
GC_9_31 ref NI_9 NS_31 0 -2.9094897439540104e-02
GC_9_32 ref NI_9 NS_32 0 2.1996572769513043e-01
GC_9_33 ref NI_9 NS_33 0 4.4552391619231757e-01
GC_9_34 ref NI_9 NS_34 0 -1.1697801798132611e-01
GC_9_35 ref NI_9 NS_35 0 -5.8372776115266979e-04
GC_9_36 ref NI_9 NS_36 0 -4.6033396024516164e-05
GC_9_37 ref NI_9 NS_37 0 -1.1666913192718299e-01
GC_9_38 ref NI_9 NS_38 0 1.9079569491782891e-01
GC_9_39 ref NI_9 NS_39 0 4.8400421479127820e-01
GC_9_40 ref NI_9 NS_40 0 -1.2530248458108634e-01
GC_9_41 ref NI_9 NS_41 0 -3.3827238272701385e-04
GC_9_42 ref NI_9 NS_42 0 -1.8402258878193555e-05
GC_9_43 ref NI_9 NS_43 0 2.2595040626406129e-02
GC_9_44 ref NI_9 NS_44 0 -1.4584414833723391e-01
GC_9_45 ref NI_9 NS_45 0 5.0686093033320379e-01
GC_9_46 ref NI_9 NS_46 0 -8.1478732276890439e-02
GC_9_47 ref NI_9 NS_47 0 -8.8046195347981564e-04
GC_9_48 ref NI_9 NS_48 0 2.2235562385169551e-05
GC_9_49 ref NI_9 NS_49 0 9.0053646388824049e-01
GC_9_50 ref NI_9 NS_50 0 -1.2336838000368671e+00
GC_9_51 ref NI_9 NS_51 0 -2.3743973314529057e+00
GC_9_52 ref NI_9 NS_52 0 -5.0015180197677978e-01
GC_9_53 ref NI_9 NS_53 0 -1.7053607258750152e-02
GC_9_54 ref NI_9 NS_54 0 -5.1466402063001849e-04
GC_9_55 ref NI_9 NS_55 0 -5.3934232123446291e-01
GC_9_56 ref NI_9 NS_56 0 9.9612564366838408e-01
GC_9_57 ref NI_9 NS_57 0 4.8560061285213807e-01
GC_9_58 ref NI_9 NS_58 0 -2.7100741407201184e-01
GC_9_59 ref NI_9 NS_59 0 -1.6787537901079253e-04
GC_9_60 ref NI_9 NS_60 0 3.0626357243807213e-04
GC_9_61 ref NI_9 NS_61 0 4.0606810561568119e-02
GC_9_62 ref NI_9 NS_62 0 -1.1702995367158432e-01
GC_9_63 ref NI_9 NS_63 0 1.4256306551657183e-01
GC_9_64 ref NI_9 NS_64 0 8.5909426628047417e-02
GC_9_65 ref NI_9 NS_65 0 2.1546856015915207e-04
GC_9_66 ref NI_9 NS_66 0 3.9709310392362843e-05
GC_9_67 ref NI_9 NS_67 0 4.5846136207358858e-03
GC_9_68 ref NI_9 NS_68 0 -5.8720484301579258e-02
GC_9_69 ref NI_9 NS_69 0 5.1727762920668000e-03
GC_9_70 ref NI_9 NS_70 0 1.4098912495499091e-01
GC_9_71 ref NI_9 NS_71 0 9.4598216821010746e-04
GC_9_72 ref NI_9 NS_72 0 6.3804381061732761e-05
GC_9_73 ref NI_9 NS_73 0 -4.8480129082612303e-02
GC_9_74 ref NI_9 NS_74 0 2.0394410742576585e-02
GC_9_75 ref NI_9 NS_75 0 -7.1443374714675559e-02
GC_9_76 ref NI_9 NS_76 0 1.6323856114098584e-01
GC_9_77 ref NI_9 NS_77 0 2.2352842195833486e-03
GC_9_78 ref NI_9 NS_78 0 3.4726659181076957e-05
GC_9_79 ref NI_9 NS_79 0 -7.7634203401130225e-02
GC_9_80 ref NI_9 NS_80 0 6.4997907147795422e-02
GC_9_81 ref NI_9 NS_81 0 -1.8555347471096933e-01
GC_9_82 ref NI_9 NS_82 0 2.0906546479025997e-01
GC_9_83 ref NI_9 NS_83 0 3.1933823883820820e-03
GC_9_84 ref NI_9 NS_84 0 4.2709183408112354e-05
GC_9_85 ref NI_9 NS_85 0 -2.9142265412399151e-03
GC_9_86 ref NI_9 NS_86 0 1.2647512200171664e-02
GC_9_87 ref NI_9 NS_87 0 -1.2474846059399770e-01
GC_9_88 ref NI_9 NS_88 0 1.9670221699491006e-01
GC_9_89 ref NI_9 NS_89 0 8.4739774148555054e-04
GC_9_90 ref NI_9 NS_90 0 3.5309370789407401e-05
GD_9_1 ref NI_9 NA_1 0 1.6371365073705069e-02
GD_9_2 ref NI_9 NA_2 0 -3.6770733464139220e-02
GD_9_3 ref NI_9 NA_3 0 -5.9716208492877594e-03
GD_9_4 ref NI_9 NA_4 0 -9.9967370486201447e-03
GD_9_5 ref NI_9 NA_5 0 -9.0262947338557407e-03
GD_9_6 ref NI_9 NA_6 0 -1.2548895980242284e-03
GD_9_7 ref NI_9 NA_7 0 6.7091554151602261e-03
GD_9_8 ref NI_9 NA_8 0 -2.3293735811228144e-03
GD_9_9 ref NI_9 NA_9 0 6.1133540331502561e+00
GD_9_10 ref NI_9 NA_10 0 9.0462256005074682e-02
GD_9_11 ref NI_9 NA_11 0 1.9207134622713454e-03
GD_9_12 ref NI_9 NA_12 0 3.7107778380402637e-03
GD_9_13 ref NI_9 NA_13 0 6.1627841424859806e-03
GD_9_14 ref NI_9 NA_14 0 8.0174092437902619e-03
GD_9_15 ref NI_9 NA_15 0 -5.7145586039819571e-03
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -1.1405020586468159e-01
GC_10_2 ref NI_10 NS_2 0 7.4656507621982879e-02
GC_10_3 ref NI_10 NS_3 0 -1.5316699383988955e-01
GC_10_4 ref NI_10 NS_4 0 1.6387346122659155e-01
GC_10_5 ref NI_10 NS_5 0 8.8813586060149646e-03
GC_10_6 ref NI_10 NS_6 0 2.1636870436846244e-04
GC_10_7 ref NI_10 NS_7 0 1.1730085376544061e-01
GC_10_8 ref NI_10 NS_8 0 4.2826981201480019e-01
GC_10_9 ref NI_10 NS_9 0 9.6711045638116069e-02
GC_10_10 ref NI_10 NS_10 0 3.6668758371949015e-04
GC_10_11 ref NI_10 NS_11 0 -3.0258513530125920e-04
GC_10_12 ref NI_10 NS_12 0 5.0709744436657635e-05
GC_10_13 ref NI_10 NS_13 0 4.4796007209815074e-02
GC_10_14 ref NI_10 NS_14 0 -1.2253638266607580e-01
GC_10_15 ref NI_10 NS_15 0 7.7473914566131494e-02
GC_10_16 ref NI_10 NS_16 0 1.1771620593282915e-01
GC_10_17 ref NI_10 NS_17 0 7.9818765311617617e-04
GC_10_18 ref NI_10 NS_18 0 4.3755878369311934e-05
GC_10_19 ref NI_10 NS_19 0 1.9374405515037298e-02
GC_10_20 ref NI_10 NS_20 0 -1.4966908722213607e-01
GC_10_21 ref NI_10 NS_21 0 2.2837814653575317e-01
GC_10_22 ref NI_10 NS_22 0 5.1704741719242886e-02
GC_10_23 ref NI_10 NS_23 0 5.4111193211569338e-04
GC_10_24 ref NI_10 NS_24 0 3.4481379631492980e-05
GC_10_25 ref NI_10 NS_25 0 -3.8331644030712952e-01
GC_10_26 ref NI_10 NS_26 0 9.8217714242908549e-01
GC_10_27 ref NI_10 NS_27 0 1.8599482132509298e-01
GC_10_28 ref NI_10 NS_28 0 -1.2705633956594661e-01
GC_10_29 ref NI_10 NS_29 0 1.3605486321583819e-03
GC_10_30 ref NI_10 NS_30 0 -2.0228717773790826e-05
GC_10_31 ref NI_10 NS_31 0 7.4371743912537119e-02
GC_10_32 ref NI_10 NS_32 0 -4.2157936494316162e-01
GC_10_33 ref NI_10 NS_33 0 3.9186059958581909e-01
GC_10_34 ref NI_10 NS_34 0 2.6453407622746547e-02
GC_10_35 ref NI_10 NS_35 0 -6.1575674042557238e-04
GC_10_36 ref NI_10 NS_36 0 3.0671115593409625e-05
GC_10_37 ref NI_10 NS_37 0 2.0315227145811357e-01
GC_10_38 ref NI_10 NS_38 0 -2.4531290122036623e-01
GC_10_39 ref NI_10 NS_39 0 2.9724041504848148e-01
GC_10_40 ref NI_10 NS_40 0 2.9752404145808289e-02
GC_10_41 ref NI_10 NS_41 0 -1.1946399137422632e-03
GC_10_42 ref NI_10 NS_42 0 3.1739091324464886e-05
GC_10_43 ref NI_10 NS_43 0 1.2812745472612080e-01
GC_10_44 ref NI_10 NS_44 0 -2.6774692344033646e-01
GC_10_45 ref NI_10 NS_45 0 2.8420538156330954e-01
GC_10_46 ref NI_10 NS_46 0 4.5803501346678550e-02
GC_10_47 ref NI_10 NS_47 0 -1.1103130072361335e-03
GC_10_48 ref NI_10 NS_48 0 4.4084833274384186e-05
GC_10_49 ref NI_10 NS_49 0 -5.3934232123446346e-01
GC_10_50 ref NI_10 NS_50 0 9.9612564366838496e-01
GC_10_51 ref NI_10 NS_51 0 4.8560061285213701e-01
GC_10_52 ref NI_10 NS_52 0 -2.7100741407201123e-01
GC_10_53 ref NI_10 NS_53 0 -1.6787537901089526e-04
GC_10_54 ref NI_10 NS_54 0 3.0626357243807484e-04
GC_10_55 ref NI_10 NS_55 0 1.0071583718763555e+00
GC_10_56 ref NI_10 NS_56 0 -1.5904267469340569e+00
GC_10_57 ref NI_10 NS_57 0 -1.9314505563513602e+00
GC_10_58 ref NI_10 NS_58 0 -6.3007480619247991e-01
GC_10_59 ref NI_10 NS_59 0 -2.3351312059947824e-02
GC_10_60 ref NI_10 NS_60 0 -4.1839819965774498e-04
GC_10_61 ref NI_10 NS_61 0 -7.8527261757933370e-02
GC_10_62 ref NI_10 NS_62 0 1.6077022987394085e-01
GC_10_63 ref NI_10 NS_63 0 2.9230118859646975e-01
GC_10_64 ref NI_10 NS_64 0 -3.1856522015807673e-02
GC_10_65 ref NI_10 NS_65 0 -2.8967415657070875e-05
GC_10_66 ref NI_10 NS_66 0 1.1173224222790455e-05
GC_10_67 ref NI_10 NS_67 0 1.3490972947845733e-03
GC_10_68 ref NI_10 NS_68 0 -5.6919294876642122e-02
GC_10_69 ref NI_10 NS_69 0 1.1002468854559695e-01
GC_10_70 ref NI_10 NS_70 0 8.9347037160146012e-02
GC_10_71 ref NI_10 NS_71 0 9.7534725990070111e-04
GC_10_72 ref NI_10 NS_72 0 3.7404397464373273e-05
GC_10_73 ref NI_10 NS_73 0 -5.1804719505541809e-02
GC_10_74 ref NI_10 NS_74 0 3.1806265024295184e-02
GC_10_75 ref NI_10 NS_75 0 -2.2252971898086022e-02
GC_10_76 ref NI_10 NS_76 0 1.3755836505144481e-01
GC_10_77 ref NI_10 NS_77 0 2.1959356642182602e-03
GC_10_78 ref NI_10 NS_78 0 1.9959178006938830e-05
GC_10_79 ref NI_10 NS_79 0 -6.4774195413742755e-02
GC_10_80 ref NI_10 NS_80 0 5.1109808400336451e-02
GC_10_81 ref NI_10 NS_81 0 -1.4963916144901745e-01
GC_10_82 ref NI_10 NS_82 0 1.9424927124200625e-01
GC_10_83 ref NI_10 NS_83 0 2.9683292392902686e-03
GC_10_84 ref NI_10 NS_84 0 3.9817181680001767e-05
GC_10_85 ref NI_10 NS_85 0 -6.3057326573325106e-02
GC_10_86 ref NI_10 NS_86 0 6.9299327169337399e-02
GC_10_87 ref NI_10 NS_87 0 -1.9741725322025380e-01
GC_10_88 ref NI_10 NS_88 0 2.1698343649650048e-01
GC_10_89 ref NI_10 NS_89 0 3.0014410095188272e-03
GC_10_90 ref NI_10 NS_90 0 2.8121008830034706e-05
GD_10_1 ref NI_10 NA_1 0 1.7168938566001820e-02
GD_10_2 ref NI_10 NA_2 0 -3.2111577907632208e-02
GD_10_3 ref NI_10 NA_3 0 -3.8516233713632585e-03
GD_10_4 ref NI_10 NA_4 0 -8.1856992333746942e-04
GD_10_5 ref NI_10 NA_5 0 4.4535667981603987e-02
GD_10_6 ref NI_10 NA_6 0 -8.6036206167567075e-03
GD_10_7 ref NI_10 NA_7 0 -1.1864020847628259e-02
GD_10_8 ref NI_10 NA_8 0 -9.9767752982454841e-03
GD_10_9 ref NI_10 NA_9 0 9.0462256005074682e-02
GD_10_10 ref NI_10 NA_10 0 6.0637075668289375e+00
GD_10_11 ref NI_10 NA_11 0 1.8658480781281850e-02
GD_10_12 ref NI_10 NA_12 0 7.5345161231671837e-03
GD_10_13 ref NI_10 NA_13 0 8.5060545700511893e-03
GD_10_14 ref NI_10 NA_14 0 7.9262646175814119e-03
GD_10_15 ref NI_10 NA_15 0 1.5872807627821651e-03
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -1.4204171831315579e-01
GC_11_2 ref NI_11 NS_2 0 1.3308308847153075e-01
GC_11_3 ref NI_11 NS_3 0 -1.6709136437793454e-01
GC_11_4 ref NI_11 NS_4 0 1.5902686556367227e-01
GC_11_5 ref NI_11 NS_5 0 9.3750638652342413e-03
GC_11_6 ref NI_11 NS_6 0 2.1892956389264230e-04
GC_11_7 ref NI_11 NS_7 0 1.4623270295319116e-01
GC_11_8 ref NI_11 NS_8 0 5.2447691992288958e-01
GC_11_9 ref NI_11 NS_9 0 6.4678881869545762e-02
GC_11_10 ref NI_11 NS_10 0 -3.6716204282307785e-03
GC_11_11 ref NI_11 NS_11 0 -3.9533907939563062e-04
GC_11_12 ref NI_11 NS_12 0 4.1266681446488675e-05
GC_11_13 ref NI_11 NS_13 0 6.6835269452294566e-02
GC_11_14 ref NI_11 NS_14 0 -1.0589900651813254e-01
GC_11_15 ref NI_11 NS_15 0 1.5574538979703662e-01
GC_11_16 ref NI_11 NS_16 0 7.8125888099153010e-02
GC_11_17 ref NI_11 NS_17 0 -4.9532973777158100e-04
GC_11_18 ref NI_11 NS_18 0 7.1490751448037552e-05
GC_11_19 ref NI_11 NS_19 0 3.3241926527289745e-02
GC_11_20 ref NI_11 NS_20 0 -2.2725841487520632e-01
GC_11_21 ref NI_11 NS_21 0 3.9636558456274934e-01
GC_11_22 ref NI_11 NS_22 0 -1.4534198677824958e-02
GC_11_23 ref NI_11 NS_23 0 2.4434590298124677e-04
GC_11_24 ref NI_11 NS_24 0 3.5604774685495745e-05
GC_11_25 ref NI_11 NS_25 0 -4.3715610037839969e-02
GC_11_26 ref NI_11 NS_26 0 1.5457830656626395e-01
GC_11_27 ref NI_11 NS_27 0 2.2756448450304995e-01
GC_11_28 ref NI_11 NS_28 0 -7.7250234857347455e-04
GC_11_29 ref NI_11 NS_29 0 2.6201347067095600e-04
GC_11_30 ref NI_11 NS_30 0 1.4115108743830836e-05
GC_11_31 ref NI_11 NS_31 0 7.4657830512006487e-02
GC_11_32 ref NI_11 NS_32 0 -1.7009160939360876e-01
GC_11_33 ref NI_11 NS_33 0 1.6292724863445940e-01
GC_11_34 ref NI_11 NS_34 0 8.8032707089326936e-02
GC_11_35 ref NI_11 NS_35 0 -2.8755205024782717e-04
GC_11_36 ref NI_11 NS_36 0 3.4847519153554510e-05
GC_11_37 ref NI_11 NS_37 0 6.1961984069639674e-02
GC_11_38 ref NI_11 NS_38 0 -8.9812843465290768e-02
GC_11_39 ref NI_11 NS_39 0 1.5884049490865815e-01
GC_11_40 ref NI_11 NS_40 0 7.6105057582315366e-02
GC_11_41 ref NI_11 NS_41 0 -4.5762214672962571e-04
GC_11_42 ref NI_11 NS_42 0 2.8783047928867830e-05
GC_11_43 ref NI_11 NS_43 0 4.3006014800357852e-02
GC_11_44 ref NI_11 NS_44 0 -1.2796869892585244e-01
GC_11_45 ref NI_11 NS_45 0 1.7022883975313982e-01
GC_11_46 ref NI_11 NS_46 0 7.8712332558377313e-02
GC_11_47 ref NI_11 NS_47 0 -3.9129179220212832e-04
GC_11_48 ref NI_11 NS_48 0 3.4286170078397373e-05
GC_11_49 ref NI_11 NS_49 0 4.0606810561567418e-02
GC_11_50 ref NI_11 NS_50 0 -1.1702995367158321e-01
GC_11_51 ref NI_11 NS_51 0 1.4256306551657097e-01
GC_11_52 ref NI_11 NS_52 0 8.5909426628047708e-02
GC_11_53 ref NI_11 NS_53 0 2.1546856015919558e-04
GC_11_54 ref NI_11 NS_54 0 3.9709310392360986e-05
GC_11_55 ref NI_11 NS_55 0 -7.8527261757933634e-02
GC_11_56 ref NI_11 NS_56 0 1.6077022987394110e-01
GC_11_57 ref NI_11 NS_57 0 2.9230118859646986e-01
GC_11_58 ref NI_11 NS_58 0 -3.1856522015807888e-02
GC_11_59 ref NI_11 NS_59 0 -2.8967415656951352e-05
GC_11_60 ref NI_11 NS_60 0 1.1173224222770792e-05
GC_11_61 ref NI_11 NS_61 0 7.3584030929846100e-01
GC_11_62 ref NI_11 NS_62 0 -1.0837691702906040e+00
GC_11_63 ref NI_11 NS_63 0 -2.0283894606597945e+00
GC_11_64 ref NI_11 NS_64 0 -6.8330184339252098e-01
GC_11_65 ref NI_11 NS_65 0 -1.8881436103172864e-02
GC_11_66 ref NI_11 NS_66 0 -4.9126744748267059e-04
GC_11_67 ref NI_11 NS_67 0 -4.6361465753643988e-01
GC_11_68 ref NI_11 NS_68 0 8.8014242149625299e-01
GC_11_69 ref NI_11 NS_69 0 4.6588578054784807e-01
GC_11_70 ref NI_11 NS_70 0 -2.4524082723942386e-01
GC_11_71 ref NI_11 NS_71 0 -9.1152176882527625e-06
GC_11_72 ref NI_11 NS_72 0 3.0760554274876593e-04
GC_11_73 ref NI_11 NS_73 0 9.5097620588181532e-03
GC_11_74 ref NI_11 NS_74 0 -7.5651678813238421e-02
GC_11_75 ref NI_11 NS_75 0 1.6623916866147051e-01
GC_11_76 ref NI_11 NS_76 0 6.7309104245504681e-02
GC_11_77 ref NI_11 NS_77 0 4.5620168532067043e-04
GC_11_78 ref NI_11 NS_78 0 3.5510268805963278e-05
GC_11_79 ref NI_11 NS_79 0 1.9282939095711073e-02
GC_11_80 ref NI_11 NS_80 0 -7.2048207524512756e-02
GC_11_81 ref NI_11 NS_81 0 -1.0287467719363650e-02
GC_11_82 ref NI_11 NS_82 0 1.5212538320820079e-01
GC_11_83 ref NI_11 NS_83 0 7.9114102846430424e-04
GC_11_84 ref NI_11 NS_84 0 5.7163342671145773e-05
GC_11_85 ref NI_11 NS_85 0 -8.1039089976415818e-02
GC_11_86 ref NI_11 NS_86 0 1.0570123124342630e-01
GC_11_87 ref NI_11 NS_87 0 -1.8599442983643488e-01
GC_11_88 ref NI_11 NS_88 0 2.0326830367011892e-01
GC_11_89 ref NI_11 NS_89 0 3.6753735939116933e-03
GC_11_90 ref NI_11 NS_90 0 1.7633841743998006e-05
GD_11_1 ref NI_11 NA_1 0 1.9999689043709724e-02
GD_11_2 ref NI_11 NA_2 0 -3.7813775352277326e-02
GD_11_3 ref NI_11 NA_3 0 -5.2009778954253162e-03
GD_11_4 ref NI_11 NA_4 0 -6.6472509043282195e-03
GD_11_5 ref NI_11 NA_5 0 3.5874533397585876e-03
GD_11_6 ref NI_11 NA_6 0 -7.3918823159972932e-03
GD_11_7 ref NI_11 NA_7 0 -6.8932572634914941e-03
GD_11_8 ref NI_11 NA_8 0 -5.9260674732797411e-03
GD_11_9 ref NI_11 NA_9 0 1.9207134622713454e-03
GD_11_10 ref NI_11 NA_10 0 1.8658480781281850e-02
GD_11_11 ref NI_11 NA_11 0 6.0925098355134812e+00
GD_11_12 ref NI_11 NA_12 0 9.0102905713011910e-02
GD_11_13 ref NI_11 NA_13 0 6.1656006559655694e-03
GD_11_14 ref NI_11 NA_14 0 2.0077702811227669e-03
GD_11_15 ref NI_11 NA_15 0 2.1198406748560140e-03
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -1.4218906460072583e-01
GC_12_2 ref NI_12 NS_2 0 1.1384611229556887e-01
GC_12_3 ref NI_12 NS_3 0 -1.7511748933460924e-01
GC_12_4 ref NI_12 NS_4 0 1.6468039173238155e-01
GC_12_5 ref NI_12 NS_5 0 9.8042215362501503e-03
GC_12_6 ref NI_12 NS_6 0 2.2314011211064977e-04
GC_12_7 ref NI_12 NS_7 0 5.6085882655045216e-02
GC_12_8 ref NI_12 NS_8 0 5.4060376867980908e-01
GC_12_9 ref NI_12 NS_9 0 6.1128729578980634e-02
GC_12_10 ref NI_12 NS_10 0 1.1219283055735839e-03
GC_12_11 ref NI_12 NS_11 0 -4.9013921685794133e-04
GC_12_12 ref NI_12 NS_12 0 4.7185488590366736e-05
GC_12_13 ref NI_12 NS_13 0 -1.7599528761135903e-03
GC_12_14 ref NI_12 NS_14 0 -1.5180817221214885e-01
GC_12_15 ref NI_12 NS_15 0 3.6715497417449627e-01
GC_12_16 ref NI_12 NS_16 0 -1.3784128381279258e-02
GC_12_17 ref NI_12 NS_17 0 2.2228326685110397e-04
GC_12_18 ref NI_12 NS_18 0 2.0898143236128178e-05
GC_12_19 ref NI_12 NS_19 0 -4.6196955147838459e-01
GC_12_20 ref NI_12 NS_20 0 1.1151341180349212e+00
GC_12_21 ref NI_12 NS_21 0 1.8875658450098728e-01
GC_12_22 ref NI_12 NS_22 0 -1.5215356345070091e-01
GC_12_23 ref NI_12 NS_23 0 2.1783433964862788e-03
GC_12_24 ref NI_12 NS_24 0 -3.8299974054457264e-05
GC_12_25 ref NI_12 NS_25 0 5.4152201663332789e-02
GC_12_26 ref NI_12 NS_26 0 -2.9738687548534415e-01
GC_12_27 ref NI_12 NS_27 0 3.0001210163982567e-01
GC_12_28 ref NI_12 NS_28 0 4.4097436332905915e-02
GC_12_29 ref NI_12 NS_29 0 4.8795556225509241e-04
GC_12_30 ref NI_12 NS_30 0 2.9945026260878572e-05
GC_12_31 ref NI_12 NS_31 0 7.3550899664257041e-02
GC_12_32 ref NI_12 NS_32 0 -2.0270514519133195e-01
GC_12_33 ref NI_12 NS_33 0 1.0149597777249315e-01
GC_12_34 ref NI_12 NS_34 0 1.2269573276119698e-01
GC_12_35 ref NI_12 NS_35 0 -2.1102800132421183e-04
GC_12_36 ref NI_12 NS_36 0 7.3346314526150254e-05
GC_12_37 ref NI_12 NS_37 0 6.3684076881170934e-02
GC_12_38 ref NI_12 NS_38 0 -1.1073038710766669e-01
GC_12_39 ref NI_12 NS_39 0 8.4925211242733542e-02
GC_12_40 ref NI_12 NS_40 0 1.1439715864826228e-01
GC_12_41 ref NI_12 NS_41 0 -4.2848589372924267e-04
GC_12_42 ref NI_12 NS_42 0 6.9315208545754853e-05
GC_12_43 ref NI_12 NS_43 0 3.5966461047907558e-02
GC_12_44 ref NI_12 NS_44 0 -1.2606822225884953e-01
GC_12_45 ref NI_12 NS_45 0 1.0117616520972100e-01
GC_12_46 ref NI_12 NS_46 0 1.1074446352942804e-01
GC_12_47 ref NI_12 NS_47 0 -3.2135214085716400e-04
GC_12_48 ref NI_12 NS_48 0 7.1522187658156833e-05
GC_12_49 ref NI_12 NS_49 0 4.5846136207352735e-03
GC_12_50 ref NI_12 NS_50 0 -5.8720484301578488e-02
GC_12_51 ref NI_12 NS_51 0 5.1727762920662813e-03
GC_12_52 ref NI_12 NS_52 0 1.4098912495499111e-01
GC_12_53 ref NI_12 NS_53 0 9.4598216821008729e-04
GC_12_54 ref NI_12 NS_54 0 6.3804381061726784e-05
GC_12_55 ref NI_12 NS_55 0 1.3490972947856285e-03
GC_12_56 ref NI_12 NS_56 0 -5.6919294876643649e-02
GC_12_57 ref NI_12 NS_57 0 1.1002468854559827e-01
GC_12_58 ref NI_12 NS_58 0 8.9347037160145359e-02
GC_12_59 ref NI_12 NS_59 0 9.7534725990079056e-04
GC_12_60 ref NI_12 NS_60 0 3.7404397464383884e-05
GC_12_61 ref NI_12 NS_61 0 -4.6361465753644099e-01
GC_12_62 ref NI_12 NS_62 0 8.8014242149625455e-01
GC_12_63 ref NI_12 NS_63 0 4.6588578054784652e-01
GC_12_64 ref NI_12 NS_64 0 -2.4524082723942298e-01
GC_12_65 ref NI_12 NS_65 0 -9.1152176884406852e-06
GC_12_66 ref NI_12 NS_66 0 3.0760554274876370e-04
GC_12_67 ref NI_12 NS_67 0 1.1041995202010877e+00
GC_12_68 ref NI_12 NS_68 0 -1.7586232063722325e+00
GC_12_69 ref NI_12 NS_69 0 -1.9812558770286626e+00
GC_12_70 ref NI_12 NS_70 0 -5.8118101278828838e-01
GC_12_71 ref NI_12 NS_71 0 -2.1111468529357389e-02
GC_12_72 ref NI_12 NS_72 0 -5.3887429858064052e-04
GC_12_73 ref NI_12 NS_73 0 -9.8245723814951072e-02
GC_12_74 ref NI_12 NS_74 0 2.1117096938186092e-01
GC_12_75 ref NI_12 NS_75 0 3.7179509821731410e-01
GC_12_76 ref NI_12 NS_76 0 -7.7132592120774682e-02
GC_12_77 ref NI_12 NS_77 0 -8.2010262792304024e-04
GC_12_78 ref NI_12 NS_78 0 8.1453884240530017e-06
GC_12_79 ref NI_12 NS_79 0 1.2858231527608879e-01
GC_12_80 ref NI_12 NS_80 0 -2.3326099119615701e-01
GC_12_81 ref NI_12 NS_81 0 2.0124068111573726e-01
GC_12_82 ref NI_12 NS_82 0 8.0114447836320560e-02
GC_12_83 ref NI_12 NS_83 0 -1.3092067597824579e-03
GC_12_84 ref NI_12 NS_84 0 4.5733537608915424e-05
GC_12_85 ref NI_12 NS_85 0 -9.1622311068828774e-02
GC_12_86 ref NI_12 NS_86 0 9.5067218824206795e-02
GC_12_87 ref NI_12 NS_87 0 -2.1168030244121849e-01
GC_12_88 ref NI_12 NS_88 0 2.1626501681846366e-01
GC_12_89 ref NI_12 NS_89 0 4.0171305088319096e-03
GC_12_90 ref NI_12 NS_90 0 3.5171519234612980e-05
GD_12_1 ref NI_12 NA_1 0 1.9527718619251580e-02
GD_12_2 ref NI_12 NA_2 0 -2.8194506199163624e-02
GD_12_3 ref NI_12 NA_3 0 3.1629939182118857e-03
GD_12_4 ref NI_12 NA_4 0 5.2937930395157998e-02
GD_12_5 ref NI_12 NA_5 0 -6.0577653854758462e-03
GD_12_6 ref NI_12 NA_6 0 -6.8009738184829638e-03
GD_12_7 ref NI_12 NA_7 0 -6.1983703789898039e-03
GD_12_8 ref NI_12 NA_8 0 -4.6007527147581074e-03
GD_12_9 ref NI_12 NA_9 0 3.7107778380402637e-03
GD_12_10 ref NI_12 NA_10 0 7.5345161231671837e-03
GD_12_11 ref NI_12 NA_11 0 9.0102905713011910e-02
GD_12_12 ref NI_12 NA_12 0 6.0502567351314003e+00
GD_12_13 ref NI_12 NA_13 0 2.2689584203541842e-02
GD_12_14 ref NI_12 NA_14 0 -4.4299087593861874e-03
GD_12_15 ref NI_12 NA_15 0 4.4984336647388443e-03
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -1.6468133022701645e-01
GC_13_2 ref NI_13 NS_2 0 1.6243086020251521e-01
GC_13_3 ref NI_13 NS_3 0 -1.8628585600505981e-01
GC_13_4 ref NI_13 NS_4 0 1.6013361524833444e-01
GC_13_5 ref NI_13 NS_5 0 1.0387552861638711e-02
GC_13_6 ref NI_13 NS_6 0 2.1836600214517773e-04
GC_13_7 ref NI_13 NS_7 0 1.5480973724393909e-01
GC_13_8 ref NI_13 NS_8 0 5.8309433133151556e-01
GC_13_9 ref NI_13 NS_9 0 7.1930268854515315e-03
GC_13_10 ref NI_13 NS_10 0 1.2013149680040806e-02
GC_13_11 ref NI_13 NS_11 0 -3.7115722699807778e-04
GC_13_12 ref NI_13 NS_12 0 4.4050680083240178e-05
GC_13_13 ref NI_13 NS_13 0 1.5932882337242132e-01
GC_13_14 ref NI_13 NS_14 0 -4.3308938368885597e-01
GC_13_15 ref NI_13 NS_15 0 5.9231521845553248e-01
GC_13_16 ref NI_13 NS_16 0 -7.2047705854834679e-02
GC_13_17 ref NI_13 NS_17 0 -1.7863603677127384e-03
GC_13_18 ref NI_13 NS_18 0 4.2017955132014029e-05
GC_13_19 ref NI_13 NS_19 0 -2.7629122773045991e-02
GC_13_20 ref NI_13 NS_20 0 1.3223544350781588e-01
GC_13_21 ref NI_13 NS_21 0 2.9531485842489280e-01
GC_13_22 ref NI_13 NS_22 0 -2.9434503491973716e-02
GC_13_23 ref NI_13 NS_23 0 -2.7974578916613920e-04
GC_13_24 ref NI_13 NS_24 0 2.2093027422823510e-05
GC_13_25 ref NI_13 NS_25 0 3.0380742040479195e-02
GC_13_26 ref NI_13 NS_26 0 -6.8693560263387576e-02
GC_13_27 ref NI_13 NS_27 0 1.0143317536179050e-01
GC_13_28 ref NI_13 NS_28 0 9.8558067531617888e-02
GC_13_29 ref NI_13 NS_29 0 5.3674023433235838e-04
GC_13_30 ref NI_13 NS_30 0 3.1166988198583224e-05
GC_13_31 ref NI_13 NS_31 0 2.8754049015220294e-02
GC_13_32 ref NI_13 NS_32 0 -9.2252553835920709e-02
GC_13_33 ref NI_13 NS_33 0 2.5067288122809245e-02
GC_13_34 ref NI_13 NS_34 0 1.3872304951822217e-01
GC_13_35 ref NI_13 NS_35 0 9.7408051926771802e-04
GC_13_36 ref NI_13 NS_36 0 3.9671008732546418e-05
GC_13_37 ref NI_13 NS_37 0 -2.7809276296468398e-03
GC_13_38 ref NI_13 NS_38 0 -3.6469038136896170e-02
GC_13_39 ref NI_13 NS_39 0 2.9489303583327398e-02
GC_13_40 ref NI_13 NS_40 0 1.2863280467630445e-01
GC_13_41 ref NI_13 NS_41 0 8.5699644387384475e-04
GC_13_42 ref NI_13 NS_42 0 3.5893844076771894e-05
GC_13_43 ref NI_13 NS_43 0 -1.6780300854482125e-02
GC_13_44 ref NI_13 NS_44 0 -5.1552485132513620e-02
GC_13_45 ref NI_13 NS_45 0 4.6424548764616921e-02
GC_13_46 ref NI_13 NS_46 0 1.2418440336650420e-01
GC_13_47 ref NI_13 NS_47 0 8.1142970865777917e-04
GC_13_48 ref NI_13 NS_48 0 3.6811769271412993e-05
GC_13_49 ref NI_13 NS_49 0 -4.8480129082613031e-02
GC_13_50 ref NI_13 NS_50 0 2.0394410742577772e-02
GC_13_51 ref NI_13 NS_51 0 -7.1443374714676586e-02
GC_13_52 ref NI_13 NS_52 0 1.6323856114098642e-01
GC_13_53 ref NI_13 NS_53 0 2.2352842195832341e-03
GC_13_54 ref NI_13 NS_54 0 3.4726659181119424e-05
GC_13_55 ref NI_13 NS_55 0 -5.1804719505539942e-02
GC_13_56 ref NI_13 NS_56 0 3.1806265024292325e-02
GC_13_57 ref NI_13 NS_57 0 -2.2252971898083458e-02
GC_13_58 ref NI_13 NS_58 0 1.3755836505144345e-01
GC_13_59 ref NI_13 NS_59 0 2.1959356642184979e-03
GC_13_60 ref NI_13 NS_60 0 1.9959178006898443e-05
GC_13_61 ref NI_13 NS_61 0 9.5097620588161756e-03
GC_13_62 ref NI_13 NS_62 0 -7.5651678813235562e-02
GC_13_63 ref NI_13 NS_63 0 1.6623916866146815e-01
GC_13_64 ref NI_13 NS_64 0 6.7309104245505860e-02
GC_13_65 ref NI_13 NS_65 0 4.5620168532043836e-04
GC_13_66 ref NI_13 NS_66 0 3.5510268806020707e-05
GC_13_67 ref NI_13 NS_67 0 -9.8245723814950614e-02
GC_13_68 ref NI_13 NS_68 0 2.1117096938186014e-01
GC_13_69 ref NI_13 NS_69 0 3.7179509821731499e-01
GC_13_70 ref NI_13 NS_70 0 -7.7132592120775265e-02
GC_13_71 ref NI_13 NS_71 0 -8.2010262792287121e-04
GC_13_72 ref NI_13 NS_72 0 8.1453884240040551e-06
GC_13_73 ref NI_13 NS_73 0 8.2182103510840598e-01
GC_13_74 ref NI_13 NS_74 0 -1.1824379923346364e+00
GC_13_75 ref NI_13 NS_75 0 -1.9473178182124147e+00
GC_13_76 ref NI_13 NS_76 0 -7.0119268970843263e-01
GC_13_77 ref NI_13 NS_77 0 -2.1573124579756714e-02
GC_13_78 ref NI_13 NS_78 0 -4.4425359568282439e-04
GC_13_79 ref NI_13 NS_79 0 -2.6796117599687025e-01
GC_13_80 ref NI_13 NS_80 0 5.5158664337932894e-01
GC_13_81 ref NI_13 NS_81 0 8.0981089853733679e-01
GC_13_82 ref NI_13 NS_82 0 -3.4501163276654290e-01
GC_13_83 ref NI_13 NS_83 0 -4.5750377592625249e-03
GC_13_84 ref NI_13 NS_84 0 3.2185713278932505e-04
GC_13_85 ref NI_13 NS_85 0 -1.1500962532583812e-01
GC_13_86 ref NI_13 NS_86 0 1.4386280350165176e-01
GC_13_87 ref NI_13 NS_87 0 -2.0978120657545979e-01
GC_13_88 ref NI_13 NS_88 0 2.0482435656405304e-01
GC_13_89 ref NI_13 NS_89 0 4.9351207171987295e-03
GC_13_90 ref NI_13 NS_90 0 1.3871414078059774e-05
GD_13_1 ref NI_13 NA_1 0 2.1898767838031411e-02
GD_13_2 ref NI_13 NA_2 0 -3.6002737806601390e-02
GD_13_3 ref NI_13 NA_3 0 -1.3728095042594613e-02
GD_13_4 ref NI_13 NA_4 0 3.2780272807221519e-03
GD_13_5 ref NI_13 NA_5 0 -4.4889550180056796e-03
GD_13_6 ref NI_13 NA_6 0 -3.8113355622217673e-03
GD_13_7 ref NI_13 NA_7 0 -2.4629870343301323e-03
GD_13_8 ref NI_13 NA_8 0 -1.5304528967563802e-03
GD_13_9 ref NI_13 NA_9 0 6.1627841424859806e-03
GD_13_10 ref NI_13 NA_10 0 8.5060545700511893e-03
GD_13_11 ref NI_13 NA_11 0 6.1656006559655694e-03
GD_13_12 ref NI_13 NA_12 0 2.2689584203541842e-02
GD_13_13 ref NI_13 NA_13 0 6.0888069764757784e+00
GD_13_14 ref NI_13 NA_14 0 6.8718700731600413e-02
GD_13_15 ref NI_13 NA_15 0 5.4520878057401851e-03
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 -1.6428218653948490e-01
GC_14_2 ref NI_14 NS_2 0 1.4042105480275494e-01
GC_14_3 ref NI_14 NS_3 0 -2.0433904925410021e-01
GC_14_4 ref NI_14 NS_4 0 1.7160560332369551e-01
GC_14_5 ref NI_14 NS_5 0 1.0926717819319108e-02
GC_14_6 ref NI_14 NS_6 0 2.1410440704557350e-04
GC_14_7 ref NI_14 NS_7 0 3.2047957076933552e-03
GC_14_8 ref NI_14 NS_8 0 3.3505998652353636e-01
GC_14_9 ref NI_14 NS_9 0 1.0209673400879068e-01
GC_14_10 ref NI_14 NS_10 0 2.4645687037024893e-02
GC_14_11 ref NI_14 NS_11 0 -1.3314483435450459e-04
GC_14_12 ref NI_14 NS_12 0 4.7021707574518518e-05
GC_14_13 ref NI_14 NS_13 0 -5.8841355966368525e-01
GC_14_14 ref NI_14 NS_14 0 1.3028911656056181e+00
GC_14_15 ref NI_14 NS_15 0 6.3416150153847251e-01
GC_14_16 ref NI_14 NS_16 0 -3.8915266776928736e-01
GC_14_17 ref NI_14 NS_17 0 3.1811008202446716e-04
GC_14_18 ref NI_14 NS_18 0 -1.1854020138222792e-04
GC_14_19 ref NI_14 NS_19 0 1.7125361735288186e-01
GC_14_20 ref NI_14 NS_20 0 -5.4134129798197206e-01
GC_14_21 ref NI_14 NS_21 0 5.1151486138231106e-01
GC_14_22 ref NI_14 NS_22 0 -1.4380174425299149e-02
GC_14_23 ref NI_14 NS_23 0 -1.0779999370415566e-03
GC_14_24 ref NI_14 NS_24 0 3.7686175875623653e-05
GC_14_25 ref NI_14 NS_25 0 9.8427180003273843e-02
GC_14_26 ref NI_14 NS_26 0 -2.0018500543447801e-01
GC_14_27 ref NI_14 NS_27 0 5.4535035225376685e-02
GC_14_28 ref NI_14 NS_28 0 1.4310657174177790e-01
GC_14_29 ref NI_14 NS_29 0 2.5976475341259121e-04
GC_14_30 ref NI_14 NS_30 0 5.8281384175240082e-05
GC_14_31 ref NI_14 NS_31 0 2.4180268558174605e-02
GC_14_32 ref NI_14 NS_32 0 -8.7447132386339596e-02
GC_14_33 ref NI_14 NS_33 0 -7.0381409180391971e-02
GC_14_34 ref NI_14 NS_34 0 1.8335956755487140e-01
GC_14_35 ref NI_14 NS_35 0 1.1000093296609241e-03
GC_14_36 ref NI_14 NS_36 0 7.7320104972884929e-05
GC_14_37 ref NI_14 NS_37 0 1.3693588730061376e-02
GC_14_38 ref NI_14 NS_38 0 -5.0117786702574205e-02
GC_14_39 ref NI_14 NS_39 0 -7.1152015408175451e-02
GC_14_40 ref NI_14 NS_40 0 1.7791652528033930e-01
GC_14_41 ref NI_14 NS_41 0 9.1119042622089233e-04
GC_14_42 ref NI_14 NS_42 0 7.9939346040347074e-05
GC_14_43 ref NI_14 NS_43 0 3.5698936042855480e-03
GC_14_44 ref NI_14 NS_44 0 -6.3098634541794207e-02
GC_14_45 ref NI_14 NS_45 0 -5.0716744166954521e-02
GC_14_46 ref NI_14 NS_46 0 1.7146304353728700e-01
GC_14_47 ref NI_14 NS_47 0 9.4173999738698423e-04
GC_14_48 ref NI_14 NS_48 0 6.5070398125153246e-05
GC_14_49 ref NI_14 NS_49 0 -7.7634203401130045e-02
GC_14_50 ref NI_14 NS_50 0 6.4997907147795006e-02
GC_14_51 ref NI_14 NS_51 0 -1.8555347471096875e-01
GC_14_52 ref NI_14 NS_52 0 2.0906546479025961e-01
GC_14_53 ref NI_14 NS_53 0 3.1933823883821583e-03
GC_14_54 ref NI_14 NS_54 0 4.2709183408095759e-05
GC_14_55 ref NI_14 NS_55 0 -6.4774195413741770e-02
GC_14_56 ref NI_14 NS_56 0 5.1109808400335112e-02
GC_14_57 ref NI_14 NS_57 0 -1.4963916144901643e-01
GC_14_58 ref NI_14 NS_58 0 1.9424927124200572e-01
GC_14_59 ref NI_14 NS_59 0 2.9683292392903389e-03
GC_14_60 ref NI_14 NS_60 0 3.9817181680023187e-05
GC_14_61 ref NI_14 NS_61 0 1.9282939095709984e-02
GC_14_62 ref NI_14 NS_62 0 -7.2048207524511285e-02
GC_14_63 ref NI_14 NS_63 0 -1.0287467719364722e-02
GC_14_64 ref NI_14 NS_64 0 1.5212538320820124e-01
GC_14_65 ref NI_14 NS_65 0 7.9114102846434403e-04
GC_14_66 ref NI_14 NS_66 0 5.7163342671093616e-05
GC_14_67 ref NI_14 NS_67 0 1.2858231527608899e-01
GC_14_68 ref NI_14 NS_68 0 -2.3326099119615709e-01
GC_14_69 ref NI_14 NS_69 0 2.0124068111573709e-01
GC_14_70 ref NI_14 NS_70 0 8.0114447836320657e-02
GC_14_71 ref NI_14 NS_71 0 -1.3092067597824809e-03
GC_14_72 ref NI_14 NS_72 0 4.5733537608948364e-05
GC_14_73 ref NI_14 NS_73 0 -2.6796117599687014e-01
GC_14_74 ref NI_14 NS_74 0 5.5158664337932906e-01
GC_14_75 ref NI_14 NS_75 0 8.0981089853733657e-01
GC_14_76 ref NI_14 NS_76 0 -3.4501163276654279e-01
GC_14_77 ref NI_14 NS_77 0 -4.5750377592624746e-03
GC_14_78 ref NI_14 NS_78 0 3.2185713278929198e-04
GC_14_79 ref NI_14 NS_79 0 9.7015501742814747e-01
GC_14_80 ref NI_14 NS_80 0 -1.3394593592617654e+00
GC_14_81 ref NI_14 NS_81 0 -1.3276183807121820e+00
GC_14_82 ref NI_14 NS_82 0 -9.7131309809021571e-01
GC_14_83 ref NI_14 NS_83 0 -2.5958359878381528e-02
GC_14_84 ref NI_14 NS_84 0 -5.4322385839920297e-04
GC_14_85 ref NI_14 NS_85 0 -1.3313450045304467e-01
GC_14_86 ref NI_14 NS_86 0 1.4747037715137024e-01
GC_14_87 ref NI_14 NS_87 0 -2.6998242981889548e-01
GC_14_88 ref NI_14 NS_88 0 2.3233026380293972e-01
GC_14_89 ref NI_14 NS_89 0 5.4511491263802246e-03
GC_14_90 ref NI_14 NS_90 0 2.9176757807717781e-05
GD_14_1 ref NI_14 NA_1 0 2.0729527681449183e-02
GD_14_2 ref NI_14 NA_2 0 -2.0840314381378872e-02
GD_14_3 ref NI_14 NA_3 0 6.0614817556697002e-02
GD_14_4 ref NI_14 NA_4 0 -1.4747316016503705e-02
GD_14_5 ref NI_14 NA_5 0 -9.3537887473684259e-03
GD_14_6 ref NI_14 NA_6 0 -3.0763196222196288e-03
GD_14_7 ref NI_14 NA_7 0 -2.7981699937172943e-03
GD_14_8 ref NI_14 NA_8 0 -2.1467382504071889e-03
GD_14_9 ref NI_14 NA_9 0 8.0174092437902619e-03
GD_14_10 ref NI_14 NA_10 0 7.9262646175814119e-03
GD_14_11 ref NI_14 NA_11 0 2.0077702811227669e-03
GD_14_12 ref NI_14 NA_12 0 -4.4299087593861874e-03
GD_14_13 ref NI_14 NA_13 0 6.8718700731600413e-02
GD_14_14 ref NI_14 NA_14 0 6.1126665591945093e+00
GD_14_15 ref NI_14 NA_15 0 8.6153730659806159e-03
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -1.5452966404311663e-02
GC_15_2 ref NI_15 NS_2 0 -2.9099740996106110e-02
GC_15_3 ref NI_15 NS_3 0 8.6158621575472294e-01
GC_15_4 ref NI_15 NS_4 0 -2.8483142968428415e-01
GC_15_5 ref NI_15 NS_5 0 -6.6278001745310039e-03
GC_15_6 ref NI_15 NS_6 0 5.3618020764132528e-04
GC_15_7 ref NI_15 NS_7 0 2.3119230762867288e-01
GC_15_8 ref NI_15 NS_8 0 1.4178368912917416e-01
GC_15_9 ref NI_15 NS_9 0 6.9256606495112769e-02
GC_15_10 ref NI_15 NS_10 0 7.0000092678766251e-02
GC_15_11 ref NI_15 NS_11 0 -5.1535492005273526e-04
GC_15_12 ref NI_15 NS_12 0 3.7107344705536835e-05
GC_15_13 ref NI_15 NS_13 0 2.6705197221462595e-02
GC_15_14 ref NI_15 NS_14 0 -4.3631313139628558e-03
GC_15_15 ref NI_15 NS_15 0 4.5488139899350570e-02
GC_15_16 ref NI_15 NS_16 0 1.1364220738244724e-01
GC_15_17 ref NI_15 NS_17 0 9.5089273969448270e-04
GC_15_18 ref NI_15 NS_18 0 5.4265346440083004e-05
GC_15_19 ref NI_15 NS_19 0 6.1157478887504620e-02
GC_15_20 ref NI_15 NS_20 0 -4.5973114422979945e-02
GC_15_21 ref NI_15 NS_21 0 8.7317498891180179e-02
GC_15_22 ref NI_15 NS_22 0 1.0326990883514343e-01
GC_15_23 ref NI_15 NS_23 0 1.6470739796360954e-04
GC_15_24 ref NI_15 NS_24 0 3.4106283706234756e-05
GC_15_25 ref NI_15 NS_25 0 7.9023296270680152e-02
GC_15_26 ref NI_15 NS_26 0 -4.7739375384655565e-02
GC_15_27 ref NI_15 NS_27 0 1.4211480773320498e-01
GC_15_28 ref NI_15 NS_28 0 7.9588993474061967e-02
GC_15_29 ref NI_15 NS_29 0 -8.7624721328344605e-04
GC_15_30 ref NI_15 NS_30 0 3.6025452488537689e-05
GC_15_31 ref NI_15 NS_31 0 1.6253734312194512e-01
GC_15_32 ref NI_15 NS_32 0 -1.2509043111764429e-01
GC_15_33 ref NI_15 NS_33 0 1.4703949591586488e-01
GC_15_34 ref NI_15 NS_34 0 9.0608988028175255e-02
GC_15_35 ref NI_15 NS_35 0 -1.9911467713987058e-03
GC_15_36 ref NI_15 NS_36 0 4.2342890765018857e-05
GC_15_37 ref NI_15 NS_37 0 1.0604812802944420e-01
GC_15_38 ref NI_15 NS_38 0 -1.9993675582033349e-01
GC_15_39 ref NI_15 NS_39 0 1.1844153846416118e-01
GC_15_40 ref NI_15 NS_40 0 1.2171948392344498e-01
GC_15_41 ref NI_15 NS_41 0 -1.4975289168734963e-03
GC_15_42 ref NI_15 NS_42 0 4.6146800349899190e-05
GC_15_43 ref NI_15 NS_43 0 1.3342458511737756e-01
GC_15_44 ref NI_15 NS_44 0 -1.5915963972173203e-01
GC_15_45 ref NI_15 NS_45 0 1.6698116611497144e-01
GC_15_46 ref NI_15 NS_46 0 9.0495244747908613e-02
GC_15_47 ref NI_15 NS_47 0 -1.9738717249354071e-03
GC_15_48 ref NI_15 NS_48 0 3.1233993425786522e-05
GC_15_49 ref NI_15 NS_49 0 -2.9142265412406168e-03
GC_15_50 ref NI_15 NS_50 0 1.2647512200172739e-02
GC_15_51 ref NI_15 NS_51 0 -1.2474846059399879e-01
GC_15_52 ref NI_15 NS_52 0 1.9670221699491069e-01
GC_15_53 ref NI_15 NS_53 0 8.4739774148546120e-04
GC_15_54 ref NI_15 NS_54 0 3.5309370789409380e-05
GC_15_55 ref NI_15 NS_55 0 -6.3057326573325884e-02
GC_15_56 ref NI_15 NS_56 0 6.9299327169338509e-02
GC_15_57 ref NI_15 NS_57 0 -1.9741725322025466e-01
GC_15_58 ref NI_15 NS_58 0 2.1698343649650093e-01
GC_15_59 ref NI_15 NS_59 0 3.0014410095187708e-03
GC_15_60 ref NI_15 NS_60 0 2.8121008830032456e-05
GC_15_61 ref NI_15 NS_61 0 -8.1039089976414097e-02
GC_15_62 ref NI_15 NS_62 0 1.0570123124342413e-01
GC_15_63 ref NI_15 NS_63 0 -1.8599442983643358e-01
GC_15_64 ref NI_15 NS_64 0 2.0326830367011847e-01
GC_15_65 ref NI_15 NS_65 0 3.6753735939117063e-03
GC_15_66 ref NI_15 NS_66 0 1.7633841743999029e-05
GC_15_67 ref NI_15 NS_67 0 -9.1622311068829232e-02
GC_15_68 ref NI_15 NS_68 0 9.5067218824207642e-02
GC_15_69 ref NI_15 NS_69 0 -2.1168030244121949e-01
GC_15_70 ref NI_15 NS_70 0 2.1626501681846433e-01
GC_15_71 ref NI_15 NS_71 0 4.0171305088318263e-03
GC_15_72 ref NI_15 NS_72 0 3.5171519234614478e-05
GC_15_73 ref NI_15 NS_73 0 -1.1500962532583735e-01
GC_15_74 ref NI_15 NS_74 0 1.4386280350165082e-01
GC_15_75 ref NI_15 NS_75 0 -2.0978120657545934e-01
GC_15_76 ref NI_15 NS_76 0 2.0482435656405279e-01
GC_15_77 ref NI_15 NS_77 0 4.9351207171987764e-03
GC_15_78 ref NI_15 NS_78 0 1.3871414078059699e-05
GC_15_79 ref NI_15 NS_79 0 -1.3313450045304445e-01
GC_15_80 ref NI_15 NS_80 0 1.4747037715136990e-01
GC_15_81 ref NI_15 NS_81 0 -2.6998242981889531e-01
GC_15_82 ref NI_15 NS_82 0 2.3233026380293978e-01
GC_15_83 ref NI_15 NS_83 0 5.4511491263801977e-03
GC_15_84 ref NI_15 NS_84 0 2.9176757807721949e-05
GC_15_85 ref NI_15 NS_85 0 6.8523626153646422e-01
GC_15_86 ref NI_15 NS_86 0 -4.5414932501560396e-01
GC_15_87 ref NI_15 NS_87 0 -3.6126954472228123e-01
GC_15_88 ref NI_15 NS_88 0 -1.6625904071831001e+00
GC_15_89 ref NI_15 NS_89 0 -1.5034511070110498e-02
GC_15_90 ref NI_15 NS_90 0 -5.2798774251379323e-04
GD_15_1 ref NI_15 NA_1 0 5.8750286923879957e-02
GD_15_2 ref NI_15 NA_2 0 -6.1778840755860071e-02
GD_15_3 ref NI_15 NA_3 0 -1.3746448091772069e-02
GD_15_4 ref NI_15 NA_4 0 -1.8551964706635234e-02
GD_15_5 ref NI_15 NA_5 0 -2.1107948781254722e-02
GD_15_6 ref NI_15 NA_6 0 -2.6129482000444376e-02
GD_15_7 ref NI_15 NA_7 0 -1.9812754202640424e-02
GD_15_8 ref NI_15 NA_8 0 -2.4972823865023586e-02
GD_15_9 ref NI_15 NA_9 0 -5.7145586039819571e-03
GD_15_10 ref NI_15 NA_10 0 1.5872807627821651e-03
GD_15_11 ref NI_15 NA_11 0 2.1198406748560140e-03
GD_15_12 ref NI_15 NA_12 0 4.4984336647388443e-03
GD_15_13 ref NI_15 NA_13 0 5.4520878057401851e-03
GD_15_14 ref NI_15 NA_14 0 8.6153730659806159e-03
GD_15_15 ref NI_15 NA_15 0 6.1662006823605120e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 1.7519059816169463e-01
GS_1_1 0 NS_1 NA_1 0 2.9930998605428765e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 3.9843437417510347e-01
GS_2_1 0 NS_2 NA_1 0 2.9930998605428765e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 9.8198144525838438e-01
GS_3_1 0 NS_3 NA_1 0 2.9930998605428765e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 1.9600983520637876e+00
GS_4_1 0 NS_4 NA_1 0 2.9930998605428765e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 8.0856648054138809e+00
GS_5_1 0 NS_5 NA_1 0 2.9930998605428765e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 9.0154678160517733e+01
GS_6_1 0 NS_6 NA_1 0 2.9930998605428765e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 1.7519059816169463e-01
GS_7_2 0 NS_7 NA_2 0 2.9930998605428765e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 3.9843437417510347e-01
GS_8_2 0 NS_8 NA_2 0 2.9930998605428765e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 9.8198144525838438e-01
GS_9_2 0 NS_9 NA_2 0 2.9930998605428765e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 1.9600983520637876e+00
GS_10_2 0 NS_10 NA_2 0 2.9930998605428765e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 8.0856648054138809e+00
GS_11_2 0 NS_11 NA_2 0 2.9930998605428765e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 9.0154678160517733e+01
GS_12_2 0 NS_12 NA_2 0 2.9930998605428765e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 1.7519059816169463e-01
GS_13_3 0 NS_13 NA_3 0 2.9930998605428765e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 3.9843437417510347e-01
GS_14_3 0 NS_14 NA_3 0 2.9930998605428765e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 9.8198144525838438e-01
GS_15_3 0 NS_15 NA_3 0 2.9930998605428765e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 1.9600983520637876e+00
GS_16_3 0 NS_16 NA_3 0 2.9930998605428765e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 8.0856648054138809e+00
GS_17_3 0 NS_17 NA_3 0 2.9930998605428765e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 9.0154678160517733e+01
GS_18_3 0 NS_18 NA_3 0 2.9930998605428765e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 1.7519059816169463e-01
GS_19_4 0 NS_19 NA_4 0 2.9930998605428765e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 3.9843437417510347e-01
GS_20_4 0 NS_20 NA_4 0 2.9930998605428765e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 9.8198144525838438e-01
GS_21_4 0 NS_21 NA_4 0 2.9930998605428765e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 1.9600983520637876e+00
GS_22_4 0 NS_22 NA_4 0 2.9930998605428765e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 8.0856648054138809e+00
GS_23_4 0 NS_23 NA_4 0 2.9930998605428765e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 9.0154678160517733e+01
GS_24_4 0 NS_24 NA_4 0 2.9930998605428765e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 1.7519059816169463e-01
GS_25_5 0 NS_25 NA_5 0 2.9930998605428765e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 3.9843437417510347e-01
GS_26_5 0 NS_26 NA_5 0 2.9930998605428765e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 9.8198144525838438e-01
GS_27_5 0 NS_27 NA_5 0 2.9930998605428765e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 1.9600983520637876e+00
GS_28_5 0 NS_28 NA_5 0 2.9930998605428765e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 8.0856648054138809e+00
GS_29_5 0 NS_29 NA_5 0 2.9930998605428765e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 9.0154678160517733e+01
GS_30_5 0 NS_30 NA_5 0 2.9930998605428765e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 1.7519059816169463e-01
GS_31_6 0 NS_31 NA_6 0 2.9930998605428765e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 3.9843437417510347e-01
GS_32_6 0 NS_32 NA_6 0 2.9930998605428765e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 9.8198144525838438e-01
GS_33_6 0 NS_33 NA_6 0 2.9930998605428765e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 1.9600983520637876e+00
GS_34_6 0 NS_34 NA_6 0 2.9930998605428765e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 8.0856648054138809e+00
GS_35_6 0 NS_35 NA_6 0 2.9930998605428765e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 9.0154678160517733e+01
GS_36_6 0 NS_36 NA_6 0 2.9930998605428765e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 1.7519059816169463e-01
GS_37_7 0 NS_37 NA_7 0 2.9930998605428765e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 3.9843437417510347e-01
GS_38_7 0 NS_38 NA_7 0 2.9930998605428765e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 9.8198144525838438e-01
GS_39_7 0 NS_39 NA_7 0 2.9930998605428765e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 1.9600983520637876e+00
GS_40_7 0 NS_40 NA_7 0 2.9930998605428765e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 8.0856648054138809e+00
GS_41_7 0 NS_41 NA_7 0 2.9930998605428765e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 9.0154678160517733e+01
GS_42_7 0 NS_42 NA_7 0 2.9930998605428765e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 1.7519059816169463e-01
GS_43_8 0 NS_43 NA_8 0 2.9930998605428765e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 3.9843437417510347e-01
GS_44_8 0 NS_44 NA_8 0 2.9930998605428765e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 9.8198144525838438e-01
GS_45_8 0 NS_45 NA_8 0 2.9930998605428765e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 1.9600983520637876e+00
GS_46_8 0 NS_46 NA_8 0 2.9930998605428765e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 8.0856648054138809e+00
GS_47_8 0 NS_47 NA_8 0 2.9930998605428765e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 9.0154678160517733e+01
GS_48_8 0 NS_48 NA_8 0 2.9930998605428765e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 1.7519059816169463e-01
GS_49_9 0 NS_49 NA_9 0 2.9930998605428765e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 3.9843437417510347e-01
GS_50_9 0 NS_50 NA_9 0 2.9930998605428765e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 9.8198144525838438e-01
GS_51_9 0 NS_51 NA_9 0 2.9930998605428765e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 1.9600983520637876e+00
GS_52_9 0 NS_52 NA_9 0 2.9930998605428765e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 8.0856648054138809e+00
GS_53_9 0 NS_53 NA_9 0 2.9930998605428765e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 9.0154678160517733e+01
GS_54_9 0 NS_54 NA_9 0 2.9930998605428765e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 1.7519059816169463e-01
GS_55_10 0 NS_55 NA_10 0 2.9930998605428765e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 3.9843437417510347e-01
GS_56_10 0 NS_56 NA_10 0 2.9930998605428765e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 9.8198144525838438e-01
GS_57_10 0 NS_57 NA_10 0 2.9930998605428765e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 1.9600983520637876e+00
GS_58_10 0 NS_58 NA_10 0 2.9930998605428765e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 8.0856648054138809e+00
GS_59_10 0 NS_59 NA_10 0 2.9930998605428765e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 9.0154678160517733e+01
GS_60_10 0 NS_60 NA_10 0 2.9930998605428765e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 1.7519059816169463e-01
GS_61_11 0 NS_61 NA_11 0 2.9930998605428765e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 3.9843437417510347e-01
GS_62_11 0 NS_62 NA_11 0 2.9930998605428765e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 9.8198144525838438e-01
GS_63_11 0 NS_63 NA_11 0 2.9930998605428765e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 1.9600983520637876e+00
GS_64_11 0 NS_64 NA_11 0 2.9930998605428765e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 8.0856648054138809e+00
GS_65_11 0 NS_65 NA_11 0 2.9930998605428765e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 9.0154678160517733e+01
GS_66_11 0 NS_66 NA_11 0 2.9930998605428765e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 1.7519059816169463e-01
GS_67_12 0 NS_67 NA_12 0 2.9930998605428765e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 3.9843437417510347e-01
GS_68_12 0 NS_68 NA_12 0 2.9930998605428765e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 9.8198144525838438e-01
GS_69_12 0 NS_69 NA_12 0 2.9930998605428765e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 1.9600983520637876e+00
GS_70_12 0 NS_70 NA_12 0 2.9930998605428765e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 8.0856648054138809e+00
GS_71_12 0 NS_71 NA_12 0 2.9930998605428765e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 9.0154678160517733e+01
GS_72_12 0 NS_72 NA_12 0 2.9930998605428765e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 1.7519059816169463e-01
GS_73_13 0 NS_73 NA_13 0 2.9930998605428765e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 3.9843437417510347e-01
GS_74_13 0 NS_74 NA_13 0 2.9930998605428765e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 9.8198144525838438e-01
GS_75_13 0 NS_75 NA_13 0 2.9930998605428765e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 1.9600983520637876e+00
GS_76_13 0 NS_76 NA_13 0 2.9930998605428765e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 8.0856648054138809e+00
GS_77_13 0 NS_77 NA_13 0 2.9930998605428765e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 9.0154678160517733e+01
GS_78_13 0 NS_78 NA_13 0 2.9930998605428765e+00
*
* Real pole n. 79
CS_79 NS_79 0 1.0000000000000001e-09
RS_79 NS_79 0 1.7519059816169463e-01
GS_79_14 0 NS_79 NA_14 0 2.9930998605428765e+00
*
* Real pole n. 80
CS_80 NS_80 0 1.0000000000000001e-09
RS_80 NS_80 0 3.9843437417510347e-01
GS_80_14 0 NS_80 NA_14 0 2.9930998605428765e+00
*
* Real pole n. 81
CS_81 NS_81 0 1.0000000000000001e-09
RS_81 NS_81 0 9.8198144525838438e-01
GS_81_14 0 NS_81 NA_14 0 2.9930998605428765e+00
*
* Real pole n. 82
CS_82 NS_82 0 1.0000000000000001e-09
RS_82 NS_82 0 1.9600983520637876e+00
GS_82_14 0 NS_82 NA_14 0 2.9930998605428765e+00
*
* Real pole n. 83
CS_83 NS_83 0 1.0000000000000001e-09
RS_83 NS_83 0 8.0856648054138809e+00
GS_83_14 0 NS_83 NA_14 0 2.9930998605428765e+00
*
* Real pole n. 84
CS_84 NS_84 0 1.0000000000000001e-09
RS_84 NS_84 0 9.0154678160517733e+01
GS_84_14 0 NS_84 NA_14 0 2.9930998605428765e+00
*
* Real pole n. 85
CS_85 NS_85 0 1.0000000000000001e-09
RS_85 NS_85 0 1.7519059816169463e-01
GS_85_15 0 NS_85 NA_15 0 2.9930998605428765e+00
*
* Real pole n. 86
CS_86 NS_86 0 1.0000000000000001e-09
RS_86 NS_86 0 3.9843437417510347e-01
GS_86_15 0 NS_86 NA_15 0 2.9930998605428765e+00
*
* Real pole n. 87
CS_87 NS_87 0 1.0000000000000001e-09
RS_87 NS_87 0 9.8198144525838438e-01
GS_87_15 0 NS_87 NA_15 0 2.9930998605428765e+00
*
* Real pole n. 88
CS_88 NS_88 0 1.0000000000000001e-09
RS_88 NS_88 0 1.9600983520637876e+00
GS_88_15 0 NS_88 NA_15 0 2.9930998605428765e+00
*
* Real pole n. 89
CS_89 NS_89 0 1.0000000000000001e-09
RS_89 NS_89 0 8.0856648054138809e+00
GS_89_15 0 NS_89 NA_15 0 2.9930998605428765e+00
*
* Real pole n. 90
CS_90 NS_90 0 1.0000000000000001e-09
RS_90 NS_90 0 9.0154678160517733e+01
GS_90_15 0 NS_90 NA_15 0 2.9930998605428765e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
