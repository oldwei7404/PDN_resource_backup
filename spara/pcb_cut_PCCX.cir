**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 22-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Mon Apr 21 20:43:06 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Mon Apr 21 20:43:06 2025
**
**  Modal data exported
**  Port[1] = PORT_1_L16_PWR_VPCMX0_Group_U49_GND_Group
**  Port[2] = PORT_2_U1_PWR_VPCMX0_Group_U1_GRP_0_1_GND
**  Port[3] = PWR_VPCMX0_C417_1
**  Port[4] = PWR_VPCMX0_C418_1
**  Port[5] = PWR_VPCMX0_C419_1
**  Port[6] = PWR_VPCMX0_C420_1
**  Port[7] = PWR_VPCMX0_C421_1
**  Port[8] = PWR_VPCMX0_C422_1
**  Port[9] = PWR_VPCMX0_C634_1
**  Port[10] = PWR_VPCMX0_C649_1
**  Port[11] = PWR_VPCMX0_C649_3
**  Port[12] = PWR_VPCMX0_C650_1
**  Port[13] = PWR_VPCMX0_C650_3
**  Port[14] = PWR_VPCMX0_C651_1
**  Port[15] = PWR_VPCMX0_C651_3
**  Port[16] = PWR_VPCMX0_C652_1
**  Port[17] = PWR_VPCMX0_C652_3
**  Port[18] = PWR_VPCMX0_C653_1
**  Port[19] = PWR_VPCMX0_C653_3
**  Port[20] = PWR_VPCMX0_C681_1
**  Port[21] = PWR_VPCMX0_C681_3
**  Port[22] = PWR_VPCMX0_C817_1
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_PCCX
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 a_16 a_17 a_18 a_19 a_20 a_21 a_22 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 4.4110565805477420e-04
GC_1_2 ref NI_1 NS_2 0 -4.4868465348598931e-02
GC_1_3 ref NI_1 NS_3 0 -1.2759652991302323e-03
GC_1_4 ref NI_1 NS_4 0 -3.1232605037699360e-05
GC_1_5 ref NI_1 NS_5 0 -1.4056615741404321e-02
GC_1_6 ref NI_1 NS_6 0 7.0942889226125641e-02
GC_1_7 ref NI_1 NS_7 0 3.1342529201151168e-05
GC_1_8 ref NI_1 NS_8 0 2.1928567702905479e-03
GC_1_9 ref NI_1 NS_9 0 4.1911417272331162e-05
GC_1_10 ref NI_1 NS_10 0 2.4297918954078806e-06
GC_1_11 ref NI_1 NS_11 0 1.5433253184401279e-03
GC_1_12 ref NI_1 NS_12 0 -5.4340115796604074e-05
GC_1_13 ref NI_1 NS_13 0 6.4297425502107784e-03
GC_1_14 ref NI_1 NS_14 0 -2.3225531875698561e-03
GC_1_15 ref NI_1 NS_15 0 -1.6593948850745816e-05
GC_1_16 ref NI_1 NS_16 0 1.1212017522474804e-07
GC_1_17 ref NI_1 NS_17 0 7.5918375294607232e-03
GC_1_18 ref NI_1 NS_18 0 -9.4947502542850667e-03
GC_1_19 ref NI_1 NS_19 0 -5.9828140280441221e-04
GC_1_20 ref NI_1 NS_20 0 2.3420448309561955e-03
GC_1_21 ref NI_1 NS_21 0 6.4549784150947335e-05
GC_1_22 ref NI_1 NS_22 0 2.1930679420534336e-06
GC_1_23 ref NI_1 NS_23 0 5.8604319015472894e-04
GC_1_24 ref NI_1 NS_24 0 -4.8571751174998562e-03
GC_1_25 ref NI_1 NS_25 0 -4.9697064073700135e-03
GC_1_26 ref NI_1 NS_26 0 4.1700848021719869e-03
GC_1_27 ref NI_1 NS_27 0 9.4676494324742773e-05
GC_1_28 ref NI_1 NS_28 0 2.2594018770383116e-06
GC_1_29 ref NI_1 NS_29 0 1.2670054191039034e-03
GC_1_30 ref NI_1 NS_30 0 -7.0807246084437694e-03
GC_1_31 ref NI_1 NS_31 0 1.3299545543729173e-03
GC_1_32 ref NI_1 NS_32 0 1.5438728860979523e-03
GC_1_33 ref NI_1 NS_33 0 4.5437295652292205e-05
GC_1_34 ref NI_1 NS_34 0 1.9006986308344657e-06
GC_1_35 ref NI_1 NS_35 0 4.9206174130170656e-04
GC_1_36 ref NI_1 NS_36 0 -3.7428304365613170e-03
GC_1_37 ref NI_1 NS_37 0 3.4978067266892851e-03
GC_1_38 ref NI_1 NS_38 0 3.0360535289094252e-04
GC_1_39 ref NI_1 NS_39 0 2.1819946423004903e-05
GC_1_40 ref NI_1 NS_40 0 1.3039441653130404e-06
GC_1_41 ref NI_1 NS_41 0 1.7908886136716589e-03
GC_1_42 ref NI_1 NS_42 0 -4.5323399101668002e-03
GC_1_43 ref NI_1 NS_43 0 6.0606870154910090e-03
GC_1_44 ref NI_1 NS_44 0 -1.4249151428477123e-03
GC_1_45 ref NI_1 NS_45 0 -5.6940798185053226e-06
GC_1_46 ref NI_1 NS_46 0 5.8219381321073154e-07
GC_1_47 ref NI_1 NS_47 0 4.2653732089232930e-03
GC_1_48 ref NI_1 NS_48 0 -6.9142262420294380e-03
GC_1_49 ref NI_1 NS_49 0 7.1387005682201337e-03
GC_1_50 ref NI_1 NS_50 0 -3.2830819500347568e-03
GC_1_51 ref NI_1 NS_51 0 3.6450794979055294e-05
GC_1_52 ref NI_1 NS_52 0 4.1744771002079728e-06
GC_1_53 ref NI_1 NS_53 0 7.7054137468148152e-03
GC_1_54 ref NI_1 NS_54 0 -1.1620072850802975e-02
GC_1_55 ref NI_1 NS_55 0 1.6769969806799882e-03
GC_1_56 ref NI_1 NS_56 0 2.1592555672450423e-03
GC_1_57 ref NI_1 NS_57 0 2.2353941749153152e-05
GC_1_58 ref NI_1 NS_58 0 1.3869666332740668e-06
GC_1_59 ref NI_1 NS_59 0 -1.3123271969332224e-03
GC_1_60 ref NI_1 NS_60 0 2.9590942269845633e-03
GC_1_61 ref NI_1 NS_61 0 1.9883738829412252e-03
GC_1_62 ref NI_1 NS_62 0 2.4020118935438543e-03
GC_1_63 ref NI_1 NS_63 0 3.3441169249511982e-05
GC_1_64 ref NI_1 NS_64 0 1.3566444340366127e-06
GC_1_65 ref NI_1 NS_65 0 -3.4837904756855461e-03
GC_1_66 ref NI_1 NS_66 0 3.2734234379769660e-03
GC_1_67 ref NI_1 NS_67 0 -4.5762104242349291e-03
GC_1_68 ref NI_1 NS_68 0 3.9971354514136163e-03
GC_1_69 ref NI_1 NS_69 0 1.0327928167484343e-04
GC_1_70 ref NI_1 NS_70 0 1.8418348092120092e-06
GC_1_71 ref NI_1 NS_71 0 1.0441768312895489e-03
GC_1_72 ref NI_1 NS_72 0 -6.3259339044907572e-03
GC_1_73 ref NI_1 NS_73 0 -5.1272380331644461e-03
GC_1_74 ref NI_1 NS_74 0 4.2658436725856287e-03
GC_1_75 ref NI_1 NS_75 0 1.0601569549625315e-04
GC_1_76 ref NI_1 NS_76 0 2.3589734736960790e-06
GC_1_77 ref NI_1 NS_77 0 8.6464547667498934e-04
GC_1_78 ref NI_1 NS_78 0 -6.4376820004212604e-03
GC_1_79 ref NI_1 NS_79 0 1.2227168122697189e-03
GC_1_80 ref NI_1 NS_80 0 2.3049137239179738e-03
GC_1_81 ref NI_1 NS_81 0 3.7458837520881179e-05
GC_1_82 ref NI_1 NS_82 0 1.2425785993813833e-06
GC_1_83 ref NI_1 NS_83 0 -1.5322703234124371e-03
GC_1_84 ref NI_1 NS_84 0 1.8761386521640412e-03
GC_1_85 ref NI_1 NS_85 0 9.9547476214704414e-04
GC_1_86 ref NI_1 NS_86 0 2.7202761568683237e-03
GC_1_87 ref NI_1 NS_87 0 4.3472583202375898e-05
GC_1_88 ref NI_1 NS_88 0 1.3183674521956977e-06
GC_1_89 ref NI_1 NS_89 0 -2.8739086114732107e-03
GC_1_90 ref NI_1 NS_90 0 3.1363972786066143e-03
GC_1_91 ref NI_1 NS_91 0 -3.0390511310997791e-03
GC_1_92 ref NI_1 NS_92 0 3.5832512447459075e-03
GC_1_93 ref NI_1 NS_93 0 8.0568615401555499e-05
GC_1_94 ref NI_1 NS_94 0 1.6114159224157793e-06
GC_1_95 ref NI_1 NS_95 0 4.0305749722084231e-04
GC_1_96 ref NI_1 NS_96 0 -3.9345307891611525e-03
GC_1_97 ref NI_1 NS_97 0 -4.0860810059786500e-03
GC_1_98 ref NI_1 NS_98 0 4.0643169410999741e-03
GC_1_99 ref NI_1 NS_99 0 9.1291911021269942e-05
GC_1_100 ref NI_1 NS_100 0 2.0181312207633736e-06
GC_1_101 ref NI_1 NS_101 0 2.0285647719926869e-04
GC_1_102 ref NI_1 NS_102 0 -4.2345073340751185e-03
GC_1_103 ref NI_1 NS_103 0 -8.1466906716350215e-04
GC_1_104 ref NI_1 NS_104 0 2.9125387053465764e-03
GC_1_105 ref NI_1 NS_105 0 5.7705969784570516e-05
GC_1_106 ref NI_1 NS_106 0 1.4120599421770959e-06
GC_1_107 ref NI_1 NS_107 0 -5.5839138934784811e-04
GC_1_108 ref NI_1 NS_108 0 -8.2234724074132268e-04
GC_1_109 ref NI_1 NS_109 0 -1.8818781710834215e-03
GC_1_110 ref NI_1 NS_110 0 3.5275731480594080e-03
GC_1_111 ref NI_1 NS_111 0 6.6152877687482425e-05
GC_1_112 ref NI_1 NS_112 0 1.6878941322393449e-06
GC_1_113 ref NI_1 NS_113 0 -1.1595468077826296e-03
GC_1_114 ref NI_1 NS_114 0 -6.8043807824926916e-04
GC_1_115 ref NI_1 NS_115 0 -7.4228500259342469e-03
GC_1_116 ref NI_1 NS_116 0 4.8444262164833128e-03
GC_1_117 ref NI_1 NS_117 0 1.2662387723209246e-04
GC_1_118 ref NI_1 NS_118 0 2.2614161368097514e-06
GC_1_119 ref NI_1 NS_119 0 2.3353447967100894e-03
GC_1_120 ref NI_1 NS_120 0 -1.0622023528891191e-02
GC_1_121 ref NI_1 NS_121 0 -6.2027364293817423e-03
GC_1_122 ref NI_1 NS_122 0 4.4408052628173520e-03
GC_1_123 ref NI_1 NS_123 0 1.1892279426226526e-04
GC_1_124 ref NI_1 NS_124 0 1.8267538695382618e-06
GC_1_125 ref NI_1 NS_125 0 1.8780562483044017e-03
GC_1_126 ref NI_1 NS_126 0 -9.2828262338417802e-03
GC_1_127 ref NI_1 NS_127 0 7.6824430018798831e-03
GC_1_128 ref NI_1 NS_128 0 3.2213287265090524e-04
GC_1_129 ref NI_1 NS_129 0 2.9215013586182666e-05
GC_1_130 ref NI_1 NS_130 0 4.0195210021589101e-06
GC_1_131 ref NI_1 NS_131 0 -6.4280539488993016e-03
GC_1_132 ref NI_1 NS_132 0 9.3622139514175709e-03
GD_1_1 ref NI_1 NA_1 0 6.1649045888887644e+00
GD_1_2 ref NI_1 NA_2 0 5.0122058692510249e-05
GD_1_3 ref NI_1 NA_3 0 1.0178849868889693e-02
GD_1_4 ref NI_1 NA_4 0 5.7884321835709887e-03
GD_1_5 ref NI_1 NA_5 0 5.2777598632724769e-03
GD_1_6 ref NI_1 NA_6 0 6.3890781571498160e-03
GD_1_7 ref NI_1 NA_7 0 6.4271003955899200e-03
GD_1_8 ref NI_1 NA_8 0 8.2669643761186552e-03
GD_1_9 ref NI_1 NA_9 0 2.3163125839090526e-02
GD_1_10 ref NI_1 NA_10 0 3.6126636270241820e-03
GD_1_11 ref NI_1 NA_11 0 2.1866791917838514e-03
GD_1_12 ref NI_1 NA_12 0 6.2166334399340311e-03
GD_1_13 ref NI_1 NA_13 0 5.5815796225181418e-03
GD_1_14 ref NI_1 NA_14 0 4.7989809896120802e-03
GD_1_15 ref NI_1 NA_15 0 2.5493417260283369e-03
GD_1_16 ref NI_1 NA_16 0 5.5971701841131764e-03
GD_1_17 ref NI_1 NA_17 0 4.9015922341986515e-03
GD_1_18 ref NI_1 NA_18 0 5.1513276921904784e-03
GD_1_19 ref NI_1 NA_19 0 3.5760853144381961e-03
GD_1_20 ref NI_1 NA_20 0 6.8566097392338968e-03
GD_1_21 ref NI_1 NA_21 0 6.8455692527148067e-03
GD_1_22 ref NI_1 NA_22 0 2.1947785187478590e-03
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 3.1342529201134614e-05
GC_2_2 ref NI_2 NS_2 0 2.1928567702905557e-03
GC_2_3 ref NI_2 NS_3 0 4.1911417272329508e-05
GC_2_4 ref NI_2 NS_4 0 2.4297918954081360e-06
GC_2_5 ref NI_2 NS_5 0 1.5433253184401353e-03
GC_2_6 ref NI_2 NS_6 0 -5.4340115796645355e-05
GC_2_7 ref NI_2 NS_7 0 1.4173189985476248e-02
GC_2_8 ref NI_2 NS_8 0 -5.9298411731462924e-03
GC_2_9 ref NI_2 NS_9 0 2.1758179276641073e-05
GC_2_10 ref NI_2 NS_10 0 -5.6433898311068186e-06
GC_2_11 ref NI_2 NS_11 0 -2.8000213856102618e-01
GC_2_12 ref NI_2 NS_12 0 5.4453343411666535e-02
GC_2_13 ref NI_2 NS_13 0 2.1256952702199223e-03
GC_2_14 ref NI_2 NS_14 0 -6.1465826245482623e-04
GC_2_15 ref NI_2 NS_15 0 3.1173629167203637e-07
GC_2_16 ref NI_2 NS_16 0 4.4568791820590871e-07
GC_2_17 ref NI_2 NS_17 0 1.5032619285991325e-02
GC_2_18 ref NI_2 NS_18 0 1.3681475866484320e-02
GC_2_19 ref NI_2 NS_19 0 1.6615709153482764e-03
GC_2_20 ref NI_2 NS_20 0 -3.6563048316434841e-04
GC_2_21 ref NI_2 NS_21 0 -2.1676377248645291e-06
GC_2_22 ref NI_2 NS_22 0 5.3796150477194621e-07
GC_2_23 ref NI_2 NS_23 0 1.4893585705804223e-02
GC_2_24 ref NI_2 NS_24 0 1.2986712724440559e-02
GC_2_25 ref NI_2 NS_25 0 2.3786294336556150e-03
GC_2_26 ref NI_2 NS_26 0 -1.6593252257244670e-04
GC_2_27 ref NI_2 NS_27 0 -1.6414651364797716e-06
GC_2_28 ref NI_2 NS_28 0 7.2358405534512878e-07
GC_2_29 ref NI_2 NS_29 0 1.1238516216459191e-02
GC_2_30 ref NI_2 NS_30 0 9.8870777121997499e-03
GC_2_31 ref NI_2 NS_31 0 2.3584037265538291e-03
GC_2_32 ref NI_2 NS_32 0 -4.7781649264017349e-04
GC_2_33 ref NI_2 NS_33 0 -1.4396635850242225e-06
GC_2_34 ref NI_2 NS_34 0 5.1739715323944092e-07
GC_2_35 ref NI_2 NS_35 0 1.2460263399034327e-02
GC_2_36 ref NI_2 NS_36 0 7.7555945397304342e-03
GC_2_37 ref NI_2 NS_37 0 2.4877850586296000e-03
GC_2_38 ref NI_2 NS_38 0 -5.6414905097933329e-04
GC_2_39 ref NI_2 NS_39 0 -1.8823072398554885e-06
GC_2_40 ref NI_2 NS_40 0 4.5848264809246962e-07
GC_2_41 ref NI_2 NS_41 0 1.2552945863524808e-02
GC_2_42 ref NI_2 NS_42 0 7.4295940520814523e-03
GC_2_43 ref NI_2 NS_43 0 2.5587473799056812e-03
GC_2_44 ref NI_2 NS_44 0 -5.8029240967262866e-04
GC_2_45 ref NI_2 NS_45 0 -1.3748729521792170e-06
GC_2_46 ref NI_2 NS_46 0 4.6039892288198192e-07
GC_2_47 ref NI_2 NS_47 0 1.1892731608014483e-02
GC_2_48 ref NI_2 NS_48 0 4.9686463319281188e-03
GC_2_49 ref NI_2 NS_49 0 3.0676125220255816e-03
GC_2_50 ref NI_2 NS_50 0 6.1656874985702257e-04
GC_2_51 ref NI_2 NS_51 0 -7.9249535270301874e-06
GC_2_52 ref NI_2 NS_52 0 1.0638101845624235e-06
GC_2_53 ref NI_2 NS_53 0 5.1792468874603459e-03
GC_2_54 ref NI_2 NS_54 0 7.4171273888280374e-03
GC_2_55 ref NI_2 NS_55 0 1.4569841213744857e-03
GC_2_56 ref NI_2 NS_56 0 -8.4378043552441691e-04
GC_2_57 ref NI_2 NS_57 0 4.9390088840704749e-06
GC_2_58 ref NI_2 NS_58 0 2.9128277018800811e-07
GC_2_59 ref NI_2 NS_59 0 1.8624536296370304e-02
GC_2_60 ref NI_2 NS_60 0 1.9224747723533078e-02
GC_2_61 ref NI_2 NS_61 0 1.1622630795088170e-03
GC_2_62 ref NI_2 NS_62 0 -7.2271213448558698e-04
GC_2_63 ref NI_2 NS_63 0 3.6873315350040742e-06
GC_2_64 ref NI_2 NS_64 0 2.7198768743950466e-07
GC_2_65 ref NI_2 NS_65 0 1.8636775681336260e-02
GC_2_66 ref NI_2 NS_66 0 1.8549138556487509e-02
GC_2_67 ref NI_2 NS_67 0 1.5020810516109886e-03
GC_2_68 ref NI_2 NS_68 0 -4.5857671834573542e-04
GC_2_69 ref NI_2 NS_69 0 8.6011171199044284e-06
GC_2_70 ref NI_2 NS_70 0 9.0660199496428249e-08
GC_2_71 ref NI_2 NS_71 0 1.6290967069313239e-02
GC_2_72 ref NI_2 NS_72 0 1.8064357205721214e-02
GC_2_73 ref NI_2 NS_73 0 5.3402664663278860e-04
GC_2_74 ref NI_2 NS_74 0 -3.4407166187666783e-04
GC_2_75 ref NI_2 NS_75 0 -3.7533172379125093e-06
GC_2_76 ref NI_2 NS_76 0 1.3545743867141754e-06
GC_2_77 ref NI_2 NS_77 0 1.8002017034446080e-02
GC_2_78 ref NI_2 NS_78 0 1.7367559314164508e-02
GC_2_79 ref NI_2 NS_79 0 2.3226312353556520e-03
GC_2_80 ref NI_2 NS_80 0 -5.3947760898504903e-04
GC_2_81 ref NI_2 NS_81 0 4.9120690472675025e-07
GC_2_82 ref NI_2 NS_82 0 3.6477755220393915e-07
GC_2_83 ref NI_2 NS_83 0 1.4361937297372170e-02
GC_2_84 ref NI_2 NS_84 0 1.6257951253143801e-02
GC_2_85 ref NI_2 NS_85 0 1.7934741539980890e-03
GC_2_86 ref NI_2 NS_86 0 -5.6667609650897237e-04
GC_2_87 ref NI_2 NS_87 0 -3.5835641949581427e-06
GC_2_88 ref NI_2 NS_88 0 3.1401944248276165e-07
GC_2_89 ref NI_2 NS_89 0 1.6478603119803533e-02
GC_2_90 ref NI_2 NS_90 0 1.8803355503325864e-02
GC_2_91 ref NI_2 NS_91 0 1.9613463386896983e-03
GC_2_92 ref NI_2 NS_92 0 -5.7643845874002597e-04
GC_2_93 ref NI_2 NS_93 0 4.2950884015106655e-06
GC_2_94 ref NI_2 NS_94 0 5.3574181594674762e-08
GC_2_95 ref NI_2 NS_95 0 1.5999588971224978e-02
GC_2_96 ref NI_2 NS_96 0 1.8755744780818925e-02
GC_2_97 ref NI_2 NS_97 0 1.2935420038488938e-03
GC_2_98 ref NI_2 NS_98 0 -4.6077786895588007e-04
GC_2_99 ref NI_2 NS_99 0 -4.1155705350941879e-06
GC_2_100 ref NI_2 NS_100 0 1.0996179880224314e-06
GC_2_101 ref NI_2 NS_101 0 1.6443173826548880e-02
GC_2_102 ref NI_2 NS_102 0 1.6104431736878165e-02
GC_2_103 ref NI_2 NS_103 0 2.0336337137601386e-03
GC_2_104 ref NI_2 NS_104 0 -5.6499011552555410e-04
GC_2_105 ref NI_2 NS_105 0 1.9720471886507089e-06
GC_2_106 ref NI_2 NS_106 0 1.2021858209710041e-07
GC_2_107 ref NI_2 NS_107 0 1.5770772951414443e-02
GC_2_108 ref NI_2 NS_108 0 1.8656254277698108e-02
GC_2_109 ref NI_2 NS_109 0 1.3874394923304014e-03
GC_2_110 ref NI_2 NS_110 0 -5.2409130678289072e-04
GC_2_111 ref NI_2 NS_111 0 -5.4407683755624542e-06
GC_2_112 ref NI_2 NS_112 0 6.4472647059386722e-07
GC_2_113 ref NI_2 NS_113 0 1.7232210747963782e-02
GC_2_114 ref NI_2 NS_114 0 1.8723152808457731e-02
GC_2_115 ref NI_2 NS_115 0 1.6344734842639536e-03
GC_2_116 ref NI_2 NS_116 0 1.3285780719916483e-04
GC_2_117 ref NI_2 NS_117 0 -1.3513046437978761e-06
GC_2_118 ref NI_2 NS_118 0 1.3845272188983467e-06
GC_2_119 ref NI_2 NS_119 0 1.1310947018052431e-02
GC_2_120 ref NI_2 NS_120 0 1.0656102221433074e-02
GC_2_121 ref NI_2 NS_121 0 1.3167768934508708e-03
GC_2_122 ref NI_2 NS_122 0 -2.6853944098491778e-04
GC_2_123 ref NI_2 NS_123 0 7.2628176883661265e-06
GC_2_124 ref NI_2 NS_124 0 1.7317033206311081e-07
GC_2_125 ref NI_2 NS_125 0 1.6093672800812229e-02
GC_2_126 ref NI_2 NS_126 0 1.9232011656257864e-02
GC_2_127 ref NI_2 NS_127 0 2.5892738889668450e-03
GC_2_128 ref NI_2 NS_128 0 6.5505483405843621e-04
GC_2_129 ref NI_2 NS_129 0 -7.7958605536093501e-06
GC_2_130 ref NI_2 NS_130 0 1.1482190843231880e-06
GC_2_131 ref NI_2 NS_131 0 7.3835550451446475e-03
GC_2_132 ref NI_2 NS_132 0 1.2772880146594820e-02
GD_2_1 ref NI_2 NA_1 0 5.0122058692510249e-05
GD_2_2 ref NI_2 NA_2 0 6.0026658234654926e+00
GD_2_3 ref NI_2 NA_3 0 -1.9079965063177155e-02
GD_2_4 ref NI_2 NA_4 0 -2.0442571798862431e-02
GD_2_5 ref NI_2 NA_5 0 -1.4789940632274368e-02
GD_2_6 ref NI_2 NA_6 0 -1.6797182851512077e-02
GD_2_7 ref NI_2 NA_7 0 -1.8400762556759372e-02
GD_2_8 ref NI_2 NA_8 0 -1.7741321162489273e-02
GD_2_9 ref NI_2 NA_9 0 -1.2693650314158545e-02
GD_2_10 ref NI_2 NA_10 0 -6.7116580290697498e-03
GD_2_11 ref NI_2 NA_11 0 -5.8026119293826100e-03
GD_2_12 ref NI_2 NA_12 0 -7.1301559501052514e-03
GD_2_13 ref NI_2 NA_13 0 -7.7544147872603371e-03
GD_2_14 ref NI_2 NA_14 0 -8.1349533786269374e-03
GD_2_15 ref NI_2 NA_15 0 -7.6012988064772490e-03
GD_2_16 ref NI_2 NA_16 0 -8.1342950007982171e-03
GD_2_17 ref NI_2 NA_17 0 -6.8220509832818636e-03
GD_2_18 ref NI_2 NA_18 0 -8.2045733044707522e-03
GD_2_19 ref NI_2 NA_19 0 -7.1339049672474279e-03
GD_2_20 ref NI_2 NA_20 0 -6.4966636563124460e-03
GD_2_21 ref NI_2 NA_21 0 -7.2184018087830962e-03
GD_2_22 ref NI_2 NA_22 0 -1.3797445144011020e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 6.4297425502107689e-03
GC_3_2 ref NI_3 NS_2 0 -2.3225531875698544e-03
GC_3_3 ref NI_3 NS_3 0 -1.6593948850745312e-05
GC_3_4 ref NI_3 NS_4 0 1.1212017522462180e-07
GC_3_5 ref NI_3 NS_5 0 7.5918375294607337e-03
GC_3_6 ref NI_3 NS_6 0 -9.4947502542851135e-03
GC_3_7 ref NI_3 NS_7 0 2.1256952702199332e-03
GC_3_8 ref NI_3 NS_8 0 -6.1465826245483686e-04
GC_3_9 ref NI_3 NS_9 0 3.1173629167540549e-07
GC_3_10 ref NI_3 NS_10 0 4.4568791820553401e-07
GC_3_11 ref NI_3 NS_11 0 1.5032619285991323e-02
GC_3_12 ref NI_3 NS_12 0 1.3681475866484322e-02
GC_3_13 ref NI_3 NS_13 0 -5.0174722733954076e-02
GC_3_14 ref NI_3 NS_14 0 -7.7878863100272011e-04
GC_3_15 ref NI_3 NS_15 0 -2.2722811021132794e-04
GC_3_16 ref NI_3 NS_16 0 -5.6003954603969252e-07
GC_3_17 ref NI_3 NS_17 0 -1.2270226863998517e-01
GC_3_18 ref NI_3 NS_18 0 1.4509418526119330e-01
GC_3_19 ref NI_3 NS_19 0 1.1481705191988428e-03
GC_3_20 ref NI_3 NS_20 0 1.7569235445205604e-03
GC_3_21 ref NI_3 NS_21 0 1.4794835668512451e-05
GC_3_22 ref NI_3 NS_22 0 4.9968390685832286e-07
GC_3_23 ref NI_3 NS_23 0 1.0239392155681119e-03
GC_3_24 ref NI_3 NS_24 0 -3.4873730378790803e-03
GC_3_25 ref NI_3 NS_25 0 -1.7818167154566942e-03
GC_3_26 ref NI_3 NS_26 0 3.2934678916677262e-03
GC_3_27 ref NI_3 NS_27 0 2.9857529924744530e-05
GC_3_28 ref NI_3 NS_28 0 6.8615928596849069e-07
GC_3_29 ref NI_3 NS_29 0 3.3250421010896746e-04
GC_3_30 ref NI_3 NS_30 0 -3.1786783711559336e-03
GC_3_31 ref NI_3 NS_31 0 2.5191891817099546e-03
GC_3_32 ref NI_3 NS_32 0 7.3600137192414937e-04
GC_3_33 ref NI_3 NS_33 0 4.1139191248702806e-06
GC_3_34 ref NI_3 NS_34 0 3.4961906917330251e-07
GC_3_35 ref NI_3 NS_35 0 2.3518923134740232e-03
GC_3_36 ref NI_3 NS_36 0 -6.3864193948012446e-03
GC_3_37 ref NI_3 NS_37 0 1.3022876610211255e-03
GC_3_38 ref NI_3 NS_38 0 -1.0209063451989857e-03
GC_3_39 ref NI_3 NS_39 0 -8.4829516413733757e-06
GC_3_40 ref NI_3 NS_40 0 2.7945940706157546e-08
GC_3_41 ref NI_3 NS_41 0 1.1983942029534273e-02
GC_3_42 ref NI_3 NS_42 0 -1.8789860885792563e-02
GC_3_43 ref NI_3 NS_43 0 -9.4033744765294521e-03
GC_3_44 ref NI_3 NS_44 0 -2.5988135584509098e-03
GC_3_45 ref NI_3 NS_45 0 -3.6618598429238699e-05
GC_3_46 ref NI_3 NS_46 0 -2.1022110346224596e-07
GC_3_47 ref NI_3 NS_47 0 4.9376070228291893e-02
GC_3_48 ref NI_3 NS_48 0 -1.1384835683919934e-02
GC_3_49 ref NI_3 NS_49 0 2.4681985753641461e-03
GC_3_50 ref NI_3 NS_50 0 1.7936344071869438e-03
GC_3_51 ref NI_3 NS_51 0 5.0072115087770485e-06
GC_3_52 ref NI_3 NS_52 0 9.5057351781163663e-07
GC_3_53 ref NI_3 NS_53 0 -1.5278515140229553e-03
GC_3_54 ref NI_3 NS_54 0 -3.7512202563275105e-04
GC_3_55 ref NI_3 NS_55 0 1.1620360638471114e-02
GC_3_56 ref NI_3 NS_56 0 -5.7139403491795757e-03
GC_3_57 ref NI_3 NS_57 0 -1.7498909385319581e-05
GC_3_58 ref NI_3 NS_58 0 9.1358130004890192e-07
GC_3_59 ref NI_3 NS_59 0 8.6907362278931515e-03
GC_3_60 ref NI_3 NS_60 0 -2.2194970391801880e-02
GC_3_61 ref NI_3 NS_61 0 8.1152517323458044e-04
GC_3_62 ref NI_3 NS_62 0 -5.8808494652857167e-03
GC_3_63 ref NI_3 NS_63 0 -1.7842671047955348e-05
GC_3_64 ref NI_3 NS_64 0 1.8565855432257254e-07
GC_3_65 ref NI_3 NS_65 0 3.5460990841546122e-02
GC_3_66 ref NI_3 NS_66 0 -2.7723902400446081e-02
GC_3_67 ref NI_3 NS_67 0 2.5250654953577994e-04
GC_3_68 ref NI_3 NS_68 0 2.5422869758415442e-03
GC_3_69 ref NI_3 NS_69 0 3.4261075805466772e-05
GC_3_70 ref NI_3 NS_70 0 2.4226518492000252e-07
GC_3_71 ref NI_3 NS_71 0 -7.5982301338281934e-04
GC_3_72 ref NI_3 NS_72 0 -1.3437208325980700e-03
GC_3_73 ref NI_3 NS_73 0 -2.1553141139104434e-04
GC_3_74 ref NI_3 NS_74 0 2.8017809015621607e-03
GC_3_75 ref NI_3 NS_75 0 4.3708149158339518e-05
GC_3_76 ref NI_3 NS_76 0 1.1344117210391358e-06
GC_3_77 ref NI_3 NS_77 0 -1.4177229873964759e-03
GC_3_78 ref NI_3 NS_78 0 -1.6163157047986393e-03
GC_3_79 ref NI_3 NS_79 0 7.6995246137099779e-03
GC_3_80 ref NI_3 NS_80 0 -4.1097245822292938e-03
GC_3_81 ref NI_3 NS_81 0 -8.0785586994368609e-06
GC_3_82 ref NI_3 NS_82 0 -8.2201082223508659e-07
GC_3_83 ref NI_3 NS_83 0 1.3323454079090056e-02
GC_3_84 ref NI_3 NS_84 0 -9.7110212260079817e-03
GC_3_85 ref NI_3 NS_85 0 1.3273462451632481e-02
GC_3_86 ref NI_3 NS_86 0 -3.2477069739127581e-03
GC_3_87 ref NI_3 NS_87 0 2.7435846161247133e-06
GC_3_88 ref NI_3 NS_88 0 4.5453501722342485e-08
GC_3_89 ref NI_3 NS_89 0 -6.9130610292804867e-03
GC_3_90 ref NI_3 NS_90 0 -1.6017051043330975e-02
GC_3_91 ref NI_3 NS_91 0 3.1691572057110642e-03
GC_3_92 ref NI_3 NS_92 0 1.4231823445478844e-03
GC_3_93 ref NI_3 NS_93 0 1.4256882620251969e-05
GC_3_94 ref NI_3 NS_94 0 1.4640949274043074e-07
GC_3_95 ref NI_3 NS_95 0 -1.4972209018005013e-03
GC_3_96 ref NI_3 NS_96 0 7.0432698654854665e-04
GC_3_97 ref NI_3 NS_97 0 2.2151829432915972e-03
GC_3_98 ref NI_3 NS_98 0 2.1534516573098149e-03
GC_3_99 ref NI_3 NS_99 0 1.6433805777495498e-05
GC_3_100 ref NI_3 NS_100 0 1.1957495951845893e-06
GC_3_101 ref NI_3 NS_101 0 -2.8404362220530630e-03
GC_3_102 ref NI_3 NS_102 0 1.8081854260957673e-03
GC_3_103 ref NI_3 NS_103 0 7.0725708090815338e-03
GC_3_104 ref NI_3 NS_104 0 -6.6875272873603766e-04
GC_3_105 ref NI_3 NS_105 0 -1.1284976320661539e-06
GC_3_106 ref NI_3 NS_106 0 -4.2980664988706988e-08
GC_3_107 ref NI_3 NS_107 0 -9.3485777119867869e-04
GC_3_108 ref NI_3 NS_108 0 -1.6558974612127344e-03
GC_3_109 ref NI_3 NS_109 0 7.3025403176479658e-03
GC_3_110 ref NI_3 NS_110 0 2.4378966813510438e-04
GC_3_111 ref NI_3 NS_111 0 1.9269327319981173e-06
GC_3_112 ref NI_3 NS_112 0 6.0573666656818652e-07
GC_3_113 ref NI_3 NS_113 0 -5.3227306591105738e-03
GC_3_114 ref NI_3 NS_114 0 2.9498337514277128e-03
GC_3_115 ref NI_3 NS_115 0 -3.4127190313371224e-03
GC_3_116 ref NI_3 NS_116 0 3.8961451583532669e-03
GC_3_117 ref NI_3 NS_117 0 4.9447966310126347e-05
GC_3_118 ref NI_3 NS_118 0 1.1333761245736971e-06
GC_3_119 ref NI_3 NS_119 0 2.8064994919503329e-04
GC_3_120 ref NI_3 NS_120 0 -4.8520342364519291e-03
GC_3_121 ref NI_3 NS_121 0 -1.9413165134533133e-03
GC_3_122 ref NI_3 NS_122 0 3.2630760487970308e-03
GC_3_123 ref NI_3 NS_123 0 4.4135123418266279e-05
GC_3_124 ref NI_3 NS_124 0 3.5220050909690701e-07
GC_3_125 ref NI_3 NS_125 0 1.9500610574796733e-04
GC_3_126 ref NI_3 NS_126 0 -4.3284324788464045e-03
GC_3_127 ref NI_3 NS_127 0 8.0425371541910839e-04
GC_3_128 ref NI_3 NS_128 0 2.4600901299944187e-03
GC_3_129 ref NI_3 NS_129 0 6.0014096778525032e-06
GC_3_130 ref NI_3 NS_130 0 8.9876271120064910e-07
GC_3_131 ref NI_3 NS_131 0 -3.2220917516840724e-04
GC_3_132 ref NI_3 NS_132 0 1.4112893380724436e-03
GD_3_1 ref NI_3 NA_1 0 1.0178849868889693e-02
GD_3_2 ref NI_3 NA_2 0 -1.9079965063177155e-02
GD_3_3 ref NI_3 NA_3 0 6.2115171310242943e+00
GD_3_4 ref NI_3 NA_4 0 -2.7657904953011332e-03
GD_3_5 ref NI_3 NA_5 0 -9.4042248177539432e-04
GD_3_6 ref NI_3 NA_6 0 -1.6715730176409449e-03
GD_3_7 ref NI_3 NA_7 0 -1.9025631364984307e-03
GD_3_8 ref NI_3 NA_8 0 -1.1455955794286118e-03
GD_3_9 ref NI_3 NA_9 0 -3.2224229781183315e-03
GD_3_10 ref NI_3 NA_10 0 7.0259814347434510e-03
GD_3_11 ref NI_3 NA_11 0 2.5163701141596183e-02
GD_3_12 ref NI_3 NA_12 0 2.6316161630690968e-04
GD_3_13 ref NI_3 NA_13 0 1.4077100391006762e-04
GD_3_14 ref NI_3 NA_14 0 1.2279534501943709e-02
GD_3_15 ref NI_3 NA_15 0 2.7560385658971834e-03
GD_3_16 ref NI_3 NA_16 0 -3.2309702217020523e-04
GD_3_17 ref NI_3 NA_17 0 -6.5714500995533315e-04
GD_3_18 ref NI_3 NA_18 0 1.5289120456543478e-03
GD_3_19 ref NI_3 NA_19 0 -8.2048432475100887e-04
GD_3_20 ref NI_3 NA_20 0 1.5816443810128017e-03
GD_3_21 ref NI_3 NA_21 0 1.1741825524586083e-03
GD_3_22 ref NI_3 NA_22 0 -3.1745812727353557e-03
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -5.9828140280442272e-04
GC_4_2 ref NI_4 NS_2 0 2.3420448309561994e-03
GC_4_3 ref NI_4 NS_3 0 6.4549784150946956e-05
GC_4_4 ref NI_4 NS_4 0 2.1930679420535136e-06
GC_4_5 ref NI_4 NS_5 0 5.8604319015473502e-04
GC_4_6 ref NI_4 NS_6 0 -4.8571751174998788e-03
GC_4_7 ref NI_4 NS_7 0 1.6615709153482690e-03
GC_4_8 ref NI_4 NS_8 0 -3.6563048316434944e-04
GC_4_9 ref NI_4 NS_9 0 -2.1676377248633814e-06
GC_4_10 ref NI_4 NS_10 0 5.3796150477185918e-07
GC_4_11 ref NI_4 NS_11 0 1.4893585705804227e-02
GC_4_12 ref NI_4 NS_12 0 1.2986712724440515e-02
GC_4_13 ref NI_4 NS_13 0 1.1481705191988361e-03
GC_4_14 ref NI_4 NS_14 0 1.7569235445205650e-03
GC_4_15 ref NI_4 NS_15 0 1.4794835668511275e-05
GC_4_16 ref NI_4 NS_16 0 4.9968390685850455e-07
GC_4_17 ref NI_4 NS_17 0 1.0239392155681135e-03
GC_4_18 ref NI_4 NS_18 0 -3.4873730378790898e-03
GC_4_19 ref NI_4 NS_19 0 -4.2463203756633955e-02
GC_4_20 ref NI_4 NS_20 0 -3.5129439245851621e-05
GC_4_21 ref NI_4 NS_21 0 -2.0926490851005456e-04
GC_4_22 ref NI_4 NS_22 0 -5.3214359081692876e-07
GC_4_23 ref NI_4 NS_23 0 -1.4866432720648376e-01
GC_4_24 ref NI_4 NS_24 0 1.3534326934684376e-01
GC_4_25 ref NI_4 NS_25 0 3.5109510849228309e-03
GC_4_26 ref NI_4 NS_26 0 -2.6041710763984273e-03
GC_4_27 ref NI_4 NS_27 0 -3.5236239069287939e-05
GC_4_28 ref NI_4 NS_28 0 -9.3901664245389073e-08
GC_4_29 ref NI_4 NS_29 0 1.8287499186324337e-02
GC_4_30 ref NI_4 NS_30 0 -4.2269864050113954e-03
GC_4_31 ref NI_4 NS_31 0 -7.5758518925941451e-03
GC_4_32 ref NI_4 NS_32 0 -1.0631409902933675e-03
GC_4_33 ref NI_4 NS_33 0 -3.0290318974452388e-05
GC_4_34 ref NI_4 NS_34 0 -1.0947925472616692e-07
GC_4_35 ref NI_4 NS_35 0 3.9824556334115059e-02
GC_4_36 ref NI_4 NS_36 0 2.2847440307363037e-03
GC_4_37 ref NI_4 NS_37 0 4.0248373983806573e-04
GC_4_38 ref NI_4 NS_38 0 1.8129355925008736e-04
GC_4_39 ref NI_4 NS_39 0 -3.0198277727643704e-06
GC_4_40 ref NI_4 NS_40 0 1.5908233143170488e-07
GC_4_41 ref NI_4 NS_41 0 9.1577650271845324e-03
GC_4_42 ref NI_4 NS_42 0 -1.3786038693409887e-02
GC_4_43 ref NI_4 NS_43 0 1.5116276853997961e-03
GC_4_44 ref NI_4 NS_44 0 1.3887120123371676e-03
GC_4_45 ref NI_4 NS_45 0 8.9309926595438928e-06
GC_4_46 ref NI_4 NS_46 0 3.5982447559605294e-07
GC_4_47 ref NI_4 NS_47 0 1.7539992084413560e-03
GC_4_48 ref NI_4 NS_48 0 -5.2847658456106469e-03
GC_4_49 ref NI_4 NS_49 0 4.0298811850243837e-03
GC_4_50 ref NI_4 NS_50 0 -2.0512872809654806e-03
GC_4_51 ref NI_4 NS_51 0 -2.0886608923557129e-05
GC_4_52 ref NI_4 NS_52 0 -1.3881433991204564e-07
GC_4_53 ref NI_4 NS_53 0 1.2876820999626927e-02
GC_4_54 ref NI_4 NS_54 0 -9.1822020202866270e-03
GC_4_55 ref NI_4 NS_55 0 -4.7588526686924757e-04
GC_4_56 ref NI_4 NS_56 0 2.8300202234309338e-03
GC_4_57 ref NI_4 NS_57 0 2.6478260144171100e-05
GC_4_58 ref NI_4 NS_58 0 5.7885469007260178e-07
GC_4_59 ref NI_4 NS_59 0 -4.0907583323540798e-04
GC_4_60 ref NI_4 NS_60 0 -2.1163125169242139e-03
GC_4_61 ref NI_4 NS_61 0 -4.8515301835984332e-04
GC_4_62 ref NI_4 NS_62 0 2.9775867508124282e-03
GC_4_63 ref NI_4 NS_63 0 3.2170544930265176e-05
GC_4_64 ref NI_4 NS_64 0 5.5661019460885429e-07
GC_4_65 ref NI_4 NS_65 0 -1.3006338619716549e-03
GC_4_66 ref NI_4 NS_66 0 -2.2723184324150263e-03
GC_4_67 ref NI_4 NS_67 0 6.0716243683492915e-03
GC_4_68 ref NI_4 NS_68 0 -3.0170785786881212e-03
GC_4_69 ref NI_4 NS_69 0 1.3216920478374259e-05
GC_4_70 ref NI_4 NS_70 0 1.2534591599039022e-06
GC_4_71 ref NI_4 NS_71 0 8.2870497814774291e-03
GC_4_72 ref NI_4 NS_72 0 -2.1268559506079334e-02
GC_4_73 ref NI_4 NS_73 0 -7.9633141150090500e-03
GC_4_74 ref NI_4 NS_74 0 -3.9251854058315432e-03
GC_4_75 ref NI_4 NS_75 0 -2.6824290484946840e-06
GC_4_76 ref NI_4 NS_76 0 1.6094720275608695e-07
GC_4_77 ref NI_4 NS_77 0 4.7699164434967585e-02
GC_4_78 ref NI_4 NS_78 0 -2.5665360326410386e-02
GC_4_79 ref NI_4 NS_79 0 -7.1174481451345413e-04
GC_4_80 ref NI_4 NS_80 0 2.8961427946694557e-03
GC_4_81 ref NI_4 NS_81 0 2.9593370408950439e-05
GC_4_82 ref NI_4 NS_82 0 6.1641300266316738e-07
GC_4_83 ref NI_4 NS_83 0 -2.6482766207576149e-04
GC_4_84 ref NI_4 NS_84 0 -2.1333692722667209e-03
GC_4_85 ref NI_4 NS_85 0 4.4715169518796423e-04
GC_4_86 ref NI_4 NS_86 0 2.6694454533344038e-03
GC_4_87 ref NI_4 NS_87 0 2.7353887528720971e-05
GC_4_88 ref NI_4 NS_88 0 3.7910066394327471e-07
GC_4_89 ref NI_4 NS_89 0 -1.7368687895108288e-03
GC_4_90 ref NI_4 NS_90 0 -1.2854190877709295e-03
GC_4_91 ref NI_4 NS_91 0 4.9939425862536215e-03
GC_4_92 ref NI_4 NS_92 0 2.8481396602950473e-04
GC_4_93 ref NI_4 NS_93 0 8.9421034793283150e-06
GC_4_94 ref NI_4 NS_94 0 1.0284883269215049e-06
GC_4_95 ref NI_4 NS_95 0 -9.9804838314698991e-04
GC_4_96 ref NI_4 NS_96 0 -1.5085502320017490e-03
GC_4_97 ref NI_4 NS_97 0 6.6792832123122757e-03
GC_4_98 ref NI_4 NS_98 0 -1.0664222603146494e-03
GC_4_99 ref NI_4 NS_99 0 1.5919514020796553e-05
GC_4_100 ref NI_4 NS_100 0 3.1740619423475771e-07
GC_4_101 ref NI_4 NS_101 0 -1.6640674930038742e-03
GC_4_102 ref NI_4 NS_102 0 -1.6042707427158302e-02
GC_4_103 ref NI_4 NS_103 0 1.5079072124445244e-03
GC_4_104 ref NI_4 NS_104 0 2.0221877345192340e-03
GC_4_105 ref NI_4 NS_105 0 2.1459041312121498e-05
GC_4_106 ref NI_4 NS_106 0 7.2585294426454267e-07
GC_4_107 ref NI_4 NS_107 0 -9.3877919772731016e-04
GC_4_108 ref NI_4 NS_108 0 -5.4205067910960219e-04
GC_4_109 ref NI_4 NS_109 0 3.6341175539353755e-03
GC_4_110 ref NI_4 NS_110 0 1.3162599605128879e-03
GC_4_111 ref NI_4 NS_111 0 1.8688643862344427e-05
GC_4_112 ref NI_4 NS_112 0 3.3533928770147435e-07
GC_4_113 ref NI_4 NS_113 0 -2.9478726166186939e-03
GC_4_114 ref NI_4 NS_114 0 -2.1633949057182126e-03
GC_4_115 ref NI_4 NS_115 0 1.2517589111199686e-02
GC_4_116 ref NI_4 NS_116 0 -2.1342294059590594e-03
GC_4_117 ref NI_4 NS_117 0 -1.4478409850595508e-05
GC_4_118 ref NI_4 NS_118 0 -6.6613654625873272e-08
GC_4_119 ref NI_4 NS_119 0 -7.2582500218549952e-03
GC_4_120 ref NI_4 NS_120 0 -3.2991571031970725e-03
GC_4_121 ref NI_4 NS_121 0 5.5345715452183872e-03
GC_4_122 ref NI_4 NS_122 0 -2.5827812365917069e-03
GC_4_123 ref NI_4 NS_123 0 -1.1141854884247030e-05
GC_4_124 ref NI_4 NS_124 0 -4.5929813393899081e-07
GC_4_125 ref NI_4 NS_125 0 1.1879635784846304e-02
GC_4_126 ref NI_4 NS_126 0 -6.3676479999414601e-03
GC_4_127 ref NI_4 NS_127 0 9.7116190973979295e-03
GC_4_128 ref NI_4 NS_128 0 -2.3674646030965646e-03
GC_4_129 ref NI_4 NS_129 0 -2.0114799221942781e-05
GC_4_130 ref NI_4 NS_130 0 -1.6100366454865632e-08
GC_4_131 ref NI_4 NS_131 0 1.2942851055933059e-03
GC_4_132 ref NI_4 NS_132 0 -3.1947090352206051e-03
GD_4_1 ref NI_4 NA_1 0 5.7884321835709887e-03
GD_4_2 ref NI_4 NA_2 0 -2.0442571798862431e-02
GD_4_3 ref NI_4 NA_3 0 -2.7657904953011332e-03
GD_4_4 ref NI_4 NA_4 0 6.2086218401963009e+00
GD_4_5 ref NI_4 NA_5 0 -1.4971164873851244e-03
GD_4_6 ref NI_4 NA_6 0 -2.6752368648287088e-03
GD_4_7 ref NI_4 NA_7 0 -3.0428857387176313e-03
GD_4_8 ref NI_4 NA_8 0 -2.4275963069892558e-03
GD_4_9 ref NI_4 NA_9 0 -3.7884595005840968e-03
GD_4_10 ref NI_4 NA_10 0 -3.3004880437579356e-04
GD_4_11 ref NI_4 NA_11 0 2.3204129030252090e-04
GD_4_12 ref NI_4 NA_12 0 1.6243555604465464e-02
GD_4_13 ref NI_4 NA_13 0 3.4362631633273147e-02
GD_4_14 ref NI_4 NA_14 0 5.2073898481894360e-04
GD_4_15 ref NI_4 NA_15 0 5.8121442823275046e-05
GD_4_16 ref NI_4 NA_16 0 2.3273275430263978e-03
GD_4_17 ref NI_4 NA_17 0 4.6188823176230159e-03
GD_4_18 ref NI_4 NA_18 0 4.1148431816096946e-04
GD_4_19 ref NI_4 NA_19 0 5.2833147032979838e-04
GD_4_20 ref NI_4 NA_20 0 -1.6601904495293657e-03
GD_4_21 ref NI_4 NA_21 0 9.1592875396988970e-03
GD_4_22 ref NI_4 NA_22 0 -4.0853095058907621e-03
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -4.9697064073700179e-03
GC_5_2 ref NI_5 NS_2 0 4.1700848021719878e-03
GC_5_3 ref NI_5 NS_3 0 9.4676494324742556e-05
GC_5_4 ref NI_5 NS_4 0 2.2594018770383649e-06
GC_5_5 ref NI_5 NS_5 0 1.2670054191039040e-03
GC_5_6 ref NI_5 NS_6 0 -7.0807246084437902e-03
GC_5_7 ref NI_5 NS_7 0 2.3786294336556246e-03
GC_5_8 ref NI_5 NS_8 0 -1.6593252257245212e-04
GC_5_9 ref NI_5 NS_9 0 -1.6414651364785662e-06
GC_5_10 ref NI_5 NS_10 0 7.2358405534493121e-07
GC_5_11 ref NI_5 NS_11 0 1.1238516216459184e-02
GC_5_12 ref NI_5 NS_12 0 9.8870777121997707e-03
GC_5_13 ref NI_5 NS_13 0 -1.7818167154566935e-03
GC_5_14 ref NI_5 NS_14 0 3.2934678916677288e-03
GC_5_15 ref NI_5 NS_15 0 2.9857529924743036e-05
GC_5_16 ref NI_5 NS_16 0 6.8615928596886540e-07
GC_5_17 ref NI_5 NS_17 0 3.3250421010896491e-04
GC_5_18 ref NI_5 NS_18 0 -3.1786783711559245e-03
GC_5_19 ref NI_5 NS_19 0 3.5109510849228262e-03
GC_5_20 ref NI_5 NS_20 0 -2.6041710763984255e-03
GC_5_21 ref NI_5 NS_21 0 -3.5236239069288657e-05
GC_5_22 ref NI_5 NS_22 0 -9.3901664245205399e-08
GC_5_23 ref NI_5 NS_23 0 1.8287499186324337e-02
GC_5_24 ref NI_5 NS_24 0 -4.2269864050113954e-03
GC_5_25 ref NI_5 NS_25 0 -5.7586555824403425e-02
GC_5_26 ref NI_5 NS_26 0 -1.0918112863340592e-02
GC_5_27 ref NI_5 NS_27 0 -2.6738286382814626e-04
GC_5_28 ref NI_5 NS_28 0 -3.5175871318480299e-06
GC_5_29 ref NI_5 NS_29 0 -6.3974643938032510e-02
GC_5_30 ref NI_5 NS_30 0 8.9251479432356812e-02
GC_5_31 ref NI_5 NS_31 0 5.0581554152610043e-03
GC_5_32 ref NI_5 NS_32 0 2.1884812928390390e-04
GC_5_33 ref NI_5 NS_33 0 -1.3091788518546931e-05
GC_5_34 ref NI_5 NS_34 0 5.5792575491624933e-07
GC_5_35 ref NI_5 NS_35 0 -1.6366457095656964e-04
GC_5_36 ref NI_5 NS_36 0 -2.5700066473950465e-03
GC_5_37 ref NI_5 NS_37 0 1.6285657060511184e-03
GC_5_38 ref NI_5 NS_38 0 2.0672766374729258e-03
GC_5_39 ref NI_5 NS_39 0 4.0374679229873221e-06
GC_5_40 ref NI_5 NS_40 0 6.0729882771935414e-07
GC_5_41 ref NI_5 NS_41 0 -7.4074948782013776e-04
GC_5_42 ref NI_5 NS_42 0 -1.8957690344500091e-04
GC_5_43 ref NI_5 NS_43 0 -1.0939300248856614e-03
GC_5_44 ref NI_5 NS_44 0 3.1433009693369166e-03
GC_5_45 ref NI_5 NS_45 0 2.1935616226062717e-05
GC_5_46 ref NI_5 NS_46 0 6.3723221713515183e-07
GC_5_47 ref NI_5 NS_47 0 -1.1803965979551695e-04
GC_5_48 ref NI_5 NS_48 0 -1.8075185150171150e-03
GC_5_49 ref NI_5 NS_49 0 9.0760570117321988e-03
GC_5_50 ref NI_5 NS_50 0 -9.3486236533660337e-04
GC_5_51 ref NI_5 NS_51 0 -3.3930385932495287e-05
GC_5_52 ref NI_5 NS_52 0 8.6983118050632860e-08
GC_5_53 ref NI_5 NS_53 0 -1.8670885926798978e-03
GC_5_54 ref NI_5 NS_54 0 5.5691868910575718e-03
GC_5_55 ref NI_5 NS_55 0 -3.5941416781930342e-03
GC_5_56 ref NI_5 NS_56 0 3.8682573718205561e-03
GC_5_57 ref NI_5 NS_57 0 5.0876740988519091e-05
GC_5_58 ref NI_5 NS_58 0 5.2627324400701510e-07
GC_5_59 ref NI_5 NS_59 0 7.4930733398884976e-04
GC_5_60 ref NI_5 NS_60 0 -6.0846936292498202e-03
GC_5_61 ref NI_5 NS_61 0 -3.9189037482111420e-03
GC_5_62 ref NI_5 NS_62 0 4.0354096103936690e-03
GC_5_63 ref NI_5 NS_63 0 5.8386655517603164e-05
GC_5_64 ref NI_5 NS_64 0 5.1252077131739842e-07
GC_5_65 ref NI_5 NS_65 0 4.6486762662560307e-04
GC_5_66 ref NI_5 NS_66 0 -6.4458527537629177e-03
GC_5_67 ref NI_5 NS_67 0 6.7580140920713901e-03
GC_5_68 ref NI_5 NS_68 0 4.1959797475855259e-04
GC_5_69 ref NI_5 NS_69 0 -1.9659260636012517e-05
GC_5_70 ref NI_5 NS_70 0 1.2077051550924681e-06
GC_5_71 ref NI_5 NS_71 0 -3.4795506327116436e-03
GC_5_72 ref NI_5 NS_72 0 6.9657176803698496e-03
GC_5_73 ref NI_5 NS_73 0 1.1294670675507790e-02
GC_5_74 ref NI_5 NS_74 0 -1.8256737876496873e-03
GC_5_75 ref NI_5 NS_75 0 -2.2847006783314236e-05
GC_5_76 ref NI_5 NS_76 0 2.3813963816355187e-07
GC_5_77 ref NI_5 NS_77 0 -4.7636436839683261e-03
GC_5_78 ref NI_5 NS_78 0 6.3742588816610441e-04
GC_5_79 ref NI_5 NS_79 0 -4.0880107463945742e-03
GC_5_80 ref NI_5 NS_80 0 4.0156702514655938e-03
GC_5_81 ref NI_5 NS_81 0 5.3153189640468291e-05
GC_5_82 ref NI_5 NS_82 0 6.2954318720079946e-07
GC_5_83 ref NI_5 NS_83 0 1.0499458922099277e-03
GC_5_84 ref NI_5 NS_84 0 -6.5034264128805887e-03
GC_5_85 ref NI_5 NS_85 0 -3.5407877876248448e-03
GC_5_86 ref NI_5 NS_86 0 3.9860482238871075e-03
GC_5_87 ref NI_5 NS_87 0 4.9349509268201196e-05
GC_5_88 ref NI_5 NS_88 0 4.5081399204342285e-07
GC_5_89 ref NI_5 NS_89 0 2.6519665438113374e-04
GC_5_90 ref NI_5 NS_90 0 -5.2142545257059759e-03
GC_5_91 ref NI_5 NS_91 0 9.7089120931287865e-04
GC_5_92 ref NI_5 NS_92 0 2.5382629696470110e-03
GC_5_93 ref NI_5 NS_93 0 7.8037560754337704e-06
GC_5_94 ref NI_5 NS_94 0 9.6944599986927188e-07
GC_5_95 ref NI_5 NS_95 0 -1.3127716230504779e-03
GC_5_96 ref NI_5 NS_96 0 1.8563289268170445e-03
GC_5_97 ref NI_5 NS_97 0 3.7247414070365817e-03
GC_5_98 ref NI_5 NS_98 0 1.7564351475502760e-03
GC_5_99 ref NI_5 NS_99 0 -3.0026165982269166e-07
GC_5_100 ref NI_5 NS_100 0 6.8085605087342389e-07
GC_5_101 ref NI_5 NS_101 0 -3.3365351820335647e-03
GC_5_102 ref NI_5 NS_102 0 5.0415485447820466e-03
GC_5_103 ref NI_5 NS_103 0 -2.3163796149552906e-03
GC_5_104 ref NI_5 NS_104 0 3.5092091121975209e-03
GC_5_105 ref NI_5 NS_105 0 3.7117764775742291e-05
GC_5_106 ref NI_5 NS_106 0 7.5325057842104486e-07
GC_5_107 ref NI_5 NS_107 0 2.0999791531990116e-04
GC_5_108 ref NI_5 NS_108 0 -3.4130903562377924e-03
GC_5_109 ref NI_5 NS_109 0 -9.5289916140438020e-04
GC_5_110 ref NI_5 NS_110 0 3.2640270748887008e-03
GC_5_111 ref NI_5 NS_111 0 2.5723374267157648e-05
GC_5_112 ref NI_5 NS_112 0 5.2532775843001488e-07
GC_5_113 ref NI_5 NS_113 0 -1.0901163848624669e-03
GC_5_114 ref NI_5 NS_114 0 -9.8150711973862413e-04
GC_5_115 ref NI_5 NS_115 0 1.0814459788764639e-02
GC_5_116 ref NI_5 NS_116 0 -1.5778679966321957e-02
GC_5_117 ref NI_5 NS_117 0 -4.1647741779584767e-05
GC_5_118 ref NI_5 NS_118 0 -2.2091039159249342e-06
GC_5_119 ref NI_5 NS_119 0 5.2581197864295603e-02
GC_5_120 ref NI_5 NS_120 0 -6.2764836927056228e-02
GC_5_121 ref NI_5 NS_121 0 1.9817879114969728e-02
GC_5_122 ref NI_5 NS_122 0 -6.8131703335112450e-03
GC_5_123 ref NI_5 NS_123 0 -2.6162649294073139e-05
GC_5_124 ref NI_5 NS_124 0 1.9418969117548439e-06
GC_5_125 ref NI_5 NS_125 0 -2.5093650626502200e-03
GC_5_126 ref NI_5 NS_126 0 -3.6854791197141008e-03
GC_5_127 ref NI_5 NS_127 0 1.0534090170616605e-02
GC_5_128 ref NI_5 NS_128 0 -1.4869962561872639e-03
GC_5_129 ref NI_5 NS_129 0 -4.3540152731825451e-05
GC_5_130 ref NI_5 NS_130 0 1.7743194235973097e-07
GC_5_131 ref NI_5 NS_131 0 -2.0396667059082228e-03
GC_5_132 ref NI_5 NS_132 0 7.9749438997724267e-03
GD_5_1 ref NI_5 NA_1 0 5.2777598632724769e-03
GD_5_2 ref NI_5 NA_2 0 -1.4789940632274368e-02
GD_5_3 ref NI_5 NA_3 0 -9.4042248177539432e-04
GD_5_4 ref NI_5 NA_4 0 -1.4971164873851244e-03
GD_5_5 ref NI_5 NA_5 0 6.2119385045657642e+00
GD_5_6 ref NI_5 NA_6 0 -2.9776933295326711e-03
GD_5_7 ref NI_5 NA_7 0 -2.6300967043683689e-03
GD_5_8 ref NI_5 NA_8 0 -1.2889787042905583e-03
GD_5_9 ref NI_5 NA_9 0 -6.2480887461461090e-03
GD_5_10 ref NI_5 NA_10 0 1.9477779561398263e-03
GD_5_11 ref NI_5 NA_11 0 2.4429318510253276e-03
GD_5_12 ref NI_5 NA_12 0 -8.9306413039432994e-04
GD_5_13 ref NI_5 NA_13 0 4.4975860361180168e-04
GD_5_14 ref NI_5 NA_14 0 2.5892530045981553e-03
GD_5_15 ref NI_5 NA_15 0 1.9079183095310319e-03
GD_5_16 ref NI_5 NA_16 0 -3.6088485184287061e-04
GD_5_17 ref NI_5 NA_17 0 -1.4020426645425473e-03
GD_5_18 ref NI_5 NA_18 0 1.3982512293740073e-03
GD_5_19 ref NI_5 NA_19 0 3.5462616711148765e-04
GD_5_20 ref NI_5 NA_20 0 5.8486614509905076e-02
GD_5_21 ref NI_5 NA_21 0 1.2177660150392376e-02
GD_5_22 ref NI_5 NA_22 0 -7.1454222281599261e-03
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 1.3299545543729232e-03
GC_6_2 ref NI_6 NS_2 0 1.5438728860979510e-03
GC_6_3 ref NI_6 NS_3 0 4.5437295652292110e-05
GC_6_4 ref NI_6 NS_4 0 1.9006986308343865e-06
GC_6_5 ref NI_6 NS_5 0 4.9206174130170287e-04
GC_6_6 ref NI_6 NS_6 0 -3.7428304365612957e-03
GC_6_7 ref NI_6 NS_7 0 2.3584037265538373e-03
GC_6_8 ref NI_6 NS_8 0 -4.7781649264017713e-04
GC_6_9 ref NI_6 NS_9 0 -1.4396635850236014e-06
GC_6_10 ref NI_6 NS_10 0 5.1739715323929333e-07
GC_6_11 ref NI_6 NS_11 0 1.2460263399034322e-02
GC_6_12 ref NI_6 NS_12 0 7.7555945397304550e-03
GC_6_13 ref NI_6 NS_13 0 2.5191891817099498e-03
GC_6_14 ref NI_6 NS_14 0 7.3600137192415631e-04
GC_6_15 ref NI_6 NS_15 0 4.1139191248679513e-06
GC_6_16 ref NI_6 NS_16 0 3.4961906917367848e-07
GC_6_17 ref NI_6 NS_17 0 2.3518923134740249e-03
GC_6_18 ref NI_6 NS_18 0 -6.3864193948012246e-03
GC_6_19 ref NI_6 NS_19 0 -7.5758518925941494e-03
GC_6_20 ref NI_6 NS_20 0 -1.0631409902933638e-03
GC_6_21 ref NI_6 NS_21 0 -3.0290318974453323e-05
GC_6_22 ref NI_6 NS_22 0 -1.0947925472603440e-07
GC_6_23 ref NI_6 NS_23 0 3.9824556334115066e-02
GC_6_24 ref NI_6 NS_24 0 2.2847440307363007e-03
GC_6_25 ref NI_6 NS_25 0 5.0581554152610000e-03
GC_6_26 ref NI_6 NS_26 0 2.1884812928390672e-04
GC_6_27 ref NI_6 NS_27 0 -1.3091788518547586e-05
GC_6_28 ref NI_6 NS_28 0 5.5792575491623736e-07
GC_6_29 ref NI_6 NS_29 0 -1.6366457095656845e-04
GC_6_30 ref NI_6 NS_30 0 -2.5700066473950500e-03
GC_6_31 ref NI_6 NS_31 0 -4.8142131210490921e-02
GC_6_32 ref NI_6 NS_32 0 9.8644824623079727e-04
GC_6_33 ref NI_6 NS_33 0 -1.9937251026259004e-04
GC_6_34 ref NI_6 NS_34 0 -1.2103972221035864e-06
GC_6_35 ref NI_6 NS_35 0 -1.4156341734355862e-01
GC_6_36 ref NI_6 NS_36 0 1.2430014926430601e-01
GC_6_37 ref NI_6 NS_37 0 -7.2355087992032295e-03
GC_6_38 ref NI_6 NS_38 0 -6.9376442962728528e-04
GC_6_39 ref NI_6 NS_39 0 -1.8610034029945331e-05
GC_6_40 ref NI_6 NS_40 0 -1.0483652118711684e-07
GC_6_41 ref NI_6 NS_41 0 3.5770336769180330e-02
GC_6_42 ref NI_6 NS_42 0 -2.0381692093507098e-03
GC_6_43 ref NI_6 NS_43 0 1.4138835591316289e-03
GC_6_44 ref NI_6 NS_44 0 2.2099796145307502e-04
GC_6_45 ref NI_6 NS_45 0 -2.1521030807118032e-07
GC_6_46 ref NI_6 NS_46 0 1.8521199949850684e-07
GC_6_47 ref NI_6 NS_47 0 6.5184501850433819e-03
GC_6_48 ref NI_6 NS_48 0 -1.2644706574747793e-02
GC_6_49 ref NI_6 NS_49 0 4.0457954527757418e-03
GC_6_50 ref NI_6 NS_50 0 -1.6017536285208860e-03
GC_6_51 ref NI_6 NS_51 0 -1.8793682186964908e-05
GC_6_52 ref NI_6 NS_52 0 -2.3966792951629409e-07
GC_6_53 ref NI_6 NS_53 0 1.0293285836783085e-02
GC_6_54 ref NI_6 NS_54 0 -9.8809722248070636e-03
GC_6_55 ref NI_6 NS_55 0 1.6661515285946124e-03
GC_6_56 ref NI_6 NS_56 0 2.1947242297224892e-03
GC_6_57 ref NI_6 NS_57 0 1.1523972057116884e-05
GC_6_58 ref NI_6 NS_58 0 6.1002164967405511e-07
GC_6_59 ref NI_6 NS_59 0 -1.4547166267403202e-03
GC_6_60 ref NI_6 NS_60 0 1.4241650182204983e-03
GC_6_61 ref NI_6 NS_61 0 1.9681728443985093e-03
GC_6_62 ref NI_6 NS_62 0 2.2783964529700948e-03
GC_6_63 ref NI_6 NS_63 0 1.7298751197395286e-05
GC_6_64 ref NI_6 NS_64 0 5.6693588383619957e-07
GC_6_65 ref NI_6 NS_65 0 -2.7416602893903901e-03
GC_6_66 ref NI_6 NS_66 0 1.5731941906229137e-03
GC_6_67 ref NI_6 NS_67 0 4.2642974931152086e-03
GC_6_68 ref NI_6 NS_68 0 -1.9517310618469132e-03
GC_6_69 ref NI_6 NS_69 0 1.1268629555083062e-05
GC_6_70 ref NI_6 NS_70 0 -3.9047925420140054e-07
GC_6_71 ref NI_6 NS_71 0 1.0560939112646831e-02
GC_6_72 ref NI_6 NS_72 0 -9.6546066415493965e-03
GC_6_73 ref NI_6 NS_73 0 8.2287670379421959e-03
GC_6_74 ref NI_6 NS_74 0 -1.3463905435039134e-03
GC_6_75 ref NI_6 NS_75 0 1.7438489240987069e-05
GC_6_76 ref NI_6 NS_76 0 3.5242668705673405e-08
GC_6_77 ref NI_6 NS_77 0 -4.6592378366261695e-03
GC_6_78 ref NI_6 NS_78 0 -1.8547698042632572e-02
GC_6_79 ref NI_6 NS_79 0 1.7032719357673001e-03
GC_6_80 ref NI_6 NS_80 0 2.1183115641990771e-03
GC_6_81 ref NI_6 NS_81 0 1.5721876921392140e-05
GC_6_82 ref NI_6 NS_82 0 6.8316569333329840e-07
GC_6_83 ref NI_6 NS_83 0 -1.3975365361897614e-03
GC_6_84 ref NI_6 NS_84 0 1.0668863089342987e-03
GC_6_85 ref NI_6 NS_85 0 3.4068630674194056e-03
GC_6_86 ref NI_6 NS_86 0 1.6144458133128341e-03
GC_6_87 ref NI_6 NS_87 0 1.6915589714747026e-05
GC_6_88 ref NI_6 NS_88 0 3.6117300293164363e-07
GC_6_89 ref NI_6 NS_89 0 -3.2087077756464463e-03
GC_6_90 ref NI_6 NS_90 0 6.4968692263457954e-04
GC_6_91 ref NI_6 NS_91 0 5.4545199792215048e-03
GC_6_92 ref NI_6 NS_92 0 -2.3735746788573703e-03
GC_6_93 ref NI_6 NS_93 0 2.8497467050273644e-05
GC_6_94 ref NI_6 NS_94 0 1.2848306087992298e-06
GC_6_95 ref NI_6 NS_95 0 6.4482316931523658e-03
GC_6_96 ref NI_6 NS_96 0 -2.0084703094342387e-02
GC_6_97 ref NI_6 NS_97 0 -7.1241569335207368e-03
GC_6_98 ref NI_6 NS_98 0 -3.4229574391080697e-03
GC_6_99 ref NI_6 NS_99 0 2.4247184537980119e-05
GC_6_100 ref NI_6 NS_100 0 4.8625970458278434e-07
GC_6_101 ref NI_6 NS_101 0 4.1814099757233048e-02
GC_6_102 ref NI_6 NS_102 0 -2.7321158928224114e-02
GC_6_103 ref NI_6 NS_103 0 4.2692959074571192e-03
GC_6_104 ref NI_6 NS_104 0 7.3983167467584236e-04
GC_6_105 ref NI_6 NS_105 0 1.3104038187360689e-05
GC_6_106 ref NI_6 NS_106 0 1.0746471275226350e-06
GC_6_107 ref NI_6 NS_107 0 -1.3475318245800172e-03
GC_6_108 ref NI_6 NS_108 0 -4.6496026670532752e-04
GC_6_109 ref NI_6 NS_109 0 5.9319419999908762e-03
GC_6_110 ref NI_6 NS_110 0 -4.8432575626329843e-04
GC_6_111 ref NI_6 NS_111 0 2.0599106856714287e-05
GC_6_112 ref NI_6 NS_112 0 2.3011907535068258e-07
GC_6_113 ref NI_6 NS_113 0 -2.1294855191809083e-03
GC_6_114 ref NI_6 NS_114 0 -1.2964708387288680e-02
GC_6_115 ref NI_6 NS_115 0 5.1880331833151095e-03
GC_6_116 ref NI_6 NS_116 0 1.3116582810549964e-03
GC_6_117 ref NI_6 NS_117 0 1.3924255938324883e-06
GC_6_118 ref NI_6 NS_118 0 1.3107225364343371e-06
GC_6_119 ref NI_6 NS_119 0 -4.3423532002440498e-03
GC_6_120 ref NI_6 NS_120 0 8.0608681742791490e-03
GC_6_121 ref NI_6 NS_121 0 4.9960719606933646e-03
GC_6_122 ref NI_6 NS_122 0 5.1564534790163677e-04
GC_6_123 ref NI_6 NS_123 0 2.6405676631253112e-06
GC_6_124 ref NI_6 NS_124 0 1.8628213525847132e-07
GC_6_125 ref NI_6 NS_125 0 -1.6253281341007217e-03
GC_6_126 ref NI_6 NS_126 0 -8.9908435935799819e-04
GC_6_127 ref NI_6 NS_127 0 8.9346401930816832e-03
GC_6_128 ref NI_6 NS_128 0 -1.5183673410661910e-03
GC_6_129 ref NI_6 NS_129 0 -1.7309566447434158e-05
GC_6_130 ref NI_6 NS_130 0 3.4021741417366206e-08
GC_6_131 ref NI_6 NS_131 0 -6.7160515353777790e-04
GC_6_132 ref NI_6 NS_132 0 -1.0198961290168280e-03
GD_6_1 ref NI_6 NA_1 0 6.3890781571498160e-03
GD_6_2 ref NI_6 NA_2 0 -1.6797182851512077e-02
GD_6_3 ref NI_6 NA_3 0 -1.6715730176409449e-03
GD_6_4 ref NI_6 NA_4 0 -2.6752368648287088e-03
GD_6_5 ref NI_6 NA_5 0 -2.9776933295326711e-03
GD_6_6 ref NI_6 NA_6 0 6.1929567446058522e+00
GD_6_7 ref NI_6 NA_7 0 2.1108397305586541e-03
GD_6_8 ref NI_6 NA_8 0 -5.2649818204834897e-04
GD_6_9 ref NI_6 NA_9 0 -2.3880549033531372e-03
GD_6_10 ref NI_6 NA_10 0 -9.2485093849568672e-04
GD_6_11 ref NI_6 NA_11 0 -4.7910857096038293e-04
GD_6_12 ref NI_6 NA_12 0 1.1376432371412155e-02
GD_6_13 ref NI_6 NA_13 0 3.2965121684141573e-03
GD_6_14 ref NI_6 NA_14 0 4.0854446076550669e-04
GD_6_15 ref NI_6 NA_15 0 3.1426474255253376e-04
GD_6_16 ref NI_6 NA_16 0 1.7043723441758012e-02
GD_6_17 ref NI_6 NA_17 0 3.8958575818230347e-02
GD_6_18 ref NI_6 NA_18 0 2.7889875966975058e-03
GD_6_19 ref NI_6 NA_19 0 4.5817172734004203e-03
GD_6_20 ref NI_6 NA_20 0 -2.5418363204090040e-03
GD_6_21 ref NI_6 NA_21 0 6.4905622488259655e-04
GD_6_22 ref NI_6 NA_22 0 -3.3312546667283436e-03
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 3.4978067266892942e-03
GC_7_2 ref NI_7 NS_2 0 3.0360535289093932e-04
GC_7_3 ref NI_7 NS_3 0 2.1819946423004879e-05
GC_7_4 ref NI_7 NS_4 0 1.3039441653131427e-06
GC_7_5 ref NI_7 NS_5 0 1.7908886136716530e-03
GC_7_6 ref NI_7 NS_6 0 -4.5323399101667846e-03
GC_7_7 ref NI_7 NS_7 0 2.4877850586296013e-03
GC_7_8 ref NI_7 NS_8 0 -5.6414905097933621e-04
GC_7_9 ref NI_7 NS_9 0 -1.8823072398545261e-06
GC_7_10 ref NI_7 NS_10 0 4.5848264809248301e-07
GC_7_11 ref NI_7 NS_11 0 1.2552945863524810e-02
GC_7_12 ref NI_7 NS_12 0 7.4295940520814358e-03
GC_7_13 ref NI_7 NS_13 0 1.3022876610211266e-03
GC_7_14 ref NI_7 NS_14 0 -1.0209063451989855e-03
GC_7_15 ref NI_7 NS_15 0 -8.4829516413736823e-06
GC_7_16 ref NI_7 NS_16 0 2.7945940705935782e-08
GC_7_17 ref NI_7 NS_17 0 1.1983942029534273e-02
GC_7_18 ref NI_7 NS_18 0 -1.8789860885792545e-02
GC_7_19 ref NI_7 NS_19 0 4.0248373983806562e-04
GC_7_20 ref NI_7 NS_20 0 1.8129355925008763e-04
GC_7_21 ref NI_7 NS_21 0 -3.0198277727647156e-06
GC_7_22 ref NI_7 NS_22 0 1.5908233143190165e-07
GC_7_23 ref NI_7 NS_23 0 9.1577650271845324e-03
GC_7_24 ref NI_7 NS_24 0 -1.3786038693409887e-02
GC_7_25 ref NI_7 NS_25 0 1.6285657060511138e-03
GC_7_26 ref NI_7 NS_26 0 2.0672766374729276e-03
GC_7_27 ref NI_7 NS_27 0 4.0374679229869316e-06
GC_7_28 ref NI_7 NS_28 0 6.0729882771955795e-07
GC_7_29 ref NI_7 NS_29 0 -7.4074948782013527e-04
GC_7_30 ref NI_7 NS_30 0 -1.8957690344501910e-04
GC_7_31 ref NI_7 NS_31 0 -7.2355087992032295e-03
GC_7_32 ref NI_7 NS_32 0 -6.9376442962728626e-04
GC_7_33 ref NI_7 NS_33 0 -1.8610034029945081e-05
GC_7_34 ref NI_7 NS_34 0 -1.0483652118696375e-07
GC_7_35 ref NI_7 NS_35 0 3.5770336769180330e-02
GC_7_36 ref NI_7 NS_36 0 -2.0381692093507102e-03
GC_7_37 ref NI_7 NS_37 0 -4.7845626500213810e-02
GC_7_38 ref NI_7 NS_38 0 1.0119466651301241e-03
GC_7_39 ref NI_7 NS_39 0 -1.8671325277131381e-04
GC_7_40 ref NI_7 NS_40 0 -5.8533369793944930e-07
GC_7_41 ref NI_7 NS_41 0 -1.4080242577729177e-01
GC_7_42 ref NI_7 NS_42 0 1.3619897444661322e-01
GC_7_43 ref NI_7 NS_43 0 -6.3657427085613005e-03
GC_7_44 ref NI_7 NS_44 0 -1.2718073789016002e-03
GC_7_45 ref NI_7 NS_45 0 -2.2581788487581894e-05
GC_7_46 ref NI_7 NS_46 0 -9.2962603572855912e-08
GC_7_47 ref NI_7 NS_47 0 3.5724110380557283e-02
GC_7_48 ref NI_7 NS_48 0 -6.3898388492502475e-03
GC_7_49 ref NI_7 NS_49 0 3.6974566436458666e-03
GC_7_50 ref NI_7 NS_50 0 1.4884205043207328e-04
GC_7_51 ref NI_7 NS_51 0 -8.8846506143478312e-06
GC_7_52 ref NI_7 NS_52 0 2.8502567061485414e-07
GC_7_53 ref NI_7 NS_53 0 3.1067345095205632e-03
GC_7_54 ref NI_7 NS_54 0 -5.0270690203243753e-03
GC_7_55 ref NI_7 NS_55 0 5.6869374794981161e-03
GC_7_56 ref NI_7 NS_56 0 5.8929933407887800e-04
GC_7_57 ref NI_7 NS_57 0 -5.4835300247118547e-06
GC_7_58 ref NI_7 NS_58 0 6.2388979361499198e-07
GC_7_59 ref NI_7 NS_59 0 -2.4577966588063696e-03
GC_7_60 ref NI_7 NS_60 0 4.2909119481019846e-03
GC_7_61 ref NI_7 NS_61 0 6.6961043607651066e-03
GC_7_62 ref NI_7 NS_62 0 4.5318823689135851e-04
GC_7_63 ref NI_7 NS_63 0 2.2300443804695695e-06
GC_7_64 ref NI_7 NS_64 0 5.3831860212811292e-07
GC_7_65 ref NI_7 NS_65 0 -4.8935259213064687e-03
GC_7_66 ref NI_7 NS_66 0 2.5541283794734311e-03
GC_7_67 ref NI_7 NS_67 0 3.9801143834845383e-03
GC_7_68 ref NI_7 NS_68 0 7.7235601625768593e-04
GC_7_69 ref NI_7 NS_69 0 1.8556462465629004e-05
GC_7_70 ref NI_7 NS_70 0 1.6550418056070445e-08
GC_7_71 ref NI_7 NS_71 0 -1.0616466331666494e-03
GC_7_72 ref NI_7 NS_72 0 -2.4413179483570237e-03
GC_7_73 ref NI_7 NS_73 0 4.3394120154242330e-03
GC_7_74 ref NI_7 NS_74 0 1.2315680449396769e-03
GC_7_75 ref NI_7 NS_75 0 1.7314585770802995e-05
GC_7_76 ref NI_7 NS_76 0 7.3035554200075154e-07
GC_7_77 ref NI_7 NS_77 0 -3.9330978283261299e-03
GC_7_78 ref NI_7 NS_78 0 -1.9225219689045670e-04
GC_7_79 ref NI_7 NS_79 0 6.0901349993318131e-03
GC_7_80 ref NI_7 NS_80 0 1.3451902963870977e-04
GC_7_81 ref NI_7 NS_81 0 2.6710352920729550e-06
GC_7_82 ref NI_7 NS_82 0 8.0236165128410729e-07
GC_7_83 ref NI_7 NS_83 0 -2.0933713206904149e-03
GC_7_84 ref NI_7 NS_84 0 1.5838191273449876e-03
GC_7_85 ref NI_7 NS_85 0 7.4654644621419096e-03
GC_7_86 ref NI_7 NS_86 0 -9.0183726892148952e-04
GC_7_87 ref NI_7 NS_87 0 1.1590351441381409e-05
GC_7_88 ref NI_7 NS_88 0 2.2314764675647527e-07
GC_7_89 ref NI_7 NS_89 0 -3.0893672079241709e-03
GC_7_90 ref NI_7 NS_90 0 -1.0410375750321815e-02
GC_7_91 ref NI_7 NS_91 0 3.4944281443793526e-03
GC_7_92 ref NI_7 NS_92 0 -1.6558922099608512e-03
GC_7_93 ref NI_7 NS_93 0 1.4465930531241848e-05
GC_7_94 ref NI_7 NS_94 0 -4.1397777368130298e-07
GC_7_95 ref NI_7 NS_95 0 1.0955796522028365e-02
GC_7_96 ref NI_7 NS_96 0 -9.7425446530568435e-03
GC_7_97 ref NI_7 NS_97 0 7.5174796445313464e-03
GC_7_98 ref NI_7 NS_98 0 -8.2184766072245386e-04
GC_7_99 ref NI_7 NS_99 0 2.4018978377426173e-05
GC_7_100 ref NI_7 NS_100 0 2.5134111706998753e-07
GC_7_101 ref NI_7 NS_101 0 -4.8347781262688665e-03
GC_7_102 ref NI_7 NS_102 0 -1.4545098872313924e-02
GC_7_103 ref NI_7 NS_103 0 6.0480453286272601e-03
GC_7_104 ref NI_7 NS_104 0 -2.5201306045609098e-03
GC_7_105 ref NI_7 NS_105 0 2.2565239679199537e-05
GC_7_106 ref NI_7 NS_106 0 1.2724321919794399e-06
GC_7_107 ref NI_7 NS_107 0 6.0641299567512023e-03
GC_7_108 ref NI_7 NS_108 0 -1.9304002305536704e-02
GC_7_109 ref NI_7 NS_109 0 -6.8612815723506681e-03
GC_7_110 ref NI_7 NS_110 0 -3.6481297176382621e-03
GC_7_111 ref NI_7 NS_111 0 1.6632629620078133e-05
GC_7_112 ref NI_7 NS_112 0 4.9725082219046065e-07
GC_7_113 ref NI_7 NS_113 0 4.2220164398640098e-02
GC_7_114 ref NI_7 NS_114 0 -2.9177036764370286e-02
GC_7_115 ref NI_7 NS_115 0 1.0507278951172959e-04
GC_7_116 ref NI_7 NS_116 0 2.9926360193730560e-03
GC_7_117 ref NI_7 NS_117 0 1.8546715060485956e-05
GC_7_118 ref NI_7 NS_118 0 1.0913770338134001e-06
GC_7_119 ref NI_7 NS_119 0 -1.7455701078090153e-03
GC_7_120 ref NI_7 NS_120 0 1.7967759882602395e-03
GC_7_121 ref NI_7 NS_121 0 1.3317101999582158e-03
GC_7_122 ref NI_7 NS_122 0 2.2064557295623857e-03
GC_7_123 ref NI_7 NS_123 0 1.9657223695199884e-05
GC_7_124 ref NI_7 NS_124 0 2.1416305391802933e-07
GC_7_125 ref NI_7 NS_125 0 -1.1975132563301393e-03
GC_7_126 ref NI_7 NS_126 0 -3.6356188820025546e-04
GC_7_127 ref NI_7 NS_127 0 5.1086543926157253e-03
GC_7_128 ref NI_7 NS_128 0 5.7462022534908192e-04
GC_7_129 ref NI_7 NS_129 0 -7.8354121872374757e-06
GC_7_130 ref NI_7 NS_130 0 4.2826255124722402e-07
GC_7_131 ref NI_7 NS_131 0 -1.2431508575356267e-03
GC_7_132 ref NI_7 NS_132 0 1.5654508815753836e-03
GD_7_1 ref NI_7 NA_1 0 6.4271003955899200e-03
GD_7_2 ref NI_7 NA_2 0 -1.8400762556759372e-02
GD_7_3 ref NI_7 NA_3 0 -1.9025631364984307e-03
GD_7_4 ref NI_7 NA_4 0 -3.0428857387176313e-03
GD_7_5 ref NI_7 NA_5 0 -2.6300967043683689e-03
GD_7_6 ref NI_7 NA_6 0 2.1108397305586541e-03
GD_7_7 ref NI_7 NA_7 0 6.2110503646074200e+00
GD_7_8 ref NI_7 NA_8 0 -1.7807476901251899e-03
GD_7_9 ref NI_7 NA_9 0 -3.7665470350313722e-03
GD_7_10 ref NI_7 NA_10 0 -1.8757479391029491e-03
GD_7_11 ref NI_7 NA_11 0 -8.4721306916238251e-04
GD_7_12 ref NI_7 NA_12 0 1.5517211659091194e-03
GD_7_13 ref NI_7 NA_13 0 1.8659994439460936e-04
GD_7_14 ref NI_7 NA_14 0 1.6114523622985965e-03
GD_7_15 ref NI_7 NA_15 0 3.3251551287073202e-03
GD_7_16 ref NI_7 NA_16 0 1.0103604290132835e-02
GD_7_17 ref NI_7 NA_17 0 2.7703101527972113e-03
GD_7_18 ref NI_7 NA_18 0 1.5084514913171665e-02
GD_7_19 ref NI_7 NA_19 0 3.2271365425159133e-02
GD_7_20 ref NI_7 NA_20 0 -8.4187186974183812e-04
GD_7_21 ref NI_7 NA_21 0 1.2541102086742887e-05
GD_7_22 ref NI_7 NA_22 0 -4.0605794618878413e-03
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 6.0606870154909908e-03
GC_8_2 ref NI_8 NS_2 0 -1.4249151428477049e-03
GC_8_3 ref NI_8 NS_3 0 -5.6940798185061628e-06
GC_8_4 ref NI_8 NS_4 0 5.8219381321090667e-07
GC_8_5 ref NI_8 NS_5 0 4.2653732089233051e-03
GC_8_6 ref NI_8 NS_6 0 -6.9142262420294849e-03
GC_8_7 ref NI_8 NS_7 0 2.5587473799056656e-03
GC_8_8 ref NI_8 NS_8 0 -5.8029240967262389e-04
GC_8_9 ref NI_8 NS_9 0 -1.3748729521793019e-06
GC_8_10 ref NI_8 NS_10 0 4.6039892288190606e-07
GC_8_11 ref NI_8 NS_11 0 1.1892731608014493e-02
GC_8_12 ref NI_8 NS_12 0 4.9686463319280720e-03
GC_8_13 ref NI_8 NS_13 0 -9.4033744765294452e-03
GC_8_14 ref NI_8 NS_14 0 -2.5988135584509081e-03
GC_8_15 ref NI_8 NS_15 0 -3.6618598429240299e-05
GC_8_16 ref NI_8 NS_16 0 -2.1022110346207526e-07
GC_8_17 ref NI_8 NS_17 0 4.9376070228291886e-02
GC_8_18 ref NI_8 NS_18 0 -1.1384835683919899e-02
GC_8_19 ref NI_8 NS_19 0 1.5116276853997833e-03
GC_8_20 ref NI_8 NS_20 0 1.3887120123371737e-03
GC_8_21 ref NI_8 NS_21 0 8.9309926595427002e-06
GC_8_22 ref NI_8 NS_22 0 3.5982447559606437e-07
GC_8_23 ref NI_8 NS_23 0 1.7539992084413623e-03
GC_8_24 ref NI_8 NS_24 0 -5.2847658456106721e-03
GC_8_25 ref NI_8 NS_25 0 -1.0939300248856843e-03
GC_8_26 ref NI_8 NS_26 0 3.1433009693369249e-03
GC_8_27 ref NI_8 NS_27 0 2.1935616226061646e-05
GC_8_28 ref NI_8 NS_28 0 6.3723221713526861e-07
GC_8_29 ref NI_8 NS_29 0 -1.1803965979550361e-04
GC_8_30 ref NI_8 NS_30 0 -1.8075185150171729e-03
GC_8_31 ref NI_8 NS_31 0 1.4138835591316293e-03
GC_8_32 ref NI_8 NS_32 0 2.2099796145307317e-04
GC_8_33 ref NI_8 NS_33 0 -2.1521030807064603e-07
GC_8_34 ref NI_8 NS_34 0 1.8521199949834363e-07
GC_8_35 ref NI_8 NS_35 0 6.5184501850433828e-03
GC_8_36 ref NI_8 NS_36 0 -1.2644706574747800e-02
GC_8_37 ref NI_8 NS_37 0 -6.3657427085613309e-03
GC_8_38 ref NI_8 NS_38 0 -1.2718073789015902e-03
GC_8_39 ref NI_8 NS_39 0 -2.2581788487583313e-05
GC_8_40 ref NI_8 NS_40 0 -9.2962603572645213e-08
GC_8_41 ref NI_8 NS_41 0 3.5724110380557311e-02
GC_8_42 ref NI_8 NS_42 0 -6.3898388492503290e-03
GC_8_43 ref NI_8 NS_43 0 -4.6740353805478786e-02
GC_8_44 ref NI_8 NS_44 0 -5.1999390748072214e-04
GC_8_45 ref NI_8 NS_45 0 -2.0226021773849618e-04
GC_8_46 ref NI_8 NS_46 0 -7.7926571547450641e-07
GC_8_47 ref NI_8 NS_47 0 -1.3728593282044388e-01
GC_8_48 ref NI_8 NS_48 0 1.2771172010305445e-01
GC_8_49 ref NI_8 NS_49 0 2.9075754634026638e-03
GC_8_50 ref NI_8 NS_50 0 1.4893659650243001e-03
GC_8_51 ref NI_8 NS_51 0 -1.0096450959765498e-07
GC_8_52 ref NI_8 NS_52 0 7.7487746045294500e-07
GC_8_53 ref NI_8 NS_53 0 -9.8703232281561809e-04
GC_8_54 ref NI_8 NS_54 0 -5.7819915562489453e-04
GC_8_55 ref NI_8 NS_55 0 1.0803598507283713e-02
GC_8_56 ref NI_8 NS_56 0 -2.0180142402422070e-03
GC_8_57 ref NI_8 NS_57 0 -1.6989428062066068e-05
GC_8_58 ref NI_8 NS_58 0 6.2055568536305707e-07
GC_8_59 ref NI_8 NS_59 0 -2.2769262377666018e-03
GC_8_60 ref NI_8 NS_60 0 3.0358583286387224e-03
GC_8_61 ref NI_8 NS_61 0 1.1774131881497120e-02
GC_8_62 ref NI_8 NS_62 0 -2.5250750949303083e-03
GC_8_63 ref NI_8 NS_63 0 -4.8824041417063566e-06
GC_8_64 ref NI_8 NS_64 0 4.4491684836916257e-07
GC_8_65 ref NI_8 NS_65 0 -5.4417919954277277e-03
GC_8_66 ref NI_8 NS_66 0 -1.0527916113440308e-02
GC_8_67 ref NI_8 NS_67 0 1.2648118335475257e-03
GC_8_68 ref NI_8 NS_68 0 2.2407532281960899e-03
GC_8_69 ref NI_8 NS_69 0 2.7758083659504719e-05
GC_8_70 ref NI_8 NS_70 0 1.2585217553932756e-07
GC_8_71 ref NI_8 NS_71 0 -1.3191904206541337e-03
GC_8_72 ref NI_8 NS_72 0 -9.1571533961296139e-05
GC_8_73 ref NI_8 NS_73 0 8.7214868562051620e-04
GC_8_74 ref NI_8 NS_74 0 2.6090859026159487e-03
GC_8_75 ref NI_8 NS_75 0 2.9689041576922440e-05
GC_8_76 ref NI_8 NS_76 0 7.9142294006115329e-07
GC_8_77 ref NI_8 NS_77 0 -2.3081083494308433e-03
GC_8_78 ref NI_8 NS_78 0 3.5192087087626653e-04
GC_8_79 ref NI_8 NS_79 0 9.5454086422532159e-03
GC_8_80 ref NI_8 NS_80 0 -3.7177750217322696e-03
GC_8_81 ref NI_8 NS_81 0 9.1918468190187164e-06
GC_8_82 ref NI_8 NS_82 0 1.2147455496568026e-06
GC_8_83 ref NI_8 NS_83 0 4.0869099727588428e-03
GC_8_84 ref NI_8 NS_84 0 -1.7181850437289585e-02
GC_8_85 ref NI_8 NS_85 0 -3.2905658081026105e-03
GC_8_86 ref NI_8 NS_86 0 -4.7666450586048448e-03
GC_8_87 ref NI_8 NS_87 0 2.1380009301311295e-06
GC_8_88 ref NI_8 NS_88 0 6.0523579858983848e-07
GC_8_89 ref NI_8 NS_89 0 4.0058840680183623e-02
GC_8_90 ref NI_8 NS_90 0 -2.5068119685712157e-02
GC_8_91 ref NI_8 NS_91 0 4.3529117304689285e-03
GC_8_92 ref NI_8 NS_92 0 7.2719634911191629e-04
GC_8_93 ref NI_8 NS_93 0 1.2801888108900015e-05
GC_8_94 ref NI_8 NS_94 0 7.1275673333730241e-09
GC_8_95 ref NI_8 NS_95 0 -1.3297020160516707e-03
GC_8_96 ref NI_8 NS_96 0 -1.1685551414998322e-03
GC_8_97 ref NI_8 NS_97 0 3.9664128566587759e-03
GC_8_98 ref NI_8 NS_98 0 1.5585519670626390e-03
GC_8_99 ref NI_8 NS_99 0 1.5779309244150790e-05
GC_8_100 ref NI_8 NS_100 0 8.0756786755847457e-07
GC_8_101 ref NI_8 NS_101 0 -4.0146402851568919e-03
GC_8_102 ref NI_8 NS_102 0 2.4511696674934698e-03
GC_8_103 ref NI_8 NS_103 0 5.3831402716118170e-03
GC_8_104 ref NI_8 NS_104 0 -2.2424235279425980e-03
GC_8_105 ref NI_8 NS_105 0 2.1784663738530188e-06
GC_8_106 ref NI_8 NS_106 0 -5.2037950614739486e-07
GC_8_107 ref NI_8 NS_107 0 1.0094448534187461e-02
GC_8_108 ref NI_8 NS_108 0 -6.9321962802417446e-03
GC_8_109 ref NI_8 NS_109 0 9.2295966801960658e-03
GC_8_110 ref NI_8 NS_110 0 -1.2370173379443817e-03
GC_8_111 ref NI_8 NS_111 0 1.1615471898271400e-05
GC_8_112 ref NI_8 NS_112 0 2.3743380650094094e-07
GC_8_113 ref NI_8 NS_113 0 -6.0638280617691803e-03
GC_8_114 ref NI_8 NS_114 0 -1.1464839528529872e-02
GC_8_115 ref NI_8 NS_115 0 -2.8520629769226351e-03
GC_8_116 ref NI_8 NS_116 0 3.8454050932873324e-03
GC_8_117 ref NI_8 NS_117 0 4.0943201456577180e-05
GC_8_118 ref NI_8 NS_118 0 1.0536844783583294e-06
GC_8_119 ref NI_8 NS_119 0 -1.9024215585421153e-04
GC_8_120 ref NI_8 NS_120 0 -2.8916304211840933e-03
GC_8_121 ref NI_8 NS_121 0 -1.2777462011677081e-03
GC_8_122 ref NI_8 NS_122 0 3.1518578512570285e-03
GC_8_123 ref NI_8 NS_123 0 3.6985975134974266e-05
GC_8_124 ref NI_8 NS_124 0 2.4496918895582159e-07
GC_8_125 ref NI_8 NS_125 0 -3.1790895451222213e-04
GC_8_126 ref NI_8 NS_126 0 -2.6027144179927553e-03
GC_8_127 ref NI_8 NS_127 0 1.8534426178763855e-03
GC_8_128 ref NI_8 NS_128 0 2.1167194067926824e-03
GC_8_129 ref NI_8 NS_129 0 1.0956176645594488e-06
GC_8_130 ref NI_8 NS_130 0 7.9555257848632014e-07
GC_8_131 ref NI_8 NS_131 0 -9.2978773547644836e-04
GC_8_132 ref NI_8 NS_132 0 2.1863215893059671e-03
GD_8_1 ref NI_8 NA_1 0 8.2669643761186552e-03
GD_8_2 ref NI_8 NA_2 0 -1.7741321162489273e-02
GD_8_3 ref NI_8 NA_3 0 -1.1455955794286118e-03
GD_8_4 ref NI_8 NA_4 0 -2.4275963069892558e-03
GD_8_5 ref NI_8 NA_5 0 -1.2889787042905583e-03
GD_8_6 ref NI_8 NA_6 0 -5.2649818204834897e-04
GD_8_7 ref NI_8 NA_7 0 -1.7807476901251899e-03
GD_8_8 ref NI_8 NA_8 0 6.2092601425281044e+00
GD_8_9 ref NI_8 NA_9 0 -3.2532273323506089e-03
GD_8_10 ref NI_8 NA_10 0 7.2811475942572820e-05
GD_8_11 ref NI_8 NA_11 0 2.5664594748227498e-03
GD_8_12 ref NI_8 NA_12 0 2.9248946998171251e-04
GD_8_13 ref NI_8 NA_13 0 -9.2706961359422627e-05
GD_8_14 ref NI_8 NA_14 0 1.4485941261031171e-02
GD_8_15 ref NI_8 NA_15 0 3.1682219116082766e-02
GD_8_16 ref NI_8 NA_16 0 9.4600934364111279e-04
GD_8_17 ref NI_8 NA_17 0 -2.7280583518103678e-04
GD_8_18 ref NI_8 NA_18 0 9.7739775925262014e-03
GD_8_19 ref NI_8 NA_19 0 1.7384495035672664e-03
GD_8_20 ref NI_8 NA_20 0 1.0184467218922516e-03
GD_8_21 ref NI_8 NA_21 0 8.4863923628421311e-04
GD_8_22 ref NI_8 NA_22 0 -3.3676867462542385e-03
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 7.1387005682201103e-03
GC_9_2 ref NI_9 NS_2 0 -3.2830819500347472e-03
GC_9_3 ref NI_9 NS_3 0 3.6450794979053532e-05
GC_9_4 ref NI_9 NS_4 0 4.1744771002083946e-06
GC_9_5 ref NI_9 NS_5 0 7.7054137468148248e-03
GC_9_6 ref NI_9 NS_6 0 -1.1620072850803019e-02
GC_9_7 ref NI_9 NS_7 0 3.0676125220255985e-03
GC_9_8 ref NI_9 NS_8 0 6.1656874985701660e-04
GC_9_9 ref NI_9 NS_9 0 -7.9249535270299215e-06
GC_9_10 ref NI_9 NS_10 0 1.0638101845624817e-06
GC_9_11 ref NI_9 NS_11 0 5.1792468874603355e-03
GC_9_12 ref NI_9 NS_12 0 7.4171273888280799e-03
GC_9_13 ref NI_9 NS_13 0 2.4681985753641352e-03
GC_9_14 ref NI_9 NS_14 0 1.7936344071869527e-03
GC_9_15 ref NI_9 NS_15 0 5.0072115087751308e-06
GC_9_16 ref NI_9 NS_16 0 9.5057351781166998e-07
GC_9_17 ref NI_9 NS_17 0 -1.5278515140229509e-03
GC_9_18 ref NI_9 NS_18 0 -3.7512202563274054e-04
GC_9_19 ref NI_9 NS_19 0 4.0298811850243864e-03
GC_9_20 ref NI_9 NS_20 0 -2.0512872809654798e-03
GC_9_21 ref NI_9 NS_21 0 -2.0886608923558121e-05
GC_9_22 ref NI_9 NS_22 0 -1.3881433991186355e-07
GC_9_23 ref NI_9 NS_23 0 1.2876820999626924e-02
GC_9_24 ref NI_9 NS_24 0 -9.1822020202866114e-03
GC_9_25 ref NI_9 NS_25 0 9.0760570117322040e-03
GC_9_26 ref NI_9 NS_26 0 -9.3486236533660402e-04
GC_9_27 ref NI_9 NS_27 0 -3.3930385932495572e-05
GC_9_28 ref NI_9 NS_28 0 8.6983118050457935e-08
GC_9_29 ref NI_9 NS_29 0 -1.8670885926799022e-03
GC_9_30 ref NI_9 NS_30 0 5.5691868910575978e-03
GC_9_31 ref NI_9 NS_31 0 4.0457954527757306e-03
GC_9_32 ref NI_9 NS_32 0 -1.6017536285208832e-03
GC_9_33 ref NI_9 NS_33 0 -1.8793682186965017e-05
GC_9_34 ref NI_9 NS_34 0 -2.3966792951627763e-07
GC_9_35 ref NI_9 NS_35 0 1.0293285836783092e-02
GC_9_36 ref NI_9 NS_36 0 -9.8809722248071087e-03
GC_9_37 ref NI_9 NS_37 0 3.6974566436458727e-03
GC_9_38 ref NI_9 NS_38 0 1.4884205043207171e-04
GC_9_39 ref NI_9 NS_39 0 -8.8846506143478938e-06
GC_9_40 ref NI_9 NS_40 0 2.8502567061466706e-07
GC_9_41 ref NI_9 NS_41 0 3.1067345095205584e-03
GC_9_42 ref NI_9 NS_42 0 -5.0270690203243545e-03
GC_9_43 ref NI_9 NS_43 0 2.9075754634026777e-03
GC_9_44 ref NI_9 NS_44 0 1.4893659650242958e-03
GC_9_45 ref NI_9 NS_45 0 -1.0096450959749394e-07
GC_9_46 ref NI_9 NS_46 0 7.7487746045293230e-07
GC_9_47 ref NI_9 NS_47 0 -9.8703232281562719e-04
GC_9_48 ref NI_9 NS_48 0 -5.7819915562485464e-04
GC_9_49 ref NI_9 NS_49 0 -6.1905643696189519e-02
GC_9_50 ref NI_9 NS_50 0 -8.6310976383375294e-03
GC_9_51 ref NI_9 NS_51 0 -1.3415715055843295e-04
GC_9_52 ref NI_9 NS_52 0 -6.5157123022449900e-06
GC_9_53 ref NI_9 NS_53 0 -6.3428756398374794e-02
GC_9_54 ref NI_9 NS_54 0 1.1223453937054682e-01
GC_9_55 ref NI_9 NS_55 0 -2.2396739942059682e-03
GC_9_56 ref NI_9 NS_56 0 3.7494292209341936e-03
GC_9_57 ref NI_9 NS_57 0 2.1798565206740728e-05
GC_9_58 ref NI_9 NS_58 0 9.5059944557203518e-07
GC_9_59 ref NI_9 NS_59 0 -2.1183946234449184e-04
GC_9_60 ref NI_9 NS_60 0 -1.2631858245478868e-03
GC_9_61 ref NI_9 NS_61 0 -2.6592220564157572e-03
GC_9_62 ref NI_9 NS_62 0 4.0421914674656717e-03
GC_9_63 ref NI_9 NS_63 0 2.8155729376192582e-05
GC_9_64 ref NI_9 NS_64 0 9.0930119211773907e-07
GC_9_65 ref NI_9 NS_65 0 -6.1938176631721532e-04
GC_9_66 ref NI_9 NS_66 0 -5.7209573415989445e-04
GC_9_67 ref NI_9 NS_67 0 4.5909313706272844e-03
GC_9_68 ref NI_9 NS_68 0 1.0901482678300825e-03
GC_9_69 ref NI_9 NS_69 0 -1.0929789642443918e-05
GC_9_70 ref NI_9 NS_70 0 1.4364219444365406e-06
GC_9_71 ref NI_9 NS_71 0 -2.2228585182684705e-03
GC_9_72 ref NI_9 NS_72 0 4.3791465647270659e-03
GC_9_73 ref NI_9 NS_73 0 6.3410032994505481e-03
GC_9_74 ref NI_9 NS_74 0 7.1764817295666351e-04
GC_9_75 ref NI_9 NS_75 0 -6.1958595219020260e-06
GC_9_76 ref NI_9 NS_76 0 6.4217645812412570e-07
GC_9_77 ref NI_9 NS_77 0 -4.7068103183258089e-03
GC_9_78 ref NI_9 NS_78 0 3.9700281589631894e-03
GC_9_79 ref NI_9 NS_79 0 -2.4062195610219969e-03
GC_9_80 ref NI_9 NS_80 0 3.7546266629637504e-03
GC_9_81 ref NI_9 NS_81 0 2.4709990424958762e-05
GC_9_82 ref NI_9 NS_82 0 1.3714615922171584e-06
GC_9_83 ref NI_9 NS_83 0 -9.9732299734239680e-05
GC_9_84 ref NI_9 NS_84 0 -1.5655790356699955e-03
GC_9_85 ref NI_9 NS_85 0 -1.9241188677108494e-03
GC_9_86 ref NI_9 NS_86 0 3.8203669230355551e-03
GC_9_87 ref NI_9 NS_87 0 2.3613533840161325e-05
GC_9_88 ref NI_9 NS_88 0 8.0884457445278909e-07
GC_9_89 ref NI_9 NS_89 0 -9.9916887815668619e-04
GC_9_90 ref NI_9 NS_90 0 5.1235160268154787e-04
GC_9_91 ref NI_9 NS_91 0 2.2762730662050350e-03
GC_9_92 ref NI_9 NS_92 0 2.0642057628260909e-03
GC_9_93 ref NI_9 NS_93 0 1.1480933968059875e-06
GC_9_94 ref NI_9 NS_94 0 1.0012226583564080e-06
GC_9_95 ref NI_9 NS_95 0 -1.7237099391693288e-03
GC_9_96 ref NI_9 NS_96 0 3.1863148305033328e-03
GC_9_97 ref NI_9 NS_97 0 4.2800948867379209e-03
GC_9_98 ref NI_9 NS_98 0 1.5610835719778598e-03
GC_9_99 ref NI_9 NS_99 0 2.6179564005049875e-06
GC_9_100 ref NI_9 NS_100 0 6.8316387328104744e-07
GC_9_101 ref NI_9 NS_101 0 -4.0299476860755530e-03
GC_9_102 ref NI_9 NS_102 0 3.8514908051292605e-03
GC_9_103 ref NI_9 NS_103 0 -4.2436981545867608e-04
GC_9_104 ref NI_9 NS_104 0 3.0303764448367451e-03
GC_9_105 ref NI_9 NS_105 0 2.2297712405111570e-05
GC_9_106 ref NI_9 NS_106 0 1.3526482802077761e-06
GC_9_107 ref NI_9 NS_107 0 -8.9578972346872137e-04
GC_9_108 ref NI_9 NS_108 0 7.7596060628192659e-04
GC_9_109 ref NI_9 NS_109 0 8.3832235247479519e-04
GC_9_110 ref NI_9 NS_110 0 2.8538751669830872e-03
GC_9_111 ref NI_9 NS_111 0 1.3258323856976737e-05
GC_9_112 ref NI_9 NS_112 0 7.0009434300666382e-07
GC_9_113 ref NI_9 NS_113 0 -2.3931711332800644e-03
GC_9_114 ref NI_9 NS_114 0 2.5350391786103585e-03
GC_9_115 ref NI_9 NS_115 0 6.6308212714020365e-03
GC_9_116 ref NI_9 NS_116 0 8.7331484596729332e-04
GC_9_117 ref NI_9 NS_117 0 -2.8802206674479451e-05
GC_9_118 ref NI_9 NS_118 0 4.6679551366566631e-07
GC_9_119 ref NI_9 NS_119 0 -3.9195335145851256e-03
GC_9_120 ref NI_9 NS_120 0 1.1385783752702197e-02
GC_9_121 ref NI_9 NS_121 0 5.1432013512986005e-03
GC_9_122 ref NI_9 NS_122 0 1.1290962293163363e-03
GC_9_123 ref NI_9 NS_123 0 -2.3384505329943700e-05
GC_9_124 ref NI_9 NS_124 0 1.2003840720837642e-06
GC_9_125 ref NI_9 NS_125 0 -2.8489232906105744e-03
GC_9_126 ref NI_9 NS_126 0 6.6272837445222697e-03
GC_9_127 ref NI_9 NS_127 0 8.4443894471368363e-03
GC_9_128 ref NI_9 NS_128 0 -1.6832191074544763e-02
GC_9_129 ref NI_9 NS_129 0 4.7705172671581946e-05
GC_9_130 ref NI_9 NS_130 0 -3.7407742115430455e-06
GC_9_131 ref NI_9 NS_131 0 5.4750256582989605e-02
GC_9_132 ref NI_9 NS_132 0 -9.7770796292063519e-02
GD_9_1 ref NI_9 NA_1 0 2.3163125839090526e-02
GD_9_2 ref NI_9 NA_2 0 -1.2693650314158545e-02
GD_9_3 ref NI_9 NA_3 0 -3.2224229781183315e-03
GD_9_4 ref NI_9 NA_4 0 -3.7884595005840968e-03
GD_9_5 ref NI_9 NA_5 0 -6.2480887461461090e-03
GD_9_6 ref NI_9 NA_6 0 -2.3880549033531372e-03
GD_9_7 ref NI_9 NA_7 0 -3.7665470350313722e-03
GD_9_8 ref NI_9 NA_8 0 -3.2532273323506089e-03
GD_9_9 ref NI_9 NA_9 0 6.2343400078094824e+00
GD_9_10 ref NI_9 NA_10 0 -1.3951521954167967e-04
GD_9_11 ref NI_9 NA_11 0 3.5212834402387520e-04
GD_9_12 ref NI_9 NA_12 0 3.1679358057147512e-04
GD_9_13 ref NI_9 NA_13 0 -1.2382884203712659e-03
GD_9_14 ref NI_9 NA_14 0 7.1570483308497530e-04
GD_9_15 ref NI_9 NA_15 0 3.6445121355464171e-05
GD_9_16 ref NI_9 NA_16 0 -6.9080449535755594e-05
GD_9_17 ref NI_9 NA_17 0 -8.0925677972763571e-04
GD_9_18 ref NI_9 NA_18 0 1.5434314589660942e-04
GD_9_19 ref NI_9 NA_19 0 -5.8202904854894575e-04
GD_9_20 ref NI_9 NA_20 0 -3.6467899045623310e-03
GD_9_21 ref NI_9 NA_21 0 -1.4932655180511384e-03
GD_9_22 ref NI_9 NA_22 0 2.3528104723446724e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 1.6769969806799667e-03
GC_10_2 ref NI_10 NS_2 0 2.1592555672450505e-03
GC_10_3 ref NI_10 NS_3 0 2.2353941749151621e-05
GC_10_4 ref NI_10 NS_4 0 1.3869666332741562e-06
GC_10_5 ref NI_10 NS_5 0 -1.3123271969332105e-03
GC_10_6 ref NI_10 NS_6 0 2.9590942269845013e-03
GC_10_7 ref NI_10 NS_7 0 1.4569841213744245e-03
GC_10_8 ref NI_10 NS_8 0 -8.4378043552439208e-04
GC_10_9 ref NI_10 NS_9 0 4.9390088840664896e-06
GC_10_10 ref NI_10 NS_10 0 2.9128277018851797e-07
GC_10_11 ref NI_10 NS_11 0 1.8624536296370332e-02
GC_10_12 ref NI_10 NS_12 0 1.9224747723532928e-02
GC_10_13 ref NI_10 NS_13 0 1.1620360638471074e-02
GC_10_14 ref NI_10 NS_14 0 -5.7139403491795540e-03
GC_10_15 ref NI_10 NS_15 0 -1.7498909385323705e-05
GC_10_16 ref NI_10 NS_16 0 9.1358130004940887e-07
GC_10_17 ref NI_10 NS_17 0 8.6907362278931706e-03
GC_10_18 ref NI_10 NS_18 0 -2.2194970391801960e-02
GC_10_19 ref NI_10 NS_19 0 -4.7588526686928606e-04
GC_10_20 ref NI_10 NS_20 0 2.8300202234309508e-03
GC_10_21 ref NI_10 NS_21 0 2.6478260144168437e-05
GC_10_22 ref NI_10 NS_22 0 5.7885469007277510e-07
GC_10_23 ref NI_10 NS_23 0 -4.0907583323538776e-04
GC_10_24 ref NI_10 NS_24 0 -2.1163125169243110e-03
GC_10_25 ref NI_10 NS_25 0 -3.5941416781930810e-03
GC_10_26 ref NI_10 NS_26 0 3.8682573718205764e-03
GC_10_27 ref NI_10 NS_27 0 5.0876740988516008e-05
GC_10_28 ref NI_10 NS_28 0 5.2627324400738028e-07
GC_10_29 ref NI_10 NS_29 0 7.4930733398887611e-04
GC_10_30 ref NI_10 NS_30 0 -6.0846936292499269e-03
GC_10_31 ref NI_10 NS_31 0 1.6661515285945833e-03
GC_10_32 ref NI_10 NS_32 0 2.1947242297224992e-03
GC_10_33 ref NI_10 NS_33 0 1.1523972057115793e-05
GC_10_34 ref NI_10 NS_34 0 6.1002164967385204e-07
GC_10_35 ref NI_10 NS_35 0 -1.4547166267403031e-03
GC_10_36 ref NI_10 NS_36 0 1.4241650182204122e-03
GC_10_37 ref NI_10 NS_37 0 5.6869374794981196e-03
GC_10_38 ref NI_10 NS_38 0 5.8929933407887974e-04
GC_10_39 ref NI_10 NS_39 0 -5.4835300247133336e-06
GC_10_40 ref NI_10 NS_40 0 6.2388979361503380e-07
GC_10_41 ref NI_10 NS_41 0 -2.4577966588063748e-03
GC_10_42 ref NI_10 NS_42 0 4.2909119481020132e-03
GC_10_43 ref NI_10 NS_43 0 1.0803598507283713e-02
GC_10_44 ref NI_10 NS_44 0 -2.0180142402422031e-03
GC_10_45 ref NI_10 NS_45 0 -1.6989428062067834e-05
GC_10_46 ref NI_10 NS_46 0 6.2055568536332092e-07
GC_10_47 ref NI_10 NS_47 0 -2.2769262377666018e-03
GC_10_48 ref NI_10 NS_48 0 3.0358583286387410e-03
GC_10_49 ref NI_10 NS_49 0 -2.2396739942059994e-03
GC_10_50 ref NI_10 NS_50 0 3.7494292209342044e-03
GC_10_51 ref NI_10 NS_51 0 2.1798565206738902e-05
GC_10_52 ref NI_10 NS_52 0 9.5059944557224302e-07
GC_10_53 ref NI_10 NS_53 0 -2.1183946234447414e-04
GC_10_54 ref NI_10 NS_54 0 -1.2631858245479766e-03
GC_10_55 ref NI_10 NS_55 0 -5.6057299222121874e-02
GC_10_56 ref NI_10 NS_56 0 -1.7546234758859018e-02
GC_10_57 ref NI_10 NS_57 0 -3.5021105854790075e-04
GC_10_58 ref NI_10 NS_58 0 -1.1298558823083091e-05
GC_10_59 ref NI_10 NS_59 0 -3.5953834178245880e-02
GC_10_60 ref NI_10 NS_60 0 5.8414687172391525e-02
GC_10_61 ref NI_10 NS_61 0 1.2618199062146677e-02
GC_10_62 ref NI_10 NS_62 0 -1.1529710339096373e-02
GC_10_63 ref NI_10 NS_63 0 -4.3832363505799493e-05
GC_10_64 ref NI_10 NS_64 0 6.7588780218074236e-06
GC_10_65 ref NI_10 NS_65 0 3.0396978292241035e-02
GC_10_66 ref NI_10 NS_66 0 -4.2598130382798208e-02
GC_10_67 ref NI_10 NS_67 0 -1.6822817785236575e-03
GC_10_68 ref NI_10 NS_68 0 3.1586904104158641e-03
GC_10_69 ref NI_10 NS_69 0 4.6795874993344586e-05
GC_10_70 ref NI_10 NS_70 0 1.8835744896475836e-07
GC_10_71 ref NI_10 NS_71 0 -4.9342522964084319e-05
GC_10_72 ref NI_10 NS_72 0 -4.3386087975540912e-03
GC_10_73 ref NI_10 NS_73 0 -2.2512843463231551e-03
GC_10_74 ref NI_10 NS_74 0 3.3341580368083626e-03
GC_10_75 ref NI_10 NS_75 0 4.8634134456889249e-05
GC_10_76 ref NI_10 NS_76 0 1.0159061158297492e-06
GC_10_77 ref NI_10 NS_77 0 -8.2536149000293004e-05
GC_10_78 ref NI_10 NS_78 0 -5.7284085099275689e-03
GC_10_79 ref NI_10 NS_79 0 1.3777844094694885e-02
GC_10_80 ref NI_10 NS_80 0 -2.7678667542503149e-03
GC_10_81 ref NI_10 NS_81 0 -3.2382364740300641e-05
GC_10_82 ref NI_10 NS_82 0 3.0040481319910203e-08
GC_10_83 ref NI_10 NS_83 0 -4.0872948689162523e-03
GC_10_84 ref NI_10 NS_84 0 9.4891213179962037e-03
GC_10_85 ref NI_10 NS_85 0 1.0968434146065362e-02
GC_10_86 ref NI_10 NS_86 0 -1.1683177304499389e-03
GC_10_87 ref NI_10 NS_87 0 -2.7689527216944135e-05
GC_10_88 ref NI_10 NS_88 0 2.4497759264305213e-07
GC_10_89 ref NI_10 NS_89 0 -4.9183911574267464e-03
GC_10_90 ref NI_10 NS_90 0 1.0971546050459441e-02
GC_10_91 ref NI_10 NS_91 0 8.6109686358248091e-04
GC_10_92 ref NI_10 NS_92 0 2.3955593123017342e-03
GC_10_93 ref NI_10 NS_93 0 1.7344678847471781e-05
GC_10_94 ref NI_10 NS_94 0 5.3679932008872369e-07
GC_10_95 ref NI_10 NS_95 0 -1.0163355432650767e-03
GC_10_96 ref NI_10 NS_96 0 -2.1121680066492113e-04
GC_10_97 ref NI_10 NS_97 0 -5.6994721719926488e-04
GC_10_98 ref NI_10 NS_98 0 2.9422292391482834e-03
GC_10_99 ref NI_10 NS_99 0 2.7434361800388303e-05
GC_10_100 ref NI_10 NS_100 0 8.3843873526191730e-07
GC_10_101 ref NI_10 NS_101 0 -9.2191917429261451e-04
GC_10_102 ref NI_10 NS_102 0 -2.0505432711496255e-03
GC_10_103 ref NI_10 NS_103 0 5.3320995357135498e-03
GC_10_104 ref NI_10 NS_104 0 8.0449944568470070e-04
GC_10_105 ref NI_10 NS_105 0 -2.0077758622596478e-05
GC_10_106 ref NI_10 NS_106 0 1.3088719829145970e-06
GC_10_107 ref NI_10 NS_107 0 -2.3659949774508765e-03
GC_10_108 ref NI_10 NS_108 0 4.9591981500600553e-03
GC_10_109 ref NI_10 NS_109 0 3.5807624398570452e-03
GC_10_110 ref NI_10 NS_110 0 1.6031590862320847e-03
GC_10_111 ref NI_10 NS_111 0 4.8204792366217541e-07
GC_10_112 ref NI_10 NS_112 0 4.2923809197325812e-07
GC_10_113 ref NI_10 NS_113 0 -2.5665062095633446e-03
GC_10_114 ref NI_10 NS_114 0 3.7453102212390570e-03
GC_10_115 ref NI_10 NS_115 0 -4.9571432014288595e-03
GC_10_116 ref NI_10 NS_116 0 4.1818534081746548e-03
GC_10_117 ref NI_10 NS_117 0 7.1334373810140345e-05
GC_10_118 ref NI_10 NS_118 0 9.3067194632017202e-07
GC_10_119 ref NI_10 NS_119 0 1.2081390860224452e-03
GC_10_120 ref NI_10 NS_120 0 -8.9329864320335725e-03
GC_10_121 ref NI_10 NS_121 0 -3.3896645807184353e-03
GC_10_122 ref NI_10 NS_122 0 3.6292423834180117e-03
GC_10_123 ref NI_10 NS_123 0 6.2400598077823823e-05
GC_10_124 ref NI_10 NS_124 0 1.7881379981601454e-07
GC_10_125 ref NI_10 NS_125 0 7.5669314010242523e-04
GC_10_126 ref NI_10 NS_126 0 -7.5522122665502983e-03
GC_10_127 ref NI_10 NS_127 0 -3.1727358421062275e-03
GC_10_128 ref NI_10 NS_128 0 3.8893652241928220e-03
GC_10_129 ref NI_10 NS_129 0 2.9312736778611150e-05
GC_10_130 ref NI_10 NS_130 0 7.8959276372282788e-07
GC_10_131 ref NI_10 NS_131 0 6.8716669070664912e-04
GC_10_132 ref NI_10 NS_132 0 -3.8577397395255656e-03
GD_10_1 ref NI_10 NA_1 0 3.6126636270241820e-03
GD_10_2 ref NI_10 NA_2 0 -6.7116580290697498e-03
GD_10_3 ref NI_10 NA_3 0 7.0259814347434510e-03
GD_10_4 ref NI_10 NA_4 0 -3.3004880437579356e-04
GD_10_5 ref NI_10 NA_5 0 1.9477779561398263e-03
GD_10_6 ref NI_10 NA_6 0 -9.2485093849568672e-04
GD_10_7 ref NI_10 NA_7 0 -1.8757479391029491e-03
GD_10_8 ref NI_10 NA_8 0 7.2811475942572820e-05
GD_10_9 ref NI_10 NA_9 0 -1.3951521954167967e-04
GD_10_10 ref NI_10 NA_10 0 6.1747588314156001e+00
GD_10_11 ref NI_10 NA_11 0 6.0797365054475853e-02
GD_10_12 ref NI_10 NA_12 0 2.4419499042921929e-03
GD_10_13 ref NI_10 NA_13 0 2.6791918943266779e-03
GD_10_14 ref NI_10 NA_14 0 1.6378291359916150e-03
GD_10_15 ref NI_10 NA_15 0 -7.0826244958463122e-04
GD_10_16 ref NI_10 NA_16 0 1.0739414780642719e-03
GD_10_17 ref NI_10 NA_17 0 1.6630928223035745e-03
GD_10_18 ref NI_10 NA_18 0 2.8859629413047227e-04
GD_10_19 ref NI_10 NA_19 0 -4.7673554165490896e-05
GD_10_20 ref NI_10 NA_20 0 4.2145234315141417e-03
GD_10_21 ref NI_10 NA_21 0 3.5489389162013498e-03
GD_10_22 ref NI_10 NA_22 0 7.5714288132040298e-04
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 1.9883738829412365e-03
GC_11_2 ref NI_11 NS_2 0 2.4020118935438460e-03
GC_11_3 ref NI_11 NS_3 0 3.3441169249514184e-05
GC_11_4 ref NI_11 NS_4 0 1.3566444340363071e-06
GC_11_5 ref NI_11 NS_5 0 -3.4837904756855509e-03
GC_11_6 ref NI_11 NS_6 0 3.2734234379769751e-03
GC_11_7 ref NI_11 NS_7 0 1.1622630795088220e-03
GC_11_8 ref NI_11 NS_8 0 -7.2271213448559771e-04
GC_11_9 ref NI_11 NS_9 0 3.6873315350087744e-06
GC_11_10 ref NI_11 NS_10 0 2.7198768743903927e-07
GC_11_11 ref NI_11 NS_11 0 1.8636775681336260e-02
GC_11_12 ref NI_11 NS_12 0 1.8549138556487477e-02
GC_11_13 ref NI_11 NS_13 0 8.1152517323459584e-04
GC_11_14 ref NI_11 NS_14 0 -5.8808494652857228e-03
GC_11_15 ref NI_11 NS_15 0 -1.7842671047953915e-05
GC_11_16 ref NI_11 NS_16 0 1.8565855432243607e-07
GC_11_17 ref NI_11 NS_17 0 3.5460990841546108e-02
GC_11_18 ref NI_11 NS_18 0 -2.7723902400446046e-02
GC_11_19 ref NI_11 NS_19 0 -4.8515301835982033e-04
GC_11_20 ref NI_11 NS_20 0 2.9775867508124183e-03
GC_11_21 ref NI_11 NS_21 0 3.2170544930267175e-05
GC_11_22 ref NI_11 NS_22 0 5.5661019460869156e-07
GC_11_23 ref NI_11 NS_23 0 -1.3006338619716668e-03
GC_11_24 ref NI_11 NS_24 0 -2.2723184324149690e-03
GC_11_25 ref NI_11 NS_25 0 -3.9189037482111125e-03
GC_11_26 ref NI_11 NS_26 0 4.0354096103936551e-03
GC_11_27 ref NI_11 NS_27 0 5.8386655517605779e-05
GC_11_28 ref NI_11 NS_28 0 5.1252077131713658e-07
GC_11_29 ref NI_11 NS_29 0 4.6486762662558740e-04
GC_11_30 ref NI_11 NS_30 0 -6.4458527537628492e-03
GC_11_31 ref NI_11 NS_31 0 1.9681728443985413e-03
GC_11_32 ref NI_11 NS_32 0 2.2783964529700784e-03
GC_11_33 ref NI_11 NS_33 0 1.7298751197399057e-05
GC_11_34 ref NI_11 NS_34 0 5.6693588383566499e-07
GC_11_35 ref NI_11 NS_35 0 -2.7416602893904057e-03
GC_11_36 ref NI_11 NS_36 0 1.5731941906229738e-03
GC_11_37 ref NI_11 NS_37 0 6.6961043607651404e-03
GC_11_38 ref NI_11 NS_38 0 4.5318823689134485e-04
GC_11_39 ref NI_11 NS_39 0 2.2300443804719162e-06
GC_11_40 ref NI_11 NS_40 0 5.3831860212784377e-07
GC_11_41 ref NI_11 NS_41 0 -4.8935259213064870e-03
GC_11_42 ref NI_11 NS_42 0 2.5541283794735152e-03
GC_11_43 ref NI_11 NS_43 0 1.1774131881497157e-02
GC_11_44 ref NI_11 NS_44 0 -2.5250750949303252e-03
GC_11_45 ref NI_11 NS_45 0 -4.8824041417030506e-06
GC_11_46 ref NI_11 NS_46 0 4.4491684836889221e-07
GC_11_47 ref NI_11 NS_47 0 -5.4417919954277486e-03
GC_11_48 ref NI_11 NS_48 0 -1.0527916113440223e-02
GC_11_49 ref NI_11 NS_49 0 -2.6592220564157043e-03
GC_11_50 ref NI_11 NS_50 0 4.0421914674656475e-03
GC_11_51 ref NI_11 NS_51 0 2.8155729376196647e-05
GC_11_52 ref NI_11 NS_52 0 9.0930119211741497e-07
GC_11_53 ref NI_11 NS_53 0 -6.1938176631724318e-04
GC_11_54 ref NI_11 NS_54 0 -5.7209573415978234e-04
GC_11_55 ref NI_11 NS_55 0 1.2618199062146729e-02
GC_11_56 ref NI_11 NS_56 0 -1.1529710339096397e-02
GC_11_57 ref NI_11 NS_57 0 -4.3832363505794092e-05
GC_11_58 ref NI_11 NS_58 0 6.7588780218066663e-06
GC_11_59 ref NI_11 NS_59 0 3.0396978292241007e-02
GC_11_60 ref NI_11 NS_60 0 -4.2598130382798104e-02
GC_11_61 ref NI_11 NS_61 0 -4.7332337770137130e-02
GC_11_62 ref NI_11 NS_62 0 -1.6363700377934703e-02
GC_11_63 ref NI_11 NS_63 0 -4.5245293112765095e-04
GC_11_64 ref NI_11 NS_64 0 -8.3609086621109691e-06
GC_11_65 ref NI_11 NS_65 0 -5.7334129443317602e-02
GC_11_66 ref NI_11 NS_66 0 8.0255513250954327e-02
GC_11_67 ref NI_11 NS_67 0 -1.9316649413668450e-03
GC_11_68 ref NI_11 NS_68 0 3.2818173794400456e-03
GC_11_69 ref NI_11 NS_69 0 5.3682882456040497e-05
GC_11_70 ref NI_11 NS_70 0 -8.5804065040063205e-08
GC_11_71 ref NI_11 NS_71 0 -1.9527177922892475e-04
GC_11_72 ref NI_11 NS_72 0 -4.5935994866493895e-03
GC_11_73 ref NI_11 NS_73 0 -2.7131073155771913e-03
GC_11_74 ref NI_11 NS_74 0 3.4741663260218236e-03
GC_11_75 ref NI_11 NS_75 0 5.2404778108065273e-05
GC_11_76 ref NI_11 NS_76 0 1.0057802106855224e-06
GC_11_77 ref NI_11 NS_77 0 2.0818311069216241e-04
GC_11_78 ref NI_11 NS_78 0 -6.0879144010462915e-03
GC_11_79 ref NI_11 NS_79 0 1.4203027123727927e-02
GC_11_80 ref NI_11 NS_80 0 -4.0249532721823812e-03
GC_11_81 ref NI_11 NS_81 0 -3.5723053016738565e-05
GC_11_82 ref NI_11 NS_82 0 2.9690907385565564e-07
GC_11_83 ref NI_11 NS_83 0 -2.9297524660303021e-04
GC_11_84 ref NI_11 NS_84 0 1.6765519569181496e-03
GC_11_85 ref NI_11 NS_85 0 1.1794760898401696e-02
GC_11_86 ref NI_11 NS_86 0 -1.8175906548376784e-03
GC_11_87 ref NI_11 NS_87 0 -3.6041417009326568e-05
GC_11_88 ref NI_11 NS_88 0 4.4808574380776196e-07
GC_11_89 ref NI_11 NS_89 0 -3.6436080201866553e-03
GC_11_90 ref NI_11 NS_90 0 1.1112099947532490e-02
GC_11_91 ref NI_11 NS_91 0 8.7957548315787607e-04
GC_11_92 ref NI_11 NS_92 0 2.4500886860167816e-03
GC_11_93 ref NI_11 NS_93 0 2.5669247904602409e-05
GC_11_94 ref NI_11 NS_94 0 -4.8906729074731783e-08
GC_11_95 ref NI_11 NS_95 0 -1.3473023856840015e-03
GC_11_96 ref NI_11 NS_96 0 1.2440281782604662e-05
GC_11_97 ref NI_11 NS_97 0 -9.3642183348904286e-04
GC_11_98 ref NI_11 NS_98 0 3.0482336041802059e-03
GC_11_99 ref NI_11 NS_99 0 2.9817211044069122e-05
GC_11_100 ref NI_11 NS_100 0 7.4784936893706980e-07
GC_11_101 ref NI_11 NS_101 0 -5.8163899878682429e-04
GC_11_102 ref NI_11 NS_102 0 -2.1056629663618299e-03
GC_11_103 ref NI_11 NS_103 0 5.9288256354305272e-03
GC_11_104 ref NI_11 NS_104 0 6.0528682387134009e-04
GC_11_105 ref NI_11 NS_105 0 -6.1938096019186346e-06
GC_11_106 ref NI_11 NS_106 0 4.1267136732193860e-08
GC_11_107 ref NI_11 NS_107 0 -2.8068311314042214e-03
GC_11_108 ref NI_11 NS_108 0 5.4324814377291310e-03
GC_11_109 ref NI_11 NS_109 0 3.4919457545587273e-03
GC_11_110 ref NI_11 NS_110 0 1.5662526275865435e-03
GC_11_111 ref NI_11 NS_111 0 -1.2959213847245101e-06
GC_11_112 ref NI_11 NS_112 0 4.0196807436042649e-07
GC_11_113 ref NI_11 NS_113 0 -1.9733098990335285e-03
GC_11_114 ref NI_11 NS_114 0 4.4228668902307599e-03
GC_11_115 ref NI_11 NS_115 0 -5.3631129032317921e-03
GC_11_116 ref NI_11 NS_116 0 4.2743490783467590e-03
GC_11_117 ref NI_11 NS_117 0 8.1179670734444172e-05
GC_11_118 ref NI_11 NS_118 0 1.0512874714858687e-06
GC_11_119 ref NI_11 NS_119 0 1.3943722347370231e-03
GC_11_120 ref NI_11 NS_120 0 -9.3711394475067128e-03
GC_11_121 ref NI_11 NS_121 0 -3.7066751027390690e-03
GC_11_122 ref NI_11 NS_122 0 3.7608156773081148e-03
GC_11_123 ref NI_11 NS_123 0 7.0116704876725542e-05
GC_11_124 ref NI_11 NS_124 0 -2.6185833594645060e-09
GC_11_125 ref NI_11 NS_125 0 6.4911811289837822e-04
GC_11_126 ref NI_11 NS_126 0 -8.0126855677260904e-03
GC_11_127 ref NI_11 NS_127 0 -3.7019006863888682e-03
GC_11_128 ref NI_11 NS_128 0 4.1915463893475750e-03
GC_11_129 ref NI_11 NS_129 0 3.5734363845095207e-05
GC_11_130 ref NI_11 NS_130 0 7.6136955402392849e-07
GC_11_131 ref NI_11 NS_131 0 2.9834605839892150e-04
GC_11_132 ref NI_11 NS_132 0 -4.1170267658044105e-03
GD_11_1 ref NI_11 NA_1 0 2.1866791917838514e-03
GD_11_2 ref NI_11 NA_2 0 -5.8026119293826100e-03
GD_11_3 ref NI_11 NA_3 0 2.5163701141596183e-02
GD_11_4 ref NI_11 NA_4 0 2.3204129030252090e-04
GD_11_5 ref NI_11 NA_5 0 2.4429318510253276e-03
GD_11_6 ref NI_11 NA_6 0 -4.7910857096038293e-04
GD_11_7 ref NI_11 NA_7 0 -8.4721306916238251e-04
GD_11_8 ref NI_11 NA_8 0 2.5664594748227498e-03
GD_11_9 ref NI_11 NA_9 0 3.5212834402387520e-04
GD_11_10 ref NI_11 NA_10 0 6.0797365054475853e-02
GD_11_11 ref NI_11 NA_11 0 6.1535814023669113e+00
GD_11_12 ref NI_11 NA_12 0 2.6865169723447719e-03
GD_11_13 ref NI_11 NA_13 0 3.1111241966282691e-03
GD_11_14 ref NI_11 NA_14 0 5.5711392735048691e-03
GD_11_15 ref NI_11 NA_15 0 1.9035097678073833e-03
GD_11_16 ref NI_11 NA_16 0 1.1632653239129977e-03
GD_11_17 ref NI_11 NA_17 0 2.0697851376548452e-03
GD_11_18 ref NI_11 NA_18 0 5.0102097970273162e-04
GD_11_19 ref NI_11 NA_19 0 5.5537184488417004e-04
GD_11_20 ref NI_11 NA_20 0 4.5878266961644730e-03
GD_11_21 ref NI_11 NA_21 0 3.8655096774734546e-03
GD_11_22 ref NI_11 NA_22 0 1.2745820506245890e-03
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -4.5762104242349855e-03
GC_12_2 ref NI_12 NS_2 0 3.9971354514136415e-03
GC_12_3 ref NI_12 NS_3 0 1.0327928167483887e-04
GC_12_4 ref NI_12 NS_4 0 1.8418348092123779e-06
GC_12_5 ref NI_12 NS_5 0 1.0441768312895781e-03
GC_12_6 ref NI_12 NS_6 0 -6.3259339044908986e-03
GC_12_7 ref NI_12 NS_7 0 1.5020810516109156e-03
GC_12_8 ref NI_12 NS_8 0 -4.5857671834569969e-04
GC_12_9 ref NI_12 NS_9 0 8.6011171198971558e-06
GC_12_10 ref NI_12 NS_10 0 9.0660199497088736e-08
GC_12_11 ref NI_12 NS_11 0 1.6290967069313277e-02
GC_12_12 ref NI_12 NS_12 0 1.8064357205721068e-02
GC_12_13 ref NI_12 NS_13 0 2.5250654953573251e-04
GC_12_14 ref NI_12 NS_14 0 2.5422869758415707e-03
GC_12_15 ref NI_12 NS_15 0 3.4261075805460714e-05
GC_12_16 ref NI_12 NS_16 0 2.4226518492058814e-07
GC_12_17 ref NI_12 NS_17 0 -7.5982301338279668e-04
GC_12_18 ref NI_12 NS_18 0 -1.3437208325981431e-03
GC_12_19 ref NI_12 NS_19 0 6.0716243683492360e-03
GC_12_20 ref NI_12 NS_20 0 -3.0170785786880943e-03
GC_12_21 ref NI_12 NS_21 0 1.3216920478368750e-05
GC_12_22 ref NI_12 NS_22 0 1.2534591599045337e-06
GC_12_23 ref NI_12 NS_23 0 8.2870497814774569e-03
GC_12_24 ref NI_12 NS_24 0 -2.1268559506079449e-02
GC_12_25 ref NI_12 NS_25 0 6.7580140920713502e-03
GC_12_26 ref NI_12 NS_26 0 4.1959797475857297e-04
GC_12_27 ref NI_12 NS_27 0 -1.9659260636016773e-05
GC_12_28 ref NI_12 NS_28 0 1.2077051550927398e-06
GC_12_29 ref NI_12 NS_29 0 -3.4795506327116232e-03
GC_12_30 ref NI_12 NS_30 0 6.9657176803697785e-03
GC_12_31 ref NI_12 NS_31 0 4.2642974931151583e-03
GC_12_32 ref NI_12 NS_32 0 -1.9517310618468902e-03
GC_12_33 ref NI_12 NS_33 0 1.1268629555078807e-05
GC_12_34 ref NI_12 NS_34 0 -3.9047925420102583e-07
GC_12_35 ref NI_12 NS_35 0 1.0560939112646855e-02
GC_12_36 ref NI_12 NS_36 0 -9.6546066415495145e-03
GC_12_37 ref NI_12 NS_37 0 3.9801143834844975e-03
GC_12_38 ref NI_12 NS_38 0 7.7235601625770837e-04
GC_12_39 ref NI_12 NS_39 0 1.8556462465623908e-05
GC_12_40 ref NI_12 NS_40 0 1.6550418056779580e-08
GC_12_41 ref NI_12 NS_41 0 -1.0616466331666297e-03
GC_12_42 ref NI_12 NS_42 0 -2.4413179483571000e-03
GC_12_43 ref NI_12 NS_43 0 1.2648118335474965e-03
GC_12_44 ref NI_12 NS_44 0 2.2407532281961064e-03
GC_12_45 ref NI_12 NS_45 0 2.7758083659500596e-05
GC_12_46 ref NI_12 NS_46 0 1.2585217553999121e-07
GC_12_47 ref NI_12 NS_47 0 -1.3191904206541192e-03
GC_12_48 ref NI_12 NS_48 0 -9.1571533961339142e-05
GC_12_49 ref NI_12 NS_49 0 4.5909313706272341e-03
GC_12_50 ref NI_12 NS_50 0 1.0901482678301057e-03
GC_12_51 ref NI_12 NS_51 0 -1.0929789642448092e-05
GC_12_52 ref NI_12 NS_52 0 1.4364219444369264e-06
GC_12_53 ref NI_12 NS_53 0 -2.2228585182684437e-03
GC_12_54 ref NI_12 NS_54 0 4.3791465647269427e-03
GC_12_55 ref NI_12 NS_55 0 -1.6822817785236996e-03
GC_12_56 ref NI_12 NS_56 0 3.1586904104158827e-03
GC_12_57 ref NI_12 NS_57 0 4.6795874993341530e-05
GC_12_58 ref NI_12 NS_58 0 1.8835744896511769e-07
GC_12_59 ref NI_12 NS_59 0 -4.9342522964061829e-05
GC_12_60 ref NI_12 NS_60 0 -4.3386087975541918e-03
GC_12_61 ref NI_12 NS_61 0 -1.9316649413668994e-03
GC_12_62 ref NI_12 NS_62 0 3.2818173794400755e-03
GC_12_63 ref NI_12 NS_63 0 5.3682882456033369e-05
GC_12_64 ref NI_12 NS_64 0 -8.5804065039315249e-08
GC_12_65 ref NI_12 NS_65 0 -1.9527177922889783e-04
GC_12_66 ref NI_12 NS_66 0 -4.5935994866494797e-03
GC_12_67 ref NI_12 NS_67 0 -5.8738914928680781e-02
GC_12_68 ref NI_12 NS_68 0 -1.6510735342275217e-02
GC_12_69 ref NI_12 NS_69 0 -4.5673895867031240e-04
GC_12_70 ref NI_12 NS_70 0 -8.6760509795385054e-06
GC_12_71 ref NI_12 NS_71 0 -3.4006994630841884e-02
GC_12_72 ref NI_12 NS_72 0 5.2729420402453882e-02
GC_12_73 ref NI_12 NS_73 0 8.3251875861168473e-03
GC_12_74 ref NI_12 NS_74 0 -6.8770138163370235e-03
GC_12_75 ref NI_12 NS_75 0 -5.7415232073001941e-05
GC_12_76 ref NI_12 NS_76 0 8.6311860516410336e-06
GC_12_77 ref NI_12 NS_77 0 2.0636379773857981e-02
GC_12_78 ref NI_12 NS_78 0 -3.1905402460853702e-02
GC_12_79 ref NI_12 NS_79 0 -2.0357722248196359e-03
GC_12_80 ref NI_12 NS_80 0 3.3082555739279229e-03
GC_12_81 ref NI_12 NS_81 0 4.9438451961339946e-05
GC_12_82 ref NI_12 NS_82 0 1.2638436023530407e-07
GC_12_83 ref NI_12 NS_83 0 9.1868432498689554e-05
GC_12_84 ref NI_12 NS_84 0 -4.0383531268646565e-03
GC_12_85 ref NI_12 NS_85 0 -1.1483887936803447e-03
GC_12_86 ref NI_12 NS_86 0 3.0456001294942251e-03
GC_12_87 ref NI_12 NS_87 0 4.6834659871153507e-05
GC_12_88 ref NI_12 NS_88 0 -3.6196659974095166e-07
GC_12_89 ref NI_12 NS_89 0 -3.8834204779137054e-04
GC_12_90 ref NI_12 NS_90 0 -2.9647279864063081e-03
GC_12_91 ref NI_12 NS_91 0 5.9095167936177827e-03
GC_12_92 ref NI_12 NS_92 0 3.5318529900642157e-04
GC_12_93 ref NI_12 NS_93 0 1.2690763562520756e-05
GC_12_94 ref NI_12 NS_94 0 4.2357629264477464e-07
GC_12_95 ref NI_12 NS_95 0 -2.7511212210283784e-03
GC_12_96 ref NI_12 NS_96 0 2.7142041363379054e-03
GC_12_97 ref NI_12 NS_97 0 8.5944238949366217e-03
GC_12_98 ref NI_12 NS_98 0 -2.1984689408638155e-03
GC_12_99 ref NI_12 NS_99 0 8.6077739354389367e-06
GC_12_100 ref NI_12 NS_100 0 2.6429862724641353e-07
GC_12_101 ref NI_12 NS_101 0 1.7527254428915306e-03
GC_12_102 ref NI_12 NS_102 0 -6.0399065091483661e-03
GC_12_103 ref NI_12 NS_103 0 4.4033414035697514e-04
GC_12_104 ref NI_12 NS_104 0 2.4566639039563251e-03
GC_12_105 ref NI_12 NS_105 0 3.7734845938367202e-05
GC_12_106 ref NI_12 NS_106 0 -2.9392412448988254e-09
GC_12_107 ref NI_12 NS_107 0 -8.5551275223156751e-04
GC_12_108 ref NI_12 NS_108 0 -9.8994250125306700e-04
GC_12_109 ref NI_12 NS_109 0 2.4198166566318717e-03
GC_12_110 ref NI_12 NS_110 0 1.6525968048534292e-03
GC_12_111 ref NI_12 NS_111 0 3.0312798033282818e-05
GC_12_112 ref NI_12 NS_112 0 -4.2664247234710794e-07
GC_12_113 ref NI_12 NS_113 0 -1.2588552644518575e-03
GC_12_114 ref NI_12 NS_114 0 1.7442091091766923e-04
GC_12_115 ref NI_12 NS_115 0 4.9934092380244516e-03
GC_12_116 ref NI_12 NS_116 0 1.3172575968760640e-03
GC_12_117 ref NI_12 NS_117 0 -1.1923942677342950e-05
GC_12_118 ref NI_12 NS_118 0 6.9634469809987550e-07
GC_12_119 ref NI_12 NS_119 0 -3.3876653519948948e-03
GC_12_120 ref NI_12 NS_120 0 8.4050140265462189e-03
GC_12_121 ref NI_12 NS_121 0 7.4894937816575979e-03
GC_12_122 ref NI_12 NS_122 0 -1.5926082500350311e-04
GC_12_123 ref NI_12 NS_123 0 -2.9388587251416777e-06
GC_12_124 ref NI_12 NS_124 0 6.1994195205239774e-08
GC_12_125 ref NI_12 NS_125 0 -3.2413528361214679e-03
GC_12_126 ref NI_12 NS_126 0 4.6479727287496598e-03
GC_12_127 ref NI_12 NS_127 0 4.5043071117053255e-03
GC_12_128 ref NI_12 NS_128 0 1.3802256277796413e-03
GC_12_129 ref NI_12 NS_129 0 -1.7921810596050823e-05
GC_12_130 ref NI_12 NS_130 0 1.7945943286576318e-06
GC_12_131 ref NI_12 NS_131 0 -2.7320729916974987e-03
GC_12_132 ref NI_12 NS_132 0 7.1907875358616247e-03
GD_12_1 ref NI_12 NA_1 0 6.2166334399340311e-03
GD_12_2 ref NI_12 NA_2 0 -7.1301559501052514e-03
GD_12_3 ref NI_12 NA_3 0 2.6316161630690968e-04
GD_12_4 ref NI_12 NA_4 0 1.6243555604465464e-02
GD_12_5 ref NI_12 NA_5 0 -8.9306413039432994e-04
GD_12_6 ref NI_12 NA_6 0 1.1376432371412155e-02
GD_12_7 ref NI_12 NA_7 0 1.5517211659091194e-03
GD_12_8 ref NI_12 NA_8 0 2.9248946998171251e-04
GD_12_9 ref NI_12 NA_9 0 3.1679358057147512e-04
GD_12_10 ref NI_12 NA_10 0 2.4419499042921929e-03
GD_12_11 ref NI_12 NA_11 0 2.6865169723447719e-03
GD_12_12 ref NI_12 NA_12 0 6.1634788171313311e+00
GD_12_13 ref NI_12 NA_13 0 4.5654059535435672e-02
GD_12_14 ref NI_12 NA_14 0 2.7540999751930941e-03
GD_12_15 ref NI_12 NA_15 0 2.1853797681116232e-03
GD_12_16 ref NI_12 NA_16 0 2.6839865743620225e-03
GD_12_17 ref NI_12 NA_17 0 8.3765721282839673e-03
GD_12_18 ref NI_12 NA_18 0 2.0750082190968363e-03
GD_12_19 ref NI_12 NA_19 0 2.2285252700151924e-03
GD_12_20 ref NI_12 NA_20 0 -8.8008583729509194e-04
GD_12_21 ref NI_12 NA_21 0 1.9722645145962723e-03
GD_12_22 ref NI_12 NA_22 0 -1.6446586028337974e-03
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -5.1272380331644097e-03
GC_13_2 ref NI_13 NS_2 0 4.2658436725856114e-03
GC_13_3 ref NI_13 NS_3 0 1.0601569549625618e-04
GC_13_4 ref NI_13 NS_4 0 2.3589734736958973e-06
GC_13_5 ref NI_13 NS_5 0 8.6464547667496863e-04
GC_13_6 ref NI_13 NS_6 0 -6.4376820004211910e-03
GC_13_7 ref NI_13 NS_7 0 5.3402664663284910e-04
GC_13_8 ref NI_13 NS_8 0 -3.4407166187669814e-04
GC_13_9 ref NI_13 NS_9 0 -3.7533172379060685e-06
GC_13_10 ref NI_13 NS_10 0 1.3545743867139009e-06
GC_13_11 ref NI_13 NS_11 0 1.8002017034446049e-02
GC_13_12 ref NI_13 NS_12 0 1.7367559314164630e-02
GC_13_13 ref NI_13 NS_13 0 -2.1553141139103588e-04
GC_13_14 ref NI_13 NS_14 0 2.8017809015621546e-03
GC_13_15 ref NI_13 NS_15 0 4.3708149158341402e-05
GC_13_16 ref NI_13 NS_16 0 1.1344117210387771e-06
GC_13_17 ref NI_13 NS_17 0 -1.4177229873964809e-03
GC_13_18 ref NI_13 NS_18 0 -1.6163157047986291e-03
GC_13_19 ref NI_13 NS_19 0 -7.9633141150090344e-03
GC_13_20 ref NI_13 NS_20 0 -3.9251854058315518e-03
GC_13_21 ref NI_13 NS_21 0 -2.6824290484923640e-06
GC_13_22 ref NI_13 NS_22 0 1.6094720275585926e-07
GC_13_23 ref NI_13 NS_23 0 4.7699164434967578e-02
GC_13_24 ref NI_13 NS_24 0 -2.5665360326410373e-02
GC_13_25 ref NI_13 NS_25 0 1.1294670675507835e-02
GC_13_26 ref NI_13 NS_26 0 -1.8256737876497062e-03
GC_13_27 ref NI_13 NS_27 0 -2.2847006783311085e-05
GC_13_28 ref NI_13 NS_28 0 2.3813963816336774e-07
GC_13_29 ref NI_13 NS_29 0 -4.7636436839683504e-03
GC_13_30 ref NI_13 NS_30 0 6.3742588816621663e-04
GC_13_31 ref NI_13 NS_31 0 8.2287670379422393e-03
GC_13_32 ref NI_13 NS_32 0 -1.3463905435039337e-03
GC_13_33 ref NI_13 NS_33 0 1.7438489240991095e-05
GC_13_34 ref NI_13 NS_34 0 3.5242668705310717e-08
GC_13_35 ref NI_13 NS_35 0 -4.6592378366261912e-03
GC_13_36 ref NI_13 NS_36 0 -1.8547698042632486e-02
GC_13_37 ref NI_13 NS_37 0 4.3394120154242781e-03
GC_13_38 ref NI_13 NS_38 0 1.2315680449396587e-03
GC_13_39 ref NI_13 NS_39 0 1.7314585770805939e-05
GC_13_40 ref NI_13 NS_40 0 7.3035554200073291e-07
GC_13_41 ref NI_13 NS_41 0 -3.9330978283261550e-03
GC_13_42 ref NI_13 NS_42 0 -1.9225219689034096e-04
GC_13_43 ref NI_13 NS_43 0 8.7214868562055219e-04
GC_13_44 ref NI_13 NS_44 0 2.6090859026159301e-03
GC_13_45 ref NI_13 NS_45 0 2.9689041576926170e-05
GC_13_46 ref NI_13 NS_46 0 7.9142294006095127e-07
GC_13_47 ref NI_13 NS_47 0 -2.3081083494308611e-03
GC_13_48 ref NI_13 NS_48 0 3.5192087087633408e-04
GC_13_49 ref NI_13 NS_49 0 6.3410032994505811e-03
GC_13_50 ref NI_13 NS_50 0 7.1764817295664411e-04
GC_13_51 ref NI_13 NS_51 0 -6.1958595218976129e-06
GC_13_52 ref NI_13 NS_52 0 6.4217645812363749e-07
GC_13_53 ref NI_13 NS_53 0 -4.7068103183258245e-03
GC_13_54 ref NI_13 NS_54 0 3.9700281589632258e-03
GC_13_55 ref NI_13 NS_55 0 -2.2512843463230845e-03
GC_13_56 ref NI_13 NS_56 0 3.3341580368083283e-03
GC_13_57 ref NI_13 NS_57 0 4.8634134456895774e-05
GC_13_58 ref NI_13 NS_58 0 1.0159061158290203e-06
GC_13_59 ref NI_13 NS_59 0 -8.2536149000329840e-05
GC_13_60 ref NI_13 NS_60 0 -5.7284085099274145e-03
GC_13_61 ref NI_13 NS_61 0 -2.7131073155772013e-03
GC_13_62 ref NI_13 NS_62 0 3.4741663260218249e-03
GC_13_63 ref NI_13 NS_63 0 5.2404778108065714e-05
GC_13_64 ref NI_13 NS_64 0 1.0057802106854785e-06
GC_13_65 ref NI_13 NS_65 0 2.0818311069216832e-04
GC_13_66 ref NI_13 NS_66 0 -6.0879144010463357e-03
GC_13_67 ref NI_13 NS_67 0 8.3251875861169167e-03
GC_13_68 ref NI_13 NS_68 0 -6.8770138163370591e-03
GC_13_69 ref NI_13 NS_69 0 -5.7415232072994182e-05
GC_13_70 ref NI_13 NS_70 0 8.6311860516405390e-06
GC_13_71 ref NI_13 NS_71 0 2.0636379773857946e-02
GC_13_72 ref NI_13 NS_72 0 -3.1905402460853591e-02
GC_13_73 ref NI_13 NS_73 0 -5.6205644418242363e-02
GC_13_74 ref NI_13 NS_74 0 -1.3018268468710473e-02
GC_13_75 ref NI_13 NS_75 0 -4.3502201123109724e-04
GC_13_76 ref NI_13 NS_76 0 -1.0617678871157709e-05
GC_13_77 ref NI_13 NS_77 0 -5.3661445476842262e-02
GC_13_78 ref NI_13 NS_78 0 7.0417662187791413e-02
GC_13_79 ref NI_13 NS_79 0 -2.6091588064493985e-03
GC_13_80 ref NI_13 NS_80 0 3.5179982165501091e-03
GC_13_81 ref NI_13 NS_81 0 5.6597387119364133e-05
GC_13_82 ref NI_13 NS_82 0 4.0205281563884651e-07
GC_13_83 ref NI_13 NS_83 0 -2.2623874639001768e-05
GC_13_84 ref NI_13 NS_84 0 -5.1039153469126571e-03
GC_13_85 ref NI_13 NS_85 0 -2.1322493451524354e-03
GC_13_86 ref NI_13 NS_86 0 3.3361483298748572e-03
GC_13_87 ref NI_13 NS_87 0 4.5377654600225414e-05
GC_13_88 ref NI_13 NS_88 0 3.8448636417044322e-07
GC_13_89 ref NI_13 NS_89 0 1.3483603398622559e-04
GC_13_90 ref NI_13 NS_90 0 -4.4075085631819048e-03
GC_13_91 ref NI_13 NS_91 0 4.4117352434258940e-03
GC_13_92 ref NI_13 NS_92 0 1.1423434022596447e-03
GC_13_93 ref NI_13 NS_93 0 1.9359724712289903e-05
GC_13_94 ref NI_13 NS_94 0 1.9801179717440537e-07
GC_13_95 ref NI_13 NS_95 0 -2.9027477225582682e-03
GC_13_96 ref NI_13 NS_96 0 3.3152537678772715e-03
GC_13_97 ref NI_13 NS_97 0 7.4570505911156458e-03
GC_13_98 ref NI_13 NS_98 0 -6.3395510978239082e-04
GC_13_99 ref NI_13 NS_99 0 6.1509587542735350e-06
GC_13_100 ref NI_13 NS_100 0 -6.5740937597866760e-08
GC_13_101 ref NI_13 NS_101 0 -1.5327431661675114e-03
GC_13_102 ref NI_13 NS_102 0 2.6147818487861616e-03
GC_13_103 ref NI_13 NS_103 0 -3.4463404921659106e-04
GC_13_104 ref NI_13 NS_104 0 2.7979137298140906e-03
GC_13_105 ref NI_13 NS_105 0 4.2698163999120677e-05
GC_13_106 ref NI_13 NS_106 0 2.1836608496055188e-07
GC_13_107 ref NI_13 NS_107 0 -1.0033788766504624e-03
GC_13_108 ref NI_13 NS_108 0 -1.9762238509309690e-03
GC_13_109 ref NI_13 NS_109 0 1.1034549260598794e-03
GC_13_110 ref NI_13 NS_110 0 2.1605761415714997e-03
GC_13_111 ref NI_13 NS_111 0 2.6954840717869599e-05
GC_13_112 ref NI_13 NS_112 0 1.4622427223075261e-07
GC_13_113 ref NI_13 NS_113 0 -6.9117951191729034e-04
GC_13_114 ref NI_13 NS_114 0 -3.1808501034346601e-04
GC_13_115 ref NI_13 NS_115 0 1.0347086194512224e-02
GC_13_116 ref NI_13 NS_116 0 -1.0823395452398236e-03
GC_13_117 ref NI_13 NS_117 0 -2.8310122996982152e-05
GC_13_118 ref NI_13 NS_118 0 -4.7314417302609191e-07
GC_13_119 ref NI_13 NS_119 0 -3.5216592964871060e-03
GC_13_120 ref NI_13 NS_120 0 1.1574367893450233e-02
GC_13_121 ref NI_13 NS_121 0 1.0708741045144325e-02
GC_13_122 ref NI_13 NS_122 0 -3.3297966573567601e-03
GC_13_123 ref NI_13 NS_123 0 -1.6640178122010248e-05
GC_13_124 ref NI_13 NS_124 0 -5.0857454539630499e-07
GC_13_125 ref NI_13 NS_125 0 2.7787066891902757e-03
GC_13_126 ref NI_13 NS_126 0 -6.6536507408180333e-03
GC_13_127 ref NI_13 NS_127 0 6.1357904885113324e-03
GC_13_128 ref NI_13 NS_128 0 9.9571039687992901e-04
GC_13_129 ref NI_13 NS_129 0 -1.7553379812969947e-05
GC_13_130 ref NI_13 NS_130 0 7.7845837956241552e-07
GC_13_131 ref NI_13 NS_131 0 -4.2028771669082943e-03
GC_13_132 ref NI_13 NS_132 0 9.1693230629541177e-03
GD_13_1 ref NI_13 NA_1 0 5.5815796225181418e-03
GD_13_2 ref NI_13 NA_2 0 -7.7544147872603371e-03
GD_13_3 ref NI_13 NA_3 0 1.4077100391006762e-04
GD_13_4 ref NI_13 NA_4 0 3.4362631633273147e-02
GD_13_5 ref NI_13 NA_5 0 4.4975860361180168e-04
GD_13_6 ref NI_13 NA_6 0 3.2965121684141573e-03
GD_13_7 ref NI_13 NA_7 0 1.8659994439460936e-04
GD_13_8 ref NI_13 NA_8 0 -9.2706961359422627e-05
GD_13_9 ref NI_13 NA_9 0 -1.2382884203712659e-03
GD_13_10 ref NI_13 NA_10 0 2.6791918943266779e-03
GD_13_11 ref NI_13 NA_11 0 3.1111241966282691e-03
GD_13_12 ref NI_13 NA_12 0 4.5654059535435672e-02
GD_13_13 ref NI_13 NA_13 0 6.1623514911828350e+00
GD_13_14 ref NI_13 NA_14 0 2.7030412775667211e-03
GD_13_15 ref NI_13 NA_15 0 2.4371844508501816e-03
GD_13_16 ref NI_13 NA_16 0 8.4946250272683156e-04
GD_13_17 ref NI_13 NA_17 0 4.1740064811592514e-03
GD_13_18 ref NI_13 NA_18 0 1.6981691046598240e-03
GD_13_19 ref NI_13 NA_19 0 1.8678064447058026e-03
GD_13_20 ref NI_13 NA_20 0 2.7066405612623495e-04
GD_13_21 ref NI_13 NA_21 0 8.0592103199978466e-03
GD_13_22 ref NI_13 NA_22 0 -2.8344620963715156e-03
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 1.2227168122697051e-03
GC_14_2 ref NI_14 NS_2 0 2.3049137239179807e-03
GC_14_3 ref NI_14 NS_3 0 3.7458837520879308e-05
GC_14_4 ref NI_14 NS_4 0 1.2425785993815354e-06
GC_14_5 ref NI_14 NS_5 0 -1.5322703234124306e-03
GC_14_6 ref NI_14 NS_6 0 1.8761386521640045e-03
GC_14_7 ref NI_14 NS_7 0 2.3226312353556346e-03
GC_14_8 ref NI_14 NS_8 0 -5.3947760898504047e-04
GC_14_9 ref NI_14 NS_9 0 4.9120690472466507e-07
GC_14_10 ref NI_14 NS_10 0 3.6477755220395317e-07
GC_14_11 ref NI_14 NS_11 0 1.4361937297372181e-02
GC_14_12 ref NI_14 NS_12 0 1.6257951253143766e-02
GC_14_13 ref NI_14 NS_13 0 7.6995246137099554e-03
GC_14_14 ref NI_14 NS_14 0 -4.1097245822292790e-03
GC_14_15 ref NI_14 NS_15 0 -8.0785586994405184e-06
GC_14_16 ref NI_14 NS_16 0 -8.2201082223468298e-07
GC_14_17 ref NI_14 NS_17 0 1.3323454079090071e-02
GC_14_18 ref NI_14 NS_18 0 -9.7110212260080025e-03
GC_14_19 ref NI_14 NS_19 0 -7.1174481451345489e-04
GC_14_20 ref NI_14 NS_20 0 2.8961427946694604e-03
GC_14_21 ref NI_14 NS_21 0 2.9593370408948708e-05
GC_14_22 ref NI_14 NS_22 0 6.1641300266319004e-07
GC_14_23 ref NI_14 NS_23 0 -2.6482766207576236e-04
GC_14_24 ref NI_14 NS_24 0 -2.1333692722667092e-03
GC_14_25 ref NI_14 NS_25 0 -4.0880107463946184e-03
GC_14_26 ref NI_14 NS_26 0 4.0156702514656129e-03
GC_14_27 ref NI_14 NS_27 0 5.3153189640465634e-05
GC_14_28 ref NI_14 NS_28 0 6.2954318720099227e-07
GC_14_29 ref NI_14 NS_29 0 1.0499458922099533e-03
GC_14_30 ref NI_14 NS_30 0 -6.5034264128806816e-03
GC_14_31 ref NI_14 NS_31 0 1.7032719357672488e-03
GC_14_32 ref NI_14 NS_32 0 2.1183115641990949e-03
GC_14_33 ref NI_14 NS_33 0 1.5721876921390382e-05
GC_14_34 ref NI_14 NS_34 0 6.8316569333315324e-07
GC_14_35 ref NI_14 NS_35 0 -1.3975365361897317e-03
GC_14_36 ref NI_14 NS_36 0 1.0668863089341521e-03
GC_14_37 ref NI_14 NS_37 0 6.0901349993317871e-03
GC_14_38 ref NI_14 NS_38 0 1.3451902963872124e-04
GC_14_39 ref NI_14 NS_39 0 2.6710352920708628e-06
GC_14_40 ref NI_14 NS_40 0 8.0236165128418183e-07
GC_14_41 ref NI_14 NS_41 0 -2.0933713206904019e-03
GC_14_42 ref NI_14 NS_42 0 1.5838191273449306e-03
GC_14_43 ref NI_14 NS_43 0 9.5454086422531968e-03
GC_14_44 ref NI_14 NS_44 0 -3.7177750217322635e-03
GC_14_45 ref NI_14 NS_45 0 9.1918468190179337e-06
GC_14_46 ref NI_14 NS_46 0 1.2147455496566451e-06
GC_14_47 ref NI_14 NS_47 0 4.0869099727588523e-03
GC_14_48 ref NI_14 NS_48 0 -1.7181850437289644e-02
GC_14_49 ref NI_14 NS_49 0 -2.4062195610220043e-03
GC_14_50 ref NI_14 NS_50 0 3.7546266629637534e-03
GC_14_51 ref NI_14 NS_51 0 2.4709990424957749e-05
GC_14_52 ref NI_14 NS_52 0 1.3714615922172003e-06
GC_14_53 ref NI_14 NS_53 0 -9.9732299734235695e-05
GC_14_54 ref NI_14 NS_54 0 -1.5655790356700239e-03
GC_14_55 ref NI_14 NS_55 0 1.3777844094694900e-02
GC_14_56 ref NI_14 NS_56 0 -2.7678667542503210e-03
GC_14_57 ref NI_14 NS_57 0 -3.2382364740300323e-05
GC_14_58 ref NI_14 NS_58 0 3.0040481319929798e-08
GC_14_59 ref NI_14 NS_59 0 -4.0872948689162627e-03
GC_14_60 ref NI_14 NS_60 0 9.4891213179962436e-03
GC_14_61 ref NI_14 NS_61 0 1.4203027123727865e-02
GC_14_62 ref NI_14 NS_62 0 -4.0249532721823517e-03
GC_14_63 ref NI_14 NS_63 0 -3.5723053016743614e-05
GC_14_64 ref NI_14 NS_64 0 2.9690907385595046e-07
GC_14_65 ref NI_14 NS_65 0 -2.9297524660299395e-04
GC_14_66 ref NI_14 NS_66 0 1.6765519569179976e-03
GC_14_67 ref NI_14 NS_67 0 -2.0357722248196281e-03
GC_14_68 ref NI_14 NS_68 0 3.3082555739279138e-03
GC_14_69 ref NI_14 NS_69 0 4.9438451961342676e-05
GC_14_70 ref NI_14 NS_70 0 1.2638436023486734e-07
GC_14_71 ref NI_14 NS_71 0 9.1868432498686464e-05
GC_14_72 ref NI_14 NS_72 0 -4.0383531268646765e-03
GC_14_73 ref NI_14 NS_73 0 -2.6091588064494371e-03
GC_14_74 ref NI_14 NS_74 0 3.5179982165501299e-03
GC_14_75 ref NI_14 NS_75 0 5.6597387119359078e-05
GC_14_76 ref NI_14 NS_76 0 4.0205281563922477e-07
GC_14_77 ref NI_14 NS_77 0 -2.2623874638982561e-05
GC_14_78 ref NI_14 NS_78 0 -5.1039153469127265e-03
GC_14_79 ref NI_14 NS_79 0 -5.3745887078030928e-02
GC_14_80 ref NI_14 NS_80 0 -1.8093021125863855e-02
GC_14_81 ref NI_14 NS_81 0 -4.5324516141668814e-04
GC_14_82 ref NI_14 NS_82 0 -1.0858851113616518e-05
GC_14_83 ref NI_14 NS_83 0 -3.6721525756211827e-02
GC_14_84 ref NI_14 NS_84 0 5.9190850945796285e-02
GC_14_85 ref NI_14 NS_85 0 1.0825670808798440e-02
GC_14_86 ref NI_14 NS_86 0 -7.9435901142786754e-03
GC_14_87 ref NI_14 NS_87 0 -5.1711372064148886e-05
GC_14_88 ref NI_14 NS_88 0 9.0377115981348585e-06
GC_14_89 ref NI_14 NS_89 0 2.0290663661347838e-02
GC_14_90 ref NI_14 NS_90 0 -2.7643473324896372e-02
GC_14_91 ref NI_14 NS_91 0 9.8625651222556060e-04
GC_14_92 ref NI_14 NS_92 0 2.3907796539641589e-03
GC_14_93 ref NI_14 NS_93 0 2.3898601538234314e-05
GC_14_94 ref NI_14 NS_94 0 6.3344900391967180e-08
GC_14_95 ref NI_14 NS_95 0 -1.1531572532925206e-03
GC_14_96 ref NI_14 NS_96 0 7.5462958430563994e-04
GC_14_97 ref NI_14 NS_97 0 -6.1387105387925424e-04
GC_14_98 ref NI_14 NS_98 0 3.0340176253606825e-03
GC_14_99 ref NI_14 NS_99 0 3.5052069721114111e-05
GC_14_100 ref NI_14 NS_100 0 3.6203339303705504e-07
GC_14_101 ref NI_14 NS_101 0 -1.0798775331447741e-03
GC_14_102 ref NI_14 NS_102 0 -8.5476543634055576e-04
GC_14_103 ref NI_14 NS_103 0 7.1124973414737301e-03
GC_14_104 ref NI_14 NS_104 0 1.5794640484122953e-04
GC_14_105 ref NI_14 NS_105 0 -8.5545536874324099e-06
GC_14_106 ref NI_14 NS_106 0 3.3925121251146367e-07
GC_14_107 ref NI_14 NS_107 0 -3.3849939080072382e-03
GC_14_108 ref NI_14 NS_108 0 6.3308562401494916e-03
GC_14_109 ref NI_14 NS_109 0 4.5969314417154961e-03
GC_14_110 ref NI_14 NS_110 0 1.3602077411060854e-03
GC_14_111 ref NI_14 NS_111 0 4.3438661240959743e-06
GC_14_112 ref NI_14 NS_112 0 2.3302467058221562e-07
GC_14_113 ref NI_14 NS_113 0 -3.3877485456462447e-03
GC_14_114 ref NI_14 NS_114 0 6.2781297016463707e-03
GC_14_115 ref NI_14 NS_115 0 -5.4507898343557114e-03
GC_14_116 ref NI_14 NS_116 0 4.3503190138234520e-03
GC_14_117 ref NI_14 NS_117 0 7.6141333013771562e-05
GC_14_118 ref NI_14 NS_118 0 7.5519995000837071e-07
GC_14_119 ref NI_14 NS_119 0 1.4463184935041070e-03
GC_14_120 ref NI_14 NS_120 0 -9.2022134477189998e-03
GC_14_121 ref NI_14 NS_121 0 -3.8737891017464900e-03
GC_14_122 ref NI_14 NS_122 0 3.7933335029287350e-03
GC_14_123 ref NI_14 NS_123 0 6.3087688396910047e-05
GC_14_124 ref NI_14 NS_124 0 5.3346769505814233e-07
GC_14_125 ref NI_14 NS_125 0 1.0116724819781437e-03
GC_14_126 ref NI_14 NS_126 0 -7.6050798419050993e-03
GC_14_127 ref NI_14 NS_127 0 -3.3688089671522728e-03
GC_14_128 ref NI_14 NS_128 0 3.9248706817997447e-03
GC_14_129 ref NI_14 NS_129 0 3.1120027906946035e-05
GC_14_130 ref NI_14 NS_130 0 1.1982138459012699e-06
GC_14_131 ref NI_14 NS_131 0 7.7195553329234968e-04
GC_14_132 ref NI_14 NS_132 0 -4.0346754465418119e-03
GD_14_1 ref NI_14 NA_1 0 4.7989809896120802e-03
GD_14_2 ref NI_14 NA_2 0 -8.1349533786269374e-03
GD_14_3 ref NI_14 NA_3 0 1.2279534501943709e-02
GD_14_4 ref NI_14 NA_4 0 5.2073898481894360e-04
GD_14_5 ref NI_14 NA_5 0 2.5892530045981553e-03
GD_14_6 ref NI_14 NA_6 0 4.0854446076550669e-04
GD_14_7 ref NI_14 NA_7 0 1.6114523622985965e-03
GD_14_8 ref NI_14 NA_8 0 1.4485941261031171e-02
GD_14_9 ref NI_14 NA_9 0 7.1570483308497530e-04
GD_14_10 ref NI_14 NA_10 0 1.6378291359916150e-03
GD_14_11 ref NI_14 NA_11 0 5.5711392735048691e-03
GD_14_12 ref NI_14 NA_12 0 2.7540999751930941e-03
GD_14_13 ref NI_14 NA_13 0 2.7030412775667211e-03
GD_14_14 ref NI_14 NA_14 0 6.1605787303330715e+00
GD_14_15 ref NI_14 NA_15 0 4.8100415650860817e-02
GD_14_16 ref NI_14 NA_16 0 1.3064973314522838e-03
GD_14_17 ref NI_14 NA_17 0 1.4488406147858211e-03
GD_14_18 ref NI_14 NA_18 0 1.1161509070768815e-03
GD_14_19 ref NI_14 NA_19 0 -4.3961444236544225e-04
GD_14_20 ref NI_14 NA_20 0 4.5347707317906936e-03
GD_14_21 ref NI_14 NA_21 0 3.9600114580507165e-03
GD_14_22 ref NI_14 NA_22 0 1.4845990821456489e-03
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 9.9547476214704588e-04
GC_15_2 ref NI_15 NS_2 0 2.7202761568683198e-03
GC_15_3 ref NI_15 NS_3 0 4.3472583202377247e-05
GC_15_4 ref NI_15 NS_4 0 1.3183674521955486e-06
GC_15_5 ref NI_15 NS_5 0 -2.8739086114732111e-03
GC_15_6 ref NI_15 NS_6 0 3.1363972786065900e-03
GC_15_7 ref NI_15 NS_7 0 1.7934741539981172e-03
GC_15_8 ref NI_15 NS_8 0 -5.6667609650898939e-04
GC_15_9 ref NI_15 NS_9 0 -3.5835641949537149e-06
GC_15_10 ref NI_15 NS_10 0 3.1401944248232511e-07
GC_15_11 ref NI_15 NS_11 0 1.6478603119803523e-02
GC_15_12 ref NI_15 NS_12 0 1.8803355503325913e-02
GC_15_13 ref NI_15 NS_13 0 1.3273462451632478e-02
GC_15_14 ref NI_15 NS_14 0 -3.2477069739127577e-03
GC_15_15 ref NI_15 NS_15 0 2.7435846161250741e-06
GC_15_16 ref NI_15 NS_16 0 4.5453501722300412e-08
GC_15_17 ref NI_15 NS_17 0 -6.9130610292804867e-03
GC_15_18 ref NI_15 NS_18 0 -1.6017051043330986e-02
GC_15_19 ref NI_15 NS_19 0 4.4715169518798754e-04
GC_15_20 ref NI_15 NS_20 0 2.6694454533343929e-03
GC_15_21 ref NI_15 NS_21 0 2.7353887528722994e-05
GC_15_22 ref NI_15 NS_22 0 3.7910066394312335e-07
GC_15_23 ref NI_15 NS_23 0 -1.7368687895108410e-03
GC_15_24 ref NI_15 NS_24 0 -1.2854190877708883e-03
GC_15_25 ref NI_15 NS_25 0 -3.5407877876248218e-03
GC_15_26 ref NI_15 NS_26 0 3.9860482238870953e-03
GC_15_27 ref NI_15 NS_27 0 4.9349509268203581e-05
GC_15_28 ref NI_15 NS_28 0 4.5081399204321094e-07
GC_15_29 ref NI_15 NS_29 0 2.6519665438112263e-04
GC_15_30 ref NI_15 NS_30 0 -5.2142545257059273e-03
GC_15_31 ref NI_15 NS_31 0 3.4068630674193908e-03
GC_15_32 ref NI_15 NS_32 0 1.6144458133128341e-03
GC_15_33 ref NI_15 NS_33 0 1.6915589714749092e-05
GC_15_34 ref NI_15 NS_34 0 3.6117300293154776e-07
GC_15_35 ref NI_15 NS_35 0 -3.2087077756464345e-03
GC_15_36 ref NI_15 NS_36 0 6.4968692263450798e-04
GC_15_37 ref NI_15 NS_37 0 7.4654644621419382e-03
GC_15_38 ref NI_15 NS_38 0 -9.0183726892150253e-04
GC_15_39 ref NI_15 NS_39 0 1.1590351441383561e-05
GC_15_40 ref NI_15 NS_40 0 2.2314764675631256e-07
GC_15_41 ref NI_15 NS_41 0 -3.0893672079241874e-03
GC_15_42 ref NI_15 NS_42 0 -1.0410375750321747e-02
GC_15_43 ref NI_15 NS_43 0 -3.2905658081025719e-03
GC_15_44 ref NI_15 NS_44 0 -4.7666450586048622e-03
GC_15_45 ref NI_15 NS_45 0 2.1380009301343516e-06
GC_15_46 ref NI_15 NS_46 0 6.0523579858944958e-07
GC_15_47 ref NI_15 NS_47 0 4.0058840680183595e-02
GC_15_48 ref NI_15 NS_48 0 -2.5068119685712067e-02
GC_15_49 ref NI_15 NS_49 0 -1.9241188677108160e-03
GC_15_50 ref NI_15 NS_50 0 3.8203669230355386e-03
GC_15_51 ref NI_15 NS_51 0 2.3613533840164415e-05
GC_15_52 ref NI_15 NS_52 0 8.0884457445245610e-07
GC_15_53 ref NI_15 NS_53 0 -9.9916887815670310e-04
GC_15_54 ref NI_15 NS_54 0 5.1235160268160848e-04
GC_15_55 ref NI_15 NS_55 0 1.0968434146065409e-02
GC_15_56 ref NI_15 NS_56 0 -1.1683177304499623e-03
GC_15_57 ref NI_15 NS_57 0 -2.7689527216939812e-05
GC_15_58 ref NI_15 NS_58 0 2.4497759264275286e-07
GC_15_59 ref NI_15 NS_59 0 -4.9183911574267724e-03
GC_15_60 ref NI_15 NS_60 0 1.0971546050459541e-02
GC_15_61 ref NI_15 NS_61 0 1.1794760898401669e-02
GC_15_62 ref NI_15 NS_62 0 -1.8175906548376683e-03
GC_15_63 ref NI_15 NS_63 0 -3.6041417009327964e-05
GC_15_64 ref NI_15 NS_64 0 4.4808574380792432e-07
GC_15_65 ref NI_15 NS_65 0 -3.6436080201866414e-03
GC_15_66 ref NI_15 NS_66 0 1.1112099947532419e-02
GC_15_67 ref NI_15 NS_67 0 -1.1483887936802847e-03
GC_15_68 ref NI_15 NS_68 0 3.0456001294941934e-03
GC_15_69 ref NI_15 NS_69 0 4.6834659871160344e-05
GC_15_70 ref NI_15 NS_70 0 -3.6196659974159323e-07
GC_15_71 ref NI_15 NS_71 0 -3.8834204779140030e-04
GC_15_72 ref NI_15 NS_72 0 -2.9647279864062010e-03
GC_15_73 ref NI_15 NS_73 0 -2.1322493451524658e-03
GC_15_74 ref NI_15 NS_74 0 3.3361483298748689e-03
GC_15_75 ref NI_15 NS_75 0 4.5377654600223801e-05
GC_15_76 ref NI_15 NS_76 0 3.8448636417064015e-07
GC_15_77 ref NI_15 NS_77 0 1.3483603398624285e-04
GC_15_78 ref NI_15 NS_78 0 -4.4075085631819855e-03
GC_15_79 ref NI_15 NS_79 0 1.0825670808798496e-02
GC_15_80 ref NI_15 NS_80 0 -7.9435901142787015e-03
GC_15_81 ref NI_15 NS_81 0 -5.1711372064143533e-05
GC_15_82 ref NI_15 NS_82 0 9.0377115981340538e-06
GC_15_83 ref NI_15 NS_83 0 2.0290663661347810e-02
GC_15_84 ref NI_15 NS_84 0 -2.7643473324896264e-02
GC_15_85 ref NI_15 NS_85 0 -5.6430376216981576e-02
GC_15_86 ref NI_15 NS_86 0 -1.4857604185779128e-02
GC_15_87 ref NI_15 NS_87 0 -4.1508802337303005e-04
GC_15_88 ref NI_15 NS_88 0 -7.5547932503622268e-06
GC_15_89 ref NI_15 NS_89 0 -4.6727650033486508e-02
GC_15_90 ref NI_15 NS_90 0 6.3997445743428111e-02
GC_15_91 ref NI_15 NS_91 0 2.5981861072275057e-03
GC_15_92 ref NI_15 NS_92 0 1.7340841355769371e-03
GC_15_93 ref NI_15 NS_93 0 2.0777572999361993e-05
GC_15_94 ref NI_15 NS_94 0 -4.0164265078311353e-07
GC_15_95 ref NI_15 NS_95 0 -1.5538847403033192e-03
GC_15_96 ref NI_15 NS_96 0 1.5232289142023488e-03
GC_15_97 ref NI_15 NS_97 0 4.7711053918077988e-04
GC_15_98 ref NI_15 NS_98 0 2.5378643715251300e-03
GC_15_99 ref NI_15 NS_99 0 2.4474998937181515e-05
GC_15_100 ref NI_15 NS_100 0 2.7071058098231851e-07
GC_15_101 ref NI_15 NS_101 0 -8.3260027151585685e-04
GC_15_102 ref NI_15 NS_102 0 2.0386285846645287e-04
GC_15_103 ref NI_15 NS_103 0 9.2718092354552809e-03
GC_15_104 ref NI_15 NS_104 0 -2.0573931316940322e-03
GC_15_105 ref NI_15 NS_105 0 -1.3027047160187831e-05
GC_15_106 ref NI_15 NS_106 0 3.1961874257019133e-07
GC_15_107 ref NI_15 NS_107 0 7.4814733107256748e-04
GC_15_108 ref NI_15 NS_108 0 -2.4225469553905742e-03
GC_15_109 ref NI_15 NS_109 0 7.0833262333365298e-03
GC_15_110 ref NI_15 NS_110 0 -1.3245183574219131e-04
GC_15_111 ref NI_15 NS_111 0 -7.5844274121977183e-06
GC_15_112 ref NI_15 NS_112 0 1.3243187371938603e-07
GC_15_113 ref NI_15 NS_113 0 -2.1493958532314422e-03
GC_15_114 ref NI_15 NS_114 0 5.3656479708947590e-03
GC_15_115 ref NI_15 NS_115 0 -5.1936351113701148e-03
GC_15_116 ref NI_15 NS_116 0 4.2865586823015557e-03
GC_15_117 ref NI_15 NS_117 0 7.0157782840541387e-05
GC_15_118 ref NI_15 NS_118 0 9.8609568416075477e-07
GC_15_119 ref NI_15 NS_119 0 1.3948596680623091e-03
GC_15_120 ref NI_15 NS_120 0 -8.4539396437294679e-03
GC_15_121 ref NI_15 NS_121 0 -3.3592973928345802e-03
GC_15_122 ref NI_15 NS_122 0 3.7061593242481128e-03
GC_15_123 ref NI_15 NS_123 0 6.2696233179155222e-05
GC_15_124 ref NI_15 NS_124 0 -2.1343021325930919e-07
GC_15_125 ref NI_15 NS_125 0 5.5880020630377314e-04
GC_15_126 ref NI_15 NS_126 0 -6.7404959146909948e-03
GC_15_127 ref NI_15 NS_127 0 -3.0498739438083690e-03
GC_15_128 ref NI_15 NS_128 0 4.0470084445461676e-03
GC_15_129 ref NI_15 NS_129 0 2.9995816524221643e-05
GC_15_130 ref NI_15 NS_130 0 6.7615914062069779e-07
GC_15_131 ref NI_15 NS_131 0 -8.5038252481239564e-05
GC_15_132 ref NI_15 NS_132 0 -2.3325257185161730e-03
GD_15_1 ref NI_15 NA_1 0 2.5493417260283369e-03
GD_15_2 ref NI_15 NA_2 0 -7.6012988064772490e-03
GD_15_3 ref NI_15 NA_3 0 2.7560385658971834e-03
GD_15_4 ref NI_15 NA_4 0 5.8121442823275046e-05
GD_15_5 ref NI_15 NA_5 0 1.9079183095310319e-03
GD_15_6 ref NI_15 NA_6 0 3.1426474255253376e-04
GD_15_7 ref NI_15 NA_7 0 3.3251551287073202e-03
GD_15_8 ref NI_15 NA_8 0 3.1682219116082766e-02
GD_15_9 ref NI_15 NA_9 0 3.6445121355464171e-05
GD_15_10 ref NI_15 NA_10 0 -7.0826244958463122e-04
GD_15_11 ref NI_15 NA_11 0 1.9035097678073833e-03
GD_15_12 ref NI_15 NA_12 0 2.1853797681116232e-03
GD_15_13 ref NI_15 NA_13 0 2.4371844508501816e-03
GD_15_14 ref NI_15 NA_14 0 4.8100415650860817e-02
GD_15_15 ref NI_15 NA_15 0 6.1643550940292258e+00
GD_15_16 ref NI_15 NA_16 0 1.2388332944350800e-03
GD_15_17 ref NI_15 NA_17 0 1.5259044191133504e-03
GD_15_18 ref NI_15 NA_18 0 5.4798350455017705e-03
GD_15_19 ref NI_15 NA_19 0 2.2949554521807035e-03
GD_15_20 ref NI_15 NA_20 0 4.0990858189099526e-03
GD_15_21 ref NI_15 NA_21 0 3.3060918191656153e-03
GD_15_22 ref NI_15 NA_22 0 6.9411868552406901e-04
*
* Port 16
VI_16 a_16 NI_16 0
RI_16 NI_16 ref 1.0000000000000001e-01
GC_16_1 ref NI_16 NS_1 0 -3.0390511310998060e-03
GC_16_2 ref NI_16 NS_2 0 3.5832512447459227e-03
GC_16_3 ref NI_16 NS_3 0 8.0568615401552192e-05
GC_16_4 ref NI_16 NS_4 0 1.6114159224160758e-06
GC_16_5 ref NI_16 NS_5 0 4.0305749722085587e-04
GC_16_6 ref NI_16 NS_6 0 -3.9345307891612020e-03
GC_16_7 ref NI_16 NS_7 0 1.9613463386896415e-03
GC_16_8 ref NI_16 NS_8 0 -5.7643845873999811e-04
GC_16_9 ref NI_16 NS_9 0 4.2950884015047371e-06
GC_16_10 ref NI_16 NS_10 0 5.3574181595489072e-08
GC_16_11 ref NI_16 NS_11 0 1.5999588971225009e-02
GC_16_12 ref NI_16 NS_12 0 1.8755744780818810e-02
GC_16_13 ref NI_16 NS_13 0 3.1691572057110243e-03
GC_16_14 ref NI_16 NS_14 0 1.4231823445479065e-03
GC_16_15 ref NI_16 NS_15 0 1.4256882620247050e-05
GC_16_16 ref NI_16 NS_16 0 1.4640949274083101e-07
GC_16_17 ref NI_16 NS_17 0 -1.4972209018004829e-03
GC_16_18 ref NI_16 NS_18 0 7.0432698654847520e-04
GC_16_19 ref NI_16 NS_19 0 4.9939425862535799e-03
GC_16_20 ref NI_16 NS_20 0 2.8481396602952447e-04
GC_16_21 ref NI_16 NS_21 0 8.9421034793244627e-06
GC_16_22 ref NI_16 NS_22 0 1.0284883269217923e-06
GC_16_23 ref NI_16 NS_23 0 -9.9804838314696801e-04
GC_16_24 ref NI_16 NS_24 0 -1.5085502320018418e-03
GC_16_25 ref NI_16 NS_25 0 9.7089120931284612e-04
GC_16_26 ref NI_16 NS_26 0 2.5382629696470275e-03
GC_16_27 ref NI_16 NS_27 0 7.8037560754303467e-06
GC_16_28 ref NI_16 NS_28 0 9.6944599986959249e-07
GC_16_29 ref NI_16 NS_29 0 -1.3127716230504623e-03
GC_16_30 ref NI_16 NS_30 0 1.8563289268169686e-03
GC_16_31 ref NI_16 NS_31 0 5.4545199792214692e-03
GC_16_32 ref NI_16 NS_32 0 -2.3735746788573543e-03
GC_16_33 ref NI_16 NS_33 0 2.8497467050271259e-05
GC_16_34 ref NI_16 NS_34 0 1.2848306087991413e-06
GC_16_35 ref NI_16 NS_35 0 6.4482316931523849e-03
GC_16_36 ref NI_16 NS_36 0 -2.0084703094342481e-02
GC_16_37 ref NI_16 NS_37 0 3.4944281443793127e-03
GC_16_38 ref NI_16 NS_38 0 -1.6558922099608330e-03
GC_16_39 ref NI_16 NS_39 0 1.4465930531238257e-05
GC_16_40 ref NI_16 NS_40 0 -4.1397777368094337e-07
GC_16_41 ref NI_16 NS_41 0 1.0955796522028386e-02
GC_16_42 ref NI_16 NS_42 0 -9.7425446530569303e-03
GC_16_43 ref NI_16 NS_43 0 4.3529117304688999e-03
GC_16_44 ref NI_16 NS_44 0 7.2719634911192930e-04
GC_16_45 ref NI_16 NS_45 0 1.2801888108897770e-05
GC_16_46 ref NI_16 NS_46 0 7.1275673332933451e-09
GC_16_47 ref NI_16 NS_47 0 -1.3297020160516558e-03
GC_16_48 ref NI_16 NS_48 0 -1.1685551414999042e-03
GC_16_49 ref NI_16 NS_49 0 2.2762730662050121e-03
GC_16_50 ref NI_16 NS_50 0 2.0642057628261017e-03
GC_16_51 ref NI_16 NS_51 0 1.1480933968037892e-06
GC_16_52 ref NI_16 NS_52 0 1.0012226583564392e-06
GC_16_53 ref NI_16 NS_53 0 -1.7237099391693165e-03
GC_16_54 ref NI_16 NS_54 0 3.1863148305032859e-03
GC_16_55 ref NI_16 NS_55 0 8.6109686358247235e-04
GC_16_56 ref NI_16 NS_56 0 2.3955593123017381e-03
GC_16_57 ref NI_16 NS_57 0 1.7344678847470995e-05
GC_16_58 ref NI_16 NS_58 0 5.3679932008879230e-07
GC_16_59 ref NI_16 NS_59 0 -1.0163355432650711e-03
GC_16_60 ref NI_16 NS_60 0 -2.1121680066492885e-04
GC_16_61 ref NI_16 NS_61 0 8.7957548315778511e-04
GC_16_62 ref NI_16 NS_62 0 2.4500886860168215e-03
GC_16_63 ref NI_16 NS_63 0 2.5669247904595744e-05
GC_16_64 ref NI_16 NS_64 0 -4.8906729074116824e-08
GC_16_65 ref NI_16 NS_65 0 -1.3473023856839525e-03
GC_16_66 ref NI_16 NS_66 0 1.2440281782396505e-05
GC_16_67 ref NI_16 NS_67 0 5.9095167936178052e-03
GC_16_68 ref NI_16 NS_68 0 3.5318529900641240e-04
GC_16_69 ref NI_16 NS_69 0 1.2690763562522040e-05
GC_16_70 ref NI_16 NS_70 0 4.2357629264479608e-07
GC_16_71 ref NI_16 NS_71 0 -2.7511212210283905e-03
GC_16_72 ref NI_16 NS_72 0 2.7142041363379700e-03
GC_16_73 ref NI_16 NS_73 0 4.4117352434258298e-03
GC_16_74 ref NI_16 NS_74 0 1.1423434022596770e-03
GC_16_75 ref NI_16 NS_75 0 1.9359724712283215e-05
GC_16_76 ref NI_16 NS_76 0 1.9801179717500256e-07
GC_16_77 ref NI_16 NS_77 0 -2.9027477225582340e-03
GC_16_78 ref NI_16 NS_78 0 3.3152537678771458e-03
GC_16_79 ref NI_16 NS_79 0 9.8625651222554716e-04
GC_16_80 ref NI_16 NS_80 0 2.3907796539641662e-03
GC_16_81 ref NI_16 NS_81 0 2.3898601538232996e-05
GC_16_82 ref NI_16 NS_82 0 6.3344900391932465e-08
GC_16_83 ref NI_16 NS_83 0 -1.1531572532925130e-03
GC_16_84 ref NI_16 NS_84 0 7.5462958430562042e-04
GC_16_85 ref NI_16 NS_85 0 2.5981861072274484e-03
GC_16_86 ref NI_16 NS_86 0 1.7340841355769638e-03
GC_16_87 ref NI_16 NS_87 0 2.0777572999356809e-05
GC_16_88 ref NI_16 NS_88 0 -4.0164265078282416e-07
GC_16_89 ref NI_16 NS_89 0 -1.5538847403032900e-03
GC_16_90 ref NI_16 NS_90 0 1.5232289142022226e-03
GC_16_91 ref NI_16 NS_91 0 -5.9793689451304151e-02
GC_16_92 ref NI_16 NS_92 0 -1.6427481670513010e-02
GC_16_93 ref NI_16 NS_93 0 -4.2374878606204108e-04
GC_16_94 ref NI_16 NS_94 0 -9.1065568690950823e-06
GC_16_95 ref NI_16 NS_95 0 -3.3181536962094714e-02
GC_16_96 ref NI_16 NS_96 0 4.9733873755300168e-02
GC_16_97 ref NI_16 NS_97 0 6.6183306155024133e-03
GC_16_98 ref NI_16 NS_98 0 -6.8690663552390171e-03
GC_16_99 ref NI_16 NS_99 0 -1.4378300354757747e-05
GC_16_100 ref NI_16 NS_100 0 9.1999263087182042e-06
GC_16_101 ref NI_16 NS_101 0 2.2389017816774038e-02
GC_16_102 ref NI_16 NS_102 0 -3.7099800261550527e-02
GC_16_103 ref NI_16 NS_103 0 5.3812798390864853e-03
GC_16_104 ref NI_16 NS_104 0 6.0223198064286352e-04
GC_16_105 ref NI_16 NS_105 0 1.0981634336417481e-05
GC_16_106 ref NI_16 NS_106 0 3.4432706266323055e-07
GC_16_107 ref NI_16 NS_107 0 -2.5888494103339559e-03
GC_16_108 ref NI_16 NS_108 0 2.6844902803544769e-03
GC_16_109 ref NI_16 NS_109 0 7.9037624420062076e-03
GC_16_110 ref NI_16 NS_110 0 -1.8133037995367966e-03
GC_16_111 ref NI_16 NS_111 0 5.1037574395942449e-06
GC_16_112 ref NI_16 NS_112 0 4.0508848869622165e-07
GC_16_113 ref NI_16 NS_113 0 1.6617259925955010e-03
GC_16_114 ref NI_16 NS_114 0 -5.9955252177972930e-03
GC_16_115 ref NI_16 NS_115 0 -8.2696263534823365e-04
GC_16_116 ref NI_16 NS_116 0 3.1534129026736329e-03
GC_16_117 ref NI_16 NS_117 0 2.8917587009096250e-05
GC_16_118 ref NI_16 NS_118 0 3.9921263266738192e-07
GC_16_119 ref NI_16 NS_119 0 -8.5386301244587924e-04
GC_16_120 ref NI_16 NS_120 0 -2.3826366089697534e-04
GC_16_121 ref NI_16 NS_121 0 1.0951855501707532e-03
GC_16_122 ref NI_16 NS_122 0 2.2831456725422223e-03
GC_16_123 ref NI_16 NS_123 0 2.3545281784070655e-05
GC_16_124 ref NI_16 NS_124 0 7.2988111868736364e-08
GC_16_125 ref NI_16 NS_125 0 -1.0665593610875046e-03
GC_16_126 ref NI_16 NS_126 0 7.4627915358566589e-05
GC_16_127 ref NI_16 NS_127 0 1.5868321388002313e-03
GC_16_128 ref NI_16 NS_128 0 2.4393608554422138e-03
GC_16_129 ref NI_16 NS_129 0 1.4107498018753230e-06
GC_16_130 ref NI_16 NS_130 0 7.5422902451061291e-07
GC_16_131 ref NI_16 NS_131 0 -1.6176433543631545e-03
GC_16_132 ref NI_16 NS_132 0 4.0414089807528364e-03
GD_16_1 ref NI_16 NA_1 0 5.5971701841131764e-03
GD_16_2 ref NI_16 NA_2 0 -8.1342950007982171e-03
GD_16_3 ref NI_16 NA_3 0 -3.2309702217020523e-04
GD_16_4 ref NI_16 NA_4 0 2.3273275430263978e-03
GD_16_5 ref NI_16 NA_5 0 -3.6088485184287061e-04
GD_16_6 ref NI_16 NA_6 0 1.7043723441758012e-02
GD_16_7 ref NI_16 NA_7 0 1.0103604290132835e-02
GD_16_8 ref NI_16 NA_8 0 9.4600934364111279e-04
GD_16_9 ref NI_16 NA_9 0 -6.9080449535755594e-05
GD_16_10 ref NI_16 NA_10 0 1.0739414780642719e-03
GD_16_11 ref NI_16 NA_11 0 1.1632653239129977e-03
GD_16_12 ref NI_16 NA_12 0 2.6839865743620225e-03
GD_16_13 ref NI_16 NA_13 0 8.4946250272683156e-04
GD_16_14 ref NI_16 NA_14 0 1.3064973314522838e-03
GD_16_15 ref NI_16 NA_15 0 1.2388332944350800e-03
GD_16_16 ref NI_16 NA_16 0 6.1645606456905098e+00
GD_16_17 ref NI_16 NA_17 0 5.1217995795992746e-02
GD_16_18 ref NI_16 NA_18 0 2.2266710092191688e-03
GD_16_19 ref NI_16 NA_19 0 7.0880407448233656e-03
GD_16_20 ref NI_16 NA_20 0 1.2007104975234808e-03
GD_16_21 ref NI_16 NA_21 0 1.7149448203934909e-03
GD_16_22 ref NI_16 NA_22 0 -1.1399631248750208e-03
*
* Port 17
VI_17 a_17 NI_17 0
RI_17 NI_17 ref 1.0000000000000001e-01
GC_17_1 ref NI_17 NS_1 0 -4.0860810059786083e-03
GC_17_2 ref NI_17 NS_2 0 4.0643169410999550e-03
GC_17_3 ref NI_17 NS_3 0 9.1291911021273682e-05
GC_17_4 ref NI_17 NS_4 0 2.0181312207629890e-06
GC_17_5 ref NI_17 NS_5 0 2.0285647719924641e-04
GC_17_6 ref NI_17 NS_6 0 -4.2345073340750421e-03
GC_17_7 ref NI_17 NS_7 0 1.2935420038489940e-03
GC_17_8 ref NI_17 NS_8 0 -4.6077786895592734e-04
GC_17_9 ref NI_17 NS_9 0 -4.1155705350849612e-06
GC_17_10 ref NI_17 NS_10 0 1.0996179880215255e-06
GC_17_11 ref NI_17 NS_11 0 1.6443173826548828e-02
GC_17_12 ref NI_17 NS_12 0 1.6104431736878377e-02
GC_17_13 ref NI_17 NS_13 0 2.2151829432916167e-03
GC_17_14 ref NI_17 NS_14 0 2.1534516573098049e-03
GC_17_15 ref NI_17 NS_15 0 1.6433805777497670e-05
GC_17_16 ref NI_17 NS_16 0 1.1957495951845033e-06
GC_17_17 ref NI_17 NS_17 0 -2.8404362220530743e-03
GC_17_18 ref NI_17 NS_18 0 1.8081854260958115e-03
GC_17_19 ref NI_17 NS_19 0 6.6792832123123121e-03
GC_17_20 ref NI_17 NS_20 0 -1.0664222603146681e-03
GC_17_21 ref NI_17 NS_21 0 1.5919514020800684e-05
GC_17_22 ref NI_17 NS_22 0 3.1740619423426506e-07
GC_17_23 ref NI_17 NS_23 0 -1.6640674930038931e-03
GC_17_24 ref NI_17 NS_24 0 -1.6042707427158239e-02
GC_17_25 ref NI_17 NS_25 0 3.7247414070365973e-03
GC_17_26 ref NI_17 NS_26 0 1.7564351475502647e-03
GC_17_27 ref NI_17 NS_27 0 -3.0026165981927065e-07
GC_17_28 ref NI_17 NS_28 0 6.8085605087315517e-07
GC_17_29 ref NI_17 NS_29 0 -3.3365351820335699e-03
GC_17_30 ref NI_17 NS_30 0 5.0415485447820639e-03
GC_17_31 ref NI_17 NS_31 0 -7.1241569335206874e-03
GC_17_32 ref NI_17 NS_32 0 -3.4229574391080944e-03
GC_17_33 ref NI_17 NS_33 0 2.4247184537985113e-05
GC_17_34 ref NI_17 NS_34 0 4.8625970458240667e-07
GC_17_35 ref NI_17 NS_35 0 4.1814099757233013e-02
GC_17_36 ref NI_17 NS_36 0 -2.7321158928224003e-02
GC_17_37 ref NI_17 NS_37 0 7.5174796445314019e-03
GC_17_38 ref NI_17 NS_38 0 -8.2184766072247977e-04
GC_17_39 ref NI_17 NS_39 0 2.4018978377431076e-05
GC_17_40 ref NI_17 NS_40 0 2.5134111706938179e-07
GC_17_41 ref NI_17 NS_41 0 -4.8347781262688960e-03
GC_17_42 ref NI_17 NS_42 0 -1.4545098872313792e-02
GC_17_43 ref NI_17 NS_43 0 3.9664128566588332e-03
GC_17_44 ref NI_17 NS_44 0 1.5585519670626112e-03
GC_17_45 ref NI_17 NS_45 0 1.5779309244156215e-05
GC_17_46 ref NI_17 NS_46 0 8.0756786755787614e-07
GC_17_47 ref NI_17 NS_47 0 -4.0146402851569214e-03
GC_17_48 ref NI_17 NS_48 0 2.4511696674935930e-03
GC_17_49 ref NI_17 NS_49 0 4.2800948867379564e-03
GC_17_50 ref NI_17 NS_50 0 1.5610835719778410e-03
GC_17_51 ref NI_17 NS_51 0 2.6179564005092553e-06
GC_17_52 ref NI_17 NS_52 0 6.8316387328078698e-07
GC_17_53 ref NI_17 NS_53 0 -4.0299476860755686e-03
GC_17_54 ref NI_17 NS_54 0 3.8514908051293264e-03
GC_17_55 ref NI_17 NS_55 0 -5.6994721719920394e-04
GC_17_56 ref NI_17 NS_56 0 2.9422292391482530e-03
GC_17_57 ref NI_17 NS_57 0 2.7434361800394764e-05
GC_17_58 ref NI_17 NS_58 0 8.3843873526118674e-07
GC_17_59 ref NI_17 NS_59 0 -9.2191917429264672e-04
GC_17_60 ref NI_17 NS_60 0 -2.0505432711495023e-03
GC_17_61 ref NI_17 NS_61 0 -9.3642183348903983e-04
GC_17_62 ref NI_17 NS_62 0 3.0482336041802015e-03
GC_17_63 ref NI_17 NS_63 0 2.9817211044070558e-05
GC_17_64 ref NI_17 NS_64 0 7.4784936893692157e-07
GC_17_65 ref NI_17 NS_65 0 -5.8163899878682515e-04
GC_17_66 ref NI_17 NS_66 0 -2.1056629663618355e-03
GC_17_67 ref NI_17 NS_67 0 8.5944238949366893e-03
GC_17_68 ref NI_17 NS_68 0 -2.1984689408638507e-03
GC_17_69 ref NI_17 NS_69 0 8.6077739354470072e-06
GC_17_70 ref NI_17 NS_70 0 2.6429862724577720e-07
GC_17_71 ref NI_17 NS_71 0 1.7527254428914975e-03
GC_17_72 ref NI_17 NS_72 0 -6.0399065091482568e-03
GC_17_73 ref NI_17 NS_73 0 7.4570505911156649e-03
GC_17_74 ref NI_17 NS_74 0 -6.3395510978239873e-04
GC_17_75 ref NI_17 NS_75 0 6.1509587542752960e-06
GC_17_76 ref NI_17 NS_76 0 -6.5740937598327374e-08
GC_17_77 ref NI_17 NS_77 0 -1.5327431661675205e-03
GC_17_78 ref NI_17 NS_78 0 2.6147818487862154e-03
GC_17_79 ref NI_17 NS_79 0 -6.1387105387918377e-04
GC_17_80 ref NI_17 NS_80 0 3.0340176253606486e-03
GC_17_81 ref NI_17 NS_81 0 3.5052069721120996e-05
GC_17_82 ref NI_17 NS_82 0 3.6203339303622939e-07
GC_17_83 ref NI_17 NS_83 0 -1.0798775331448106e-03
GC_17_84 ref NI_17 NS_84 0 -8.5476543634039823e-04
GC_17_85 ref NI_17 NS_85 0 4.7711053918079950e-04
GC_17_86 ref NI_17 NS_86 0 2.5378643715251187e-03
GC_17_87 ref NI_17 NS_87 0 2.4474998937183795e-05
GC_17_88 ref NI_17 NS_88 0 2.7071058098208008e-07
GC_17_89 ref NI_17 NS_89 0 -8.3260027151586770e-04
GC_17_90 ref NI_17 NS_90 0 2.0386285846648271e-04
GC_17_91 ref NI_17 NS_91 0 6.6183306155024940e-03
GC_17_92 ref NI_17 NS_92 0 -6.8690663552390535e-03
GC_17_93 ref NI_17 NS_93 0 -1.4378300354750787e-05
GC_17_94 ref NI_17 NS_94 0 9.1999263087180298e-06
GC_17_95 ref NI_17 NS_95 0 2.2389017816773993e-02
GC_17_96 ref NI_17 NS_96 0 -3.7099800261550339e-02
GC_17_97 ref NI_17 NS_97 0 -5.6696581632914217e-02
GC_17_98 ref NI_17 NS_98 0 -1.4735570953891474e-02
GC_17_99 ref NI_17 NS_99 0 -4.3448570392267256e-04
GC_17_100 ref NI_17 NS_100 0 -1.2307989262699994e-05
GC_17_101 ref NI_17 NS_101 0 -4.5178302894314223e-02
GC_17_102 ref NI_17 NS_102 0 6.2555324469570142e-02
GC_17_103 ref NI_17 NS_103 0 3.1998719075124024e-03
GC_17_104 ref NI_17 NS_104 0 1.6559394844649488e-03
GC_17_105 ref NI_17 NS_105 0 2.3985669965358549e-05
GC_17_106 ref NI_17 NS_106 0 3.2255518383578630e-07
GC_17_107 ref NI_17 NS_107 0 -2.6090601979773475e-03
GC_17_108 ref NI_17 NS_108 0 3.0717533117826314e-03
GC_17_109 ref NI_17 NS_109 0 6.2269474182825397e-03
GC_17_110 ref NI_17 NS_110 0 2.4349448285967670e-05
GC_17_111 ref NI_17 NS_111 0 1.0593167099334932e-05
GC_17_112 ref NI_17 NS_112 0 2.1235150689017851e-07
GC_17_113 ref NI_17 NS_113 0 -1.8533744414814188e-03
GC_17_114 ref NI_17 NS_114 0 2.7964428950976766e-03
GC_17_115 ref NI_17 NS_115 0 1.1447749541115366e-03
GC_17_116 ref NI_17 NS_116 0 2.4695996519358112e-03
GC_17_117 ref NI_17 NS_117 0 1.0459804925074799e-05
GC_17_118 ref NI_17 NS_118 0 5.2578028545261890e-07
GC_17_119 ref NI_17 NS_119 0 -1.1969933657834187e-03
GC_17_120 ref NI_17 NS_120 0 3.1454241667275783e-03
GC_17_121 ref NI_17 NS_121 0 3.5299929086828269e-03
GC_17_122 ref NI_17 NS_122 0 1.3539833534187827e-03
GC_17_123 ref NI_17 NS_123 0 1.2959376825989289e-05
GC_17_124 ref NI_17 NS_124 0 -1.6437216559523470e-07
GC_17_125 ref NI_17 NS_125 0 -1.7364827272279110e-03
GC_17_126 ref NI_17 NS_126 0 2.1899624289923392e-03
GC_17_127 ref NI_17 NS_127 0 3.4128954124444475e-03
GC_17_128 ref NI_17 NS_128 0 2.1039032648268625e-03
GC_17_129 ref NI_17 NS_129 0 -5.1230416982758492e-06
GC_17_130 ref NI_17 NS_130 0 7.9508184020770518e-07
GC_17_131 ref NI_17 NS_131 0 -3.5314376084637608e-03
GC_17_132 ref NI_17 NS_132 0 7.7780992640244274e-03
GD_17_1 ref NI_17 NA_1 0 4.9015922341986515e-03
GD_17_2 ref NI_17 NA_2 0 -6.8220509832818636e-03
GD_17_3 ref NI_17 NA_3 0 -6.5714500995533315e-04
GD_17_4 ref NI_17 NA_4 0 4.6188823176230159e-03
GD_17_5 ref NI_17 NA_5 0 -1.4020426645425473e-03
GD_17_6 ref NI_17 NA_6 0 3.8958575818230347e-02
GD_17_7 ref NI_17 NA_7 0 2.7703101527972113e-03
GD_17_8 ref NI_17 NA_8 0 -2.7280583518103678e-04
GD_17_9 ref NI_17 NA_9 0 -8.0925677972763571e-04
GD_17_10 ref NI_17 NA_10 0 1.6630928223035745e-03
GD_17_11 ref NI_17 NA_11 0 2.0697851376548452e-03
GD_17_12 ref NI_17 NA_12 0 8.3765721282839673e-03
GD_17_13 ref NI_17 NA_13 0 4.1740064811592514e-03
GD_17_14 ref NI_17 NA_14 0 1.4488406147858211e-03
GD_17_15 ref NI_17 NA_15 0 1.5259044191133504e-03
GD_17_16 ref NI_17 NA_16 0 5.1217995795992746e-02
GD_17_17 ref NI_17 NA_17 0 6.1557978554700314e+00
GD_17_18 ref NI_17 NA_18 0 9.1096660718902977e-04
GD_17_19 ref NI_17 NA_19 0 3.7036126577213121e-03
GD_17_20 ref NI_17 NA_20 0 5.4459646356059578e-04
GD_17_21 ref NI_17 NA_21 0 1.5990442272803107e-03
GD_17_22 ref NI_17 NA_22 0 -2.3853459472693290e-03
*
* Port 18
VI_18 a_18 NI_18 0
RI_18 NI_18 ref 1.0000000000000001e-01
GC_18_1 ref NI_18 NS_1 0 -8.1466906716351809e-04
GC_18_2 ref NI_18 NS_2 0 2.9125387053465799e-03
GC_18_3 ref NI_18 NS_3 0 5.7705969784570706e-05
GC_18_4 ref NI_18 NS_4 0 1.4120599421769945e-06
GC_18_5 ref NI_18 NS_5 0 -5.5839138934783792e-04
GC_18_6 ref NI_18 NS_6 0 -8.2234724074136593e-04
GC_18_7 ref NI_18 NS_7 0 2.0336337137601451e-03
GC_18_8 ref NI_18 NS_8 0 -5.6499011552556071e-04
GC_18_9 ref NI_18 NS_9 0 1.9720471886530298e-06
GC_18_10 ref NI_18 NS_10 0 1.2021858209684357e-07
GC_18_11 ref NI_18 NS_11 0 1.5770772951414443e-02
GC_18_12 ref NI_18 NS_12 0 1.8656254277698112e-02
GC_18_13 ref NI_18 NS_13 0 7.0725708090815373e-03
GC_18_14 ref NI_18 NS_14 0 -6.6875272873603722e-04
GC_18_15 ref NI_18 NS_15 0 -1.1284976320666430e-06
GC_18_16 ref NI_18 NS_16 0 -4.2980664988553192e-08
GC_18_17 ref NI_18 NS_17 0 -9.3485777119868129e-04
GC_18_18 ref NI_18 NS_18 0 -1.6558974612127027e-03
GC_18_19 ref NI_18 NS_19 0 1.5079072124445151e-03
GC_18_20 ref NI_18 NS_20 0 2.0221877345192370e-03
GC_18_21 ref NI_18 NS_21 0 2.1459041312121210e-05
GC_18_22 ref NI_18 NS_22 0 7.2585294426472309e-07
GC_18_23 ref NI_18 NS_23 0 -9.3877919772730398e-04
GC_18_24 ref NI_18 NS_24 0 -5.4205067910963179e-04
GC_18_25 ref NI_18 NS_25 0 -2.3163796149552811e-03
GC_18_26 ref NI_18 NS_26 0 3.5092091121975174e-03
GC_18_27 ref NI_18 NS_27 0 3.7117764775742670e-05
GC_18_28 ref NI_18 NS_28 0 7.5325057842115106e-07
GC_18_29 ref NI_18 NS_29 0 2.0999791531989579e-04
GC_18_30 ref NI_18 NS_30 0 -3.4130903562377595e-03
GC_18_31 ref NI_18 NS_31 0 4.2692959074571366e-03
GC_18_32 ref NI_18 NS_32 0 7.3983167467583401e-04
GC_18_33 ref NI_18 NS_33 0 1.3104038187361883e-05
GC_18_34 ref NI_18 NS_34 0 1.0746471275228067e-06
GC_18_35 ref NI_18 NS_35 0 -1.3475318245800261e-03
GC_18_36 ref NI_18 NS_36 0 -4.6496026670529201e-04
GC_18_37 ref NI_18 NS_37 0 6.0480453286272584e-03
GC_18_38 ref NI_18 NS_38 0 -2.5201306045609119e-03
GC_18_39 ref NI_18 NS_39 0 2.2565239679200815e-05
GC_18_40 ref NI_18 NS_40 0 1.2724321919789986e-06
GC_18_41 ref NI_18 NS_41 0 6.0641299567512049e-03
GC_18_42 ref NI_18 NS_42 0 -1.9304002305536715e-02
GC_18_43 ref NI_18 NS_43 0 5.3831402716118170e-03
GC_18_44 ref NI_18 NS_44 0 -2.2424235279426006e-03
GC_18_45 ref NI_18 NS_45 0 2.1784663738541466e-06
GC_18_46 ref NI_18 NS_46 0 -5.2037950614750604e-07
GC_18_47 ref NI_18 NS_47 0 1.0094448534187461e-02
GC_18_48 ref NI_18 NS_48 0 -6.9321962802417576e-03
GC_18_49 ref NI_18 NS_49 0 -4.2436981545867537e-04
GC_18_50 ref NI_18 NS_50 0 3.0303764448367421e-03
GC_18_51 ref NI_18 NS_51 0 2.2297712405112648e-05
GC_18_52 ref NI_18 NS_52 0 1.3526482802077831e-06
GC_18_53 ref NI_18 NS_53 0 -8.9578972346871985e-04
GC_18_54 ref NI_18 NS_54 0 7.7596060628190859e-04
GC_18_55 ref NI_18 NS_55 0 5.3320995357135715e-03
GC_18_56 ref NI_18 NS_56 0 8.0449944568468856e-04
GC_18_57 ref NI_18 NS_57 0 -2.0077758622593314e-05
GC_18_58 ref NI_18 NS_58 0 1.3088719829141960e-06
GC_18_59 ref NI_18 NS_59 0 -2.3659949774508882e-03
GC_18_60 ref NI_18 NS_60 0 4.9591981500600960e-03
GC_18_61 ref NI_18 NS_61 0 5.9288256354304899e-03
GC_18_62 ref NI_18 NS_62 0 6.0528682387135581e-04
GC_18_63 ref NI_18 NS_63 0 -6.1938096019210470e-06
GC_18_64 ref NI_18 NS_64 0 4.1267136732467008e-08
GC_18_65 ref NI_18 NS_65 0 -2.8068311314042005e-03
GC_18_66 ref NI_18 NS_66 0 5.4324814377290339e-03
GC_18_67 ref NI_18 NS_67 0 4.4033414035703580e-04
GC_18_68 ref NI_18 NS_68 0 2.4566639039562944e-03
GC_18_69 ref NI_18 NS_69 0 3.7734845938373619e-05
GC_18_70 ref NI_18 NS_70 0 -2.9392412456793911e-09
GC_18_71 ref NI_18 NS_71 0 -8.5551275223159874e-04
GC_18_72 ref NI_18 NS_72 0 -9.8994250125295446e-04
GC_18_73 ref NI_18 NS_73 0 -3.4463404921660998e-04
GC_18_74 ref NI_18 NS_74 0 2.7979137298141028e-03
GC_18_75 ref NI_18 NS_75 0 4.2698163999117756e-05
GC_18_76 ref NI_18 NS_76 0 2.1836608496090329e-07
GC_18_77 ref NI_18 NS_77 0 -1.0033788766504524e-03
GC_18_78 ref NI_18 NS_78 0 -1.9762238509309902e-03
GC_18_79 ref NI_18 NS_79 0 7.1124973414737605e-03
GC_18_80 ref NI_18 NS_80 0 1.5794640484121460e-04
GC_18_81 ref NI_18 NS_81 0 -8.5545536874294301e-06
GC_18_82 ref NI_18 NS_82 0 3.3925121251128812e-07
GC_18_83 ref NI_18 NS_83 0 -3.3849939080072529e-03
GC_18_84 ref NI_18 NS_84 0 6.3308562401495324e-03
GC_18_85 ref NI_18 NS_85 0 9.2718092354552688e-03
GC_18_86 ref NI_18 NS_86 0 -2.0573931316940257e-03
GC_18_87 ref NI_18 NS_87 0 -1.3027047160188710e-05
GC_18_88 ref NI_18 NS_88 0 3.1961874256992754e-07
GC_18_89 ref NI_18 NS_89 0 7.4814733107257507e-04
GC_18_90 ref NI_18 NS_90 0 -2.4225469553906006e-03
GC_18_91 ref NI_18 NS_91 0 5.3812798390865295e-03
GC_18_92 ref NI_18 NS_92 0 6.0223198064283977e-04
GC_18_93 ref NI_18 NS_93 0 1.0981634336422577e-05
GC_18_94 ref NI_18 NS_94 0 3.4432706266259988e-07
GC_18_95 ref NI_18 NS_95 0 -2.5888494103339784e-03
GC_18_96 ref NI_18 NS_96 0 2.6844902803545645e-03
GC_18_97 ref NI_18 NS_97 0 3.1998719075123660e-03
GC_18_98 ref NI_18 NS_98 0 1.6559394844649655e-03
GC_18_99 ref NI_18 NS_99 0 2.3985669965355134e-05
GC_18_100 ref NI_18 NS_100 0 3.2255518383611590e-07
GC_18_101 ref NI_18 NS_101 0 -2.6090601979773280e-03
GC_18_102 ref NI_18 NS_102 0 3.0717533117825451e-03
GC_18_103 ref NI_18 NS_103 0 -5.7982880581239390e-02
GC_18_104 ref NI_18 NS_104 0 -1.6663766873212089e-02
GC_18_105 ref NI_18 NS_105 0 -4.4468394086522701e-04
GC_18_106 ref NI_18 NS_106 0 -1.1448470558781173e-05
GC_18_107 ref NI_18 NS_107 0 -3.4774882199744291e-02
GC_18_108 ref NI_18 NS_108 0 5.2698926979626852e-02
GC_18_109 ref NI_18 NS_109 0 7.4870103607978045e-03
GC_18_110 ref NI_18 NS_110 0 -7.1297249302877293e-03
GC_18_111 ref NI_18 NS_111 0 -2.7639524293376113e-05
GC_18_112 ref NI_18 NS_112 0 8.9138328107200622e-06
GC_18_113 ref NI_18 NS_113 0 2.2336327845030906e-02
GC_18_114 ref NI_18 NS_114 0 -3.5187855731054596e-02
GC_18_115 ref NI_18 NS_115 0 -3.8464487514647768e-03
GC_18_116 ref NI_18 NS_116 0 3.9404135939472033e-03
GC_18_117 ref NI_18 NS_117 0 6.0677681242419052e-05
GC_18_118 ref NI_18 NS_118 0 4.6648192769419610e-07
GC_18_119 ref NI_18 NS_119 0 6.4249425972348856e-04
GC_18_120 ref NI_18 NS_120 0 -6.0868508656475454e-03
GC_18_121 ref NI_18 NS_121 0 -2.1911353131186442e-03
GC_18_122 ref NI_18 NS_122 0 3.3031229496930108e-03
GC_18_123 ref NI_18 NS_123 0 4.9936019132672678e-05
GC_18_124 ref NI_18 NS_124 0 1.1579278767057749e-07
GC_18_125 ref NI_18 NS_125 0 2.9116215068887444e-04
GC_18_126 ref NI_18 NS_126 0 -4.8866944985694050e-03
GC_18_127 ref NI_18 NS_127 0 -1.3117854544127065e-03
GC_18_128 ref NI_18 NS_128 0 3.1618312152708792e-03
GC_18_129 ref NI_18 NS_129 0 4.0602561321334969e-05
GC_18_130 ref NI_18 NS_130 0 1.4849938434379171e-06
GC_18_131 ref NI_18 NS_131 0 -1.3911164454417512e-04
GC_18_132 ref NI_18 NS_132 0 -6.1482392826655349e-04
GD_18_1 ref NI_18 NA_1 0 5.1513276921904784e-03
GD_18_2 ref NI_18 NA_2 0 -8.2045733044707522e-03
GD_18_3 ref NI_18 NA_3 0 1.5289120456543478e-03
GD_18_4 ref NI_18 NA_4 0 4.1148431816096946e-04
GD_18_5 ref NI_18 NA_5 0 1.3982512293740073e-03
GD_18_6 ref NI_18 NA_6 0 2.7889875966975058e-03
GD_18_7 ref NI_18 NA_7 0 1.5084514913171665e-02
GD_18_8 ref NI_18 NA_8 0 9.7739775925262014e-03
GD_18_9 ref NI_18 NA_9 0 1.5434314589660942e-04
GD_18_10 ref NI_18 NA_10 0 2.8859629413047227e-04
GD_18_11 ref NI_18 NA_11 0 5.0102097970273162e-04
GD_18_12 ref NI_18 NA_12 0 2.0750082190968363e-03
GD_18_13 ref NI_18 NA_13 0 1.6981691046598240e-03
GD_18_14 ref NI_18 NA_14 0 1.1161509070768815e-03
GD_18_15 ref NI_18 NA_15 0 5.4798350455017705e-03
GD_18_16 ref NI_18 NA_16 0 2.2266710092191688e-03
GD_18_17 ref NI_18 NA_17 0 9.1096660718902977e-04
GD_18_18 ref NI_18 NA_18 0 6.1631324391697992e+00
GD_18_19 ref NI_18 NA_19 0 5.0557239886711333e-02
GD_18_20 ref NI_18 NA_20 0 3.2860038995013016e-03
GD_18_21 ref NI_18 NA_21 0 3.0318421705596370e-03
GD_18_22 ref NI_18 NA_22 0 2.6129117445780929e-04
*
* Port 19
VI_19 a_19 NI_19 0
RI_19 NI_19 ref 1.0000000000000001e-01
GC_19_1 ref NI_19 NS_1 0 -1.8818781710834306e-03
GC_19_2 ref NI_19 NS_2 0 3.5275731480594119e-03
GC_19_3 ref NI_19 NS_3 0 6.6152877687481612e-05
GC_19_4 ref NI_19 NS_4 0 1.6878941322395022e-06
GC_19_5 ref NI_19 NS_5 0 -1.1595468077826238e-03
GC_19_6 ref NI_19 NS_6 0 -6.8043807824927946e-04
GC_19_7 ref NI_19 NS_7 0 1.3874394923303721e-03
GC_19_8 ref NI_19 NS_8 0 -5.2409130678288162e-04
GC_19_9 ref NI_19 NS_9 0 -5.4407683755628879e-06
GC_19_10 ref NI_19 NS_10 0 6.4472647059374239e-07
GC_19_11 ref NI_19 NS_11 0 1.7232210747963796e-02
GC_19_12 ref NI_19 NS_12 0 1.8723152808457648e-02
GC_19_13 ref NI_19 NS_13 0 7.3025403176479467e-03
GC_19_14 ref NI_19 NS_14 0 2.4378966813511498e-04
GC_19_15 ref NI_19 NS_15 0 1.9269327319956457e-06
GC_19_16 ref NI_19 NS_16 0 6.0573666656854228e-07
GC_19_17 ref NI_19 NS_17 0 -5.3227306591105659e-03
GC_19_18 ref NI_19 NS_18 0 2.9498337514276781e-03
GC_19_19 ref NI_19 NS_19 0 3.6341175539353629e-03
GC_19_20 ref NI_19 NS_20 0 1.3162599605128931e-03
GC_19_21 ref NI_19 NS_21 0 1.8688643862343339e-05
GC_19_22 ref NI_19 NS_22 0 3.3533928770159770e-07
GC_19_23 ref NI_19 NS_23 0 -2.9478726166186874e-03
GC_19_24 ref NI_19 NS_24 0 -2.1633949057182395e-03
GC_19_25 ref NI_19 NS_25 0 -9.5289916140439571e-04
GC_19_26 ref NI_19 NS_26 0 3.2640270748887077e-03
GC_19_27 ref NI_19 NS_27 0 2.5723374267156662e-05
GC_19_28 ref NI_19 NS_28 0 5.2532775843013686e-07
GC_19_29 ref NI_19 NS_29 0 -1.0901163848624574e-03
GC_19_30 ref NI_19 NS_30 0 -9.8150711973865449e-04
GC_19_31 ref NI_19 NS_31 0 5.9319419999908779e-03
GC_19_32 ref NI_19 NS_32 0 -4.8432575626329788e-04
GC_19_33 ref NI_19 NS_33 0 2.0599106856713809e-05
GC_19_34 ref NI_19 NS_34 0 2.3011907535087091e-07
GC_19_35 ref NI_19 NS_35 0 -2.1294855191809083e-03
GC_19_36 ref NI_19 NS_36 0 -1.2964708387288675e-02
GC_19_37 ref NI_19 NS_37 0 -6.8612815723506602e-03
GC_19_38 ref NI_19 NS_38 0 -3.6481297176382652e-03
GC_19_39 ref NI_19 NS_39 0 1.6632629620077618e-05
GC_19_40 ref NI_19 NS_40 0 4.9725082219051380e-07
GC_19_41 ref NI_19 NS_41 0 4.2220164398640084e-02
GC_19_42 ref NI_19 NS_42 0 -2.9177036764370248e-02
GC_19_43 ref NI_19 NS_43 0 9.2295966801960588e-03
GC_19_44 ref NI_19 NS_44 0 -1.2370173379443804e-03
GC_19_45 ref NI_19 NS_45 0 1.1615471898270905e-05
GC_19_46 ref NI_19 NS_46 0 2.3743380650133174e-07
GC_19_47 ref NI_19 NS_47 0 -6.0638280617691760e-03
GC_19_48 ref NI_19 NS_48 0 -1.1464839528529886e-02
GC_19_49 ref NI_19 NS_49 0 8.3832235247477307e-04
GC_19_50 ref NI_19 NS_50 0 2.8538751669830950e-03
GC_19_51 ref NI_19 NS_51 0 1.3258323856975741e-05
GC_19_52 ref NI_19 NS_52 0 7.0009434300694365e-07
GC_19_53 ref NI_19 NS_53 0 -2.3931711332800514e-03
GC_19_54 ref NI_19 NS_54 0 2.5350391786102969e-03
GC_19_55 ref NI_19 NS_55 0 3.5807624398570470e-03
GC_19_56 ref NI_19 NS_56 0 1.6031590862320821e-03
GC_19_57 ref NI_19 NS_57 0 4.8204792366316940e-07
GC_19_58 ref NI_19 NS_58 0 4.2923809197332117e-07
GC_19_59 ref NI_19 NS_59 0 -2.5665062095633455e-03
GC_19_60 ref NI_19 NS_60 0 3.7453102212390509e-03
GC_19_61 ref NI_19 NS_61 0 3.4919457545586792e-03
GC_19_62 ref NI_19 NS_62 0 1.5662526275865662e-03
GC_19_63 ref NI_19 NS_63 0 -1.2959213847287294e-06
GC_19_64 ref NI_19 NS_64 0 4.0196807436104625e-07
GC_19_65 ref NI_19 NS_65 0 -1.9733098990335021e-03
GC_19_66 ref NI_19 NS_66 0 4.4228668902306619e-03
GC_19_67 ref NI_19 NS_67 0 2.4198166566319337e-03
GC_19_68 ref NI_19 NS_68 0 1.6525968048534032e-03
GC_19_69 ref NI_19 NS_69 0 3.0312798033287013e-05
GC_19_70 ref NI_19 NS_70 0 -4.2664247234738974e-07
GC_19_71 ref NI_19 NS_71 0 -1.2588552644518902e-03
GC_19_72 ref NI_19 NS_72 0 1.7442091091782167e-04
GC_19_73 ref NI_19 NS_73 0 1.1034549260598410e-03
GC_19_74 ref NI_19 NS_74 0 2.1605761415715184e-03
GC_19_75 ref NI_19 NS_75 0 2.6954840717865730e-05
GC_19_76 ref NI_19 NS_76 0 1.4622427223115329e-07
GC_19_77 ref NI_19 NS_77 0 -6.9117951191727039e-04
GC_19_78 ref NI_19 NS_78 0 -3.1808501034354131e-04
GC_19_79 ref NI_19 NS_79 0 4.5969314417155134e-03
GC_19_80 ref NI_19 NS_80 0 1.3602077411060801e-03
GC_19_81 ref NI_19 NS_81 0 4.3438661240965605e-06
GC_19_82 ref NI_19 NS_82 0 2.3302467058254228e-07
GC_19_83 ref NI_19 NS_83 0 -3.3877485456462546e-03
GC_19_84 ref NI_19 NS_84 0 6.2781297016464201e-03
GC_19_85 ref NI_19 NS_85 0 7.0833262333365073e-03
GC_19_86 ref NI_19 NS_86 0 -1.3245183574217919e-04
GC_19_87 ref NI_19 NS_87 0 -7.5844274122003729e-06
GC_19_88 ref NI_19 NS_88 0 1.3243187371959795e-07
GC_19_89 ref NI_19 NS_89 0 -2.1493958532314305e-03
GC_19_90 ref NI_19 NS_90 0 5.3656479708947330e-03
GC_19_91 ref NI_19 NS_91 0 7.9037624420062146e-03
GC_19_92 ref NI_19 NS_92 0 -1.8133037995368025e-03
GC_19_93 ref NI_19 NS_93 0 5.1037574395956637e-06
GC_19_94 ref NI_19 NS_94 0 4.0508848869646374e-07
GC_19_95 ref NI_19 NS_95 0 1.6617259925954986e-03
GC_19_96 ref NI_19 NS_96 0 -5.9955252177972974e-03
GC_19_97 ref NI_19 NS_97 0 6.2269474182824851e-03
GC_19_98 ref NI_19 NS_98 0 2.4349448285993714e-05
GC_19_99 ref NI_19 NS_99 0 1.0593167099329945e-05
GC_19_100 ref NI_19 NS_100 0 2.1235150689055014e-07
GC_19_101 ref NI_19 NS_101 0 -1.8533744414813882e-03
GC_19_102 ref NI_19 NS_102 0 2.7964428950975556e-03
GC_19_103 ref NI_19 NS_103 0 7.4870103607978002e-03
GC_19_104 ref NI_19 NS_104 0 -7.1297249302877249e-03
GC_19_105 ref NI_19 NS_105 0 -2.7639524293377258e-05
GC_19_106 ref NI_19 NS_106 0 8.9138328107200876e-06
GC_19_107 ref NI_19 NS_107 0 2.2336327845030906e-02
GC_19_108 ref NI_19 NS_108 0 -3.5187855731054596e-02
GC_19_109 ref NI_19 NS_109 0 -5.7872325084573059e-02
GC_19_110 ref NI_19 NS_110 0 -1.4509012078145722e-02
GC_19_111 ref NI_19 NS_111 0 -3.8581426418299579e-04
GC_19_112 ref NI_19 NS_112 0 -8.5397382314908209e-06
GC_19_113 ref NI_19 NS_113 0 -4.6157886556953687e-02
GC_19_114 ref NI_19 NS_114 0 6.0393544947748054e-02
GC_19_115 ref NI_19 NS_115 0 -3.1097127532101788e-03
GC_19_116 ref NI_19 NS_116 0 3.7623602364061886e-03
GC_19_117 ref NI_19 NS_117 0 4.1052766571553704e-05
GC_19_118 ref NI_19 NS_118 0 7.1268033661781313e-07
GC_19_119 ref NI_19 NS_119 0 5.0476500349399243e-04
GC_19_120 ref NI_19 NS_120 0 -4.4145753717369845e-03
GC_19_121 ref NI_19 NS_121 0 -9.5151496531142789e-04
GC_19_122 ref NI_19 NS_122 0 2.9587402486745936e-03
GC_19_123 ref NI_19 NS_123 0 4.1013664475667904e-05
GC_19_124 ref NI_19 NS_124 0 -2.8793670394741893e-07
GC_19_125 ref NI_19 NS_125 0 -3.6560220298812493e-04
GC_19_126 ref NI_19 NS_126 0 -3.1089196381564560e-03
GC_19_127 ref NI_19 NS_127 0 -2.6334434445557750e-04
GC_19_128 ref NI_19 NS_128 0 3.2295082527633674e-03
GC_19_129 ref NI_19 NS_129 0 1.5662882498191545e-05
GC_19_130 ref NI_19 NS_130 0 7.0417777843398870e-07
GC_19_131 ref NI_19 NS_131 0 -1.6181132653789586e-03
GC_19_132 ref NI_19 NS_132 0 2.3366088237519581e-03
GD_19_1 ref NI_19 NA_1 0 3.5760853144381961e-03
GD_19_2 ref NI_19 NA_2 0 -7.1339049672474279e-03
GD_19_3 ref NI_19 NA_3 0 -8.2048432475100887e-04
GD_19_4 ref NI_19 NA_4 0 5.2833147032979838e-04
GD_19_5 ref NI_19 NA_5 0 3.5462616711148765e-04
GD_19_6 ref NI_19 NA_6 0 4.5817172734004203e-03
GD_19_7 ref NI_19 NA_7 0 3.2271365425159133e-02
GD_19_8 ref NI_19 NA_8 0 1.7384495035672664e-03
GD_19_9 ref NI_19 NA_9 0 -5.8202904854894575e-04
GD_19_10 ref NI_19 NA_10 0 -4.7673554165490896e-05
GD_19_11 ref NI_19 NA_11 0 5.5537184488417004e-04
GD_19_12 ref NI_19 NA_12 0 2.2285252700151924e-03
GD_19_13 ref NI_19 NA_13 0 1.8678064447058026e-03
GD_19_14 ref NI_19 NA_14 0 -4.3961444236544225e-04
GD_19_15 ref NI_19 NA_15 0 2.2949554521807035e-03
GD_19_16 ref NI_19 NA_16 0 7.0880407448233656e-03
GD_19_17 ref NI_19 NA_17 0 3.7036126577213121e-03
GD_19_18 ref NI_19 NA_18 0 5.0557239886711333e-02
GD_19_19 ref NI_19 NA_19 0 6.1649834255968079e+00
GD_19_20 ref NI_19 NA_20 0 2.7340729499449748e-03
GD_19_21 ref NI_19 NA_21 0 2.3270160117908633e-03
GD_19_22 ref NI_19 NA_22 0 -8.7202318466312071e-04
*
* Port 20
VI_20 a_20 NI_20 0
RI_20 NI_20 ref 1.0000000000000001e-01
GC_20_1 ref NI_20 NS_1 0 -7.4228500259342347e-03
GC_20_2 ref NI_20 NS_2 0 4.8444262164833059e-03
GC_20_3 ref NI_20 NS_3 0 1.2662387723209417e-04
GC_20_4 ref NI_20 NS_4 0 2.2614161368095718e-06
GC_20_5 ref NI_20 NS_5 0 2.3353447967100855e-03
GC_20_6 ref NI_20 NS_6 0 -1.0622023528891163e-02
GC_20_7 ref NI_20 NS_7 0 1.6344734842640054e-03
GC_20_8 ref NI_20 NS_8 0 1.3285780719914117e-04
GC_20_9 ref NI_20 NS_9 0 -1.3513046437934902e-06
GC_20_10 ref NI_20 NS_10 0 1.3845272188979967e-06
GC_20_11 ref NI_20 NS_11 0 1.1310947018052403e-02
GC_20_12 ref NI_20 NS_12 0 1.0656102221433197e-02
GC_20_13 ref NI_20 NS_13 0 -3.4127190313371111e-03
GC_20_14 ref NI_20 NS_14 0 3.8961451583532625e-03
GC_20_15 ref NI_20 NS_15 0 4.9447966310126848e-05
GC_20_16 ref NI_20 NS_16 0 1.1333761245735690e-06
GC_20_17 ref NI_20 NS_17 0 2.8064994919502559e-04
GC_20_18 ref NI_20 NS_18 0 -4.8520342364518979e-03
GC_20_19 ref NI_20 NS_19 0 1.2517589111199705e-02
GC_20_20 ref NI_20 NS_20 0 -2.1342294059590664e-03
GC_20_21 ref NI_20 NS_21 0 -1.4478409850594331e-05
GC_20_22 ref NI_20 NS_22 0 -6.6613654625924531e-08
GC_20_23 ref NI_20 NS_23 0 -7.2582500218550056e-03
GC_20_24 ref NI_20 NS_24 0 -3.2991571031970295e-03
GC_20_25 ref NI_20 NS_25 0 1.0814459788764655e-02
GC_20_26 ref NI_20 NS_26 0 -1.5778679966321964e-02
GC_20_27 ref NI_20 NS_27 0 -4.1647741779583209e-05
GC_20_28 ref NI_20 NS_28 0 -2.2091039159250020e-06
GC_20_29 ref NI_20 NS_29 0 5.2581197864295603e-02
GC_20_30 ref NI_20 NS_30 0 -6.2764836927056200e-02
GC_20_31 ref NI_20 NS_31 0 5.1880331833151199e-03
GC_20_32 ref NI_20 NS_32 0 1.3116582810549886e-03
GC_20_33 ref NI_20 NS_33 0 1.3924255938346792e-06
GC_20_34 ref NI_20 NS_34 0 1.3107225364339803e-06
GC_20_35 ref NI_20 NS_35 0 -4.3423532002440550e-03
GC_20_36 ref NI_20 NS_36 0 8.0608681742791628e-03
GC_20_37 ref NI_20 NS_37 0 1.0507278951174443e-04
GC_20_38 ref NI_20 NS_38 0 2.9926360193730478e-03
GC_20_39 ref NI_20 NS_39 0 1.8546715060487389e-05
GC_20_40 ref NI_20 NS_40 0 1.0913770338133505e-06
GC_20_41 ref NI_20 NS_41 0 -1.7455701078090244e-03
GC_20_42 ref NI_20 NS_42 0 1.7967759882602627e-03
GC_20_43 ref NI_20 NS_43 0 -2.8520629769226286e-03
GC_20_44 ref NI_20 NS_44 0 3.8454050932873267e-03
GC_20_45 ref NI_20 NS_45 0 4.0943201456579111e-05
GC_20_46 ref NI_20 NS_46 0 1.0536844783581946e-06
GC_20_47 ref NI_20 NS_47 0 -1.9024215585421305e-04
GC_20_48 ref NI_20 NS_48 0 -2.8916304211840846e-03
GC_20_49 ref NI_20 NS_49 0 6.6308212714020556e-03
GC_20_50 ref NI_20 NS_50 0 8.7331484596728367e-04
GC_20_51 ref NI_20 NS_51 0 -2.8802206674477462e-05
GC_20_52 ref NI_20 NS_52 0 4.6679551366562014e-07
GC_20_53 ref NI_20 NS_53 0 -3.9195335145851351e-03
GC_20_54 ref NI_20 NS_54 0 1.1385783752702244e-02
GC_20_55 ref NI_20 NS_55 0 -4.9571432014288040e-03
GC_20_56 ref NI_20 NS_56 0 4.1818534081746279e-03
GC_20_57 ref NI_20 NS_57 0 7.1334373810145440e-05
GC_20_58 ref NI_20 NS_58 0 9.3067194631957857e-07
GC_20_59 ref NI_20 NS_59 0 1.2081390860224147e-03
GC_20_60 ref NI_20 NS_60 0 -8.9329864320334615e-03
GC_20_61 ref NI_20 NS_61 0 -5.3631129032318077e-03
GC_20_62 ref NI_20 NS_62 0 4.2743490783467650e-03
GC_20_63 ref NI_20 NS_63 0 8.1179670734442830e-05
GC_20_64 ref NI_20 NS_64 0 1.0512874714860016e-06
GC_20_65 ref NI_20 NS_65 0 1.3943722347370309e-03
GC_20_66 ref NI_20 NS_66 0 -9.3711394475067405e-03
GC_20_67 ref NI_20 NS_67 0 4.9934092380245062e-03
GC_20_68 ref NI_20 NS_68 0 1.3172575968760354e-03
GC_20_69 ref NI_20 NS_69 0 -1.1923942677336940e-05
GC_20_70 ref NI_20 NS_70 0 6.9634469809934854e-07
GC_20_71 ref NI_20 NS_71 0 -3.3876653519949243e-03
GC_20_72 ref NI_20 NS_72 0 8.4050140265463178e-03
GC_20_73 ref NI_20 NS_73 0 1.0347086194512205e-02
GC_20_74 ref NI_20 NS_74 0 -1.0823395452398158e-03
GC_20_75 ref NI_20 NS_75 0 -2.8310122996983148e-05
GC_20_76 ref NI_20 NS_76 0 -4.7314417302636338e-07
GC_20_77 ref NI_20 NS_77 0 -3.5216592964870956e-03
GC_20_78 ref NI_20 NS_78 0 1.1574367893450182e-02
GC_20_79 ref NI_20 NS_79 0 -5.4507898343556559e-03
GC_20_80 ref NI_20 NS_80 0 4.3503190138234268e-03
GC_20_81 ref NI_20 NS_81 0 7.6141333013775655e-05
GC_20_82 ref NI_20 NS_82 0 7.5519995000807828e-07
GC_20_83 ref NI_20 NS_83 0 1.4463184935040755e-03
GC_20_84 ref NI_20 NS_84 0 -9.2022134477188766e-03
GC_20_85 ref NI_20 NS_85 0 -5.1936351113701399e-03
GC_20_86 ref NI_20 NS_86 0 4.2865586823015653e-03
GC_20_87 ref NI_20 NS_87 0 7.0157782840540099e-05
GC_20_88 ref NI_20 NS_88 0 9.8609568416109866e-07
GC_20_89 ref NI_20 NS_89 0 1.3948596680623242e-03
GC_20_90 ref NI_20 NS_90 0 -8.4539396437295355e-03
GC_20_91 ref NI_20 NS_91 0 -8.2696263534817868e-04
GC_20_92 ref NI_20 NS_92 0 3.1534129026736068e-03
GC_20_93 ref NI_20 NS_93 0 2.8917587009101532e-05
GC_20_94 ref NI_20 NS_94 0 3.9921263266689091e-07
GC_20_95 ref NI_20 NS_95 0 -8.5386301244590841e-04
GC_20_96 ref NI_20 NS_96 0 -2.3826366089686494e-04
GC_20_97 ref NI_20 NS_97 0 1.1447749541115256e-03
GC_20_98 ref NI_20 NS_98 0 2.4695996519358194e-03
GC_20_99 ref NI_20 NS_99 0 1.0459804925072615e-05
GC_20_100 ref NI_20 NS_100 0 5.2578028545286221e-07
GC_20_101 ref NI_20 NS_101 0 -1.1969933657834130e-03
GC_20_102 ref NI_20 NS_102 0 3.1454241667275749e-03
GC_20_103 ref NI_20 NS_103 0 -3.8464487514647855e-03
GC_20_104 ref NI_20 NS_104 0 3.9404135939472068e-03
GC_20_105 ref NI_20 NS_105 0 6.0677681242418930e-05
GC_20_106 ref NI_20 NS_106 0 4.6648192769437372e-07
GC_20_107 ref NI_20 NS_107 0 6.4249425972349463e-04
GC_20_108 ref NI_20 NS_108 0 -6.0868508656475523e-03
GC_20_109 ref NI_20 NS_109 0 -3.1097127532101563e-03
GC_20_110 ref NI_20 NS_110 0 3.7623602364061782e-03
GC_20_111 ref NI_20 NS_111 0 4.1052766571555540e-05
GC_20_112 ref NI_20 NS_112 0 7.1268033661781599e-07
GC_20_113 ref NI_20 NS_113 0 5.0476500349398072e-04
GC_20_114 ref NI_20 NS_114 0 -4.4145753717369368e-03
GC_20_115 ref NI_20 NS_115 0 -3.5437384867963530e-02
GC_20_116 ref NI_20 NS_116 0 -2.2089980210007541e-02
GC_20_117 ref NI_20 NS_117 0 -4.9937939737208271e-04
GC_20_118 ref NI_20 NS_118 0 -1.3598189438946999e-05
GC_20_119 ref NI_20 NS_119 0 -5.5775220699502574e-02
GC_20_120 ref NI_20 NS_120 0 8.0276892932277327e-02
GC_20_121 ref NI_20 NS_121 0 1.7180496539752777e-02
GC_20_122 ref NI_20 NS_122 0 -8.7809030997817918e-03
GC_20_123 ref NI_20 NS_123 0 -9.3155582470252842e-05
GC_20_124 ref NI_20 NS_124 0 9.3204893079695853e-06
GC_20_125 ref NI_20 NS_125 0 1.3198504276875364e-02
GC_20_126 ref NI_20 NS_126 0 -1.1856897406391946e-02
GC_20_127 ref NI_20 NS_127 0 7.5254162627363284e-03
GC_20_128 ref NI_20 NS_128 0 3.3076794168137577e-04
GC_20_129 ref NI_20 NS_129 0 -3.9795347835924039e-05
GC_20_130 ref NI_20 NS_130 0 4.7583582628844776e-07
GC_20_131 ref NI_20 NS_131 0 -3.3344282095718806e-03
GC_20_132 ref NI_20 NS_132 0 1.0804220562691662e-02
GD_20_1 ref NI_20 NA_1 0 6.8566097392338968e-03
GD_20_2 ref NI_20 NA_2 0 -6.4966636563124460e-03
GD_20_3 ref NI_20 NA_3 0 1.5816443810128017e-03
GD_20_4 ref NI_20 NA_4 0 -1.6601904495293657e-03
GD_20_5 ref NI_20 NA_5 0 5.8486614509905076e-02
GD_20_6 ref NI_20 NA_6 0 -2.5418363204090040e-03
GD_20_7 ref NI_20 NA_7 0 -8.4187186974183812e-04
GD_20_8 ref NI_20 NA_8 0 1.0184467218922516e-03
GD_20_9 ref NI_20 NA_9 0 -3.6467899045623310e-03
GD_20_10 ref NI_20 NA_10 0 4.2145234315141417e-03
GD_20_11 ref NI_20 NA_11 0 4.5878266961644730e-03
GD_20_12 ref NI_20 NA_12 0 -8.8008583729509194e-04
GD_20_13 ref NI_20 NA_13 0 2.7066405612623495e-04
GD_20_14 ref NI_20 NA_14 0 4.5347707317906936e-03
GD_20_15 ref NI_20 NA_15 0 4.0990858189099526e-03
GD_20_16 ref NI_20 NA_16 0 1.2007104975234808e-03
GD_20_17 ref NI_20 NA_17 0 5.4459646356059578e-04
GD_20_18 ref NI_20 NA_18 0 3.2860038995013016e-03
GD_20_19 ref NI_20 NA_19 0 2.7340729499449748e-03
GD_20_20 ref NI_20 NA_20 0 6.1629935725316463e+00
GD_20_21 ref NI_20 NA_21 0 3.9409655334274894e-02
GD_20_22 ref NI_20 NA_22 0 -3.2289790119990227e-03
*
* Port 21
VI_21 a_21 NI_21 0
RI_21 NI_21 ref 1.0000000000000001e-01
GC_21_1 ref NI_21 NS_1 0 -6.2027364293817683e-03
GC_21_2 ref NI_21 NS_2 0 4.4408052628173668e-03
GC_21_3 ref NI_21 NS_3 0 1.1892279426226213e-04
GC_21_4 ref NI_21 NS_4 0 1.8267538695386525e-06
GC_21_5 ref NI_21 NS_5 0 1.8780562483044158e-03
GC_21_6 ref NI_21 NS_6 0 -9.2828262338418219e-03
GC_21_7 ref NI_21 NS_7 0 1.3167768934508129e-03
GC_21_8 ref NI_21 NS_8 0 -2.6853944098489371e-04
GC_21_9 ref NI_21 NS_9 0 7.2628176883620684e-06
GC_21_10 ref NI_21 NS_10 0 1.7317033206348848e-07
GC_21_11 ref NI_21 NS_11 0 1.6093672800812264e-02
GC_21_12 ref NI_21 NS_12 0 1.9232011656257739e-02
GC_21_13 ref NI_21 NS_13 0 -1.9413165134533536e-03
GC_21_14 ref NI_21 NS_14 0 3.2630760487970521e-03
GC_21_15 ref NI_21 NS_15 0 4.4135123418261603e-05
GC_21_16 ref NI_21 NS_16 0 3.5220050909732185e-07
GC_21_17 ref NI_21 NS_17 0 1.9500610574798763e-04
GC_21_18 ref NI_21 NS_18 0 -4.3284324788464713e-03
GC_21_19 ref NI_21 NS_19 0 5.5345715452183360e-03
GC_21_20 ref NI_21 NS_20 0 -2.5827812365916856e-03
GC_21_21 ref NI_21 NS_21 0 -1.1141854884250450e-05
GC_21_22 ref NI_21 NS_22 0 -4.5929813393886968e-07
GC_21_23 ref NI_21 NS_23 0 1.1879635784846330e-02
GC_21_24 ref NI_21 NS_24 0 -6.3676479999415780e-03
GC_21_25 ref NI_21 NS_25 0 1.9817879114969704e-02
GC_21_26 ref NI_21 NS_26 0 -6.8131703335112329e-03
GC_21_27 ref NI_21 NS_27 0 -2.6162649294075772e-05
GC_21_28 ref NI_21 NS_28 0 1.9418969117549883e-06
GC_21_29 ref NI_21 NS_29 0 -2.5093650626502092e-03
GC_21_30 ref NI_21 NS_30 0 -3.6854791197141233e-03
GC_21_31 ref NI_21 NS_31 0 4.9960719606933499e-03
GC_21_32 ref NI_21 NS_32 0 5.1564534790164360e-04
GC_21_33 ref NI_21 NS_33 0 2.6405676631236891e-06
GC_21_34 ref NI_21 NS_34 0 1.8628213525842484e-07
GC_21_35 ref NI_21 NS_35 0 -1.6253281341007150e-03
GC_21_36 ref NI_21 NS_36 0 -8.9908435935802324e-04
GC_21_37 ref NI_21 NS_37 0 1.3317101999581955e-03
GC_21_38 ref NI_21 NS_38 0 2.2064557295623970e-03
GC_21_39 ref NI_21 NS_39 0 1.9657223695197211e-05
GC_21_40 ref NI_21 NS_40 0 2.1416305391821105e-07
GC_21_41 ref NI_21 NS_41 0 -1.1975132563301280e-03
GC_21_42 ref NI_21 NS_42 0 -3.6356188820027996e-04
GC_21_43 ref NI_21 NS_43 0 -1.2777462011677359e-03
GC_21_44 ref NI_21 NS_44 0 3.1518578512570415e-03
GC_21_45 ref NI_21 NS_45 0 3.6985975134971847e-05
GC_21_46 ref NI_21 NS_46 0 2.4496918895612308e-07
GC_21_47 ref NI_21 NS_47 0 -3.1790895451220755e-04
GC_21_48 ref NI_21 NS_48 0 -2.6027144179928230e-03
GC_21_49 ref NI_21 NS_49 0 5.1432013512985571e-03
GC_21_50 ref NI_21 NS_50 0 1.1290962293163539e-03
GC_21_51 ref NI_21 NS_51 0 -2.3384505329946597e-05
GC_21_52 ref NI_21 NS_52 0 1.2003840720841267e-06
GC_21_53 ref NI_21 NS_53 0 -2.8489232906105510e-03
GC_21_54 ref NI_21 NS_54 0 6.6272837445221682e-03
GC_21_55 ref NI_21 NS_55 0 -3.3896645807184366e-03
GC_21_56 ref NI_21 NS_56 0 3.6292423834180130e-03
GC_21_57 ref NI_21 NS_57 0 6.2400598077823051e-05
GC_21_58 ref NI_21 NS_58 0 1.7881379981612714e-07
GC_21_59 ref NI_21 NS_59 0 7.5669314010242490e-04
GC_21_60 ref NI_21 NS_60 0 -7.5522122665503018e-03
GC_21_61 ref NI_21 NS_61 0 -3.7066751027391119e-03
GC_21_62 ref NI_21 NS_62 0 3.7608156773081391e-03
GC_21_63 ref NI_21 NS_63 0 7.0116704876720364e-05
GC_21_64 ref NI_21 NS_64 0 -2.6185833590185501e-09
GC_21_65 ref NI_21 NS_65 0 6.4911811289839979e-04
GC_21_66 ref NI_21 NS_66 0 -8.0126855677261667e-03
GC_21_67 ref NI_21 NS_67 0 7.4894937816576005e-03
GC_21_68 ref NI_21 NS_68 0 -1.5926082500350699e-04
GC_21_69 ref NI_21 NS_69 0 -2.9388587251401145e-06
GC_21_70 ref NI_21 NS_70 0 6.1994195204973687e-08
GC_21_71 ref NI_21 NS_71 0 -3.2413528361214688e-03
GC_21_72 ref NI_21 NS_72 0 4.6479727287496563e-03
GC_21_73 ref NI_21 NS_73 0 1.0708741045144262e-02
GC_21_74 ref NI_21 NS_74 0 -3.3297966573567306e-03
GC_21_75 ref NI_21 NS_75 0 -1.6640178122016746e-05
GC_21_76 ref NI_21 NS_76 0 -5.0857454539566590e-07
GC_21_77 ref NI_21 NS_77 0 2.7787066891903052e-03
GC_21_78 ref NI_21 NS_78 0 -6.6536507408181478e-03
GC_21_79 ref NI_21 NS_79 0 -3.8737891017464727e-03
GC_21_80 ref NI_21 NS_80 0 3.7933335029287315e-03
GC_21_81 ref NI_21 NS_81 0 6.3087688396909722e-05
GC_21_82 ref NI_21 NS_82 0 5.3346769505830104e-07
GC_21_83 ref NI_21 NS_83 0 1.0116724819781348e-03
GC_21_84 ref NI_21 NS_84 0 -7.6050798419050386e-03
GC_21_85 ref NI_21 NS_85 0 -3.3592973928346296e-03
GC_21_86 ref NI_21 NS_86 0 3.7061593242481384e-03
GC_21_87 ref NI_21 NS_87 0 6.2696233179150194e-05
GC_21_88 ref NI_21 NS_88 0 -2.1343021325884491e-07
GC_21_89 ref NI_21 NS_89 0 5.5880020630379851e-04
GC_21_90 ref NI_21 NS_90 0 -6.7404959146910911e-03
GC_21_91 ref NI_21 NS_91 0 1.0951855501707603e-03
GC_21_92 ref NI_21 NS_92 0 2.2831456725422193e-03
GC_21_93 ref NI_21 NS_93 0 2.3545281784070895e-05
GC_21_94 ref NI_21 NS_94 0 7.2988111869023005e-08
GC_21_95 ref NI_21 NS_95 0 -1.0665593610875085e-03
GC_21_96 ref NI_21 NS_96 0 7.4627915358578962e-05
GC_21_97 ref NI_21 NS_97 0 3.5299929086827662e-03
GC_21_98 ref NI_21 NS_98 0 1.3539833534188146e-03
GC_21_99 ref NI_21 NS_99 0 1.2959376825982194e-05
GC_21_100 ref NI_21 NS_100 0 -1.6437216559443687e-07
GC_21_101 ref NI_21 NS_101 0 -1.7364827272278798e-03
GC_21_102 ref NI_21 NS_102 0 2.1899624289922256e-03
GC_21_103 ref NI_21 NS_103 0 -2.1911353131186789e-03
GC_21_104 ref NI_21 NS_104 0 3.3031229496930281e-03
GC_21_105 ref NI_21 NS_105 0 4.9936019132668863e-05
GC_21_106 ref NI_21 NS_106 0 1.1579278767101135e-07
GC_21_107 ref NI_21 NS_107 0 2.9116215068889162e-04
GC_21_108 ref NI_21 NS_108 0 -4.8866944985694830e-03
GC_21_109 ref NI_21 NS_109 0 -9.5151496531142073e-04
GC_21_110 ref NI_21 NS_110 0 2.9587402486745949e-03
GC_21_111 ref NI_21 NS_111 0 4.1013664475666413e-05
GC_21_112 ref NI_21 NS_112 0 -2.8793670394737647e-07
GC_21_113 ref NI_21 NS_113 0 -3.6560220298813105e-04
GC_21_114 ref NI_21 NS_114 0 -3.1089196381564204e-03
GC_21_115 ref NI_21 NS_115 0 1.7180496539752756e-02
GC_21_116 ref NI_21 NS_116 0 -8.7809030997817762e-03
GC_21_117 ref NI_21 NS_117 0 -9.3155582470256731e-05
GC_21_118 ref NI_21 NS_118 0 9.3204893079699682e-06
GC_21_119 ref NI_21 NS_119 0 1.3198504276875375e-02
GC_21_120 ref NI_21 NS_120 0 -1.1856897406391972e-02
GC_21_121 ref NI_21 NS_121 0 -5.5627201397522662e-02
GC_21_122 ref NI_21 NS_122 0 -1.8690723644840805e-02
GC_21_123 ref NI_21 NS_123 0 -4.8272559871376079e-04
GC_21_124 ref NI_21 NS_124 0 -7.7920889549950687e-06
GC_21_125 ref NI_21 NS_125 0 -3.0557651325787867e-02
GC_21_126 ref NI_21 NS_126 0 5.2723934684325596e-02
GC_21_127 ref NI_21 NS_127 0 5.7287622348153036e-03
GC_21_128 ref NI_21 NS_128 0 9.5103190465559530e-04
GC_21_129 ref NI_21 NS_129 0 -3.2949067436086052e-05
GC_21_130 ref NI_21 NS_130 0 1.4204749951425220e-06
GC_21_131 ref NI_21 NS_131 0 -2.8472258820589919e-03
GC_21_132 ref NI_21 NS_132 0 8.4893973638078806e-03
GD_21_1 ref NI_21 NA_1 0 6.8455692527148067e-03
GD_21_2 ref NI_21 NA_2 0 -7.2184018087830962e-03
GD_21_3 ref NI_21 NA_3 0 1.1741825524586083e-03
GD_21_4 ref NI_21 NA_4 0 9.1592875396988970e-03
GD_21_5 ref NI_21 NA_5 0 1.2177660150392376e-02
GD_21_6 ref NI_21 NA_6 0 6.4905622488259655e-04
GD_21_7 ref NI_21 NA_7 0 1.2541102086742887e-05
GD_21_8 ref NI_21 NA_8 0 8.4863923628421311e-04
GD_21_9 ref NI_21 NA_9 0 -1.4932655180511384e-03
GD_21_10 ref NI_21 NA_10 0 3.5489389162013498e-03
GD_21_11 ref NI_21 NA_11 0 3.8655096774734546e-03
GD_21_12 ref NI_21 NA_12 0 1.9722645145962723e-03
GD_21_13 ref NI_21 NA_13 0 8.0592103199978466e-03
GD_21_14 ref NI_21 NA_14 0 3.9600114580507165e-03
GD_21_15 ref NI_21 NA_15 0 3.3060918191656153e-03
GD_21_16 ref NI_21 NA_16 0 1.7149448203934909e-03
GD_21_17 ref NI_21 NA_17 0 1.5990442272803107e-03
GD_21_18 ref NI_21 NA_18 0 3.0318421705596370e-03
GD_21_19 ref NI_21 NA_19 0 2.3270160117908633e-03
GD_21_20 ref NI_21 NA_20 0 3.9409655334274894e-02
GD_21_21 ref NI_21 NA_21 0 6.1688002418538241e+00
GD_21_22 ref NI_21 NA_22 0 -2.2316822062711187e-03
*
* Port 22
VI_22 a_22 NI_22 0
RI_22 NI_22 ref 1.0000000000000001e-01
GC_22_1 ref NI_22 NS_1 0 7.6824430018799048e-03
GC_22_2 ref NI_22 NS_2 0 3.2213287265089782e-04
GC_22_3 ref NI_22 NS_3 0 2.9215013586183333e-05
GC_22_4 ref NI_22 NS_4 0 4.0195210021586628e-06
GC_22_5 ref NI_22 NS_5 0 -6.4280539488993172e-03
GC_22_6 ref NI_22 NS_6 0 9.3622139514176195e-03
GC_22_7 ref NI_22 NS_7 0 2.5892738889668624e-03
GC_22_8 ref NI_22 NS_8 0 6.5505483405842798e-04
GC_22_9 ref NI_22 NS_9 0 -7.7958605536074850e-06
GC_22_10 ref NI_22 NS_10 0 1.1482190843229381e-06
GC_22_11 ref NI_22 NS_11 0 7.3835550451446380e-03
GC_22_12 ref NI_22 NS_12 0 1.2772880146594853e-02
GC_22_13 ref NI_22 NS_13 0 8.0425371541913441e-04
GC_22_14 ref NI_22 NS_14 0 2.4600901299944131e-03
GC_22_15 ref NI_22 NS_15 0 6.0014096778517739e-06
GC_22_16 ref NI_22 NS_16 0 8.9876271120078452e-07
GC_22_17 ref NI_22 NS_17 0 -3.2220917516842464e-04
GC_22_18 ref NI_22 NS_18 0 1.4112893380725377e-03
GC_22_19 ref NI_22 NS_19 0 9.7116190973979537e-03
GC_22_20 ref NI_22 NS_20 0 -2.3674646030965711e-03
GC_22_21 ref NI_22 NS_21 0 -2.0114799221942229e-05
GC_22_22 ref NI_22 NS_22 0 -1.6100366454910135e-08
GC_22_23 ref NI_22 NS_23 0 1.2942851055932928e-03
GC_22_24 ref NI_22 NS_24 0 -3.1947090352205379e-03
GC_22_25 ref NI_22 NS_25 0 1.0534090170616600e-02
GC_22_26 ref NI_22 NS_26 0 -1.4869962561872634e-03
GC_22_27 ref NI_22 NS_27 0 -4.3540152731825356e-05
GC_22_28 ref NI_22 NS_28 0 1.7743194235981891e-07
GC_22_29 ref NI_22 NS_29 0 -2.0396667059082206e-03
GC_22_30 ref NI_22 NS_30 0 7.9749438997724180e-03
GC_22_31 ref NI_22 NS_31 0 8.9346401930816971e-03
GC_22_32 ref NI_22 NS_32 0 -1.5183673410661973e-03
GC_22_33 ref NI_22 NS_33 0 -1.7309566447433104e-05
GC_22_34 ref NI_22 NS_34 0 3.4021741417283958e-08
GC_22_35 ref NI_22 NS_35 0 -6.7160515353778571e-04
GC_22_36 ref NI_22 NS_36 0 -1.0198961290168035e-03
GC_22_37 ref NI_22 NS_37 0 5.1086543926157392e-03
GC_22_38 ref NI_22 NS_38 0 5.7462022534907791e-04
GC_22_39 ref NI_22 NS_39 0 -7.8354121872371589e-06
GC_22_40 ref NI_22 NS_40 0 4.2826255124710793e-07
GC_22_41 ref NI_22 NS_41 0 -1.2431508575356355e-03
GC_22_42 ref NI_22 NS_42 0 1.5654508815754343e-03
GC_22_43 ref NI_22 NS_43 0 1.8534426178764139e-03
GC_22_44 ref NI_22 NS_44 0 2.1167194067926737e-03
GC_22_45 ref NI_22 NS_45 0 1.0956176645602313e-06
GC_22_46 ref NI_22 NS_46 0 7.9555257848633517e-07
GC_22_47 ref NI_22 NS_47 0 -9.2978773547646430e-04
GC_22_48 ref NI_22 NS_48 0 2.1863215893060698e-03
GC_22_49 ref NI_22 NS_49 0 8.4443894471368554e-03
GC_22_50 ref NI_22 NS_50 0 -1.6832191074544769e-02
GC_22_51 ref NI_22 NS_51 0 4.7705172671583403e-05
GC_22_52 ref NI_22 NS_52 0 -3.7407742115432090e-06
GC_22_53 ref NI_22 NS_53 0 5.4750256582989591e-02
GC_22_54 ref NI_22 NS_54 0 -9.7770796292063492e-02
GC_22_55 ref NI_22 NS_55 0 -3.1727358421062102e-03
GC_22_56 ref NI_22 NS_56 0 3.8893652241928137e-03
GC_22_57 ref NI_22 NS_57 0 2.9312736778613376e-05
GC_22_58 ref NI_22 NS_58 0 7.8959276372263412e-07
GC_22_59 ref NI_22 NS_59 0 6.8716669070664077e-04
GC_22_60 ref NI_22 NS_60 0 -3.8577397395255174e-03
GC_22_61 ref NI_22 NS_61 0 -3.7019006863888790e-03
GC_22_62 ref NI_22 NS_62 0 4.1915463893475845e-03
GC_22_63 ref NI_22 NS_63 0 3.5734363845092639e-05
GC_22_64 ref NI_22 NS_64 0 7.6136955402415899e-07
GC_22_65 ref NI_22 NS_65 0 2.9834605839892492e-04
GC_22_66 ref NI_22 NS_66 0 -4.1170267658044209e-03
GC_22_67 ref NI_22 NS_67 0 4.5043071117053897e-03
GC_22_68 ref NI_22 NS_68 0 1.3802256277796127e-03
GC_22_69 ref NI_22 NS_69 0 -1.7921810596045636e-05
GC_22_70 ref NI_22 NS_70 0 1.7945943286572185e-06
GC_22_71 ref NI_22 NS_71 0 -2.7320729916975334e-03
GC_22_72 ref NI_22 NS_72 0 7.1907875358617731e-03
GC_22_73 ref NI_22 NS_73 0 6.1357904885113159e-03
GC_22_74 ref NI_22 NS_74 0 9.9571039687994028e-04
GC_22_75 ref NI_22 NS_75 0 -1.7553379812972366e-05
GC_22_76 ref NI_22 NS_76 0 7.7845837956251981e-07
GC_22_77 ref NI_22 NS_77 0 -4.2028771669082856e-03
GC_22_78 ref NI_22 NS_78 0 9.1693230629541003e-03
GC_22_79 ref NI_22 NS_79 0 -3.3688089671522438e-03
GC_22_80 ref NI_22 NS_80 0 3.9248706817997326e-03
GC_22_81 ref NI_22 NS_81 0 3.1120027906948040e-05
GC_22_82 ref NI_22 NS_82 0 1.1982138459012009e-06
GC_22_83 ref NI_22 NS_83 0 7.7195553329233331e-04
GC_22_84 ref NI_22 NS_84 0 -4.0346754465417408e-03
GC_22_85 ref NI_22 NS_85 0 -3.0498739438083772e-03
GC_22_86 ref NI_22 NS_86 0 4.0470084445461737e-03
GC_22_87 ref NI_22 NS_87 0 2.9995816524219976e-05
GC_22_88 ref NI_22 NS_88 0 6.7615914062085810e-07
GC_22_89 ref NI_22 NS_89 0 -8.5038252481237003e-05
GC_22_90 ref NI_22 NS_90 0 -2.3325257185161808e-03
GC_22_91 ref NI_22 NS_91 0 1.5868321388002797e-03
GC_22_92 ref NI_22 NS_92 0 2.4393608554421926e-03
GC_22_93 ref NI_22 NS_93 0 1.4107498018789593e-06
GC_22_94 ref NI_22 NS_94 0 7.5422902451031443e-07
GC_22_95 ref NI_22 NS_95 0 -1.6176433543631798e-03
GC_22_96 ref NI_22 NS_96 0 4.0414089807529665e-03
GC_22_97 ref NI_22 NS_97 0 3.4128954124444328e-03
GC_22_98 ref NI_22 NS_98 0 2.1039032648268743e-03
GC_22_99 ref NI_22 NS_99 0 -5.1230416982794880e-06
GC_22_100 ref NI_22 NS_100 0 7.9508184020798407e-07
GC_22_101 ref NI_22 NS_101 0 -3.5314376084637565e-03
GC_22_102 ref NI_22 NS_102 0 7.7780992640244274e-03
GC_22_103 ref NI_22 NS_103 0 -1.3117854544127010e-03
GC_22_104 ref NI_22 NS_104 0 3.1618312152708800e-03
GC_22_105 ref NI_22 NS_105 0 4.0602561321334183e-05
GC_22_106 ref NI_22 NS_106 0 1.4849938434381320e-06
GC_22_107 ref NI_22 NS_107 0 -1.3911164454417918e-04
GC_22_108 ref NI_22 NS_108 0 -6.1482392826651001e-04
GC_22_109 ref NI_22 NS_109 0 -2.6334434445558628e-04
GC_22_110 ref NI_22 NS_110 0 3.2295082527633700e-03
GC_22_111 ref NI_22 NS_111 0 1.5662882498191687e-05
GC_22_112 ref NI_22 NS_112 0 7.0417777843390410e-07
GC_22_113 ref NI_22 NS_113 0 -1.6181132653789556e-03
GC_22_114 ref NI_22 NS_114 0 2.3366088237519282e-03
GC_22_115 ref NI_22 NS_115 0 7.5254162627363093e-03
GC_22_116 ref NI_22 NS_116 0 3.3076794168138428e-04
GC_22_117 ref NI_22 NS_117 0 -3.9795347835925618e-05
GC_22_118 ref NI_22 NS_118 0 4.7583582628862405e-07
GC_22_119 ref NI_22 NS_119 0 -3.3344282095718711e-03
GC_22_120 ref NI_22 NS_120 0 1.0804220562691617e-02
GC_22_121 ref NI_22 NS_121 0 5.7287622348153287e-03
GC_22_122 ref NI_22 NS_122 0 9.5103190465558294e-04
GC_22_123 ref NI_22 NS_123 0 -3.2949067436083179e-05
GC_22_124 ref NI_22 NS_124 0 1.4204749951421830e-06
GC_22_125 ref NI_22 NS_125 0 -2.8472258820590036e-03
GC_22_126 ref NI_22 NS_126 0 8.4893973638079257e-03
GC_22_127 ref NI_22 NS_127 0 -6.5842692284160967e-02
GC_22_128 ref NI_22 NS_128 0 -1.5268548408818508e-02
GC_22_129 ref NI_22 NS_129 0 -1.2236006711493933e-04
GC_22_130 ref NI_22 NS_130 0 -7.2856920039139870e-06
GC_22_131 ref NI_22 NS_131 0 -3.1860036187402074e-02
GC_22_132 ref NI_22 NS_132 0 5.9200353408113381e-02
GD_22_1 ref NI_22 NA_1 0 2.1947785187478590e-03
GD_22_2 ref NI_22 NA_2 0 -1.3797445144011020e-02
GD_22_3 ref NI_22 NA_3 0 -3.1745812727353557e-03
GD_22_4 ref NI_22 NA_4 0 -4.0853095058907621e-03
GD_22_5 ref NI_22 NA_5 0 -7.1454222281599261e-03
GD_22_6 ref NI_22 NA_6 0 -3.3312546667283436e-03
GD_22_7 ref NI_22 NA_7 0 -4.0605794618878413e-03
GD_22_8 ref NI_22 NA_8 0 -3.3676867462542385e-03
GD_22_9 ref NI_22 NA_9 0 2.3528104723446724e-02
GD_22_10 ref NI_22 NA_10 0 7.5714288132040298e-04
GD_22_11 ref NI_22 NA_11 0 1.2745820506245890e-03
GD_22_12 ref NI_22 NA_12 0 -1.6446586028337974e-03
GD_22_13 ref NI_22 NA_13 0 -2.8344620963715156e-03
GD_22_14 ref NI_22 NA_14 0 1.4845990821456489e-03
GD_22_15 ref NI_22 NA_15 0 6.9411868552406901e-04
GD_22_16 ref NI_22 NA_16 0 -1.1399631248750208e-03
GD_22_17 ref NI_22 NA_17 0 -2.3853459472693290e-03
GD_22_18 ref NI_22 NA_18 0 2.6129117445780929e-04
GD_22_19 ref NI_22 NA_19 0 -8.7202318466312071e-04
GD_22_20 ref NI_22 NA_20 0 -3.2289790119990227e-03
GD_22_21 ref NI_22 NA_21 0 -2.2316822062711187e-03
GD_22_22 ref NI_22 NA_22 0 6.2548650406937023e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
* Impinging wave, port 16
RA_16 NA_16 0 1.5811388300841897e-01
FA_16 0 NA_16 VI_16 1.0
GA_16 0 NA_16 a_16 ref 1.0000000000000000e+01
*
* Impinging wave, port 17
RA_17 NA_17 0 1.5811388300841897e-01
FA_17 0 NA_17 VI_17 1.0
GA_17 0 NA_17 a_17 ref 1.0000000000000000e+01
*
* Impinging wave, port 18
RA_18 NA_18 0 1.5811388300841897e-01
FA_18 0 NA_18 VI_18 1.0
GA_18 0 NA_18 a_18 ref 1.0000000000000000e+01
*
* Impinging wave, port 19
RA_19 NA_19 0 1.5811388300841897e-01
FA_19 0 NA_19 VI_19 1.0
GA_19 0 NA_19 a_19 ref 1.0000000000000000e+01
*
* Impinging wave, port 20
RA_20 NA_20 0 1.5811388300841897e-01
FA_20 0 NA_20 VI_20 1.0
GA_20 0 NA_20 a_20 ref 1.0000000000000000e+01
*
* Impinging wave, port 21
RA_21 NA_21 0 1.5811388300841897e-01
FA_21 0 NA_21 VI_21 1.0
GA_21 0 NA_21 a_21 ref 1.0000000000000000e+01
*
* Impinging wave, port 22
RA_22 NA_22 0 1.5811388300841897e-01
FA_22 0 NA_22 VI_22 1.0
GA_22 0 NA_22 a_22 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.1464137755184745e+03
GS_1_1 0 NS_1 NA_1 0 8.9717632618532425e-02
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 2.2567922184575468e+03
GS_2_1 0 NS_2 NA_1 0 8.9717632618532425e-02
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 1.1329278075555443e+04
GS_3_1 0 NS_3 NA_1 0 8.9717632618532425e-02
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 1.1063610802248793e+05
GS_4_1 0 NS_4 NA_1 0 8.9717632618532425e-02
*
* Complex pair n. 5/6
CS_5 NS_5 0 9.9999999999999998e-13
CS_6 NS_6 0 9.9999999999999998e-13
RS_5 NS_5 0 4.7633920490811545e+02
RS_6 NS_6 0 4.7633920490811545e+02
GL_5 0 NS_5 NS_6 0 4.5220934102261961e-04
GL_6 0 NS_6 NS_5 0 -4.5220934102261961e-04
GS_5_1 0 NS_5 NA_1 0 8.9717632618532425e-02
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 1.1464137755184745e+03
GS_7_2 0 NS_7 NA_2 0 8.9717632618532425e-02
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 2.2567922184575468e+03
GS_8_2 0 NS_8 NA_2 0 8.9717632618532425e-02
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.1329278075555443e+04
GS_9_2 0 NS_9 NA_2 0 8.9717632618532425e-02
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 1.1063610802248793e+05
GS_10_2 0 NS_10 NA_2 0 8.9717632618532425e-02
*
* Complex pair n. 11/12
CS_11 NS_11 0 9.9999999999999998e-13
CS_12 NS_12 0 9.9999999999999998e-13
RS_11 NS_11 0 4.7633920490811545e+02
RS_12 NS_12 0 4.7633920490811545e+02
GL_11 0 NS_11 NS_12 0 4.5220934102261961e-04
GL_12 0 NS_12 NS_11 0 -4.5220934102261961e-04
GS_11_2 0 NS_11 NA_2 0 8.9717632618532425e-02
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.1464137755184745e+03
GS_13_3 0 NS_13 NA_3 0 8.9717632618532425e-02
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 2.2567922184575468e+03
GS_14_3 0 NS_14 NA_3 0 8.9717632618532425e-02
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 1.1329278075555443e+04
GS_15_3 0 NS_15 NA_3 0 8.9717632618532425e-02
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 1.1063610802248793e+05
GS_16_3 0 NS_16 NA_3 0 8.9717632618532425e-02
*
* Complex pair n. 17/18
CS_17 NS_17 0 9.9999999999999998e-13
CS_18 NS_18 0 9.9999999999999998e-13
RS_17 NS_17 0 4.7633920490811545e+02
RS_18 NS_18 0 4.7633920490811545e+02
GL_17 0 NS_17 NS_18 0 4.5220934102261961e-04
GL_18 0 NS_18 NS_17 0 -4.5220934102261961e-04
GS_17_3 0 NS_17 NA_3 0 8.9717632618532425e-02
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 1.1464137755184745e+03
GS_19_4 0 NS_19 NA_4 0 8.9717632618532425e-02
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 2.2567922184575468e+03
GS_20_4 0 NS_20 NA_4 0 8.9717632618532425e-02
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.1329278075555443e+04
GS_21_4 0 NS_21 NA_4 0 8.9717632618532425e-02
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 1.1063610802248793e+05
GS_22_4 0 NS_22 NA_4 0 8.9717632618532425e-02
*
* Complex pair n. 23/24
CS_23 NS_23 0 9.9999999999999998e-13
CS_24 NS_24 0 9.9999999999999998e-13
RS_23 NS_23 0 4.7633920490811545e+02
RS_24 NS_24 0 4.7633920490811545e+02
GL_23 0 NS_23 NS_24 0 4.5220934102261961e-04
GL_24 0 NS_24 NS_23 0 -4.5220934102261961e-04
GS_23_4 0 NS_23 NA_4 0 8.9717632618532425e-02
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.1464137755184745e+03
GS_25_5 0 NS_25 NA_5 0 8.9717632618532425e-02
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 2.2567922184575468e+03
GS_26_5 0 NS_26 NA_5 0 8.9717632618532425e-02
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 1.1329278075555443e+04
GS_27_5 0 NS_27 NA_5 0 8.9717632618532425e-02
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 1.1063610802248793e+05
GS_28_5 0 NS_28 NA_5 0 8.9717632618532425e-02
*
* Complex pair n. 29/30
CS_29 NS_29 0 9.9999999999999998e-13
CS_30 NS_30 0 9.9999999999999998e-13
RS_29 NS_29 0 4.7633920490811545e+02
RS_30 NS_30 0 4.7633920490811545e+02
GL_29 0 NS_29 NS_30 0 4.5220934102261961e-04
GL_30 0 NS_30 NS_29 0 -4.5220934102261961e-04
GS_29_5 0 NS_29 NA_5 0 8.9717632618532425e-02
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 1.1464137755184745e+03
GS_31_6 0 NS_31 NA_6 0 8.9717632618532425e-02
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 2.2567922184575468e+03
GS_32_6 0 NS_32 NA_6 0 8.9717632618532425e-02
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 1.1329278075555443e+04
GS_33_6 0 NS_33 NA_6 0 8.9717632618532425e-02
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 1.1063610802248793e+05
GS_34_6 0 NS_34 NA_6 0 8.9717632618532425e-02
*
* Complex pair n. 35/36
CS_35 NS_35 0 9.9999999999999998e-13
CS_36 NS_36 0 9.9999999999999998e-13
RS_35 NS_35 0 4.7633920490811545e+02
RS_36 NS_36 0 4.7633920490811545e+02
GL_35 0 NS_35 NS_36 0 4.5220934102261961e-04
GL_36 0 NS_36 NS_35 0 -4.5220934102261961e-04
GS_35_6 0 NS_35 NA_6 0 8.9717632618532425e-02
*
* Real pole n. 37
CS_37 NS_37 0 9.9999999999999998e-13
RS_37 NS_37 0 1.1464137755184745e+03
GS_37_7 0 NS_37 NA_7 0 8.9717632618532425e-02
*
* Real pole n. 38
CS_38 NS_38 0 9.9999999999999998e-13
RS_38 NS_38 0 2.2567922184575468e+03
GS_38_7 0 NS_38 NA_7 0 8.9717632618532425e-02
*
* Real pole n. 39
CS_39 NS_39 0 9.9999999999999998e-13
RS_39 NS_39 0 1.1329278075555443e+04
GS_39_7 0 NS_39 NA_7 0 8.9717632618532425e-02
*
* Real pole n. 40
CS_40 NS_40 0 9.9999999999999998e-13
RS_40 NS_40 0 1.1063610802248793e+05
GS_40_7 0 NS_40 NA_7 0 8.9717632618532425e-02
*
* Complex pair n. 41/42
CS_41 NS_41 0 9.9999999999999998e-13
CS_42 NS_42 0 9.9999999999999998e-13
RS_41 NS_41 0 4.7633920490811545e+02
RS_42 NS_42 0 4.7633920490811545e+02
GL_41 0 NS_41 NS_42 0 4.5220934102261961e-04
GL_42 0 NS_42 NS_41 0 -4.5220934102261961e-04
GS_41_7 0 NS_41 NA_7 0 8.9717632618532425e-02
*
* Real pole n. 43
CS_43 NS_43 0 9.9999999999999998e-13
RS_43 NS_43 0 1.1464137755184745e+03
GS_43_8 0 NS_43 NA_8 0 8.9717632618532425e-02
*
* Real pole n. 44
CS_44 NS_44 0 9.9999999999999998e-13
RS_44 NS_44 0 2.2567922184575468e+03
GS_44_8 0 NS_44 NA_8 0 8.9717632618532425e-02
*
* Real pole n. 45
CS_45 NS_45 0 9.9999999999999998e-13
RS_45 NS_45 0 1.1329278075555443e+04
GS_45_8 0 NS_45 NA_8 0 8.9717632618532425e-02
*
* Real pole n. 46
CS_46 NS_46 0 9.9999999999999998e-13
RS_46 NS_46 0 1.1063610802248793e+05
GS_46_8 0 NS_46 NA_8 0 8.9717632618532425e-02
*
* Complex pair n. 47/48
CS_47 NS_47 0 9.9999999999999998e-13
CS_48 NS_48 0 9.9999999999999998e-13
RS_47 NS_47 0 4.7633920490811545e+02
RS_48 NS_48 0 4.7633920490811545e+02
GL_47 0 NS_47 NS_48 0 4.5220934102261961e-04
GL_48 0 NS_48 NS_47 0 -4.5220934102261961e-04
GS_47_8 0 NS_47 NA_8 0 8.9717632618532425e-02
*
* Real pole n. 49
CS_49 NS_49 0 9.9999999999999998e-13
RS_49 NS_49 0 1.1464137755184745e+03
GS_49_9 0 NS_49 NA_9 0 8.9717632618532425e-02
*
* Real pole n. 50
CS_50 NS_50 0 9.9999999999999998e-13
RS_50 NS_50 0 2.2567922184575468e+03
GS_50_9 0 NS_50 NA_9 0 8.9717632618532425e-02
*
* Real pole n. 51
CS_51 NS_51 0 9.9999999999999998e-13
RS_51 NS_51 0 1.1329278075555443e+04
GS_51_9 0 NS_51 NA_9 0 8.9717632618532425e-02
*
* Real pole n. 52
CS_52 NS_52 0 9.9999999999999998e-13
RS_52 NS_52 0 1.1063610802248793e+05
GS_52_9 0 NS_52 NA_9 0 8.9717632618532425e-02
*
* Complex pair n. 53/54
CS_53 NS_53 0 9.9999999999999998e-13
CS_54 NS_54 0 9.9999999999999998e-13
RS_53 NS_53 0 4.7633920490811545e+02
RS_54 NS_54 0 4.7633920490811545e+02
GL_53 0 NS_53 NS_54 0 4.5220934102261961e-04
GL_54 0 NS_54 NS_53 0 -4.5220934102261961e-04
GS_53_9 0 NS_53 NA_9 0 8.9717632618532425e-02
*
* Real pole n. 55
CS_55 NS_55 0 9.9999999999999998e-13
RS_55 NS_55 0 1.1464137755184745e+03
GS_55_10 0 NS_55 NA_10 0 8.9717632618532425e-02
*
* Real pole n. 56
CS_56 NS_56 0 9.9999999999999998e-13
RS_56 NS_56 0 2.2567922184575468e+03
GS_56_10 0 NS_56 NA_10 0 8.9717632618532425e-02
*
* Real pole n. 57
CS_57 NS_57 0 9.9999999999999998e-13
RS_57 NS_57 0 1.1329278075555443e+04
GS_57_10 0 NS_57 NA_10 0 8.9717632618532425e-02
*
* Real pole n. 58
CS_58 NS_58 0 9.9999999999999998e-13
RS_58 NS_58 0 1.1063610802248793e+05
GS_58_10 0 NS_58 NA_10 0 8.9717632618532425e-02
*
* Complex pair n. 59/60
CS_59 NS_59 0 9.9999999999999998e-13
CS_60 NS_60 0 9.9999999999999998e-13
RS_59 NS_59 0 4.7633920490811545e+02
RS_60 NS_60 0 4.7633920490811545e+02
GL_59 0 NS_59 NS_60 0 4.5220934102261961e-04
GL_60 0 NS_60 NS_59 0 -4.5220934102261961e-04
GS_59_10 0 NS_59 NA_10 0 8.9717632618532425e-02
*
* Real pole n. 61
CS_61 NS_61 0 9.9999999999999998e-13
RS_61 NS_61 0 1.1464137755184745e+03
GS_61_11 0 NS_61 NA_11 0 8.9717632618532425e-02
*
* Real pole n. 62
CS_62 NS_62 0 9.9999999999999998e-13
RS_62 NS_62 0 2.2567922184575468e+03
GS_62_11 0 NS_62 NA_11 0 8.9717632618532425e-02
*
* Real pole n. 63
CS_63 NS_63 0 9.9999999999999998e-13
RS_63 NS_63 0 1.1329278075555443e+04
GS_63_11 0 NS_63 NA_11 0 8.9717632618532425e-02
*
* Real pole n. 64
CS_64 NS_64 0 9.9999999999999998e-13
RS_64 NS_64 0 1.1063610802248793e+05
GS_64_11 0 NS_64 NA_11 0 8.9717632618532425e-02
*
* Complex pair n. 65/66
CS_65 NS_65 0 9.9999999999999998e-13
CS_66 NS_66 0 9.9999999999999998e-13
RS_65 NS_65 0 4.7633920490811545e+02
RS_66 NS_66 0 4.7633920490811545e+02
GL_65 0 NS_65 NS_66 0 4.5220934102261961e-04
GL_66 0 NS_66 NS_65 0 -4.5220934102261961e-04
GS_65_11 0 NS_65 NA_11 0 8.9717632618532425e-02
*
* Real pole n. 67
CS_67 NS_67 0 9.9999999999999998e-13
RS_67 NS_67 0 1.1464137755184745e+03
GS_67_12 0 NS_67 NA_12 0 8.9717632618532425e-02
*
* Real pole n. 68
CS_68 NS_68 0 9.9999999999999998e-13
RS_68 NS_68 0 2.2567922184575468e+03
GS_68_12 0 NS_68 NA_12 0 8.9717632618532425e-02
*
* Real pole n. 69
CS_69 NS_69 0 9.9999999999999998e-13
RS_69 NS_69 0 1.1329278075555443e+04
GS_69_12 0 NS_69 NA_12 0 8.9717632618532425e-02
*
* Real pole n. 70
CS_70 NS_70 0 9.9999999999999998e-13
RS_70 NS_70 0 1.1063610802248793e+05
GS_70_12 0 NS_70 NA_12 0 8.9717632618532425e-02
*
* Complex pair n. 71/72
CS_71 NS_71 0 9.9999999999999998e-13
CS_72 NS_72 0 9.9999999999999998e-13
RS_71 NS_71 0 4.7633920490811545e+02
RS_72 NS_72 0 4.7633920490811545e+02
GL_71 0 NS_71 NS_72 0 4.5220934102261961e-04
GL_72 0 NS_72 NS_71 0 -4.5220934102261961e-04
GS_71_12 0 NS_71 NA_12 0 8.9717632618532425e-02
*
* Real pole n. 73
CS_73 NS_73 0 9.9999999999999998e-13
RS_73 NS_73 0 1.1464137755184745e+03
GS_73_13 0 NS_73 NA_13 0 8.9717632618532425e-02
*
* Real pole n. 74
CS_74 NS_74 0 9.9999999999999998e-13
RS_74 NS_74 0 2.2567922184575468e+03
GS_74_13 0 NS_74 NA_13 0 8.9717632618532425e-02
*
* Real pole n. 75
CS_75 NS_75 0 9.9999999999999998e-13
RS_75 NS_75 0 1.1329278075555443e+04
GS_75_13 0 NS_75 NA_13 0 8.9717632618532425e-02
*
* Real pole n. 76
CS_76 NS_76 0 9.9999999999999998e-13
RS_76 NS_76 0 1.1063610802248793e+05
GS_76_13 0 NS_76 NA_13 0 8.9717632618532425e-02
*
* Complex pair n. 77/78
CS_77 NS_77 0 9.9999999999999998e-13
CS_78 NS_78 0 9.9999999999999998e-13
RS_77 NS_77 0 4.7633920490811545e+02
RS_78 NS_78 0 4.7633920490811545e+02
GL_77 0 NS_77 NS_78 0 4.5220934102261961e-04
GL_78 0 NS_78 NS_77 0 -4.5220934102261961e-04
GS_77_13 0 NS_77 NA_13 0 8.9717632618532425e-02
*
* Real pole n. 79
CS_79 NS_79 0 9.9999999999999998e-13
RS_79 NS_79 0 1.1464137755184745e+03
GS_79_14 0 NS_79 NA_14 0 8.9717632618532425e-02
*
* Real pole n. 80
CS_80 NS_80 0 9.9999999999999998e-13
RS_80 NS_80 0 2.2567922184575468e+03
GS_80_14 0 NS_80 NA_14 0 8.9717632618532425e-02
*
* Real pole n. 81
CS_81 NS_81 0 9.9999999999999998e-13
RS_81 NS_81 0 1.1329278075555443e+04
GS_81_14 0 NS_81 NA_14 0 8.9717632618532425e-02
*
* Real pole n. 82
CS_82 NS_82 0 9.9999999999999998e-13
RS_82 NS_82 0 1.1063610802248793e+05
GS_82_14 0 NS_82 NA_14 0 8.9717632618532425e-02
*
* Complex pair n. 83/84
CS_83 NS_83 0 9.9999999999999998e-13
CS_84 NS_84 0 9.9999999999999998e-13
RS_83 NS_83 0 4.7633920490811545e+02
RS_84 NS_84 0 4.7633920490811545e+02
GL_83 0 NS_83 NS_84 0 4.5220934102261961e-04
GL_84 0 NS_84 NS_83 0 -4.5220934102261961e-04
GS_83_14 0 NS_83 NA_14 0 8.9717632618532425e-02
*
* Real pole n. 85
CS_85 NS_85 0 9.9999999999999998e-13
RS_85 NS_85 0 1.1464137755184745e+03
GS_85_15 0 NS_85 NA_15 0 8.9717632618532425e-02
*
* Real pole n. 86
CS_86 NS_86 0 9.9999999999999998e-13
RS_86 NS_86 0 2.2567922184575468e+03
GS_86_15 0 NS_86 NA_15 0 8.9717632618532425e-02
*
* Real pole n. 87
CS_87 NS_87 0 9.9999999999999998e-13
RS_87 NS_87 0 1.1329278075555443e+04
GS_87_15 0 NS_87 NA_15 0 8.9717632618532425e-02
*
* Real pole n. 88
CS_88 NS_88 0 9.9999999999999998e-13
RS_88 NS_88 0 1.1063610802248793e+05
GS_88_15 0 NS_88 NA_15 0 8.9717632618532425e-02
*
* Complex pair n. 89/90
CS_89 NS_89 0 9.9999999999999998e-13
CS_90 NS_90 0 9.9999999999999998e-13
RS_89 NS_89 0 4.7633920490811545e+02
RS_90 NS_90 0 4.7633920490811545e+02
GL_89 0 NS_89 NS_90 0 4.5220934102261961e-04
GL_90 0 NS_90 NS_89 0 -4.5220934102261961e-04
GS_89_15 0 NS_89 NA_15 0 8.9717632618532425e-02
*
* Real pole n. 91
CS_91 NS_91 0 9.9999999999999998e-13
RS_91 NS_91 0 1.1464137755184745e+03
GS_91_16 0 NS_91 NA_16 0 8.9717632618532425e-02
*
* Real pole n. 92
CS_92 NS_92 0 9.9999999999999998e-13
RS_92 NS_92 0 2.2567922184575468e+03
GS_92_16 0 NS_92 NA_16 0 8.9717632618532425e-02
*
* Real pole n. 93
CS_93 NS_93 0 9.9999999999999998e-13
RS_93 NS_93 0 1.1329278075555443e+04
GS_93_16 0 NS_93 NA_16 0 8.9717632618532425e-02
*
* Real pole n. 94
CS_94 NS_94 0 9.9999999999999998e-13
RS_94 NS_94 0 1.1063610802248793e+05
GS_94_16 0 NS_94 NA_16 0 8.9717632618532425e-02
*
* Complex pair n. 95/96
CS_95 NS_95 0 9.9999999999999998e-13
CS_96 NS_96 0 9.9999999999999998e-13
RS_95 NS_95 0 4.7633920490811545e+02
RS_96 NS_96 0 4.7633920490811545e+02
GL_95 0 NS_95 NS_96 0 4.5220934102261961e-04
GL_96 0 NS_96 NS_95 0 -4.5220934102261961e-04
GS_95_16 0 NS_95 NA_16 0 8.9717632618532425e-02
*
* Real pole n. 97
CS_97 NS_97 0 9.9999999999999998e-13
RS_97 NS_97 0 1.1464137755184745e+03
GS_97_17 0 NS_97 NA_17 0 8.9717632618532425e-02
*
* Real pole n. 98
CS_98 NS_98 0 9.9999999999999998e-13
RS_98 NS_98 0 2.2567922184575468e+03
GS_98_17 0 NS_98 NA_17 0 8.9717632618532425e-02
*
* Real pole n. 99
CS_99 NS_99 0 9.9999999999999998e-13
RS_99 NS_99 0 1.1329278075555443e+04
GS_99_17 0 NS_99 NA_17 0 8.9717632618532425e-02
*
* Real pole n. 100
CS_100 NS_100 0 9.9999999999999998e-13
RS_100 NS_100 0 1.1063610802248793e+05
GS_100_17 0 NS_100 NA_17 0 8.9717632618532425e-02
*
* Complex pair n. 101/102
CS_101 NS_101 0 9.9999999999999998e-13
CS_102 NS_102 0 9.9999999999999998e-13
RS_101 NS_101 0 4.7633920490811545e+02
RS_102 NS_102 0 4.7633920490811545e+02
GL_101 0 NS_101 NS_102 0 4.5220934102261961e-04
GL_102 0 NS_102 NS_101 0 -4.5220934102261961e-04
GS_101_17 0 NS_101 NA_17 0 8.9717632618532425e-02
*
* Real pole n. 103
CS_103 NS_103 0 9.9999999999999998e-13
RS_103 NS_103 0 1.1464137755184745e+03
GS_103_18 0 NS_103 NA_18 0 8.9717632618532425e-02
*
* Real pole n. 104
CS_104 NS_104 0 9.9999999999999998e-13
RS_104 NS_104 0 2.2567922184575468e+03
GS_104_18 0 NS_104 NA_18 0 8.9717632618532425e-02
*
* Real pole n. 105
CS_105 NS_105 0 9.9999999999999998e-13
RS_105 NS_105 0 1.1329278075555443e+04
GS_105_18 0 NS_105 NA_18 0 8.9717632618532425e-02
*
* Real pole n. 106
CS_106 NS_106 0 9.9999999999999998e-13
RS_106 NS_106 0 1.1063610802248793e+05
GS_106_18 0 NS_106 NA_18 0 8.9717632618532425e-02
*
* Complex pair n. 107/108
CS_107 NS_107 0 9.9999999999999998e-13
CS_108 NS_108 0 9.9999999999999998e-13
RS_107 NS_107 0 4.7633920490811545e+02
RS_108 NS_108 0 4.7633920490811545e+02
GL_107 0 NS_107 NS_108 0 4.5220934102261961e-04
GL_108 0 NS_108 NS_107 0 -4.5220934102261961e-04
GS_107_18 0 NS_107 NA_18 0 8.9717632618532425e-02
*
* Real pole n. 109
CS_109 NS_109 0 9.9999999999999998e-13
RS_109 NS_109 0 1.1464137755184745e+03
GS_109_19 0 NS_109 NA_19 0 8.9717632618532425e-02
*
* Real pole n. 110
CS_110 NS_110 0 9.9999999999999998e-13
RS_110 NS_110 0 2.2567922184575468e+03
GS_110_19 0 NS_110 NA_19 0 8.9717632618532425e-02
*
* Real pole n. 111
CS_111 NS_111 0 9.9999999999999998e-13
RS_111 NS_111 0 1.1329278075555443e+04
GS_111_19 0 NS_111 NA_19 0 8.9717632618532425e-02
*
* Real pole n. 112
CS_112 NS_112 0 9.9999999999999998e-13
RS_112 NS_112 0 1.1063610802248793e+05
GS_112_19 0 NS_112 NA_19 0 8.9717632618532425e-02
*
* Complex pair n. 113/114
CS_113 NS_113 0 9.9999999999999998e-13
CS_114 NS_114 0 9.9999999999999998e-13
RS_113 NS_113 0 4.7633920490811545e+02
RS_114 NS_114 0 4.7633920490811545e+02
GL_113 0 NS_113 NS_114 0 4.5220934102261961e-04
GL_114 0 NS_114 NS_113 0 -4.5220934102261961e-04
GS_113_19 0 NS_113 NA_19 0 8.9717632618532425e-02
*
* Real pole n. 115
CS_115 NS_115 0 9.9999999999999998e-13
RS_115 NS_115 0 1.1464137755184745e+03
GS_115_20 0 NS_115 NA_20 0 8.9717632618532425e-02
*
* Real pole n. 116
CS_116 NS_116 0 9.9999999999999998e-13
RS_116 NS_116 0 2.2567922184575468e+03
GS_116_20 0 NS_116 NA_20 0 8.9717632618532425e-02
*
* Real pole n. 117
CS_117 NS_117 0 9.9999999999999998e-13
RS_117 NS_117 0 1.1329278075555443e+04
GS_117_20 0 NS_117 NA_20 0 8.9717632618532425e-02
*
* Real pole n. 118
CS_118 NS_118 0 9.9999999999999998e-13
RS_118 NS_118 0 1.1063610802248793e+05
GS_118_20 0 NS_118 NA_20 0 8.9717632618532425e-02
*
* Complex pair n. 119/120
CS_119 NS_119 0 9.9999999999999998e-13
CS_120 NS_120 0 9.9999999999999998e-13
RS_119 NS_119 0 4.7633920490811545e+02
RS_120 NS_120 0 4.7633920490811545e+02
GL_119 0 NS_119 NS_120 0 4.5220934102261961e-04
GL_120 0 NS_120 NS_119 0 -4.5220934102261961e-04
GS_119_20 0 NS_119 NA_20 0 8.9717632618532425e-02
*
* Real pole n. 121
CS_121 NS_121 0 9.9999999999999998e-13
RS_121 NS_121 0 1.1464137755184745e+03
GS_121_21 0 NS_121 NA_21 0 8.9717632618532425e-02
*
* Real pole n. 122
CS_122 NS_122 0 9.9999999999999998e-13
RS_122 NS_122 0 2.2567922184575468e+03
GS_122_21 0 NS_122 NA_21 0 8.9717632618532425e-02
*
* Real pole n. 123
CS_123 NS_123 0 9.9999999999999998e-13
RS_123 NS_123 0 1.1329278075555443e+04
GS_123_21 0 NS_123 NA_21 0 8.9717632618532425e-02
*
* Real pole n. 124
CS_124 NS_124 0 9.9999999999999998e-13
RS_124 NS_124 0 1.1063610802248793e+05
GS_124_21 0 NS_124 NA_21 0 8.9717632618532425e-02
*
* Complex pair n. 125/126
CS_125 NS_125 0 9.9999999999999998e-13
CS_126 NS_126 0 9.9999999999999998e-13
RS_125 NS_125 0 4.7633920490811545e+02
RS_126 NS_126 0 4.7633920490811545e+02
GL_125 0 NS_125 NS_126 0 4.5220934102261961e-04
GL_126 0 NS_126 NS_125 0 -4.5220934102261961e-04
GS_125_21 0 NS_125 NA_21 0 8.9717632618532425e-02
*
* Real pole n. 127
CS_127 NS_127 0 9.9999999999999998e-13
RS_127 NS_127 0 1.1464137755184745e+03
GS_127_22 0 NS_127 NA_22 0 8.9717632618532425e-02
*
* Real pole n. 128
CS_128 NS_128 0 9.9999999999999998e-13
RS_128 NS_128 0 2.2567922184575468e+03
GS_128_22 0 NS_128 NA_22 0 8.9717632618532425e-02
*
* Real pole n. 129
CS_129 NS_129 0 9.9999999999999998e-13
RS_129 NS_129 0 1.1329278075555443e+04
GS_129_22 0 NS_129 NA_22 0 8.9717632618532425e-02
*
* Real pole n. 130
CS_130 NS_130 0 9.9999999999999998e-13
RS_130 NS_130 0 1.1063610802248793e+05
GS_130_22 0 NS_130 NA_22 0 8.9717632618532425e-02
*
* Complex pair n. 131/132
CS_131 NS_131 0 9.9999999999999998e-13
CS_132 NS_132 0 9.9999999999999998e-13
RS_131 NS_131 0 4.7633920490811545e+02
RS_132 NS_132 0 4.7633920490811545e+02
GL_131 0 NS_131 NS_132 0 4.5220934102261961e-04
GL_132 0 NS_132 NS_131 0 -4.5220934102261961e-04
GS_131_22 0 NS_131 NA_22 0 8.9717632618532425e-02
*
******************************

.ends
*******************
* End of subcircuit
*******************
