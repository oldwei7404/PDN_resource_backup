**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 22-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Tue Apr 22 10:16:35 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Tue Apr 22 10:16:35 2025
**
**  Modal data exported
**  Port[1] = PORT_1_L34_SOC_VSOC_Group_U40_GND_Group
**  Port[2] = PORT_2_U1_SOC_VSOC_Group_U1_GRP_1_1_GND
**  Port[3] = SOC_VSOC_C467_1
**  Port[4] = SOC_VSOC_C468_1
**  Port[5] = SOC_VSOC_C469_1
**  Port[6] = SOC_VSOC_C470_1
**  Port[7] = SOC_VSOC_C471_1
**  Port[8] = SOC_VSOC_C473_1
**  Port[9] = SOC_VSOC_C560_1
**  Port[10] = SOC_VSOC_C560_3
**  Port[11] = SOC_VSOC_C561_1
**  Port[12] = SOC_VSOC_C561_3
**  Port[13] = SOC_VSOC_C648_1
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_SOC
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 2.9471242803144226e-02
GC_1_2 ref NI_1 NS_2 0 -3.5161452554130737e-02
GC_1_3 ref NI_1 NS_3 0 -4.7083307441285249e-05
GC_1_4 ref NI_1 NS_4 0 -1.9543619416224952e-02
GC_1_5 ref NI_1 NS_5 0 3.8244780894112297e-02
GC_1_6 ref NI_1 NS_6 0 -3.6086914225519920e-02
GC_1_7 ref NI_1 NS_7 0 -2.5605859866957318e-03
GC_1_8 ref NI_1 NS_8 0 6.1962209936828180e-03
GC_1_9 ref NI_1 NS_9 0 2.6837604464357416e-06
GC_1_10 ref NI_1 NS_10 0 1.2082742635397107e-03
GC_1_11 ref NI_1 NS_11 0 -1.7765393095133695e-03
GC_1_12 ref NI_1 NS_12 0 2.7919990190239268e-03
GC_1_13 ref NI_1 NS_13 0 -2.0758774436597550e-03
GC_1_14 ref NI_1 NS_14 0 2.0862711040359611e-03
GC_1_15 ref NI_1 NS_15 0 2.8939340151560546e-06
GC_1_16 ref NI_1 NS_16 0 1.4208826924984124e-03
GC_1_17 ref NI_1 NS_17 0 -5.1263553260702029e-03
GC_1_18 ref NI_1 NS_18 0 5.4124186636164678e-03
GC_1_19 ref NI_1 NS_19 0 -2.3677072966214953e-03
GC_1_20 ref NI_1 NS_20 0 2.5208442976247534e-03
GC_1_21 ref NI_1 NS_21 0 4.4309596092203886e-06
GC_1_22 ref NI_1 NS_22 0 1.8096439387913661e-03
GC_1_23 ref NI_1 NS_23 0 -5.3228300104849391e-03
GC_1_24 ref NI_1 NS_24 0 4.0084641751865040e-03
GC_1_25 ref NI_1 NS_25 0 -2.4061133374815311e-03
GC_1_26 ref NI_1 NS_26 0 2.6668741459970413e-03
GC_1_27 ref NI_1 NS_27 0 4.9936381217758962e-06
GC_1_28 ref NI_1 NS_28 0 1.8918508540384305e-03
GC_1_29 ref NI_1 NS_29 0 -4.9067735793316310e-03
GC_1_30 ref NI_1 NS_30 0 3.3320251240430308e-03
GC_1_31 ref NI_1 NS_31 0 -2.2793120986980015e-03
GC_1_32 ref NI_1 NS_32 0 2.9837955901070401e-03
GC_1_33 ref NI_1 NS_33 0 2.2526701028141831e-06
GC_1_34 ref NI_1 NS_34 0 1.0587096343165454e-03
GC_1_35 ref NI_1 NS_35 0 -3.3276288463230650e-03
GC_1_36 ref NI_1 NS_36 0 5.2828999301368137e-03
GC_1_37 ref NI_1 NS_37 0 -1.7901112528513059e-03
GC_1_38 ref NI_1 NS_38 0 1.6347030328125508e-03
GC_1_39 ref NI_1 NS_39 0 3.0513855744472039e-06
GC_1_40 ref NI_1 NS_40 0 1.4102211656189740e-03
GC_1_41 ref NI_1 NS_41 0 -5.3051533835109729e-03
GC_1_42 ref NI_1 NS_42 0 5.6494520888251036e-03
GC_1_43 ref NI_1 NS_43 0 -2.4221993408432198e-03
GC_1_44 ref NI_1 NS_44 0 3.3021463438623038e-03
GC_1_45 ref NI_1 NS_45 0 2.0355313534715648e-06
GC_1_46 ref NI_1 NS_46 0 1.0734880735955761e-03
GC_1_47 ref NI_1 NS_47 0 -3.0757854358112878e-03
GC_1_48 ref NI_1 NS_48 0 4.9975377385958527e-03
GC_1_49 ref NI_1 NS_49 0 -1.8287124575309874e-03
GC_1_50 ref NI_1 NS_50 0 1.8884661745530887e-03
GC_1_51 ref NI_1 NS_51 0 5.3772794883757763e-06
GC_1_52 ref NI_1 NS_52 0 2.3502566921456696e-03
GC_1_53 ref NI_1 NS_53 0 -1.3580999338031368e-03
GC_1_54 ref NI_1 NS_54 0 -9.0446997975901771e-04
GC_1_55 ref NI_1 NS_55 0 -1.6317872712137043e-03
GC_1_56 ref NI_1 NS_56 0 1.5905654553660397e-03
GC_1_57 ref NI_1 NS_57 0 4.9949767509846446e-06
GC_1_58 ref NI_1 NS_58 0 2.3221937963437294e-03
GC_1_59 ref NI_1 NS_59 0 -9.1901365741481507e-04
GC_1_60 ref NI_1 NS_60 0 -1.0644259650263693e-03
GC_1_61 ref NI_1 NS_61 0 -2.5041665930583051e-03
GC_1_62 ref NI_1 NS_62 0 2.8806049813468633e-03
GC_1_63 ref NI_1 NS_63 0 5.5589533160395616e-06
GC_1_64 ref NI_1 NS_64 0 2.2926645701745363e-03
GC_1_65 ref NI_1 NS_65 0 -3.0352677790879737e-03
GC_1_66 ref NI_1 NS_66 0 4.0797247430161094e-04
GC_1_67 ref NI_1 NS_67 0 -2.4488217985940029e-03
GC_1_68 ref NI_1 NS_68 0 2.7042998817461287e-03
GC_1_69 ref NI_1 NS_69 0 5.1937776249668926e-06
GC_1_70 ref NI_1 NS_70 0 1.9931463131530494e-03
GC_1_71 ref NI_1 NS_71 0 -3.8307707870665663e-03
GC_1_72 ref NI_1 NS_72 0 2.1332757834826442e-03
GC_1_73 ref NI_1 NS_73 0 -2.6116236049624373e-03
GC_1_74 ref NI_1 NS_74 0 3.3947013157431295e-03
GC_1_75 ref NI_1 NS_75 0 4.5550730891268626e-06
GC_1_76 ref NI_1 NS_76 0 7.5766432580101888e-04
GC_1_77 ref NI_1 NS_77 0 -4.0928811357896015e-05
GC_1_78 ref NI_1 NS_78 0 3.8162285434041000e-03
GD_1_1 ref NI_1 NA_1 0 6.2566459165308483e+00
GD_1_2 ref NI_1 NA_2 0 -3.0333498984341169e-03
GD_1_3 ref NI_1 NA_3 0 2.3976720549867135e-03
GD_1_4 ref NI_1 NA_4 0 3.3572810562605884e-03
GD_1_5 ref NI_1 NA_5 0 3.2466321327691765e-03
GD_1_6 ref NI_1 NA_6 0 1.6887310186497070e-03
GD_1_7 ref NI_1 NA_7 0 2.6462683483640453e-03
GD_1_8 ref NI_1 NA_8 0 8.5726401876248250e-04
GD_1_9 ref NI_1 NA_9 0 3.3743069745093644e-03
GD_1_10 ref NI_1 NA_10 0 3.5494994782618787e-03
GD_1_11 ref NI_1 NA_11 0 4.4647072783524444e-03
GD_1_12 ref NI_1 NA_12 0 4.4679927707844992e-03
GD_1_13 ref NI_1 NA_13 0 4.6373152133295228e-03
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -2.5605859866957023e-03
GC_2_2 ref NI_2 NS_2 0 6.1962209936827824e-03
GC_2_3 ref NI_2 NS_3 0 2.6837604464355760e-06
GC_2_4 ref NI_2 NS_4 0 1.2082742635397114e-03
GC_2_5 ref NI_2 NS_5 0 -1.7765393095133467e-03
GC_2_6 ref NI_2 NS_6 0 2.7919990190239125e-03
GC_2_7 ref NI_2 NS_7 0 2.4987447417991704e-01
GC_2_8 ref NI_2 NS_8 0 -3.7390031169822829e-01
GC_2_9 ref NI_2 NS_9 0 -1.1969393199374866e-05
GC_2_10 ref NI_2 NS_10 0 -5.3539462137664449e-04
GC_2_11 ref NI_2 NS_11 0 -3.9979872329313264e-02
GC_2_12 ref NI_2 NS_12 0 6.6910443084045200e-03
GC_2_13 ref NI_2 NS_13 0 9.5944818075630674e-04
GC_2_14 ref NI_2 NS_14 0 2.8720573337682798e-02
GC_2_15 ref NI_2 NS_15 0 -5.5442585687438112e-07
GC_2_16 ref NI_2 NS_16 0 -5.2570792653327788e-05
GC_2_17 ref NI_2 NS_17 0 7.7936309507151465e-03
GC_2_18 ref NI_2 NS_18 0 -6.2068576979454441e-03
GC_2_19 ref NI_2 NS_19 0 2.9728268001577324e-04
GC_2_20 ref NI_2 NS_20 0 8.1227934173595945e-03
GC_2_21 ref NI_2 NS_21 0 7.0091419266477894e-07
GC_2_22 ref NI_2 NS_22 0 -2.7315827571170248e-05
GC_2_23 ref NI_2 NS_23 0 9.9877709056945853e-03
GC_2_24 ref NI_2 NS_24 0 -2.3987217388105244e-03
GC_2_25 ref NI_2 NS_25 0 -1.0850453895864586e-03
GC_2_26 ref NI_2 NS_26 0 1.6869597164196868e-02
GC_2_27 ref NI_2 NS_27 0 8.1146207791402654e-07
GC_2_28 ref NI_2 NS_28 0 -3.7693625253598611e-05
GC_2_29 ref NI_2 NS_29 0 6.8181573990859301e-03
GC_2_30 ref NI_2 NS_30 0 -2.1319977624098046e-03
GC_2_31 ref NI_2 NS_31 0 -1.3825743212726376e-02
GC_2_32 ref NI_2 NS_32 0 2.6630463674010164e-02
GC_2_33 ref NI_2 NS_33 0 -2.6698476197808381e-07
GC_2_34 ref NI_2 NS_34 0 2.9593001417916392e-05
GC_2_35 ref NI_2 NS_35 0 1.8326321281503962e-02
GC_2_36 ref NI_2 NS_36 0 -1.1038677701865368e-02
GC_2_37 ref NI_2 NS_37 0 -1.3518779320568192e-02
GC_2_38 ref NI_2 NS_38 0 2.0311059067026724e-02
GC_2_39 ref NI_2 NS_39 0 -3.3977774849375649e-07
GC_2_40 ref NI_2 NS_40 0 1.5596567924418195e-05
GC_2_41 ref NI_2 NS_41 0 1.9667874377150472e-02
GC_2_42 ref NI_2 NS_42 0 -1.0373758758769362e-02
GC_2_43 ref NI_2 NS_43 0 2.7194438972167759e-03
GC_2_44 ref NI_2 NS_44 0 3.4441934236772200e-02
GC_2_45 ref NI_2 NS_45 0 -3.7789206716876055e-07
GC_2_46 ref NI_2 NS_46 0 -4.7793937040981512e-05
GC_2_47 ref NI_2 NS_47 0 5.8168219423519948e-03
GC_2_48 ref NI_2 NS_48 0 -6.5796475858068094e-03
GC_2_49 ref NI_2 NS_49 0 -6.7890756700214536e-03
GC_2_50 ref NI_2 NS_50 0 1.7872992653864935e-02
GC_2_51 ref NI_2 NS_51 0 3.9051136358445066e-07
GC_2_52 ref NI_2 NS_52 0 3.3596736702600523e-05
GC_2_53 ref NI_2 NS_53 0 4.9571029490159254e-03
GC_2_54 ref NI_2 NS_54 0 -4.0152285782664015e-04
GC_2_55 ref NI_2 NS_55 0 -4.4266864131894392e-03
GC_2_56 ref NI_2 NS_56 0 1.7298402954187334e-02
GC_2_57 ref NI_2 NS_57 0 7.1101056349480800e-07
GC_2_58 ref NI_2 NS_58 0 2.9073363535230654e-05
GC_2_59 ref NI_2 NS_59 0 2.4015266112587916e-03
GC_2_60 ref NI_2 NS_60 0 1.1604650263384055e-03
GC_2_61 ref NI_2 NS_61 0 -3.3987425136866450e-03
GC_2_62 ref NI_2 NS_62 0 9.5109059676340181e-03
GC_2_63 ref NI_2 NS_63 0 9.5623659186667258e-07
GC_2_64 ref NI_2 NS_64 0 5.7375499785296074e-05
GC_2_65 ref NI_2 NS_65 0 3.1669408834903733e-03
GC_2_66 ref NI_2 NS_66 0 2.4516346802942149e-03
GC_2_67 ref NI_2 NS_67 0 -3.5224410656645882e-03
GC_2_68 ref NI_2 NS_68 0 1.7251920377011336e-02
GC_2_69 ref NI_2 NS_69 0 2.4311675847108553e-06
GC_2_70 ref NI_2 NS_70 0 3.9708599080393230e-05
GC_2_71 ref NI_2 NS_71 0 5.4700734500865537e-03
GC_2_72 ref NI_2 NS_72 0 -1.3147360002083084e-03
GC_2_73 ref NI_2 NS_73 0 4.7267233991238724e-03
GC_2_74 ref NI_2 NS_74 0 -1.0031689734719566e-04
GC_2_75 ref NI_2 NS_75 0 5.1041882762265659e-07
GC_2_76 ref NI_2 NS_76 0 -6.1924955158905771e-05
GC_2_77 ref NI_2 NS_77 0 1.3343678593707510e-02
GC_2_78 ref NI_2 NS_78 0 -3.2358085324756471e-03
GD_2_1 ref NI_2 NA_1 0 -3.0333498984341169e-03
GD_2_2 ref NI_2 NA_2 0 5.8103579619339900e+00
GD_2_3 ref NI_2 NA_3 0 -3.0836575786743141e-02
GD_2_4 ref NI_2 NA_4 0 -1.9186634380914492e-02
GD_2_5 ref NI_2 NA_5 0 -2.3105322973765042e-02
GD_2_6 ref NI_2 NA_6 0 -1.9037484228276322e-02
GD_2_7 ref NI_2 NA_7 0 -1.3809888012927282e-02
GD_2_8 ref NI_2 NA_8 0 -3.8469745017181665e-02
GD_2_9 ref NI_2 NA_9 0 -3.8837294932748513e-03
GD_2_10 ref NI_2 NA_10 0 -2.7499020905039664e-04
GD_2_11 ref NI_2 NA_11 0 -2.9446560321128470e-03
GD_2_12 ref NI_2 NA_12 0 -4.2136712402362575e-03
GD_2_13 ref NI_2 NA_13 0 -2.3583380571558572e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 -2.0758774436597468e-03
GC_3_2 ref NI_3 NS_2 0 2.0862711040359532e-03
GC_3_3 ref NI_3 NS_3 0 2.8939340151563197e-06
GC_3_4 ref NI_3 NS_4 0 1.4208826924984113e-03
GC_3_5 ref NI_3 NS_5 0 -5.1263553260702073e-03
GC_3_6 ref NI_3 NS_6 0 5.4124186636164747e-03
GC_3_7 ref NI_3 NS_7 0 9.5944818075630609e-04
GC_3_8 ref NI_3 NS_8 0 2.8720573337682805e-02
GC_3_9 ref NI_3 NS_9 0 -5.5442585687477627e-07
GC_3_10 ref NI_3 NS_10 0 -5.2570792653326717e-05
GC_3_11 ref NI_3 NS_11 0 7.7936309507151517e-03
GC_3_12 ref NI_3 NS_12 0 -6.2068576979454502e-03
GC_3_13 ref NI_3 NS_13 0 1.4325464403354211e-02
GC_3_14 ref NI_3 NS_14 0 -2.0884267650136037e-01
GC_3_15 ref NI_3 NS_15 0 -4.5000698631410945e-06
GC_3_16 ref NI_3 NS_16 0 -6.7911223935766547e-04
GC_3_17 ref NI_3 NS_17 0 -4.4284861694623930e-02
GC_3_18 ref NI_3 NS_18 0 5.8496209204575893e-03
GC_3_19 ref NI_3 NS_19 0 -1.0276370310869004e-02
GC_3_20 ref NI_3 NS_20 0 6.8010925642502194e-03
GC_3_21 ref NI_3 NS_21 0 2.1568008345612234e-07
GC_3_22 ref NI_3 NS_22 0 -5.5921989330912239e-05
GC_3_23 ref NI_3 NS_23 0 1.1917431148643414e-02
GC_3_24 ref NI_3 NS_24 0 -1.5595706929770351e-03
GC_3_25 ref NI_3 NS_25 0 2.9178460275667499e-04
GC_3_26 ref NI_3 NS_26 0 -4.2586753975100405e-03
GC_3_27 ref NI_3 NS_27 0 9.9368901343596274e-07
GC_3_28 ref NI_3 NS_28 0 -6.2692194973747273e-05
GC_3_29 ref NI_3 NS_29 0 8.6581216346336733e-03
GC_3_30 ref NI_3 NS_30 0 1.8654496849222679e-03
GC_3_31 ref NI_3 NS_31 0 -7.6688396249744592e-02
GC_3_32 ref NI_3 NS_32 0 6.4850653042993728e-02
GC_3_33 ref NI_3 NS_33 0 -1.3671351037843017e-06
GC_3_34 ref NI_3 NS_34 0 8.4790591727301428e-05
GC_3_35 ref NI_3 NS_35 0 3.4694162295687461e-02
GC_3_36 ref NI_3 NS_36 0 -2.2268129414352033e-02
GC_3_37 ref NI_3 NS_37 0 6.6070315279030914e-02
GC_3_38 ref NI_3 NS_38 0 7.4477851783179588e-02
GC_3_39 ref NI_3 NS_39 0 -1.3184396287110811e-06
GC_3_40 ref NI_3 NS_40 0 -5.1619946484835692e-04
GC_3_41 ref NI_3 NS_41 0 -3.9377492812634703e-02
GC_3_42 ref NI_3 NS_42 0 5.8999684107166233e-03
GC_3_43 ref NI_3 NS_43 0 3.2617260986481003e-02
GC_3_44 ref NI_3 NS_44 0 1.5747193695327222e-02
GC_3_45 ref NI_3 NS_45 0 -6.1854300723467549e-07
GC_3_46 ref NI_3 NS_46 0 -6.4937400559376173e-05
GC_3_47 ref NI_3 NS_47 0 1.3971826508972647e-02
GC_3_48 ref NI_3 NS_48 0 -1.3236197905752714e-02
GC_3_49 ref NI_3 NS_49 0 -1.7870194204086596e-03
GC_3_50 ref NI_3 NS_50 0 2.3967320278226521e-03
GC_3_51 ref NI_3 NS_51 0 2.9509116321521066e-06
GC_3_52 ref NI_3 NS_52 0 6.5479414428389949e-05
GC_3_53 ref NI_3 NS_53 0 -7.4659601688181433e-03
GC_3_54 ref NI_3 NS_54 0 1.1623100289490755e-02
GC_3_55 ref NI_3 NS_55 0 -3.2665471213844028e-03
GC_3_56 ref NI_3 NS_56 0 5.4339015522271725e-03
GC_3_57 ref NI_3 NS_57 0 3.8501251519527704e-07
GC_3_58 ref NI_3 NS_58 0 1.0582186575922725e-04
GC_3_59 ref NI_3 NS_59 0 -5.7730211122804607e-03
GC_3_60 ref NI_3 NS_60 0 9.7987957194051265e-03
GC_3_61 ref NI_3 NS_61 0 2.8028483385920820e-03
GC_3_62 ref NI_3 NS_62 0 -3.8624274505027014e-03
GC_3_63 ref NI_3 NS_63 0 1.1365726684797330e-06
GC_3_64 ref NI_3 NS_64 0 2.5222210211761406e-05
GC_3_65 ref NI_3 NS_65 0 -1.2559049076539524e-03
GC_3_66 ref NI_3 NS_66 0 8.2020415250618865e-03
GC_3_67 ref NI_3 NS_67 0 -7.8266538368873696e-03
GC_3_68 ref NI_3 NS_68 0 1.6609475510124132e-02
GC_3_69 ref NI_3 NS_69 0 1.2771160956547921e-07
GC_3_70 ref NI_3 NS_70 0 -2.4343754834774476e-05
GC_3_71 ref NI_3 NS_71 0 9.3965687773297172e-03
GC_3_72 ref NI_3 NS_72 0 -2.9095902335339288e-03
GC_3_73 ref NI_3 NS_73 0 5.6183396970772587e-03
GC_3_74 ref NI_3 NS_74 0 -1.5985090848680734e-02
GC_3_75 ref NI_3 NS_75 0 5.7166062275012219e-08
GC_3_76 ref NI_3 NS_76 0 -1.3022170676494691e-04
GC_3_77 ref NI_3 NS_77 0 2.2742839890565400e-02
GC_3_78 ref NI_3 NS_78 0 -5.8789304337158142e-03
GD_3_1 ref NI_3 NA_1 0 2.3976720549867135e-03
GD_3_2 ref NI_3 NA_2 0 -3.0836575786743141e-02
GD_3_3 ref NI_3 NA_3 0 6.2236635419119803e+00
GD_3_4 ref NI_3 NA_4 0 1.8963971877622536e-03
GD_3_5 ref NI_3 NA_5 0 -4.3223813960796796e-03
GD_3_6 ref NI_3 NA_6 0 2.7220504164694959e-02
GD_3_7 ref NI_3 NA_7 0 -4.0524286758150785e-02
GD_3_8 ref NI_3 NA_8 0 8.3610551715788978e-03
GD_3_9 ref NI_3 NA_9 0 1.6884742486395232e-03
GD_3_10 ref NI_3 NA_10 0 6.0337833546119397e-03
GD_3_11 ref NI_3 NA_11 0 2.4213080616190042e-03
GD_3_12 ref NI_3 NA_12 0 1.1574081852637421e-02
GD_3_13 ref NI_3 NA_13 0 -9.3009823728069981e-03
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -2.3677072966214793e-03
GC_4_2 ref NI_4 NS_2 0 2.5208442976247343e-03
GC_4_3 ref NI_4 NS_3 0 4.4309596092202531e-06
GC_4_4 ref NI_4 NS_4 0 1.8096439387913668e-03
GC_4_5 ref NI_4 NS_5 0 -5.3228300104849260e-03
GC_4_6 ref NI_4 NS_6 0 4.0084641751864962e-03
GC_4_7 ref NI_4 NS_7 0 2.9728268001576424e-04
GC_4_8 ref NI_4 NS_8 0 8.1227934173596101e-03
GC_4_9 ref NI_4 NS_9 0 7.0091419266481134e-07
GC_4_10 ref NI_4 NS_10 0 -2.7315827571170617e-05
GC_4_11 ref NI_4 NS_11 0 9.9877709056945749e-03
GC_4_12 ref NI_4 NS_12 0 -2.3987217388105175e-03
GC_4_13 ref NI_4 NS_13 0 -1.0276370310868999e-02
GC_4_14 ref NI_4 NS_14 0 6.8010925642502107e-03
GC_4_15 ref NI_4 NS_15 0 2.1568008345611969e-07
GC_4_16 ref NI_4 NS_16 0 -5.5921989330911962e-05
GC_4_17 ref NI_4 NS_17 0 1.1917431148643420e-02
GC_4_18 ref NI_4 NS_18 0 -1.5595706929770405e-03
GC_4_19 ref NI_4 NS_19 0 9.2234655611524871e-02
GC_4_20 ref NI_4 NS_20 0 -1.9117814905455763e-01
GC_4_21 ref NI_4 NS_21 0 -6.8377449741739709e-06
GC_4_22 ref NI_4 NS_22 0 -1.1333042871382556e-03
GC_4_23 ref NI_4 NS_23 0 -8.9337327646840076e-02
GC_4_24 ref NI_4 NS_24 0 2.2073716803293179e-02
GC_4_25 ref NI_4 NS_25 0 -2.7190603796320243e-02
GC_4_26 ref NI_4 NS_26 0 6.9606414659565782e-02
GC_4_27 ref NI_4 NS_27 0 4.3368156826081524e-07
GC_4_28 ref NI_4 NS_28 0 -3.6192484282961580e-05
GC_4_29 ref NI_4 NS_29 0 3.1433303141773510e-03
GC_4_30 ref NI_4 NS_30 0 -9.1570927026038869e-03
GC_4_31 ref NI_4 NS_31 0 1.5891793562997067e-04
GC_4_32 ref NI_4 NS_32 0 3.1138716523141157e-03
GC_4_33 ref NI_4 NS_33 0 7.1616090628628748e-07
GC_4_34 ref NI_4 NS_34 0 -6.0022074461595712e-05
GC_4_35 ref NI_4 NS_35 0 6.8912057840074736e-03
GC_4_36 ref NI_4 NS_36 0 1.2245643806046294e-03
GC_4_37 ref NI_4 NS_37 0 3.0597311419917179e-03
GC_4_38 ref NI_4 NS_38 0 1.8189094298795075e-02
GC_4_39 ref NI_4 NS_39 0 2.5772852945445428e-07
GC_4_40 ref NI_4 NS_40 0 -1.2572759983351642e-04
GC_4_41 ref NI_4 NS_41 0 5.2628765526493548e-04
GC_4_42 ref NI_4 NS_42 0 1.5666490331729399e-03
GC_4_43 ref NI_4 NS_43 0 1.9842167747577935e-03
GC_4_44 ref NI_4 NS_44 0 -8.6477780368848286e-03
GC_4_45 ref NI_4 NS_45 0 6.5746161647198756e-07
GC_4_46 ref NI_4 NS_46 0 -3.6732958211325471e-05
GC_4_47 ref NI_4 NS_47 0 1.2189069342212850e-02
GC_4_48 ref NI_4 NS_48 0 9.4010095986990101e-05
GC_4_49 ref NI_4 NS_49 0 1.7609773943260360e-03
GC_4_50 ref NI_4 NS_50 0 -1.1182200923433831e-02
GC_4_51 ref NI_4 NS_51 0 1.1089864130304589e-06
GC_4_52 ref NI_4 NS_52 0 -1.7156930357875364e-05
GC_4_53 ref NI_4 NS_53 0 8.3926392952668565e-03
GC_4_54 ref NI_4 NS_54 0 3.4387206310206564e-03
GC_4_55 ref NI_4 NS_55 0 -2.8711063194277191e-03
GC_4_56 ref NI_4 NS_56 0 8.0746518266177469e-03
GC_4_57 ref NI_4 NS_57 0 -3.7347154989960116e-07
GC_4_58 ref NI_4 NS_58 0 -2.8957336765663289e-05
GC_4_59 ref NI_4 NS_59 0 2.5597446103478149e-03
GC_4_60 ref NI_4 NS_60 0 3.4850679968609325e-03
GC_4_61 ref NI_4 NS_61 0 -2.5316138236881582e-02
GC_4_62 ref NI_4 NS_62 0 6.3286773385498526e-02
GC_4_63 ref NI_4 NS_63 0 -1.3087774992297427e-06
GC_4_64 ref NI_4 NS_64 0 -1.5075173806846945e-04
GC_4_65 ref NI_4 NS_65 0 1.3481437173392176e-02
GC_4_66 ref NI_4 NS_66 0 -1.5030086341804883e-02
GC_4_67 ref NI_4 NS_67 0 9.8941288804074322e-04
GC_4_68 ref NI_4 NS_68 0 -1.1412910773056466e-02
GC_4_69 ref NI_4 NS_69 0 1.8276713375314526e-06
GC_4_70 ref NI_4 NS_70 0 -1.7601371363041826e-05
GC_4_71 ref NI_4 NS_71 0 1.3799481175507887e-02
GC_4_72 ref NI_4 NS_72 0 -2.9505315701960515e-04
GC_4_73 ref NI_4 NS_73 0 -1.5152284676519693e-02
GC_4_74 ref NI_4 NS_74 0 2.9270899036859897e-02
GC_4_75 ref NI_4 NS_75 0 -1.2885480737520196e-06
GC_4_76 ref NI_4 NS_76 0 -1.8844203287039845e-05
GC_4_77 ref NI_4 NS_77 0 1.6602442669036929e-02
GC_4_78 ref NI_4 NS_78 0 -1.0224017757990343e-02
GD_4_1 ref NI_4 NA_1 0 3.3572810562605884e-03
GD_4_2 ref NI_4 NA_2 0 -1.9186634380914492e-02
GD_4_3 ref NI_4 NA_3 0 1.8963971877622536e-03
GD_4_4 ref NI_4 NA_4 0 6.1669314302359997e+00
GD_4_5 ref NI_4 NA_5 0 2.2967524867378492e-02
GD_4_6 ref NI_4 NA_6 0 -2.2261480679423035e-03
GD_4_7 ref NI_4 NA_7 0 -1.9758991595125353e-03
GD_4_8 ref NI_4 NA_8 0 -3.3144091059642308e-03
GD_4_9 ref NI_4 NA_9 0 -4.4600078213214328e-04
GD_4_10 ref NI_4 NA_10 0 7.2903552626340561e-03
GD_4_11 ref NI_4 NA_11 0 4.3796845636921558e-02
GD_4_12 ref NI_4 NA_12 0 -1.8424578646830498e-03
GD_4_13 ref NI_4 NA_13 0 7.9434312269048343e-03
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -2.4061133374815242e-03
GC_5_2 ref NI_5 NS_2 0 2.6668741459970366e-03
GC_5_3 ref NI_5 NS_3 0 4.9936381217763756e-06
GC_5_4 ref NI_5 NS_4 0 1.8918508540384286e-03
GC_5_5 ref NI_5 NS_5 0 -4.9067735793316431e-03
GC_5_6 ref NI_5 NS_6 0 3.3320251240430421e-03
GC_5_7 ref NI_5 NS_7 0 -1.0850453895864564e-03
GC_5_8 ref NI_5 NS_8 0 1.6869597164196868e-02
GC_5_9 ref NI_5 NS_9 0 8.1146207791402876e-07
GC_5_10 ref NI_5 NS_10 0 -3.7693625253598611e-05
GC_5_11 ref NI_5 NS_11 0 6.8181573990859327e-03
GC_5_12 ref NI_5 NS_12 0 -2.1319977624098059e-03
GC_5_13 ref NI_5 NS_13 0 2.9178460275667114e-04
GC_5_14 ref NI_5 NS_14 0 -4.2586753975100361e-03
GC_5_15 ref NI_5 NS_15 0 9.9368901343617937e-07
GC_5_16 ref NI_5 NS_16 0 -6.2692194973748113e-05
GC_5_17 ref NI_5 NS_17 0 8.6581216346336663e-03
GC_5_18 ref NI_5 NS_18 0 1.8654496849222744e-03
GC_5_19 ref NI_5 NS_19 0 -2.7190603796320240e-02
GC_5_20 ref NI_5 NS_20 0 6.9606414659565782e-02
GC_5_21 ref NI_5 NS_21 0 4.3368156826073334e-07
GC_5_22 ref NI_5 NS_22 0 -3.6192484282961181e-05
GC_5_23 ref NI_5 NS_23 0 3.1433303141773579e-03
GC_5_24 ref NI_5 NS_24 0 -9.1570927026038921e-03
GC_5_25 ref NI_5 NS_25 0 7.1467476459503715e-02
GC_5_26 ref NI_5 NS_26 0 -1.2841879101517317e-01
GC_5_27 ref NI_5 NS_27 0 -7.3209349516754469e-06
GC_5_28 ref NI_5 NS_28 0 -1.2658338335466885e-03
GC_5_29 ref NI_5 NS_29 0 -1.0233169782755888e-01
GC_5_30 ref NI_5 NS_30 0 1.9146669513168457e-02
GC_5_31 ref NI_5 NS_31 0 2.5965868454120803e-03
GC_5_32 ref NI_5 NS_32 0 -4.6177413343564885e-03
GC_5_33 ref NI_5 NS_33 0 1.6662199220089225e-06
GC_5_34 ref NI_5 NS_34 0 -2.2038797139854442e-05
GC_5_35 ref NI_5 NS_35 0 5.8177621125155036e-03
GC_5_36 ref NI_5 NS_36 0 3.4399462081026342e-03
GC_5_37 ref NI_5 NS_37 0 -1.7103173276367494e-03
GC_5_38 ref NI_5 NS_38 0 3.8908244636056788e-03
GC_5_39 ref NI_5 NS_39 0 1.1034526525135634e-06
GC_5_40 ref NI_5 NS_40 0 -5.8301770473289447e-05
GC_5_41 ref NI_5 NS_41 0 6.7620384960107773e-03
GC_5_42 ref NI_5 NS_42 0 1.3851495005526044e-03
GC_5_43 ref NI_5 NS_43 0 3.9744813385118264e-03
GC_5_44 ref NI_5 NS_44 0 -8.5991649658765552e-03
GC_5_45 ref NI_5 NS_45 0 1.3825876355905698e-06
GC_5_46 ref NI_5 NS_46 0 -3.7225740254287024e-05
GC_5_47 ref NI_5 NS_47 0 6.4922438958640565e-03
GC_5_48 ref NI_5 NS_48 0 3.8520171996556424e-03
GC_5_49 ref NI_5 NS_49 0 -1.7093692522956165e-02
GC_5_50 ref NI_5 NS_50 0 3.6821466607529621e-02
GC_5_51 ref NI_5 NS_51 0 -6.1453040881665570e-06
GC_5_52 ref NI_5 NS_52 0 -1.8440342175685449e-04
GC_5_53 ref NI_5 NS_53 0 2.7127008455691631e-02
GC_5_54 ref NI_5 NS_54 0 -1.8838233938655888e-02
GC_5_55 ref NI_5 NS_55 0 2.1032746472788369e-03
GC_5_56 ref NI_5 NS_56 0 -7.7226924700623178e-03
GC_5_57 ref NI_5 NS_57 0 -1.7976330007965365e-06
GC_5_58 ref NI_5 NS_58 0 -1.1738205592636264e-04
GC_5_59 ref NI_5 NS_59 0 1.8256803558227598e-02
GC_5_60 ref NI_5 NS_60 0 -4.3010017649270571e-03
GC_5_61 ref NI_5 NS_61 0 -2.6922753570578855e-03
GC_5_62 ref NI_5 NS_62 0 -4.0266899473242208e-03
GC_5_63 ref NI_5 NS_63 0 6.9211217695207628e-07
GC_5_64 ref NI_5 NS_64 0 1.6302403809495906e-05
GC_5_65 ref NI_5 NS_65 0 1.4434577926150900e-02
GC_5_66 ref NI_5 NS_66 0 -2.2511337143773305e-03
GC_5_67 ref NI_5 NS_67 0 7.7024339959015371e-04
GC_5_68 ref NI_5 NS_68 0 -2.9908374327784260e-04
GC_5_69 ref NI_5 NS_69 0 3.4615532549993329e-06
GC_5_70 ref NI_5 NS_70 0 -6.4902429502845483e-06
GC_5_71 ref NI_5 NS_71 0 -6.0441063022938387e-04
GC_5_72 ref NI_5 NS_72 0 7.0806151562105351e-03
GC_5_73 ref NI_5 NS_73 0 -8.5422172786155850e-03
GC_5_74 ref NI_5 NS_74 0 1.2173779357075190e-02
GC_5_75 ref NI_5 NS_75 0 1.6969360516823012e-07
GC_5_76 ref NI_5 NS_76 0 3.2623746601788906e-05
GC_5_77 ref NI_5 NS_77 0 1.6049483116297572e-02
GC_5_78 ref NI_5 NS_78 0 -6.6995290959720273e-03
GD_5_1 ref NI_5 NA_1 0 3.2466321327691765e-03
GD_5_2 ref NI_5 NA_2 0 -2.3105322973765042e-02
GD_5_3 ref NI_5 NA_3 0 -4.3223813960796796e-03
GD_5_4 ref NI_5 NA_4 0 2.2967524867378492e-02
GD_5_5 ref NI_5 NA_5 0 6.1789737764430779e+00
GD_5_6 ref NI_5 NA_6 0 -4.1177876584123805e-03
GD_5_7 ref NI_5 NA_7 0 -6.4562001684446806e-04
GD_5_8 ref NI_5 NA_8 0 -7.0494662211614363e-03
GD_5_9 ref NI_5 NA_9 0 2.2066942004662193e-02
GD_5_10 ref NI_5 NA_10 0 2.9846793644573754e-03
GD_5_11 ref NI_5 NA_11 0 8.4417815103190481e-03
GD_5_12 ref NI_5 NA_12 0 3.9737338253677248e-03
GD_5_13 ref NI_5 NA_13 0 8.4362401624658821e-03
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -2.2793120986979785e-03
GC_6_2 ref NI_6 NS_2 0 2.9837955901070123e-03
GC_6_3 ref NI_6 NS_3 0 2.2526701028143580e-06
GC_6_4 ref NI_6 NS_4 0 1.0587096343165454e-03
GC_6_5 ref NI_6 NS_5 0 -3.3276288463230524e-03
GC_6_6 ref NI_6 NS_6 0 5.2828999301368093e-03
GC_6_7 ref NI_6 NS_7 0 -1.3825743212726378e-02
GC_6_8 ref NI_6 NS_8 0 2.6630463674010164e-02
GC_6_9 ref NI_6 NS_9 0 -2.6698476197787326e-07
GC_6_10 ref NI_6 NS_10 0 2.9593001417915772e-05
GC_6_11 ref NI_6 NS_11 0 1.8326321281503959e-02
GC_6_12 ref NI_6 NS_12 0 -1.1038677701865365e-02
GC_6_13 ref NI_6 NS_13 0 -7.6688396249744578e-02
GC_6_14 ref NI_6 NS_14 0 6.4850653042993714e-02
GC_6_15 ref NI_6 NS_15 0 -1.3671351037837545e-06
GC_6_16 ref NI_6 NS_16 0 8.4790591727300222e-05
GC_6_17 ref NI_6 NS_17 0 3.4694162295687461e-02
GC_6_18 ref NI_6 NS_18 0 -2.2268129414352029e-02
GC_6_19 ref NI_6 NS_19 0 1.5891793562997870e-04
GC_6_20 ref NI_6 NS_20 0 3.1138716523141040e-03
GC_6_21 ref NI_6 NS_21 0 7.1616090628612326e-07
GC_6_22 ref NI_6 NS_22 0 -6.0022074461595089e-05
GC_6_23 ref NI_6 NS_23 0 6.8912057840074823e-03
GC_6_24 ref NI_6 NS_24 0 1.2245643806046245e-03
GC_6_25 ref NI_6 NS_25 0 2.5965868454120968e-03
GC_6_26 ref NI_6 NS_26 0 -4.6177413343565111e-03
GC_6_27 ref NI_6 NS_27 0 1.6662199220086991e-06
GC_6_28 ref NI_6 NS_28 0 -2.2038797139853249e-05
GC_6_29 ref NI_6 NS_29 0 5.8177621125155236e-03
GC_6_30 ref NI_6 NS_30 0 3.4399462081026208e-03
GC_6_31 ref NI_6 NS_31 0 1.4136011508448135e-02
GC_6_32 ref NI_6 NS_32 0 -2.0443972714375322e-01
GC_6_33 ref NI_6 NS_33 0 -5.2100260477963611e-06
GC_6_34 ref NI_6 NS_34 0 -7.2522187037994494e-04
GC_6_35 ref NI_6 NS_35 0 -3.7777990298698244e-02
GC_6_36 ref NI_6 NS_36 0 1.3405507569222571e-04
GC_6_37 ref NI_6 NS_37 0 3.8489599878203523e-02
GC_6_38 ref NI_6 NS_38 0 9.6617516884392705e-03
GC_6_39 ref NI_6 NS_39 0 -1.2224484431369157e-06
GC_6_40 ref NI_6 NS_40 0 -9.2825891769076477e-05
GC_6_41 ref NI_6 NS_41 0 1.3427319850929440e-02
GC_6_42 ref NI_6 NS_42 0 -1.2141153372041871e-02
GC_6_43 ref NI_6 NS_43 0 5.8599091127855933e-02
GC_6_44 ref NI_6 NS_44 0 8.6313147193182366e-02
GC_6_45 ref NI_6 NS_45 0 -3.2632399917560225e-06
GC_6_46 ref NI_6 NS_46 0 -4.7076108068223790e-04
GC_6_47 ref NI_6 NS_47 0 -3.3470686334846747e-02
GC_6_48 ref NI_6 NS_48 0 -3.0633601478798577e-04
GC_6_49 ref NI_6 NS_49 0 -1.4510786979733290e-04
GC_6_50 ref NI_6 NS_50 0 -1.7426060025411616e-03
GC_6_51 ref NI_6 NS_51 0 1.8445550299908563e-06
GC_6_52 ref NI_6 NS_52 0 1.6196256808607856e-04
GC_6_53 ref NI_6 NS_53 0 -1.1241299638509282e-02
GC_6_54 ref NI_6 NS_54 0 1.4918361403367901e-02
GC_6_55 ref NI_6 NS_55 0 -1.8921239822781747e-03
GC_6_56 ref NI_6 NS_56 0 6.0146225281495916e-04
GC_6_57 ref NI_6 NS_57 0 1.5634819843007804e-06
GC_6_58 ref NI_6 NS_58 0 1.7653133303470369e-04
GC_6_59 ref NI_6 NS_59 0 -9.3202390196078216e-03
GC_6_60 ref NI_6 NS_60 0 1.3137449941937796e-02
GC_6_61 ref NI_6 NS_61 0 2.7826827017965756e-03
GC_6_62 ref NI_6 NS_62 0 -7.1804698426200277e-03
GC_6_63 ref NI_6 NS_63 0 1.7106321302948838e-06
GC_6_64 ref NI_6 NS_64 0 9.4396028837608065e-05
GC_6_65 ref NI_6 NS_65 0 -6.1192411118287937e-03
GC_6_66 ref NI_6 NS_66 0 1.2395835808050544e-02
GC_6_67 ref NI_6 NS_67 0 1.6574800514901572e-03
GC_6_68 ref NI_6 NS_68 0 -5.0667730626551347e-03
GC_6_69 ref NI_6 NS_69 0 3.0503789250006185e-06
GC_6_70 ref NI_6 NS_70 0 2.0759780574910083e-05
GC_6_71 ref NI_6 NS_71 0 7.7886948456313441e-03
GC_6_72 ref NI_6 NS_72 0 2.0128937705044805e-03
GC_6_73 ref NI_6 NS_73 0 -9.6649848712500634e-04
GC_6_74 ref NI_6 NS_74 0 1.1196841865227495e-02
GC_6_75 ref NI_6 NS_75 0 -1.1293807333891628e-06
GC_6_76 ref NI_6 NS_76 0 -1.3240236716403030e-04
GC_6_77 ref NI_6 NS_77 0 2.0904115418972934e-02
GC_6_78 ref NI_6 NS_78 0 -1.0569720216884248e-02
GD_6_1 ref NI_6 NA_1 0 1.6887310186497070e-03
GD_6_2 ref NI_6 NA_2 0 -1.9037484228276322e-02
GD_6_3 ref NI_6 NA_3 0 2.7220504164694959e-02
GD_6_4 ref NI_6 NA_4 0 -2.2261480679423035e-03
GD_6_5 ref NI_6 NA_5 0 -4.1177876584123805e-03
GD_6_6 ref NI_6 NA_6 0 6.2219515269568628e+00
GD_6_7 ref NI_6 NA_7 0 8.8025632729494749e-03
GD_6_8 ref NI_6 NA_8 0 -3.4946803792063386e-02
GD_6_9 ref NI_6 NA_9 0 1.2635861785012051e-03
GD_6_10 ref NI_6 NA_10 0 4.2757199899175428e-03
GD_6_11 ref NI_6 NA_11 0 -2.3079641262926338e-04
GD_6_12 ref NI_6 NA_12 0 2.4214083861287330e-03
GD_6_13 ref NI_6 NA_13 0 -7.4395515976909462e-03
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -1.7901112528512857e-03
GC_7_2 ref NI_7 NS_2 0 1.6347030328125252e-03
GC_7_3 ref NI_7 NS_3 0 3.0513855744469688e-06
GC_7_4 ref NI_7 NS_4 0 1.4102211656189748e-03
GC_7_5 ref NI_7 NS_5 0 -5.3051533835109565e-03
GC_7_6 ref NI_7 NS_6 0 5.6494520888250932e-03
GC_7_7 ref NI_7 NS_7 0 -1.3518779320568192e-02
GC_7_8 ref NI_7 NS_8 0 2.0311059067026720e-02
GC_7_9 ref NI_7 NS_9 0 -3.3977774849387751e-07
GC_7_10 ref NI_7 NS_10 0 1.5596567924418242e-05
GC_7_11 ref NI_7 NS_11 0 1.9667874377150476e-02
GC_7_12 ref NI_7 NS_12 0 -1.0373758758769362e-02
GC_7_13 ref NI_7 NS_13 0 6.6070315279030928e-02
GC_7_14 ref NI_7 NS_14 0 7.4477851783179561e-02
GC_7_15 ref NI_7 NS_15 0 -1.3184396287113672e-06
GC_7_16 ref NI_7 NS_16 0 -5.1619946484835594e-04
GC_7_17 ref NI_7 NS_17 0 -3.9377492812634689e-02
GC_7_18 ref NI_7 NS_18 0 5.8999684107166129e-03
GC_7_19 ref NI_7 NS_19 0 3.0597311419917261e-03
GC_7_20 ref NI_7 NS_20 0 1.8189094298795064e-02
GC_7_21 ref NI_7 NS_21 0 2.5772852945419551e-07
GC_7_22 ref NI_7 NS_22 0 -1.2572759983351577e-04
GC_7_23 ref NI_7 NS_23 0 5.2628765526494567e-04
GC_7_24 ref NI_7 NS_24 0 1.5666490331729328e-03
GC_7_25 ref NI_7 NS_25 0 -1.7103173276367429e-03
GC_7_26 ref NI_7 NS_26 0 3.8908244636056697e-03
GC_7_27 ref NI_7 NS_27 0 1.1034526525134878e-06
GC_7_28 ref NI_7 NS_28 0 -5.8301770473289250e-05
GC_7_29 ref NI_7 NS_29 0 6.7620384960107843e-03
GC_7_30 ref NI_7 NS_30 0 1.3851495005526003e-03
GC_7_31 ref NI_7 NS_31 0 3.8489599878203509e-02
GC_7_32 ref NI_7 NS_32 0 9.6617516884392792e-03
GC_7_33 ref NI_7 NS_33 0 -1.2224484431366899e-06
GC_7_34 ref NI_7 NS_34 0 -9.2825891769077616e-05
GC_7_35 ref NI_7 NS_35 0 1.3427319850929433e-02
GC_7_36 ref NI_7 NS_36 0 -1.2141153372041863e-02
GC_7_37 ref NI_7 NS_37 0 1.3217460178800596e-02
GC_7_38 ref NI_7 NS_38 0 -2.1637483940476238e-01
GC_7_39 ref NI_7 NS_39 0 -3.5347132397541038e-06
GC_7_40 ref NI_7 NS_40 0 -6.9301207116752197e-04
GC_7_41 ref NI_7 NS_41 0 -4.0869715122239816e-02
GC_7_42 ref NI_7 NS_42 0 5.5238809927847608e-03
GC_7_43 ref NI_7 NS_43 0 -7.6443597135167893e-02
GC_7_44 ref NI_7 NS_44 0 6.5132461795589250e-02
GC_7_45 ref NI_7 NS_45 0 -1.3295818158338014e-06
GC_7_46 ref NI_7 NS_46 0 7.9060780255045136e-05
GC_7_47 ref NI_7 NS_47 0 3.4067285522166965e-02
GC_7_48 ref NI_7 NS_48 0 -2.1900338085003548e-02
GC_7_49 ref NI_7 NS_49 0 -3.0346190600800607e-04
GC_7_50 ref NI_7 NS_50 0 -2.5163600375762494e-03
GC_7_51 ref NI_7 NS_51 0 2.6753036408034837e-06
GC_7_52 ref NI_7 NS_52 0 8.3150130010805739e-05
GC_7_53 ref NI_7 NS_53 0 -8.0813392823093372e-03
GC_7_54 ref NI_7 NS_54 0 1.3080568637148019e-02
GC_7_55 ref NI_7 NS_55 0 -2.9849163164535151e-03
GC_7_56 ref NI_7 NS_56 0 1.7933910065863713e-03
GC_7_57 ref NI_7 NS_57 0 6.6904427007355512e-07
GC_7_58 ref NI_7 NS_58 0 1.2263092846250326e-04
GC_7_59 ref NI_7 NS_59 0 -6.5394119861347496e-03
GC_7_60 ref NI_7 NS_60 0 1.1221459823671190e-02
GC_7_61 ref NI_7 NS_61 0 -2.0541743334380243e-03
GC_7_62 ref NI_7 NS_62 0 -6.3480041595220978e-03
GC_7_63 ref NI_7 NS_63 0 1.1337593566204908e-06
GC_7_64 ref NI_7 NS_64 0 4.4533023221053839e-05
GC_7_65 ref NI_7 NS_65 0 2.3082191299367179e-03
GC_7_66 ref NI_7 NS_66 0 7.0803340600092499e-03
GC_7_67 ref NI_7 NS_67 0 -4.5883689877631324e-03
GC_7_68 ref NI_7 NS_68 0 1.0355914939209943e-02
GC_7_69 ref NI_7 NS_69 0 6.4588645800364614e-08
GC_7_70 ref NI_7 NS_70 0 -3.2934563441555782e-05
GC_7_71 ref NI_7 NS_71 0 9.2996534745384534e-03
GC_7_72 ref NI_7 NS_72 0 -1.7097344725394096e-03
GC_7_73 ref NI_7 NS_73 0 3.1364845347224817e-04
GC_7_74 ref NI_7 NS_74 0 6.0289136662288944e-03
GC_7_75 ref NI_7 NS_75 0 -7.4499733628750928e-07
GC_7_76 ref NI_7 NS_76 0 -1.2913292502057634e-04
GC_7_77 ref NI_7 NS_77 0 1.9302149682527730e-02
GC_7_78 ref NI_7 NS_78 0 -8.2793199079514851e-03
GD_7_1 ref NI_7 NA_1 0 2.6462683483640453e-03
GD_7_2 ref NI_7 NA_2 0 -1.3809888012927282e-02
GD_7_3 ref NI_7 NA_3 0 -4.0524286758150785e-02
GD_7_4 ref NI_7 NA_4 0 -1.9758991595125353e-03
GD_7_5 ref NI_7 NA_5 0 -6.4562001684446806e-04
GD_7_6 ref NI_7 NA_6 0 8.8025632729494749e-03
GD_7_7 ref NI_7 NA_7 0 6.2292131294223960e+00
GD_7_8 ref NI_7 NA_8 0 2.6188021453645030e-02
GD_7_9 ref NI_7 NA_9 0 1.1590469847673557e-03
GD_7_10 ref NI_7 NA_10 0 4.9807568717033538e-03
GD_7_11 ref NI_7 NA_11 0 1.8386138207428032e-03
GD_7_12 ref NI_7 NA_12 0 7.6177603300269254e-03
GD_7_13 ref NI_7 NA_13 0 -7.0764433869443238e-03
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -2.4221993408431977e-03
GC_8_2 ref NI_8 NS_2 0 3.3021463438622778e-03
GC_8_3 ref NI_8 NS_3 0 2.0355313534715186e-06
GC_8_4 ref NI_8 NS_4 0 1.0734880735955765e-03
GC_8_5 ref NI_8 NS_5 0 -3.0757854358112748e-03
GC_8_6 ref NI_8 NS_6 0 4.9975377385958449e-03
GC_8_7 ref NI_8 NS_7 0 2.7194438972167651e-03
GC_8_8 ref NI_8 NS_8 0 3.4441934236772213e-02
GC_8_9 ref NI_8 NS_9 0 -3.7789206716828997e-07
GC_8_10 ref NI_8 NS_10 0 -4.7793937040983633e-05
GC_8_11 ref NI_8 NS_11 0 5.8168219423519714e-03
GC_8_12 ref NI_8 NS_12 0 -6.5796475858067921e-03
GC_8_13 ref NI_8 NS_13 0 3.2617260986481003e-02
GC_8_14 ref NI_8 NS_14 0 1.5747193695327219e-02
GC_8_15 ref NI_8 NS_15 0 -6.1854300723458231e-07
GC_8_16 ref NI_8 NS_16 0 -6.4937400559376729e-05
GC_8_17 ref NI_8 NS_17 0 1.3971826508972647e-02
GC_8_18 ref NI_8 NS_18 0 -1.3236197905752709e-02
GC_8_19 ref NI_8 NS_19 0 1.9842167747578022e-03
GC_8_20 ref NI_8 NS_20 0 -8.6477780368848407e-03
GC_8_21 ref NI_8 NS_21 0 6.5746161647170624e-07
GC_8_22 ref NI_8 NS_22 0 -3.6732958211324753e-05
GC_8_23 ref NI_8 NS_23 0 1.2189069342212859e-02
GC_8_24 ref NI_8 NS_24 0 9.4010095986982295e-05
GC_8_25 ref NI_8 NS_25 0 3.9744813385118333e-03
GC_8_26 ref NI_8 NS_26 0 -8.5991649658765622e-03
GC_8_27 ref NI_8 NS_27 0 1.3825876355905262e-06
GC_8_28 ref NI_8 NS_28 0 -3.7225740254287010e-05
GC_8_29 ref NI_8 NS_29 0 6.4922438958640617e-03
GC_8_30 ref NI_8 NS_30 0 3.8520171996556398e-03
GC_8_31 ref NI_8 NS_31 0 5.8599091127855912e-02
GC_8_32 ref NI_8 NS_32 0 8.6313147193182393e-02
GC_8_33 ref NI_8 NS_33 0 -3.2632399917552047e-06
GC_8_34 ref NI_8 NS_34 0 -4.7076108068224115e-04
GC_8_35 ref NI_8 NS_35 0 -3.3470686334846782e-02
GC_8_36 ref NI_8 NS_36 0 -3.0633601478795937e-04
GC_8_37 ref NI_8 NS_37 0 -7.6443597135167893e-02
GC_8_38 ref NI_8 NS_38 0 6.5132461795589250e-02
GC_8_39 ref NI_8 NS_39 0 -1.3295818158337442e-06
GC_8_40 ref NI_8 NS_40 0 7.9060780255044906e-05
GC_8_41 ref NI_8 NS_41 0 3.4067285522166965e-02
GC_8_42 ref NI_8 NS_42 0 -2.1900338085003548e-02
GC_8_43 ref NI_8 NS_43 0 8.8838751141206221e-03
GC_8_44 ref NI_8 NS_44 0 -2.0085962528253973e-01
GC_8_45 ref NI_8 NS_45 0 -4.6880187632470111e-06
GC_8_46 ref NI_8 NS_46 0 -6.4435793142673839e-04
GC_8_47 ref NI_8 NS_47 0 -3.6778892664193298e-02
GC_8_48 ref NI_8 NS_48 0 -9.0770886597895512e-04
GC_8_49 ref NI_8 NS_49 0 -2.3752525914851924e-03
GC_8_50 ref NI_8 NS_50 0 1.9734281427166316e-03
GC_8_51 ref NI_8 NS_51 0 1.7654407784263928e-06
GC_8_52 ref NI_8 NS_52 0 1.5152713398216899e-04
GC_8_53 ref NI_8 NS_53 0 -9.7173479168124934e-03
GC_8_54 ref NI_8 NS_54 0 1.3245574855515276e-02
GC_8_55 ref NI_8 NS_55 0 -3.5916963296098742e-03
GC_8_56 ref NI_8 NS_56 0 3.8574384886245075e-03
GC_8_57 ref NI_8 NS_57 0 1.3781060211775382e-06
GC_8_58 ref NI_8 NS_58 0 1.6078478762155619e-04
GC_8_59 ref NI_8 NS_59 0 -8.0562382207222082e-03
GC_8_60 ref NI_8 NS_60 0 1.1705097241768886e-02
GC_8_61 ref NI_8 NS_61 0 1.9094710020045682e-03
GC_8_62 ref NI_8 NS_62 0 -3.1258870288117420e-03
GC_8_63 ref NI_8 NS_63 0 1.5935623462872171e-06
GC_8_64 ref NI_8 NS_64 0 8.2000477791746232e-05
GC_8_65 ref NI_8 NS_65 0 -7.4403378399663950e-03
GC_8_66 ref NI_8 NS_66 0 1.2481046797170742e-02
GC_8_67 ref NI_8 NS_67 0 -1.1478109445634775e-03
GC_8_68 ref NI_8 NS_68 0 -2.6979358274320991e-04
GC_8_69 ref NI_8 NS_69 0 2.0796606900326291e-06
GC_8_70 ref NI_8 NS_70 0 1.6201960291577450e-05
GC_8_71 ref NI_8 NS_71 0 8.1054238240015203e-03
GC_8_72 ref NI_8 NS_72 0 1.0578179948902121e-03
GC_8_73 ref NI_8 NS_73 0 2.3693924418657789e-03
GC_8_74 ref NI_8 NS_74 0 -1.0141631487095258e-02
GC_8_75 ref NI_8 NS_75 0 -4.1425835255386347e-07
GC_8_76 ref NI_8 NS_76 0 -1.2492722628401081e-04
GC_8_77 ref NI_8 NS_77 0 2.5504545561928549e-02
GC_8_78 ref NI_8 NS_78 0 -8.8596336758018090e-03
GD_8_1 ref NI_8 NA_1 0 8.5726401876248250e-04
GD_8_2 ref NI_8 NA_2 0 -3.8469745017181665e-02
GD_8_3 ref NI_8 NA_3 0 8.3610551715788978e-03
GD_8_4 ref NI_8 NA_4 0 -3.3144091059642308e-03
GD_8_5 ref NI_8 NA_5 0 -7.0494662211614363e-03
GD_8_6 ref NI_8 NA_6 0 -3.4946803792063386e-02
GD_8_7 ref NI_8 NA_7 0 2.6188021453645030e-02
GD_8_8 ref NI_8 NA_8 0 6.2223023749738413e+00
GD_8_9 ref NI_8 NA_9 0 1.9403733677265484e-03
GD_8_10 ref NI_8 NA_10 0 5.1463399381708802e-03
GD_8_11 ref NI_8 NA_11 0 3.7946987159054486e-04
GD_8_12 ref NI_8 NA_12 0 4.7074122123175197e-03
GD_8_13 ref NI_8 NA_13 0 -9.3667282647628552e-03
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -1.8287124575309761e-03
GC_9_2 ref NI_9 NS_2 0 1.8884661745530754e-03
GC_9_3 ref NI_9 NS_3 0 5.3772794883758314e-06
GC_9_4 ref NI_9 NS_4 0 2.3502566921456691e-03
GC_9_5 ref NI_9 NS_5 0 -1.3580999338031344e-03
GC_9_6 ref NI_9 NS_6 0 -9.0446997975901738e-04
GC_9_7 ref NI_9 NS_7 0 -6.7890756700214605e-03
GC_9_8 ref NI_9 NS_8 0 1.7872992653864946e-02
GC_9_9 ref NI_9 NS_9 0 3.9051136358443234e-07
GC_9_10 ref NI_9 NS_10 0 3.3596736702600204e-05
GC_9_11 ref NI_9 NS_11 0 4.9571029490159159e-03
GC_9_12 ref NI_9 NS_12 0 -4.0152285782663473e-04
GC_9_13 ref NI_9 NS_13 0 -1.7870194204086553e-03
GC_9_14 ref NI_9 NS_14 0 2.3967320278226456e-03
GC_9_15 ref NI_9 NS_15 0 2.9509116321517119e-06
GC_9_16 ref NI_9 NS_16 0 6.5479414428391128e-05
GC_9_17 ref NI_9 NS_17 0 -7.4659601688181311e-03
GC_9_18 ref NI_9 NS_18 0 1.1623100289490746e-02
GC_9_19 ref NI_9 NS_19 0 1.7609773943260396e-03
GC_9_20 ref NI_9 NS_20 0 -1.1182200923433836e-02
GC_9_21 ref NI_9 NS_21 0 1.1089864130304064e-06
GC_9_22 ref NI_9 NS_22 0 -1.7156930357875222e-05
GC_9_23 ref NI_9 NS_23 0 8.3926392952668599e-03
GC_9_24 ref NI_9 NS_24 0 3.4387206310206551e-03
GC_9_25 ref NI_9 NS_25 0 -1.7093692522956158e-02
GC_9_26 ref NI_9 NS_26 0 3.6821466607529614e-02
GC_9_27 ref NI_9 NS_27 0 -6.1453040881666104e-06
GC_9_28 ref NI_9 NS_28 0 -1.8440342175685427e-04
GC_9_29 ref NI_9 NS_29 0 2.7127008455691635e-02
GC_9_30 ref NI_9 NS_30 0 -1.8838233938655892e-02
GC_9_31 ref NI_9 NS_31 0 -1.4510786979734345e-04
GC_9_32 ref NI_9 NS_32 0 -1.7426060025411473e-03
GC_9_33 ref NI_9 NS_33 0 1.8445550299909467e-06
GC_9_34 ref NI_9 NS_34 0 1.6196256808607778e-04
GC_9_35 ref NI_9 NS_35 0 -1.1241299638509294e-02
GC_9_36 ref NI_9 NS_36 0 1.4918361403367912e-02
GC_9_37 ref NI_9 NS_37 0 -3.0346190600801729e-04
GC_9_38 ref NI_9 NS_38 0 -2.5163600375762338e-03
GC_9_39 ref NI_9 NS_39 0 2.6753036408039843e-06
GC_9_40 ref NI_9 NS_40 0 8.3150130010804113e-05
GC_9_41 ref NI_9 NS_41 0 -8.0813392823093563e-03
GC_9_42 ref NI_9 NS_42 0 1.3080568637148033e-02
GC_9_43 ref NI_9 NS_43 0 -2.3752525914851955e-03
GC_9_44 ref NI_9 NS_44 0 1.9734281427166360e-03
GC_9_45 ref NI_9 NS_45 0 1.7654407784263301e-06
GC_9_46 ref NI_9 NS_46 0 1.5152713398216931e-04
GC_9_47 ref NI_9 NS_47 0 -9.7173479168124934e-03
GC_9_48 ref NI_9 NS_48 0 1.3245574855515280e-02
GC_9_49 ref NI_9 NS_49 0 5.5295640597202433e-02
GC_9_50 ref NI_9 NS_50 0 -8.4692562047855940e-02
GC_9_51 ref NI_9 NS_51 0 -2.4472832115151918e-05
GC_9_52 ref NI_9 NS_52 0 -2.3769795493111152e-03
GC_9_53 ref NI_9 NS_53 0 -2.2200968756847454e-02
GC_9_54 ref NI_9 NS_54 0 -4.3456978070911548e-02
GC_9_55 ref NI_9 NS_55 0 -1.6380482099230306e-02
GC_9_56 ref NI_9 NS_56 0 3.3661750457386293e-02
GC_9_57 ref NI_9 NS_57 0 1.1989569723409478e-05
GC_9_58 ref NI_9 NS_58 0 -6.5223756505105191e-04
GC_9_59 ref NI_9 NS_59 0 4.7386333382468074e-02
GC_9_60 ref NI_9 NS_60 0 -3.2045448274786087e-02
GC_9_61 ref NI_9 NS_61 0 2.6237996449469898e-04
GC_9_62 ref NI_9 NS_62 0 -1.6201566042750178e-03
GC_9_63 ref NI_9 NS_63 0 1.0308741877499088e-06
GC_9_64 ref NI_9 NS_64 0 8.7314005059420274e-05
GC_9_65 ref NI_9 NS_65 0 -5.7977341138559088e-03
GC_9_66 ref NI_9 NS_66 0 1.1107442940437265e-02
GC_9_67 ref NI_9 NS_67 0 -4.9464437140750994e-03
GC_9_68 ref NI_9 NS_68 0 5.2436962138034619e-03
GC_9_69 ref NI_9 NS_69 0 9.4726433924090987e-07
GC_9_70 ref NI_9 NS_70 0 2.3626273181773786e-04
GC_9_71 ref NI_9 NS_71 0 -7.6806335764563463e-03
GC_9_72 ref NI_9 NS_72 0 1.0997927604259506e-02
GC_9_73 ref NI_9 NS_73 0 9.5462307732739377e-04
GC_9_74 ref NI_9 NS_74 0 -2.8126854035989955e-03
GC_9_75 ref NI_9 NS_75 0 1.2999483363018521e-06
GC_9_76 ref NI_9 NS_76 0 1.3376661462983052e-04
GC_9_77 ref NI_9 NS_77 0 -1.2339111257797712e-02
GC_9_78 ref NI_9 NS_78 0 1.5998474188455139e-02
GD_9_1 ref NI_9 NA_1 0 3.3743069745093644e-03
GD_9_2 ref NI_9 NA_2 0 -3.8837294932748513e-03
GD_9_3 ref NI_9 NA_3 0 1.6884742486395232e-03
GD_9_4 ref NI_9 NA_4 0 -4.4600078213214328e-04
GD_9_5 ref NI_9 NA_5 0 2.2066942004662193e-02
GD_9_6 ref NI_9 NA_6 0 1.2635861785012051e-03
GD_9_7 ref NI_9 NA_7 0 1.1590469847673557e-03
GD_9_8 ref NI_9 NA_8 0 1.9403733677265484e-03
GD_9_9 ref NI_9 NA_9 0 6.1418549933333502e+00
GD_9_10 ref NI_9 NA_10 0 7.2059464725791750e-02
GD_9_11 ref NI_9 NA_11 0 7.1792379099034917e-03
GD_9_12 ref NI_9 NA_12 0 1.2515041766548619e-02
GD_9_13 ref NI_9 NA_13 0 -2.1357355601709551e-04
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -1.6317872712136941e-03
GC_10_2 ref NI_10 NS_2 0 1.5905654553660280e-03
GC_10_3 ref NI_10 NS_3 0 4.9949767509845388e-06
GC_10_4 ref NI_10 NS_4 0 2.3221937963437294e-03
GC_10_5 ref NI_10 NS_5 0 -9.1901365741481084e-04
GC_10_6 ref NI_10 NS_6 0 -1.0644259650263715e-03
GC_10_7 ref NI_10 NS_7 0 -4.4266864131894531e-03
GC_10_8 ref NI_10 NS_8 0 1.7298402954187352e-02
GC_10_9 ref NI_10 NS_9 0 7.1101056349510753e-07
GC_10_10 ref NI_10 NS_10 0 2.9073363535229329e-05
GC_10_11 ref NI_10 NS_11 0 2.4015266112587721e-03
GC_10_12 ref NI_10 NS_12 0 1.1604650263384198e-03
GC_10_13 ref NI_10 NS_13 0 -3.2665471213843967e-03
GC_10_14 ref NI_10 NS_14 0 5.4339015522271647e-03
GC_10_15 ref NI_10 NS_15 0 3.8501251519506475e-07
GC_10_16 ref NI_10 NS_16 0 1.0582186575922806e-04
GC_10_17 ref NI_10 NS_17 0 -5.7730211122804511e-03
GC_10_18 ref NI_10 NS_18 0 9.7987957194051196e-03
GC_10_19 ref NI_10 NS_19 0 -2.8711063194277165e-03
GC_10_20 ref NI_10 NS_20 0 8.0746518266177434e-03
GC_10_21 ref NI_10 NS_21 0 -3.7347154989973632e-07
GC_10_22 ref NI_10 NS_22 0 -2.8957336765662724e-05
GC_10_23 ref NI_10 NS_23 0 2.5597446103478218e-03
GC_10_24 ref NI_10 NS_24 0 3.4850679968609259e-03
GC_10_25 ref NI_10 NS_25 0 2.1032746472788347e-03
GC_10_26 ref NI_10 NS_26 0 -7.7226924700623169e-03
GC_10_27 ref NI_10 NS_27 0 -1.7976330007966677e-06
GC_10_28 ref NI_10 NS_28 0 -1.1738205592636235e-04
GC_10_29 ref NI_10 NS_29 0 1.8256803558227595e-02
GC_10_30 ref NI_10 NS_30 0 -4.3010017649270571e-03
GC_10_31 ref NI_10 NS_31 0 -1.8921239822781951e-03
GC_10_32 ref NI_10 NS_32 0 6.0146225281498757e-04
GC_10_33 ref NI_10 NS_33 0 1.5634819843011122e-06
GC_10_34 ref NI_10 NS_34 0 1.7653133303470198e-04
GC_10_35 ref NI_10 NS_35 0 -9.3202390196078493e-03
GC_10_36 ref NI_10 NS_36 0 1.3137449941937815e-02
GC_10_37 ref NI_10 NS_37 0 -2.9849163164535203e-03
GC_10_38 ref NI_10 NS_38 0 1.7933910065863765e-03
GC_10_39 ref NI_10 NS_39 0 6.6904427007339111e-07
GC_10_40 ref NI_10 NS_40 0 1.2263092846250386e-04
GC_10_41 ref NI_10 NS_41 0 -6.5394119861347478e-03
GC_10_42 ref NI_10 NS_42 0 1.1221459823671188e-02
GC_10_43 ref NI_10 NS_43 0 -3.5916963296098803e-03
GC_10_44 ref NI_10 NS_44 0 3.8574384886245153e-03
GC_10_45 ref NI_10 NS_45 0 1.3781060211775024e-06
GC_10_46 ref NI_10 NS_46 0 1.6078478762155638e-04
GC_10_47 ref NI_10 NS_47 0 -8.0562382207222116e-03
GC_10_48 ref NI_10 NS_48 0 1.1705097241768887e-02
GC_10_49 ref NI_10 NS_49 0 -1.6380482099230310e-02
GC_10_50 ref NI_10 NS_50 0 3.3661750457386293e-02
GC_10_51 ref NI_10 NS_51 0 1.1989569723409422e-05
GC_10_52 ref NI_10 NS_52 0 -6.5223756505105180e-04
GC_10_53 ref NI_10 NS_53 0 4.7386333382468081e-02
GC_10_54 ref NI_10 NS_54 0 -3.2045448274786087e-02
GC_10_55 ref NI_10 NS_55 0 5.5727472200421381e-02
GC_10_56 ref NI_10 NS_56 0 -8.6689116422927995e-02
GC_10_57 ref NI_10 NS_57 0 -2.1102918191547150e-05
GC_10_58 ref NI_10 NS_58 0 -2.4660047289699846e-03
GC_10_59 ref NI_10 NS_59 0 -2.3958306459636119e-02
GC_10_60 ref NI_10 NS_60 0 -4.1369665959878843e-02
GC_10_61 ref NI_10 NS_61 0 -4.4262168376091671e-03
GC_10_62 ref NI_10 NS_62 0 6.2938842120917752e-03
GC_10_63 ref NI_10 NS_63 0 6.6300566868088115e-07
GC_10_64 ref NI_10 NS_64 0 4.1632901651578003e-05
GC_10_65 ref NI_10 NS_65 0 2.8455084910123320e-03
GC_10_66 ref NI_10 NS_66 0 3.7279581109972114e-03
GC_10_67 ref NI_10 NS_67 0 -5.3791515167044635e-03
GC_10_68 ref NI_10 NS_68 0 6.8407801912883049e-03
GC_10_69 ref NI_10 NS_69 0 8.9819590775352317e-07
GC_10_70 ref NI_10 NS_70 0 2.1444616907727472e-04
GC_10_71 ref NI_10 NS_71 0 -4.6728746654256153e-03
GC_10_72 ref NI_10 NS_72 0 8.4804671713898817e-03
GC_10_73 ref NI_10 NS_73 0 -2.1239620133407570e-03
GC_10_74 ref NI_10 NS_74 0 2.4100796592962962e-03
GC_10_75 ref NI_10 NS_75 0 7.0890833493611768e-07
GC_10_76 ref NI_10 NS_76 0 1.7146568056542887e-04
GC_10_77 ref NI_10 NS_77 0 -1.1605915303947417e-02
GC_10_78 ref NI_10 NS_78 0 1.4480954833081426e-02
GD_10_1 ref NI_10 NA_1 0 3.5494994782618787e-03
GD_10_2 ref NI_10 NA_2 0 -2.7499020905039664e-04
GD_10_3 ref NI_10 NA_3 0 6.0337833546119397e-03
GD_10_4 ref NI_10 NA_4 0 7.2903552626340561e-03
GD_10_5 ref NI_10 NA_5 0 2.9846793644573754e-03
GD_10_6 ref NI_10 NA_6 0 4.2757199899175428e-03
GD_10_7 ref NI_10 NA_7 0 4.9807568717033538e-03
GD_10_8 ref NI_10 NA_8 0 5.1463399381708802e-03
GD_10_9 ref NI_10 NA_9 0 7.2059464725791750e-02
GD_10_10 ref NI_10 NA_10 0 6.1096664154095777e+00
GD_10_11 ref NI_10 NA_11 0 1.6169821547376388e-02
GD_10_12 ref NI_10 NA_12 0 1.7910421090076702e-02
GD_10_13 ref NI_10 NA_13 0 4.3565453093665956e-03
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -2.5041665930582869e-03
GC_11_2 ref NI_11 NS_2 0 2.8806049813468420e-03
GC_11_3 ref NI_11 NS_3 0 5.5589533160397192e-06
GC_11_4 ref NI_11 NS_4 0 2.2926645701745359e-03
GC_11_5 ref NI_11 NS_5 0 -3.0352677790879668e-03
GC_11_6 ref NI_11 NS_6 0 4.0797247430160872e-04
GC_11_7 ref NI_11 NS_7 0 -3.3987425136866489e-03
GC_11_8 ref NI_11 NS_8 0 9.5109059676340268e-03
GC_11_9 ref NI_11 NS_9 0 9.5623659186683797e-07
GC_11_10 ref NI_11 NS_10 0 5.7375499785295301e-05
GC_11_11 ref NI_11 NS_11 0 3.1669408834903647e-03
GC_11_12 ref NI_11 NS_12 0 2.4516346802942223e-03
GC_11_13 ref NI_11 NS_13 0 2.8028483385920859e-03
GC_11_14 ref NI_11 NS_14 0 -3.8624274505027066e-03
GC_11_15 ref NI_11 NS_15 0 1.1365726684798922e-06
GC_11_16 ref NI_11 NS_16 0 2.5222210211761010e-05
GC_11_17 ref NI_11 NS_17 0 -1.2559049076539504e-03
GC_11_18 ref NI_11 NS_18 0 8.2020415250618865e-03
GC_11_19 ref NI_11 NS_19 0 -2.5316138236881582e-02
GC_11_20 ref NI_11 NS_20 0 6.3286773385498526e-02
GC_11_21 ref NI_11 NS_21 0 -1.3087774992293963e-06
GC_11_22 ref NI_11 NS_22 0 -1.5075173806847070e-04
GC_11_23 ref NI_11 NS_23 0 1.3481437173392166e-02
GC_11_24 ref NI_11 NS_24 0 -1.5030086341804876e-02
GC_11_25 ref NI_11 NS_25 0 -2.6922753570578803e-03
GC_11_26 ref NI_11 NS_26 0 -4.0266899473242277e-03
GC_11_27 ref NI_11 NS_27 0 6.9211217695189195e-07
GC_11_28 ref NI_11 NS_28 0 1.6302403809496431e-05
GC_11_29 ref NI_11 NS_29 0 1.4434577926150901e-02
GC_11_30 ref NI_11 NS_30 0 -2.2511337143773357e-03
GC_11_31 ref NI_11 NS_31 0 2.7826827017965734e-03
GC_11_32 ref NI_11 NS_32 0 -7.1804698426200268e-03
GC_11_33 ref NI_11 NS_33 0 1.7106321302946019e-06
GC_11_34 ref NI_11 NS_34 0 9.4396028837608580e-05
GC_11_35 ref NI_11 NS_35 0 -6.1192411118287920e-03
GC_11_36 ref NI_11 NS_36 0 1.2395835808050544e-02
GC_11_37 ref NI_11 NS_37 0 -2.0541743334380300e-03
GC_11_38 ref NI_11 NS_38 0 -6.3480041595220882e-03
GC_11_39 ref NI_11 NS_39 0 1.1337593566206731e-06
GC_11_40 ref NI_11 NS_40 0 4.4533023221053249e-05
GC_11_41 ref NI_11 NS_41 0 2.3082191299367088e-03
GC_11_42 ref NI_11 NS_42 0 7.0803340600092595e-03
GC_11_43 ref NI_11 NS_43 0 1.9094710020045682e-03
GC_11_44 ref NI_11 NS_44 0 -3.1258870288117420e-03
GC_11_45 ref NI_11 NS_45 0 1.5935623462873634e-06
GC_11_46 ref NI_11 NS_46 0 8.2000477791746110e-05
GC_11_47 ref NI_11 NS_47 0 -7.4403378399663968e-03
GC_11_48 ref NI_11 NS_48 0 1.2481046797170742e-02
GC_11_49 ref NI_11 NS_49 0 2.6237996449469931e-04
GC_11_50 ref NI_11 NS_50 0 -1.6201566042750178e-03
GC_11_51 ref NI_11 NS_51 0 1.0308741877498048e-06
GC_11_52 ref NI_11 NS_52 0 8.7314005059420437e-05
GC_11_53 ref NI_11 NS_53 0 -5.7977341138559105e-03
GC_11_54 ref NI_11 NS_54 0 1.1107442940437265e-02
GC_11_55 ref NI_11 NS_55 0 -4.4262168376091619e-03
GC_11_56 ref NI_11 NS_56 0 6.2938842120917708e-03
GC_11_57 ref NI_11 NS_57 0 6.6300566868106728e-07
GC_11_58 ref NI_11 NS_58 0 4.1632901651577406e-05
GC_11_59 ref NI_11 NS_59 0 2.8455084910123320e-03
GC_11_60 ref NI_11 NS_60 0 3.7279581109972131e-03
GC_11_61 ref NI_11 NS_61 0 5.3788611548382652e-02
GC_11_62 ref NI_11 NS_62 0 -8.7999220335587977e-02
GC_11_63 ref NI_11 NS_63 0 -2.5739085200324422e-05
GC_11_64 ref NI_11 NS_64 0 -2.3678830893139979e-03
GC_11_65 ref NI_11 NS_65 0 -2.8343579907473031e-02
GC_11_66 ref NI_11 NS_66 0 -3.7871651916157371e-02
GC_11_67 ref NI_11 NS_67 0 -2.0233706593303133e-02
GC_11_68 ref NI_11 NS_68 0 3.8614313610098080e-02
GC_11_69 ref NI_11 NS_69 0 1.1919958388998085e-05
GC_11_70 ref NI_11 NS_70 0 -2.0924186599413964e-04
GC_11_71 ref NI_11 NS_71 0 2.0064890118374971e-02
GC_11_72 ref NI_11 NS_72 0 -1.4328104473939859e-02
GC_11_73 ref NI_11 NS_73 0 3.8110157563595879e-03
GC_11_74 ref NI_11 NS_74 0 -9.6333694467730623e-03
GC_11_75 ref NI_11 NS_75 0 1.4842412818991107e-06
GC_11_76 ref NI_11 NS_76 0 5.0700480476018888e-05
GC_11_77 ref NI_11 NS_77 0 -2.9424490412771629e-03
GC_11_78 ref NI_11 NS_78 0 1.0743494615044110e-02
GD_11_1 ref NI_11 NA_1 0 4.4647072783524444e-03
GD_11_2 ref NI_11 NA_2 0 -2.9446560321128470e-03
GD_11_3 ref NI_11 NA_3 0 2.4213080616190042e-03
GD_11_4 ref NI_11 NA_4 0 4.3796845636921558e-02
GD_11_5 ref NI_11 NA_5 0 8.4417815103190481e-03
GD_11_6 ref NI_11 NA_6 0 -2.3079641262926338e-04
GD_11_7 ref NI_11 NA_7 0 1.8386138207428032e-03
GD_11_8 ref NI_11 NA_8 0 3.7946987159054486e-04
GD_11_9 ref NI_11 NA_9 0 7.1792379099034917e-03
GD_11_10 ref NI_11 NA_10 0 1.6169821547376388e-02
GD_11_11 ref NI_11 NA_11 0 6.1206302678694398e+00
GD_11_12 ref NI_11 NA_12 0 6.8970366798127847e-02
GD_11_13 ref NI_11 NA_13 0 -1.3494293089715901e-03
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -2.4488217985939816e-03
GC_12_2 ref NI_12 NS_2 0 2.7042998817461022e-03
GC_12_3 ref NI_12 NS_3 0 5.1937776249667046e-06
GC_12_4 ref NI_12 NS_4 0 1.9931463131530498e-03
GC_12_5 ref NI_12 NS_5 0 -3.8307707870665489e-03
GC_12_6 ref NI_12 NS_6 0 2.1332757834826334e-03
GC_12_7 ref NI_12 NS_7 0 -3.5224410656645951e-03
GC_12_8 ref NI_12 NS_8 0 1.7251920377011346e-02
GC_12_9 ref NI_12 NS_9 0 2.4311675847108333e-06
GC_12_10 ref NI_12 NS_10 0 3.9708599080393068e-05
GC_12_11 ref NI_12 NS_11 0 5.4700734500865477e-03
GC_12_12 ref NI_12 NS_12 0 -1.3147360002083049e-03
GC_12_13 ref NI_12 NS_13 0 -7.8266538368873609e-03
GC_12_14 ref NI_12 NS_14 0 1.6609475510124115e-02
GC_12_15 ref NI_12 NS_15 0 1.2771160956497533e-07
GC_12_16 ref NI_12 NS_16 0 -2.4343754834772813e-05
GC_12_17 ref NI_12 NS_17 0 9.3965687773297328e-03
GC_12_18 ref NI_12 NS_18 0 -2.9095902335339423e-03
GC_12_19 ref NI_12 NS_19 0 9.8941288804075146e-04
GC_12_20 ref NI_12 NS_20 0 -1.1412910773056483e-02
GC_12_21 ref NI_12 NS_21 0 1.8276713375308931e-06
GC_12_22 ref NI_12 NS_22 0 -1.7601371363039996e-05
GC_12_23 ref NI_12 NS_23 0 1.3799481175507906e-02
GC_12_24 ref NI_12 NS_24 0 -2.9505315701962016e-04
GC_12_25 ref NI_12 NS_25 0 7.7024339959016769e-04
GC_12_26 ref NI_12 NS_26 0 -2.9908374327786326e-04
GC_12_27 ref NI_12 NS_27 0 3.4615532549987701e-06
GC_12_28 ref NI_12 NS_28 0 -6.4902429502824943e-06
GC_12_29 ref NI_12 NS_29 0 -6.0441063022935893e-04
GC_12_30 ref NI_12 NS_30 0 7.0806151562105169e-03
GC_12_31 ref NI_12 NS_31 0 1.6574800514901462e-03
GC_12_32 ref NI_12 NS_32 0 -5.0667730626551199e-03
GC_12_33 ref NI_12 NS_33 0 3.0503789250005744e-06
GC_12_34 ref NI_12 NS_34 0 2.0759780574909707e-05
GC_12_35 ref NI_12 NS_35 0 7.7886948456313346e-03
GC_12_36 ref NI_12 NS_36 0 2.0128937705044870e-03
GC_12_37 ref NI_12 NS_37 0 -4.5883689877631376e-03
GC_12_38 ref NI_12 NS_38 0 1.0355914939209950e-02
GC_12_39 ref NI_12 NS_39 0 6.4588645800305401e-08
GC_12_40 ref NI_12 NS_40 0 -3.2934563441555491e-05
GC_12_41 ref NI_12 NS_41 0 9.2996534745384499e-03
GC_12_42 ref NI_12 NS_42 0 -1.7097344725394096e-03
GC_12_43 ref NI_12 NS_43 0 -1.1478109445634658e-03
GC_12_44 ref NI_12 NS_44 0 -2.6979358274322824e-04
GC_12_45 ref NI_12 NS_45 0 2.0796606900320014e-06
GC_12_46 ref NI_12 NS_46 0 1.6201960291580012e-05
GC_12_47 ref NI_12 NS_47 0 8.1054238240015446e-03
GC_12_48 ref NI_12 NS_48 0 1.0578179948901906e-03
GC_12_49 ref NI_12 NS_49 0 -4.9464437140750977e-03
GC_12_50 ref NI_12 NS_50 0 5.2436962138034601e-03
GC_12_51 ref NI_12 NS_51 0 9.4726433924088033e-07
GC_12_52 ref NI_12 NS_52 0 2.3626273181773802e-04
GC_12_53 ref NI_12 NS_53 0 -7.6806335764563428e-03
GC_12_54 ref NI_12 NS_54 0 1.0997927604259503e-02
GC_12_55 ref NI_12 NS_55 0 -5.3791515167044592e-03
GC_12_56 ref NI_12 NS_56 0 6.8407801912882963e-03
GC_12_57 ref NI_12 NS_57 0 8.9819590775312443e-07
GC_12_58 ref NI_12 NS_58 0 2.1444616907727611e-04
GC_12_59 ref NI_12 NS_59 0 -4.6728746654256031e-03
GC_12_60 ref NI_12 NS_60 0 8.4804671713898713e-03
GC_12_61 ref NI_12 NS_61 0 -2.0233706593303136e-02
GC_12_62 ref NI_12 NS_62 0 3.8614313610098060e-02
GC_12_63 ref NI_12 NS_63 0 1.1919958388997902e-05
GC_12_64 ref NI_12 NS_64 0 -2.0924186599413904e-04
GC_12_65 ref NI_12 NS_65 0 2.0064890118374978e-02
GC_12_66 ref NI_12 NS_66 0 -1.4328104473939863e-02
GC_12_67 ref NI_12 NS_67 0 5.6738158862261058e-02
GC_12_68 ref NI_12 NS_68 0 -8.7448777495852212e-02
GC_12_69 ref NI_12 NS_69 0 -3.2912604493333366e-05
GC_12_70 ref NI_12 NS_70 0 -2.1384693363912599e-03
GC_12_71 ref NI_12 NS_71 0 -5.0666314157028651e-02
GC_12_72 ref NI_12 NS_72 0 -2.2575362008982872e-02
GC_12_73 ref NI_12 NS_73 0 2.2883791334118130e-03
GC_12_74 ref NI_12 NS_74 0 -2.4997618653528771e-03
GC_12_75 ref NI_12 NS_75 0 1.5055313960653479e-06
GC_12_76 ref NI_12 NS_76 0 -1.2016574365239962e-06
GC_12_77 ref NI_12 NS_77 0 -2.8818351519381892e-03
GC_12_78 ref NI_12 NS_78 0 9.2495127677109032e-03
GD_12_1 ref NI_12 NA_1 0 4.4679927707844992e-03
GD_12_2 ref NI_12 NA_2 0 -4.2136712402362575e-03
GD_12_3 ref NI_12 NA_3 0 1.1574081852637421e-02
GD_12_4 ref NI_12 NA_4 0 -1.8424578646830498e-03
GD_12_5 ref NI_12 NA_5 0 3.9737338253677248e-03
GD_12_6 ref NI_12 NA_6 0 2.4214083861287330e-03
GD_12_7 ref NI_12 NA_7 0 7.6177603300269254e-03
GD_12_8 ref NI_12 NA_8 0 4.7074122123175197e-03
GD_12_9 ref NI_12 NA_9 0 1.2515041766548619e-02
GD_12_10 ref NI_12 NA_10 0 1.7910421090076702e-02
GD_12_11 ref NI_12 NA_11 0 6.8970366798127847e-02
GD_12_12 ref NI_12 NA_12 0 6.1130006711245759e+00
GD_12_13 ref NI_12 NA_13 0 -4.0171651114984396e-04
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -2.6116236049624265e-03
GC_13_2 ref NI_13 NS_2 0 3.3947013157431191e-03
GC_13_3 ref NI_13 NS_3 0 4.5550730891273462e-06
GC_13_4 ref NI_13 NS_4 0 7.5766432580101726e-04
GC_13_5 ref NI_13 NS_5 0 -4.0928811357903455e-05
GC_13_6 ref NI_13 NS_6 0 3.8162285434041082e-03
GC_13_7 ref NI_13 NS_7 0 4.7267233991238793e-03
GC_13_8 ref NI_13 NS_8 0 -1.0031689734720477e-04
GC_13_9 ref NI_13 NS_9 0 5.1041882762271641e-07
GC_13_10 ref NI_13 NS_10 0 -6.1924955158905987e-05
GC_13_11 ref NI_13 NS_11 0 1.3343678593707518e-02
GC_13_12 ref NI_13 NS_12 0 -3.2358085324756501e-03
GC_13_13 ref NI_13 NS_13 0 5.6183396970772622e-03
GC_13_14 ref NI_13 NS_14 0 -1.5985090848680741e-02
GC_13_15 ref NI_13 NS_15 0 5.7166062274810122e-08
GC_13_16 ref NI_13 NS_16 0 -1.3022170676494662e-04
GC_13_17 ref NI_13 NS_17 0 2.2742839890565407e-02
GC_13_18 ref NI_13 NS_18 0 -5.8789304337158177e-03
GC_13_19 ref NI_13 NS_19 0 -1.5152284676519684e-02
GC_13_20 ref NI_13 NS_20 0 2.9270899036859897e-02
GC_13_21 ref NI_13 NS_21 0 -1.2885480737522000e-06
GC_13_22 ref NI_13 NS_22 0 -1.8844203287039404e-05
GC_13_23 ref NI_13 NS_23 0 1.6602442669036935e-02
GC_13_24 ref NI_13 NS_24 0 -1.0224017757990348e-02
GC_13_25 ref NI_13 NS_25 0 -8.5422172786155763e-03
GC_13_26 ref NI_13 NS_26 0 1.2173779357075179e-02
GC_13_27 ref NI_13 NS_27 0 1.6969360516789110e-07
GC_13_28 ref NI_13 NS_28 0 3.2623746601789814e-05
GC_13_29 ref NI_13 NS_29 0 1.6049483116297582e-02
GC_13_30 ref NI_13 NS_30 0 -6.6995290959720325e-03
GC_13_31 ref NI_13 NS_31 0 -9.6649848712502076e-04
GC_13_32 ref NI_13 NS_32 0 1.1196841865227514e-02
GC_13_33 ref NI_13 NS_33 0 -1.1293807333889072e-06
GC_13_34 ref NI_13 NS_34 0 -1.3240236716403179e-04
GC_13_35 ref NI_13 NS_35 0 2.0904115418972916e-02
GC_13_36 ref NI_13 NS_36 0 -1.0569720216884232e-02
GC_13_37 ref NI_13 NS_37 0 3.1364845347224140e-04
GC_13_38 ref NI_13 NS_38 0 6.0289136662289057e-03
GC_13_39 ref NI_13 NS_39 0 -7.4499733628713531e-07
GC_13_40 ref NI_13 NS_40 0 -1.2913292502057770e-04
GC_13_41 ref NI_13 NS_41 0 1.9302149682527716e-02
GC_13_42 ref NI_13 NS_42 0 -8.2793199079514729e-03
GC_13_43 ref NI_13 NS_43 0 2.3693924418657841e-03
GC_13_44 ref NI_13 NS_44 0 -1.0141631487095267e-02
GC_13_45 ref NI_13 NS_45 0 -4.1425835255426735e-07
GC_13_46 ref NI_13 NS_46 0 -1.2492722628400937e-04
GC_13_47 ref NI_13 NS_47 0 2.5504545561928563e-02
GC_13_48 ref NI_13 NS_48 0 -8.8596336758018212e-03
GC_13_49 ref NI_13 NS_49 0 9.5462307732739561e-04
GC_13_50 ref NI_13 NS_50 0 -2.8126854035989976e-03
GC_13_51 ref NI_13 NS_51 0 1.2999483363017784e-06
GC_13_52 ref NI_13 NS_52 0 1.3376661462983054e-04
GC_13_53 ref NI_13 NS_53 0 -1.2339111257797712e-02
GC_13_54 ref NI_13 NS_54 0 1.5998474188455136e-02
GC_13_55 ref NI_13 NS_55 0 -2.1239620133407513e-03
GC_13_56 ref NI_13 NS_56 0 2.4100796592962902e-03
GC_13_57 ref NI_13 NS_57 0 7.0890833493620196e-07
GC_13_58 ref NI_13 NS_58 0 1.7146568056542849e-04
GC_13_59 ref NI_13 NS_59 0 -1.1605915303947415e-02
GC_13_60 ref NI_13 NS_60 0 1.4480954833081426e-02
GC_13_61 ref NI_13 NS_61 0 3.8110157563595853e-03
GC_13_62 ref NI_13 NS_62 0 -9.6333694467730553e-03
GC_13_63 ref NI_13 NS_63 0 1.4842412818992234e-06
GC_13_64 ref NI_13 NS_64 0 5.0700480476018312e-05
GC_13_65 ref NI_13 NS_65 0 -2.9424490412771685e-03
GC_13_66 ref NI_13 NS_66 0 1.0743494615044114e-02
GC_13_67 ref NI_13 NS_67 0 2.2883791334118117e-03
GC_13_68 ref NI_13 NS_68 0 -2.4997618653528741e-03
GC_13_69 ref NI_13 NS_69 0 1.5055313960656743e-06
GC_13_70 ref NI_13 NS_70 0 -1.2016574365252583e-06
GC_13_71 ref NI_13 NS_71 0 -2.8818351519381987e-03
GC_13_72 ref NI_13 NS_72 0 9.2495127677109136e-03
GC_13_73 ref NI_13 NS_73 0 2.7773819698184623e-02
GC_13_74 ref NI_13 NS_74 0 -3.7651099583562456e-02
GC_13_75 ref NI_13 NS_75 0 -6.1662901133291153e-06
GC_13_76 ref NI_13 NS_76 0 -4.4754005230627245e-04
GC_13_77 ref NI_13 NS_77 0 -9.9626176933478708e-02
GC_13_78 ref NI_13 NS_78 0 -3.3880030670646322e-03
GD_13_1 ref NI_13 NA_1 0 4.6373152133295228e-03
GD_13_2 ref NI_13 NA_2 0 -2.3583380571558572e-02
GD_13_3 ref NI_13 NA_3 0 -9.3009823728069981e-03
GD_13_4 ref NI_13 NA_4 0 7.9434312269048343e-03
GD_13_5 ref NI_13 NA_5 0 8.4362401624658821e-03
GD_13_6 ref NI_13 NA_6 0 -7.4395515976909462e-03
GD_13_7 ref NI_13 NA_7 0 -7.0764433869443238e-03
GD_13_8 ref NI_13 NA_8 0 -9.3667282647628552e-03
GD_13_9 ref NI_13 NA_9 0 -2.1357355601709551e-04
GD_13_10 ref NI_13 NA_10 0 4.3565453093665956e-03
GD_13_11 ref NI_13 NA_11 0 -1.3494293089715901e-03
GD_13_12 ref NI_13 NA_12 0 -4.0171651114984396e-04
GD_13_13 ref NI_13 NA_13 0 6.2555264979963345e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 2.7901367543024685e+02
GS_1_1 0 NS_1 NA_1 0 9.1267680208743776e-02
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 4.0922194826233380e+02
GS_2_1 0 NS_2 NA_1 0 9.1267680208743776e-02
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 8.1031486683049719e+04
GS_3_1 0 NS_3 NA_1 0 9.1267680208743776e-02
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 5.3387273813276379e+03
GS_4_1 0 NS_4 NA_1 0 9.1267680208743776e-02
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.1111668213501960e+03
GS_5_1 0 NS_5 NA_1 0 9.1267680208743776e-02
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 1.5125737899819110e+03
GS_6_1 0 NS_6 NA_1 0 9.1267680208743776e-02
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 2.7901367543024685e+02
GS_7_2 0 NS_7 NA_2 0 9.1267680208743776e-02
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 4.0922194826233380e+02
GS_8_2 0 NS_8 NA_2 0 9.1267680208743776e-02
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 8.1031486683049719e+04
GS_9_2 0 NS_9 NA_2 0 9.1267680208743776e-02
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 5.3387273813276379e+03
GS_10_2 0 NS_10 NA_2 0 9.1267680208743776e-02
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 1.1111668213501960e+03
GS_11_2 0 NS_11 NA_2 0 9.1267680208743776e-02
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 1.5125737899819110e+03
GS_12_2 0 NS_12 NA_2 0 9.1267680208743776e-02
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 2.7901367543024685e+02
GS_13_3 0 NS_13 NA_3 0 9.1267680208743776e-02
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 4.0922194826233380e+02
GS_14_3 0 NS_14 NA_3 0 9.1267680208743776e-02
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 8.1031486683049719e+04
GS_15_3 0 NS_15 NA_3 0 9.1267680208743776e-02
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 5.3387273813276379e+03
GS_16_3 0 NS_16 NA_3 0 9.1267680208743776e-02
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.1111668213501960e+03
GS_17_3 0 NS_17 NA_3 0 9.1267680208743776e-02
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 1.5125737899819110e+03
GS_18_3 0 NS_18 NA_3 0 9.1267680208743776e-02
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 2.7901367543024685e+02
GS_19_4 0 NS_19 NA_4 0 9.1267680208743776e-02
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 4.0922194826233380e+02
GS_20_4 0 NS_20 NA_4 0 9.1267680208743776e-02
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 8.1031486683049719e+04
GS_21_4 0 NS_21 NA_4 0 9.1267680208743776e-02
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 5.3387273813276379e+03
GS_22_4 0 NS_22 NA_4 0 9.1267680208743776e-02
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 1.1111668213501960e+03
GS_23_4 0 NS_23 NA_4 0 9.1267680208743776e-02
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 1.5125737899819110e+03
GS_24_4 0 NS_24 NA_4 0 9.1267680208743776e-02
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 2.7901367543024685e+02
GS_25_5 0 NS_25 NA_5 0 9.1267680208743776e-02
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 4.0922194826233380e+02
GS_26_5 0 NS_26 NA_5 0 9.1267680208743776e-02
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 8.1031486683049719e+04
GS_27_5 0 NS_27 NA_5 0 9.1267680208743776e-02
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 5.3387273813276379e+03
GS_28_5 0 NS_28 NA_5 0 9.1267680208743776e-02
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.1111668213501960e+03
GS_29_5 0 NS_29 NA_5 0 9.1267680208743776e-02
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 1.5125737899819110e+03
GS_30_5 0 NS_30 NA_5 0 9.1267680208743776e-02
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 2.7901367543024685e+02
GS_31_6 0 NS_31 NA_6 0 9.1267680208743776e-02
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 4.0922194826233380e+02
GS_32_6 0 NS_32 NA_6 0 9.1267680208743776e-02
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 8.1031486683049719e+04
GS_33_6 0 NS_33 NA_6 0 9.1267680208743776e-02
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 5.3387273813276379e+03
GS_34_6 0 NS_34 NA_6 0 9.1267680208743776e-02
*
* Real pole n. 35
CS_35 NS_35 0 9.9999999999999998e-13
RS_35 NS_35 0 1.1111668213501960e+03
GS_35_6 0 NS_35 NA_6 0 9.1267680208743776e-02
*
* Real pole n. 36
CS_36 NS_36 0 9.9999999999999998e-13
RS_36 NS_36 0 1.5125737899819110e+03
GS_36_6 0 NS_36 NA_6 0 9.1267680208743776e-02
*
* Real pole n. 37
CS_37 NS_37 0 9.9999999999999998e-13
RS_37 NS_37 0 2.7901367543024685e+02
GS_37_7 0 NS_37 NA_7 0 9.1267680208743776e-02
*
* Real pole n. 38
CS_38 NS_38 0 9.9999999999999998e-13
RS_38 NS_38 0 4.0922194826233380e+02
GS_38_7 0 NS_38 NA_7 0 9.1267680208743776e-02
*
* Real pole n. 39
CS_39 NS_39 0 9.9999999999999998e-13
RS_39 NS_39 0 8.1031486683049719e+04
GS_39_7 0 NS_39 NA_7 0 9.1267680208743776e-02
*
* Real pole n. 40
CS_40 NS_40 0 9.9999999999999998e-13
RS_40 NS_40 0 5.3387273813276379e+03
GS_40_7 0 NS_40 NA_7 0 9.1267680208743776e-02
*
* Real pole n. 41
CS_41 NS_41 0 9.9999999999999998e-13
RS_41 NS_41 0 1.1111668213501960e+03
GS_41_7 0 NS_41 NA_7 0 9.1267680208743776e-02
*
* Real pole n. 42
CS_42 NS_42 0 9.9999999999999998e-13
RS_42 NS_42 0 1.5125737899819110e+03
GS_42_7 0 NS_42 NA_7 0 9.1267680208743776e-02
*
* Real pole n. 43
CS_43 NS_43 0 9.9999999999999998e-13
RS_43 NS_43 0 2.7901367543024685e+02
GS_43_8 0 NS_43 NA_8 0 9.1267680208743776e-02
*
* Real pole n. 44
CS_44 NS_44 0 9.9999999999999998e-13
RS_44 NS_44 0 4.0922194826233380e+02
GS_44_8 0 NS_44 NA_8 0 9.1267680208743776e-02
*
* Real pole n. 45
CS_45 NS_45 0 9.9999999999999998e-13
RS_45 NS_45 0 8.1031486683049719e+04
GS_45_8 0 NS_45 NA_8 0 9.1267680208743776e-02
*
* Real pole n. 46
CS_46 NS_46 0 9.9999999999999998e-13
RS_46 NS_46 0 5.3387273813276379e+03
GS_46_8 0 NS_46 NA_8 0 9.1267680208743776e-02
*
* Real pole n. 47
CS_47 NS_47 0 9.9999999999999998e-13
RS_47 NS_47 0 1.1111668213501960e+03
GS_47_8 0 NS_47 NA_8 0 9.1267680208743776e-02
*
* Real pole n. 48
CS_48 NS_48 0 9.9999999999999998e-13
RS_48 NS_48 0 1.5125737899819110e+03
GS_48_8 0 NS_48 NA_8 0 9.1267680208743776e-02
*
* Real pole n. 49
CS_49 NS_49 0 9.9999999999999998e-13
RS_49 NS_49 0 2.7901367543024685e+02
GS_49_9 0 NS_49 NA_9 0 9.1267680208743776e-02
*
* Real pole n. 50
CS_50 NS_50 0 9.9999999999999998e-13
RS_50 NS_50 0 4.0922194826233380e+02
GS_50_9 0 NS_50 NA_9 0 9.1267680208743776e-02
*
* Real pole n. 51
CS_51 NS_51 0 9.9999999999999998e-13
RS_51 NS_51 0 8.1031486683049719e+04
GS_51_9 0 NS_51 NA_9 0 9.1267680208743776e-02
*
* Real pole n. 52
CS_52 NS_52 0 9.9999999999999998e-13
RS_52 NS_52 0 5.3387273813276379e+03
GS_52_9 0 NS_52 NA_9 0 9.1267680208743776e-02
*
* Real pole n. 53
CS_53 NS_53 0 9.9999999999999998e-13
RS_53 NS_53 0 1.1111668213501960e+03
GS_53_9 0 NS_53 NA_9 0 9.1267680208743776e-02
*
* Real pole n. 54
CS_54 NS_54 0 9.9999999999999998e-13
RS_54 NS_54 0 1.5125737899819110e+03
GS_54_9 0 NS_54 NA_9 0 9.1267680208743776e-02
*
* Real pole n. 55
CS_55 NS_55 0 9.9999999999999998e-13
RS_55 NS_55 0 2.7901367543024685e+02
GS_55_10 0 NS_55 NA_10 0 9.1267680208743776e-02
*
* Real pole n. 56
CS_56 NS_56 0 9.9999999999999998e-13
RS_56 NS_56 0 4.0922194826233380e+02
GS_56_10 0 NS_56 NA_10 0 9.1267680208743776e-02
*
* Real pole n. 57
CS_57 NS_57 0 9.9999999999999998e-13
RS_57 NS_57 0 8.1031486683049719e+04
GS_57_10 0 NS_57 NA_10 0 9.1267680208743776e-02
*
* Real pole n. 58
CS_58 NS_58 0 9.9999999999999998e-13
RS_58 NS_58 0 5.3387273813276379e+03
GS_58_10 0 NS_58 NA_10 0 9.1267680208743776e-02
*
* Real pole n. 59
CS_59 NS_59 0 9.9999999999999998e-13
RS_59 NS_59 0 1.1111668213501960e+03
GS_59_10 0 NS_59 NA_10 0 9.1267680208743776e-02
*
* Real pole n. 60
CS_60 NS_60 0 9.9999999999999998e-13
RS_60 NS_60 0 1.5125737899819110e+03
GS_60_10 0 NS_60 NA_10 0 9.1267680208743776e-02
*
* Real pole n. 61
CS_61 NS_61 0 9.9999999999999998e-13
RS_61 NS_61 0 2.7901367543024685e+02
GS_61_11 0 NS_61 NA_11 0 9.1267680208743776e-02
*
* Real pole n. 62
CS_62 NS_62 0 9.9999999999999998e-13
RS_62 NS_62 0 4.0922194826233380e+02
GS_62_11 0 NS_62 NA_11 0 9.1267680208743776e-02
*
* Real pole n. 63
CS_63 NS_63 0 9.9999999999999998e-13
RS_63 NS_63 0 8.1031486683049719e+04
GS_63_11 0 NS_63 NA_11 0 9.1267680208743776e-02
*
* Real pole n. 64
CS_64 NS_64 0 9.9999999999999998e-13
RS_64 NS_64 0 5.3387273813276379e+03
GS_64_11 0 NS_64 NA_11 0 9.1267680208743776e-02
*
* Real pole n. 65
CS_65 NS_65 0 9.9999999999999998e-13
RS_65 NS_65 0 1.1111668213501960e+03
GS_65_11 0 NS_65 NA_11 0 9.1267680208743776e-02
*
* Real pole n. 66
CS_66 NS_66 0 9.9999999999999998e-13
RS_66 NS_66 0 1.5125737899819110e+03
GS_66_11 0 NS_66 NA_11 0 9.1267680208743776e-02
*
* Real pole n. 67
CS_67 NS_67 0 9.9999999999999998e-13
RS_67 NS_67 0 2.7901367543024685e+02
GS_67_12 0 NS_67 NA_12 0 9.1267680208743776e-02
*
* Real pole n. 68
CS_68 NS_68 0 9.9999999999999998e-13
RS_68 NS_68 0 4.0922194826233380e+02
GS_68_12 0 NS_68 NA_12 0 9.1267680208743776e-02
*
* Real pole n. 69
CS_69 NS_69 0 9.9999999999999998e-13
RS_69 NS_69 0 8.1031486683049719e+04
GS_69_12 0 NS_69 NA_12 0 9.1267680208743776e-02
*
* Real pole n. 70
CS_70 NS_70 0 9.9999999999999998e-13
RS_70 NS_70 0 5.3387273813276379e+03
GS_70_12 0 NS_70 NA_12 0 9.1267680208743776e-02
*
* Real pole n. 71
CS_71 NS_71 0 9.9999999999999998e-13
RS_71 NS_71 0 1.1111668213501960e+03
GS_71_12 0 NS_71 NA_12 0 9.1267680208743776e-02
*
* Real pole n. 72
CS_72 NS_72 0 9.9999999999999998e-13
RS_72 NS_72 0 1.5125737899819110e+03
GS_72_12 0 NS_72 NA_12 0 9.1267680208743776e-02
*
* Real pole n. 73
CS_73 NS_73 0 9.9999999999999998e-13
RS_73 NS_73 0 2.7901367543024685e+02
GS_73_13 0 NS_73 NA_13 0 9.1267680208743776e-02
*
* Real pole n. 74
CS_74 NS_74 0 9.9999999999999998e-13
RS_74 NS_74 0 4.0922194826233380e+02
GS_74_13 0 NS_74 NA_13 0 9.1267680208743776e-02
*
* Real pole n. 75
CS_75 NS_75 0 9.9999999999999998e-13
RS_75 NS_75 0 8.1031486683049719e+04
GS_75_13 0 NS_75 NA_13 0 9.1267680208743776e-02
*
* Real pole n. 76
CS_76 NS_76 0 9.9999999999999998e-13
RS_76 NS_76 0 5.3387273813276379e+03
GS_76_13 0 NS_76 NA_13 0 9.1267680208743776e-02
*
* Real pole n. 77
CS_77 NS_77 0 9.9999999999999998e-13
RS_77 NS_77 0 1.1111668213501960e+03
GS_77_13 0 NS_77 NA_13 0 9.1267680208743776e-02
*
* Real pole n. 78
CS_78 NS_78 0 9.9999999999999998e-13
RS_78 NS_78 0 1.5125737899819110e+03
GS_78_13 0 NS_78 NA_13 0 9.1267680208743776e-02
*
******************************

.ends
*******************
* End of subcircuit
*******************
