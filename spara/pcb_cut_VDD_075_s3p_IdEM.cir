**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 12-Jun-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Thu Jun 12 21:04:01 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Thu Jun 12 21:04:01 2025
**
**  Modal data exported
**  Port[1] = PMIC_SOC_0P75VSOC
**  Port[2] = PORT_1_U1_GRP_0_1_SOC_0P75VSOC_U1_GRP_0_1_GND
**  Port[3] = SOC_0P75VSOC_C685_1
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 8]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** n/a - model was already passive
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt pcb_cut_VDD_075_s3p_IdEM
+  a_1 a_2 a_3 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 1.6875032096035302e+01
GC_1_2 ref NI_1 NS_2 0 -5.4775151460553295e-01
GC_1_3 ref NI_1 NS_3 0 -4.8146057846917056e-01
GC_1_4 ref NI_1 NS_4 0 -4.4160454355280675e-02
GC_1_5 ref NI_1 NS_5 0 -7.1511378136696155e-04
GC_1_6 ref NI_1 NS_6 0 -2.1106178248526612e-02
GC_1_7 ref NI_1 NS_7 0 -3.7764867912730749e+00
GC_1_8 ref NI_1 NS_8 0 -6.9614229309763014e-03
GC_1_9 ref NI_1 NS_9 0 -5.3748824646362499e-02
GC_1_10 ref NI_1 NS_10 0 7.9009551513809784e-02
GC_1_11 ref NI_1 NS_11 0 6.7092419066488301e-04
GC_1_12 ref NI_1 NS_12 0 3.2693660103454751e-02
GC_1_13 ref NI_1 NS_13 0 -5.7486740330930521e+00
GC_1_14 ref NI_1 NS_14 0 5.5485212630496483e-01
GC_1_15 ref NI_1 NS_15 0 5.3598968199507324e-01
GC_1_16 ref NI_1 NS_16 0 -3.4763012626618017e-02
GC_1_17 ref NI_1 NS_17 0 4.5447435305230379e-05
GC_1_18 ref NI_1 NS_18 0 -1.1605369511395392e-02
GD_1_1 ref NI_1 NA_1 0 5.1287078015065424e+00
GD_1_2 ref NI_1 NA_2 0 2.6004122089594489e-01
GD_1_3 ref NI_1 NA_3 0 4.2035834996782390e-01
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -3.7764867912730749e+00
GC_2_2 ref NI_2 NS_2 0 -6.9614229309763126e-03
GC_2_3 ref NI_2 NS_3 0 -5.3748824646362485e-02
GC_2_4 ref NI_2 NS_4 0 7.9009551513809770e-02
GC_2_5 ref NI_2 NS_5 0 6.7092419066487976e-04
GC_2_6 ref NI_2 NS_6 0 3.2693660103454765e-02
GC_2_7 ref NI_2 NS_7 0 3.1766957848704273e+01
GC_2_8 ref NI_2 NS_8 0 -4.6777334829407963e-02
GC_2_9 ref NI_2 NS_9 0 2.0237521590539043e-02
GC_2_10 ref NI_2 NS_10 0 -1.4994504960795793e-01
GC_2_11 ref NI_2 NS_11 0 -1.1461177222066683e-03
GC_2_12 ref NI_2 NS_12 0 -5.6980348405715496e-02
GC_2_13 ref NI_2 NS_13 0 6.0568546795195193e+00
GC_2_14 ref NI_2 NS_14 0 4.7326419400919528e-02
GC_2_15 ref NI_2 NS_15 0 3.6752741012547545e-02
GC_2_16 ref NI_2 NS_16 0 7.0495228467627208e-02
GC_2_17 ref NI_2 NS_17 0 4.7380097332362084e-04
GC_2_18 ref NI_2 NS_18 0 2.4425214423665614e-02
GD_2_1 ref NI_2 NA_1 0 2.6004122089594489e-01
GD_2_2 ref NI_2 NA_2 0 4.1333216091635592e+00
GD_2_3 ref NI_2 NA_3 0 -4.1354949402202545e-01
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 -5.7486740330930521e+00
GC_3_2 ref NI_3 NS_2 0 5.5485212630496483e-01
GC_3_3 ref NI_3 NS_3 0 5.3598968199507335e-01
GC_3_4 ref NI_3 NS_4 0 -3.4763012626618031e-02
GC_3_5 ref NI_3 NS_5 0 4.5447435305227181e-05
GC_3_6 ref NI_3 NS_6 0 -1.1605369511395382e-02
GC_3_7 ref NI_3 NS_7 0 6.0568546795195193e+00
GC_3_8 ref NI_3 NS_8 0 4.7326419400919528e-02
GC_3_9 ref NI_3 NS_9 0 3.6752741012547545e-02
GC_3_10 ref NI_3 NS_10 0 7.0495228467627208e-02
GC_3_11 ref NI_3 NS_11 0 4.7380097332362084e-04
GC_3_12 ref NI_3 NS_12 0 2.4425214423665614e-02
GC_3_13 ref NI_3 NS_13 0 3.1627860954897603e+01
GC_3_14 ref NI_3 NS_14 0 -6.0921002978989758e-01
GC_3_15 ref NI_3 NS_15 0 -5.7040894718709323e-01
GC_3_16 ref NI_3 NS_16 0 -3.6072317222446672e-02
GC_3_17 ref NI_3 NS_17 0 -5.1954101388112411e-04
GC_3_18 ref NI_3 NS_18 0 -1.2689559247150501e-02
GD_3_1 ref NI_3 NA_1 0 4.2035834996782390e-01
GD_3_2 ref NI_3 NA_2 0 -4.1354949402202545e-01
GD_3_3 ref NI_3 NA_3 0 4.1248411183843059e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 1.0057709495671906e-02
GS_1_1 0 NS_1 NA_1 0 6.8674218925477764e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 5.5761161582160845e-01
GS_2_1 0 NS_2 NA_1 0 6.8674218925477764e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 1.0167794542339930e+00
GS_3_1 0 NS_3 NA_1 0 6.8674218925477764e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 4.1078814394619956e+00
GS_4_1 0 NS_4 NA_1 0 6.8674218925477764e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 4.5409148746199428e+01
GS_5_1 0 NS_5 NA_1 0 6.8674218925477764e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 8.2525381245296643e+00
GS_6_1 0 NS_6 NA_1 0 6.8674218925477764e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 1.0057709495671906e-02
GS_7_2 0 NS_7 NA_2 0 6.8674218925477764e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 5.5761161582160845e-01
GS_8_2 0 NS_8 NA_2 0 6.8674218925477764e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 1.0167794542339930e+00
GS_9_2 0 NS_9 NA_2 0 6.8674218925477764e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 4.1078814394619956e+00
GS_10_2 0 NS_10 NA_2 0 6.8674218925477764e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 4.5409148746199428e+01
GS_11_2 0 NS_11 NA_2 0 6.8674218925477764e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 8.2525381245296643e+00
GS_12_2 0 NS_12 NA_2 0 6.8674218925477764e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 1.0057709495671906e-02
GS_13_3 0 NS_13 NA_3 0 6.8674218925477764e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 5.5761161582160845e-01
GS_14_3 0 NS_14 NA_3 0 6.8674218925477764e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 1.0167794542339930e+00
GS_15_3 0 NS_15 NA_3 0 6.8674218925477764e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 4.1078814394619956e+00
GS_16_3 0 NS_16 NA_3 0 6.8674218925477764e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 4.5409148746199428e+01
GS_17_3 0 NS_17 NA_3 0 6.8674218925477764e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 8.2525381245296643e+00
GS_18_3 0 NS_18 NA_3 0 6.8674218925477764e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
