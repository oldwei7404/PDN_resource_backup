**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 17-Jun-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Tue Jun 17 17:55:25 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Tue Jun 17 17:55:25 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_GRP_1_0_VDDCR_PCCX_DIE1_GRP_1_0_VSS
**  Port[2] = PORT_2_IPD1_VDDCR_PCCX_Group_IPD1_VSS_Group
**  Port[3] = PORT_3_BGA1_GRP_0_1_VDDCR_PCCX_BGA1_GRP_0_1_VSS
**  Port[4] = VDDCR_PCCX_B1_2
**  Port[5] = VDDCR_PCCX_B2_2
**  Port[6] = VDDCR_PCCX_C11_1
**  Port[7] = VDDCR_PCCX_C14_1
**  Port[8] = VDDCR_PCCX_C15_2
**  Port[9] = VDDCR_PCCX_C20_1
**  Port[10] = VDDCR_PCCX_C25_2
**  Port[11] = VDDCR_PCCX_C26_1
**  Port[12] = VDDCR_PCCX_C107_1
**  Port[13] = VDDCR_PCCX_C110_2
**  Port[14] = VDDCR_PCCX_C111_1
**  Port[15] = VDDCR_PCCX_C112_1
**  Port[16] = VDDCR_PCCX_C113_1
**  Port[17] = VDDCR_PCCX_C114_1
**  Port[18] = VDDCR_PCCX_C115_2
**  Port[19] = VDDCR_PCCX_C116_2
**  Port[20] = VDDCR_PCCX_C117_1
**  Port[21] = VDDCR_PCCX_C118_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5-33565-final-rev_02_27_lsc_250617_cut_PCCX_IdEM
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 a_16 a_17 a_18 a_19 a_20 a_21 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -1.1771631006134973e+01
GC_1_2 ref NI_1 NS_2 0 -3.1507038914212164e+00
GC_1_3 ref NI_1 NS_3 0 5.4403812942057694e-01
GC_1_4 ref NI_1 NS_4 0 -2.9518363900999439e-01
GC_1_5 ref NI_1 NS_5 0 -1.4573858085923312e-03
GC_1_6 ref NI_1 NS_6 0 -4.3189996216455230e-02
GC_1_7 ref NI_1 NS_7 0 1.0606707527606225e+01
GC_1_8 ref NI_1 NS_8 0 -3.0332003240456431e+00
GC_1_9 ref NI_1 NS_9 0 6.2673916967277010e-01
GC_1_10 ref NI_1 NS_10 0 -2.6257625561150094e-01
GC_1_11 ref NI_1 NS_11 0 -5.4693543454300100e-04
GC_1_12 ref NI_1 NS_12 0 -2.8073113720078750e-02
GC_1_13 ref NI_1 NS_13 0 1.1687885122230258e+01
GC_1_14 ref NI_1 NS_14 0 -2.6364227793303416e+00
GC_1_15 ref NI_1 NS_15 0 7.3236511144493144e-01
GC_1_16 ref NI_1 NS_16 0 -3.3507486779876333e-01
GC_1_17 ref NI_1 NS_17 0 -8.2834247278241611e-04
GC_1_18 ref NI_1 NS_18 0 -3.8314709393353456e-02
GC_1_19 ref NI_1 NS_19 0 3.0152200652649588e-02
GC_1_20 ref NI_1 NS_20 0 1.5480089906884869e+00
GC_1_21 ref NI_1 NS_21 0 2.7851931971033000e-02
GC_1_22 ref NI_1 NS_22 0 -1.8933768575132159e-01
GC_1_23 ref NI_1 NS_23 0 -2.6902070255297524e-04
GC_1_24 ref NI_1 NS_24 0 -7.1362885688412536e-02
GC_1_25 ref NI_1 NS_25 0 -7.6746951483135220e-02
GC_1_26 ref NI_1 NS_26 0 1.5901740042001113e+00
GC_1_27 ref NI_1 NS_27 0 5.5779646313224462e-02
GC_1_28 ref NI_1 NS_28 0 -2.0541981247569002e-01
GC_1_29 ref NI_1 NS_29 0 -3.1916669859934142e-04
GC_1_30 ref NI_1 NS_30 0 -6.9914460692407254e-02
GC_1_31 ref NI_1 NS_31 0 -2.2015962290526161e-01
GC_1_32 ref NI_1 NS_32 0 7.7807453742875754e-01
GC_1_33 ref NI_1 NS_33 0 -1.6105552018404959e-01
GC_1_34 ref NI_1 NS_34 0 2.0217739538096375e-02
GC_1_35 ref NI_1 NS_35 0 1.9770111859504689e-04
GC_1_36 ref NI_1 NS_36 0 -9.2007114117935475e-03
GC_1_37 ref NI_1 NS_37 0 -3.3265845330829380e-01
GC_1_38 ref NI_1 NS_38 0 7.6333830441200090e-01
GC_1_39 ref NI_1 NS_39 0 -5.0134592032077090e-02
GC_1_40 ref NI_1 NS_40 0 -1.0396931533155726e-02
GC_1_41 ref NI_1 NS_41 0 2.6553759347741016e-04
GC_1_42 ref NI_1 NS_42 0 -1.8096667313377342e-02
GC_1_43 ref NI_1 NS_43 0 -4.3626548485697114e-01
GC_1_44 ref NI_1 NS_44 0 2.0214051487509982e-01
GC_1_45 ref NI_1 NS_45 0 -2.5759013070745812e-01
GC_1_46 ref NI_1 NS_46 0 1.5201067961112744e-01
GC_1_47 ref NI_1 NS_47 0 2.0383182033541586e-04
GC_1_48 ref NI_1 NS_48 0 3.4777037603863720e-02
GC_1_49 ref NI_1 NS_49 0 -4.3989388361637705e-01
GC_1_50 ref NI_1 NS_50 0 3.7129886064116713e-01
GC_1_51 ref NI_1 NS_51 0 -2.1039872526105709e-02
GC_1_52 ref NI_1 NS_52 0 3.5011112697697570e-02
GC_1_53 ref NI_1 NS_53 0 2.0838590254606236e-04
GC_1_54 ref NI_1 NS_54 0 7.3714784675326739e-03
GC_1_55 ref NI_1 NS_55 0 -3.0826261026378682e-01
GC_1_56 ref NI_1 NS_56 0 2.5772162631569923e-01
GC_1_57 ref NI_1 NS_57 0 -1.0637579134888612e-02
GC_1_58 ref NI_1 NS_58 0 7.7936035102866952e-02
GC_1_59 ref NI_1 NS_59 0 3.7359777113647004e-04
GC_1_60 ref NI_1 NS_60 0 3.2817991045983588e-05
GC_1_61 ref NI_1 NS_61 0 -3.9816136934549107e-01
GC_1_62 ref NI_1 NS_62 0 4.4326718189838593e-01
GC_1_63 ref NI_1 NS_63 0 -2.3024162270652047e-02
GC_1_64 ref NI_1 NS_64 0 3.2715468459170192e-02
GC_1_65 ref NI_1 NS_65 0 3.2837335983378177e-04
GC_1_66 ref NI_1 NS_66 0 -1.2394829364571686e-03
GC_1_67 ref NI_1 NS_67 0 -3.4534909917071238e-01
GC_1_68 ref NI_1 NS_68 0 5.6315502498543524e-01
GC_1_69 ref NI_1 NS_69 0 -9.7689732457710635e-02
GC_1_70 ref NI_1 NS_70 0 2.9274304755601478e-02
GC_1_71 ref NI_1 NS_71 0 2.2773975297420219e-04
GC_1_72 ref NI_1 NS_72 0 7.7865809677251123e-04
GC_1_73 ref NI_1 NS_73 0 -2.4153579580052761e-01
GC_1_74 ref NI_1 NS_74 0 3.4430016176778716e-01
GC_1_75 ref NI_1 NS_75 0 1.0052657569360304e-01
GC_1_76 ref NI_1 NS_76 0 3.4712631483697701e-02
GC_1_77 ref NI_1 NS_77 0 3.3684954115940663e-04
GC_1_78 ref NI_1 NS_78 0 -1.9469096744133919e-02
GC_1_79 ref NI_1 NS_79 0 -4.3094853828890461e-01
GC_1_80 ref NI_1 NS_80 0 2.0127814123373541e-01
GC_1_81 ref NI_1 NS_81 0 -2.2596816885223531e-01
GC_1_82 ref NI_1 NS_82 0 1.3293966072511273e-01
GC_1_83 ref NI_1 NS_83 0 1.6135117123456858e-04
GC_1_84 ref NI_1 NS_84 0 3.4894764810464801e-02
GC_1_85 ref NI_1 NS_85 0 -4.0060407580561558e-01
GC_1_86 ref NI_1 NS_86 0 1.9371025818222729e-01
GC_1_87 ref NI_1 NS_87 0 -2.4603213007114086e-01
GC_1_88 ref NI_1 NS_88 0 1.2840178585037484e-01
GC_1_89 ref NI_1 NS_89 0 1.1096114234546230e-04
GC_1_90 ref NI_1 NS_90 0 4.2025041252757911e-02
GC_1_91 ref NI_1 NS_91 0 -3.8411075831491981e-01
GC_1_92 ref NI_1 NS_92 0 1.2128887160890872e-01
GC_1_93 ref NI_1 NS_93 0 -1.2000462202983123e-01
GC_1_94 ref NI_1 NS_94 0 9.5596899746191288e-02
GC_1_95 ref NI_1 NS_95 0 1.5346171689327247e-04
GC_1_96 ref NI_1 NS_96 0 3.4541680193868905e-02
GC_1_97 ref NI_1 NS_97 0 -4.0353006435981181e-01
GC_1_98 ref NI_1 NS_98 0 1.2438011171070580e-01
GC_1_99 ref NI_1 NS_99 0 7.9787864530042555e-03
GC_1_100 ref NI_1 NS_100 0 5.8425618503246762e-02
GC_1_101 ref NI_1 NS_101 0 1.5680327219767787e-04
GC_1_102 ref NI_1 NS_102 0 2.0859612526452024e-02
GC_1_103 ref NI_1 NS_103 0 -3.9622125965680771e-01
GC_1_104 ref NI_1 NS_104 0 1.9579874171744471e-01
GC_1_105 ref NI_1 NS_105 0 -2.5263362311660598e-01
GC_1_106 ref NI_1 NS_106 0 1.1986337377845392e-01
GC_1_107 ref NI_1 NS_107 0 9.9797504325187901e-05
GC_1_108 ref NI_1 NS_108 0 4.6346943772216792e-02
GC_1_109 ref NI_1 NS_109 0 -3.8517808682201260e-01
GC_1_110 ref NI_1 NS_110 0 1.4783842578429360e-01
GC_1_111 ref NI_1 NS_111 0 -1.0724382000955543e-01
GC_1_112 ref NI_1 NS_112 0 9.2898995290152692e-02
GC_1_113 ref NI_1 NS_113 0 1.5935065368463309e-04
GC_1_114 ref NI_1 NS_114 0 3.0132486206672800e-02
GC_1_115 ref NI_1 NS_115 0 -4.0021669345301536e-01
GC_1_116 ref NI_1 NS_116 0 2.0056607624231873e-01
GC_1_117 ref NI_1 NS_117 0 -1.4092969549940665e-01
GC_1_118 ref NI_1 NS_118 0 1.0900473972698423e-01
GC_1_119 ref NI_1 NS_119 0 2.0752096479279025e-04
GC_1_120 ref NI_1 NS_120 0 2.5238356889656827e-02
GC_1_121 ref NI_1 NS_121 0 -3.9953022987332293e-01
GC_1_122 ref NI_1 NS_122 0 2.1406197746227654e-01
GC_1_123 ref NI_1 NS_123 0 -1.7202202602733715e-01
GC_1_124 ref NI_1 NS_124 0 1.2711910509535612e-01
GC_1_125 ref NI_1 NS_125 0 2.3852227579219975e-04
GC_1_126 ref NI_1 NS_126 0 2.3606790642567460e-02
GD_1_1 ref NI_1 NA_1 0 4.1364112143868583e+00
GD_1_2 ref NI_1 NA_2 0 7.0307019284309624e-01
GD_1_3 ref NI_1 NA_3 0 -1.4522238443483190e-01
GD_1_4 ref NI_1 NA_4 0 -1.5646550041211940e-01
GD_1_5 ref NI_1 NA_5 0 -1.9049537932753779e-01
GD_1_6 ref NI_1 NA_6 0 -4.6793287525228065e-02
GD_1_7 ref NI_1 NA_7 0 -3.6793661117706343e-02
GD_1_8 ref NI_1 NA_8 0 8.5274972026099599e-02
GD_1_9 ref NI_1 NA_9 0 3.6658771983289269e-02
GD_1_10 ref NI_1 NA_10 0 1.8684524276388993e-02
GD_1_11 ref NI_1 NA_11 0 1.8719262507332756e-02
GD_1_12 ref NI_1 NA_12 0 6.3550081972131925e-03
GD_1_13 ref NI_1 NA_13 0 -1.9141153603652566e-02
GD_1_14 ref NI_1 NA_14 0 8.2982718289383250e-02
GD_1_15 ref NI_1 NA_15 0 7.9078668910924813e-02
GD_1_16 ref NI_1 NA_16 0 7.5947466665961777e-02
GD_1_17 ref NI_1 NA_17 0 6.4072875497113768e-02
GD_1_18 ref NI_1 NA_18 0 8.0253263425422328e-02
GD_1_19 ref NI_1 NA_19 0 6.6908232584826491e-02
GD_1_20 ref NI_1 NA_20 0 6.4891453674361568e-02
GD_1_21 ref NI_1 NA_21 0 6.4840372047732922e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 1.0606707527606225e+01
GC_2_2 ref NI_2 NS_2 0 -3.0332003240456413e+00
GC_2_3 ref NI_2 NS_3 0 6.2673916967276710e-01
GC_2_4 ref NI_2 NS_4 0 -2.6257625561149917e-01
GC_2_5 ref NI_2 NS_5 0 -5.4693543454290288e-04
GC_2_6 ref NI_2 NS_6 0 -2.8073113720079215e-02
GC_2_7 ref NI_2 NS_7 0 -1.6075274461444980e+01
GC_2_8 ref NI_2 NS_8 0 -2.1272422039756118e+00
GC_2_9 ref NI_2 NS_9 0 3.5321299861207828e-01
GC_2_10 ref NI_2 NS_10 0 -1.9771742627573990e-01
GC_2_11 ref NI_2 NS_11 0 -9.4562678092349284e-04
GC_2_12 ref NI_2 NS_12 0 -2.8391278420085517e-02
GC_2_13 ref NI_2 NS_13 0 9.8526199138941468e+00
GC_2_14 ref NI_2 NS_14 0 -1.9696250838434188e+00
GC_2_15 ref NI_2 NS_15 0 5.0257034625989461e-01
GC_2_16 ref NI_2 NS_16 0 -2.3862815543509400e-01
GC_2_17 ref NI_2 NS_17 0 -4.5123679122469214e-04
GC_2_18 ref NI_2 NS_18 0 -3.1452040593522648e-02
GC_2_19 ref NI_2 NS_19 0 -6.4968019725473547e-01
GC_2_20 ref NI_2 NS_20 0 1.3819797077037497e+00
GC_2_21 ref NI_2 NS_21 0 -5.7767743742901251e-03
GC_2_22 ref NI_2 NS_22 0 -1.1304708313131757e-01
GC_2_23 ref NI_2 NS_23 0 1.0164270020613839e-04
GC_2_24 ref NI_2 NS_24 0 -5.6123129258222375e-02
GC_2_25 ref NI_2 NS_25 0 -5.8049112660218916e-01
GC_2_26 ref NI_2 NS_26 0 1.3667827056397730e+00
GC_2_27 ref NI_2 NS_27 0 2.5220553223863535e-02
GC_2_28 ref NI_2 NS_28 0 -1.2954815282219398e-01
GC_2_29 ref NI_2 NS_29 0 4.2978295806750758e-05
GC_2_30 ref NI_2 NS_30 0 -5.4999761900190063e-02
GC_2_31 ref NI_2 NS_31 0 9.3939391818188112e-01
GC_2_32 ref NI_2 NS_32 0 5.1556193317262200e-01
GC_2_33 ref NI_2 NS_33 0 -1.4281230611184689e-01
GC_2_34 ref NI_2 NS_34 0 -1.5780633487614812e-02
GC_2_35 ref NI_2 NS_35 0 5.3303964777768595e-05
GC_2_36 ref NI_2 NS_36 0 -8.0372966221780081e-03
GC_2_37 ref NI_2 NS_37 0 7.9513439787105233e-01
GC_2_38 ref NI_2 NS_38 0 5.5791793964709380e-01
GC_2_39 ref NI_2 NS_39 0 -6.7872836690181529e-02
GC_2_40 ref NI_2 NS_40 0 -4.6833744572276459e-02
GC_2_41 ref NI_2 NS_41 0 1.2717969809529736e-04
GC_2_42 ref NI_2 NS_42 0 -1.5224159064045437e-02
GC_2_43 ref NI_2 NS_43 0 -3.5049503702205576e-01
GC_2_44 ref NI_2 NS_44 0 1.6498617635038548e-01
GC_2_45 ref NI_2 NS_45 0 -2.1154963071552890e-01
GC_2_46 ref NI_2 NS_46 0 1.4783098488604690e-01
GC_2_47 ref NI_2 NS_47 0 1.3942359108694871e-04
GC_2_48 ref NI_2 NS_48 0 2.8243042821293883e-02
GC_2_49 ref NI_2 NS_49 0 5.4425246876769293e-02
GC_2_50 ref NI_2 NS_50 0 3.2146138307467570e-01
GC_2_51 ref NI_2 NS_51 0 -2.0311707602207740e-02
GC_2_52 ref NI_2 NS_52 0 9.7757294805863489e-03
GC_2_53 ref NI_2 NS_53 0 9.7688838053832226e-05
GC_2_54 ref NI_2 NS_54 0 5.6549277268422076e-03
GC_2_55 ref NI_2 NS_55 0 9.6735916920530296e-02
GC_2_56 ref NI_2 NS_56 0 1.9099155192381304e-01
GC_2_57 ref NI_2 NS_57 0 2.6457221320327583e-02
GC_2_58 ref NI_2 NS_58 0 4.1833648890560259e-02
GC_2_59 ref NI_2 NS_59 0 2.6791723074171784e-04
GC_2_60 ref NI_2 NS_60 0 -4.3221024342555514e-04
GC_2_61 ref NI_2 NS_61 0 1.4630793223694535e-01
GC_2_62 ref NI_2 NS_62 0 3.6252752640342217e-01
GC_2_63 ref NI_2 NS_63 0 -1.9590749376493785e-02
GC_2_64 ref NI_2 NS_64 0 4.6310816814489949e-03
GC_2_65 ref NI_2 NS_65 0 2.2122891881463998e-04
GC_2_66 ref NI_2 NS_66 0 -1.2273100555514726e-03
GC_2_67 ref NI_2 NS_67 0 6.2151300423620559e-01
GC_2_68 ref NI_2 NS_68 0 3.9046902479313061e-01
GC_2_69 ref NI_2 NS_69 0 -8.2324612896550506e-02
GC_2_70 ref NI_2 NS_70 0 -8.2247905817516825e-03
GC_2_71 ref NI_2 NS_71 0 6.7469608749631867e-05
GC_2_72 ref NI_2 NS_72 0 -3.4387684508316692e-06
GC_2_73 ref NI_2 NS_73 0 4.9136585340656980e-01
GC_2_74 ref NI_2 NS_74 0 2.3352430132577509e-01
GC_2_75 ref NI_2 NS_75 0 1.3027797918941053e-01
GC_2_76 ref NI_2 NS_76 0 -2.1985072545666277e-02
GC_2_77 ref NI_2 NS_77 0 2.0945451346595278e-04
GC_2_78 ref NI_2 NS_78 0 -1.6636185310530828e-02
GC_2_79 ref NI_2 NS_79 0 -3.3286017237369325e-01
GC_2_80 ref NI_2 NS_80 0 1.6672073284833983e-01
GC_2_81 ref NI_2 NS_81 0 -1.8530844382450973e-01
GC_2_82 ref NI_2 NS_82 0 1.2928919311787732e-01
GC_2_83 ref NI_2 NS_83 0 9.8007632957639927e-05
GC_2_84 ref NI_2 NS_84 0 2.8367617494206559e-02
GC_2_85 ref NI_2 NS_85 0 -3.0764560668154306e-01
GC_2_86 ref NI_2 NS_86 0 1.4977167824201179e-01
GC_2_87 ref NI_2 NS_87 0 -1.9899471782330691e-01
GC_2_88 ref NI_2 NS_88 0 1.2936053897962080e-01
GC_2_89 ref NI_2 NS_89 0 3.7227488902363460e-05
GC_2_90 ref NI_2 NS_90 0 3.4195203030893379e-02
GC_2_91 ref NI_2 NS_91 0 -2.5066966343675490e-01
GC_2_92 ref NI_2 NS_92 0 9.4224948783431309e-02
GC_2_93 ref NI_2 NS_93 0 -6.8788442333112154e-02
GC_2_94 ref NI_2 NS_94 0 8.1720518290561719e-02
GC_2_95 ref NI_2 NS_95 0 6.3500718207883396e-05
GC_2_96 ref NI_2 NS_96 0 2.7775534013417709e-02
GC_2_97 ref NI_2 NS_97 0 -1.1985913449538024e-01
GC_2_98 ref NI_2 NS_98 0 1.1599297778816499e-01
GC_2_99 ref NI_2 NS_99 0 4.1852962068144019e-02
GC_2_100 ref NI_2 NS_100 0 2.8714857288071913e-02
GC_2_101 ref NI_2 NS_101 0 3.7166869818207637e-05
GC_2_102 ref NI_2 NS_102 0 1.6614420628179898e-02
GC_2_103 ref NI_2 NS_103 0 -2.9971443016858262e-01
GC_2_104 ref NI_2 NS_104 0 1.4510734736334369e-01
GC_2_105 ref NI_2 NS_105 0 -2.0128622937525337e-01
GC_2_106 ref NI_2 NS_106 0 1.2301891661978567e-01
GC_2_107 ref NI_2 NS_107 0 1.0063198190138922e-05
GC_2_108 ref NI_2 NS_108 0 3.7710781538528075e-02
GC_2_109 ref NI_2 NS_109 0 -2.3395566179440416e-01
GC_2_110 ref NI_2 NS_110 0 1.2474732288258619e-01
GC_2_111 ref NI_2 NS_111 0 -6.9044793903875454e-02
GC_2_112 ref NI_2 NS_112 0 8.0307641104355634e-02
GC_2_113 ref NI_2 NS_113 0 7.6797734140834228e-05
GC_2_114 ref NI_2 NS_114 0 2.4444915674503777e-02
GC_2_115 ref NI_2 NS_115 0 -2.2301936168106781e-01
GC_2_116 ref NI_2 NS_116 0 1.6597698710351161e-01
GC_2_117 ref NI_2 NS_117 0 -1.0453432825711842e-01
GC_2_118 ref NI_2 NS_118 0 9.5756821158696145e-02
GC_2_119 ref NI_2 NS_119 0 1.3204167160182708e-04
GC_2_120 ref NI_2 NS_120 0 2.0486128849045850e-02
GC_2_121 ref NI_2 NS_121 0 -2.1955211729355686e-01
GC_2_122 ref NI_2 NS_122 0 1.7154568700056552e-01
GC_2_123 ref NI_2 NS_123 0 -1.3003709692343468e-01
GC_2_124 ref NI_2 NS_124 0 1.1272782836471629e-01
GC_2_125 ref NI_2 NS_125 0 1.6434966656081676e-04
GC_2_126 ref NI_2 NS_126 0 1.9023069394457585e-02
GD_2_1 ref NI_2 NA_1 0 7.0307019284309624e-01
GD_2_2 ref NI_2 NA_2 0 4.2342142698652045e+00
GD_2_3 ref NI_2 NA_3 0 -3.2044557893589248e-01
GD_2_4 ref NI_2 NA_4 0 -7.2175435625232570e-02
GD_2_5 ref NI_2 NA_5 0 -9.4227986858930177e-02
GD_2_6 ref NI_2 NA_6 0 -1.8729458632691053e-02
GD_2_7 ref NI_2 NA_7 0 -5.3241256590402389e-03
GD_2_8 ref NI_2 NA_8 0 8.0100134351473479e-02
GD_2_9 ref NI_2 NA_9 0 4.4533557548509892e-02
GD_2_10 ref NI_2 NA_10 0 2.6763041248504222e-02
GD_2_11 ref NI_2 NA_11 0 3.8553784104467435e-02
GD_2_12 ref NI_2 NA_12 0 1.5121405068715963e-02
GD_2_13 ref NI_2 NA_13 0 -4.0325096426256203e-03
GD_2_14 ref NI_2 NA_14 0 8.0567733577184913e-02
GD_2_15 ref NI_2 NA_15 0 7.1356486623297674e-02
GD_2_16 ref NI_2 NA_16 0 7.0158374520636113e-02
GD_2_17 ref NI_2 NA_17 0 5.7876170224360791e-02
GD_2_18 ref NI_2 NA_18 0 7.0515563284834479e-02
GD_2_19 ref NI_2 NA_19 0 6.3538987979909811e-02
GD_2_20 ref NI_2 NA_20 0 6.4758209340663578e-02
GD_2_21 ref NI_2 NA_21 0 6.3774973564370521e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 1.1687885122230258e+01
GC_3_2 ref NI_3 NS_2 0 -2.6364227793303390e+00
GC_3_3 ref NI_3 NS_3 0 7.3236511144492800e-01
GC_3_4 ref NI_3 NS_4 0 -3.3507486779876117e-01
GC_3_5 ref NI_3 NS_5 0 -8.2834247278231387e-04
GC_3_6 ref NI_3 NS_6 0 -3.8314709393353970e-02
GC_3_7 ref NI_3 NS_7 0 9.8526199138941468e+00
GC_3_8 ref NI_3 NS_8 0 -1.9696250838434191e+00
GC_3_9 ref NI_3 NS_9 0 5.0257034625989561e-01
GC_3_10 ref NI_3 NS_10 0 -2.3862815543509466e-01
GC_3_11 ref NI_3 NS_11 0 -4.5123679122473654e-04
GC_3_12 ref NI_3 NS_12 0 -3.1452040593522461e-02
GC_3_13 ref NI_3 NS_13 0 -1.7248126720456384e+01
GC_3_14 ref NI_3 NS_14 0 -1.8128424168746402e+00
GC_3_15 ref NI_3 NS_15 0 6.4038910934573268e-01
GC_3_16 ref NI_3 NS_16 0 -3.4796057316478957e-01
GC_3_17 ref NI_3 NS_17 0 -1.1679911303193308e-03
GC_3_18 ref NI_3 NS_18 0 -4.4182114925130016e-02
GC_3_19 ref NI_3 NS_19 0 2.5788203157037497e+00
GC_3_20 ref NI_3 NS_20 0 8.2674182862744783e-01
GC_3_21 ref NI_3 NS_21 0 7.9793917181367080e-02
GC_3_22 ref NI_3 NS_22 0 -2.5208510147860913e-01
GC_3_23 ref NI_3 NS_23 0 -2.0575669117118742e-04
GC_3_24 ref NI_3 NS_24 0 -7.5957464905452146e-02
GC_3_25 ref NI_3 NS_25 0 2.9370116871433369e+00
GC_3_26 ref NI_3 NS_26 0 7.4321237928677242e-01
GC_3_27 ref NI_3 NS_27 0 1.0524017868156786e-01
GC_3_28 ref NI_3 NS_28 0 -2.7039473004226727e-01
GC_3_29 ref NI_3 NS_29 0 -2.5910197100871888e-04
GC_3_30 ref NI_3 NS_30 0 -7.4130887723080283e-02
GC_3_31 ref NI_3 NS_31 0 1.7062722206015810e-01
GC_3_32 ref NI_3 NS_32 0 4.2575651212423160e-01
GC_3_33 ref NI_3 NS_33 0 -1.7134054094378925e-03
GC_3_34 ref NI_3 NS_34 0 1.0015379689586532e-02
GC_3_35 ref NI_3 NS_35 0 1.3334049513762276e-04
GC_3_36 ref NI_3 NS_36 0 -8.1221356481599276e-03
GC_3_37 ref NI_3 NS_37 0 2.2767612905402382e-01
GC_3_38 ref NI_3 NS_38 0 3.7823789198204699e-01
GC_3_39 ref NI_3 NS_39 0 1.0654262450096152e-01
GC_3_40 ref NI_3 NS_40 0 -1.8063654888374150e-02
GC_3_41 ref NI_3 NS_41 0 1.9705530350313329e-04
GC_3_42 ref NI_3 NS_42 0 -1.8073370271044154e-02
GC_3_43 ref NI_3 NS_43 0 -3.7537350631524469e-01
GC_3_44 ref NI_3 NS_44 0 2.0840432640486342e-01
GC_3_45 ref NI_3 NS_45 0 -2.6112790994448715e-01
GC_3_46 ref NI_3 NS_46 0 1.4438088142364264e-01
GC_3_47 ref NI_3 NS_47 0 1.5556355372259648e-04
GC_3_48 ref NI_3 NS_48 0 3.6687906888999464e-02
GC_3_49 ref NI_3 NS_49 0 -6.1035047252663586e-02
GC_3_50 ref NI_3 NS_50 0 1.8885006460993686e-01
GC_3_51 ref NI_3 NS_51 0 2.1257621784492534e-02
GC_3_52 ref NI_3 NS_52 0 4.0697719772107156e-02
GC_3_53 ref NI_3 NS_53 0 1.4677857921355065e-04
GC_3_54 ref NI_3 NS_54 0 8.4775603756493730e-03
GC_3_55 ref NI_3 NS_55 0 7.1707819266379522e-02
GC_3_56 ref NI_3 NS_56 0 1.2433429209074560e-01
GC_3_57 ref NI_3 NS_57 0 9.2874463812837489e-03
GC_3_58 ref NI_3 NS_58 0 8.1313526667550665e-02
GC_3_59 ref NI_3 NS_59 0 3.2013966509360328e-04
GC_3_60 ref NI_3 NS_60 0 2.6389669558316757e-04
GC_3_61 ref NI_3 NS_61 0 1.0497246151095169e-01
GC_3_62 ref NI_3 NS_62 0 2.1538395734539331e-01
GC_3_63 ref NI_3 NS_63 0 3.7984974717079997e-02
GC_3_64 ref NI_3 NS_64 0 3.2576406234719316e-02
GC_3_65 ref NI_3 NS_65 0 2.6433737068397935e-04
GC_3_66 ref NI_3 NS_66 0 -8.2874508376618917e-04
GC_3_67 ref NI_3 NS_67 0 -2.0071081390218268e-01
GC_3_68 ref NI_3 NS_68 0 3.3079564377003251e-01
GC_3_69 ref NI_3 NS_69 0 3.4068826216828831e-03
GC_3_70 ref NI_3 NS_70 0 3.5503437384553090e-02
GC_3_71 ref NI_3 NS_71 0 1.9824571076219589e-04
GC_3_72 ref NI_3 NS_72 0 2.0627643793260835e-03
GC_3_73 ref NI_3 NS_73 0 2.2091224558132738e-01
GC_3_74 ref NI_3 NS_74 0 1.1820484419264410e-01
GC_3_75 ref NI_3 NS_75 0 1.5450707319506107e-01
GC_3_76 ref NI_3 NS_76 0 4.4711392634083476e-02
GC_3_77 ref NI_3 NS_77 0 2.7904187014255973e-04
GC_3_78 ref NI_3 NS_78 0 -2.0111443018217493e-02
GC_3_79 ref NI_3 NS_79 0 -3.5308134440105621e-01
GC_3_80 ref NI_3 NS_80 0 1.9973017504018739e-01
GC_3_81 ref NI_3 NS_81 0 -2.3144540524708107e-01
GC_3_82 ref NI_3 NS_82 0 1.2730908268529767e-01
GC_3_83 ref NI_3 NS_83 0 1.1511265009970392e-04
GC_3_84 ref NI_3 NS_84 0 3.6896839540180901e-02
GC_3_85 ref NI_3 NS_85 0 -3.5984196002636648e-01
GC_3_86 ref NI_3 NS_86 0 2.0669013219286633e-01
GC_3_87 ref NI_3 NS_87 0 -2.5734423144253948e-01
GC_3_88 ref NI_3 NS_88 0 1.2183896385490504e-01
GC_3_89 ref NI_3 NS_89 0 7.1095990017763322e-05
GC_3_90 ref NI_3 NS_90 0 4.5007776537221468e-02
GC_3_91 ref NI_3 NS_91 0 -3.2990359118858603e-01
GC_3_92 ref NI_3 NS_92 0 1.2960449954569425e-01
GC_3_93 ref NI_3 NS_93 0 -1.5432154065006110e-01
GC_3_94 ref NI_3 NS_94 0 1.0415423563879135e-01
GC_3_95 ref NI_3 NS_95 0 1.2667311677403762e-04
GC_3_96 ref NI_3 NS_96 0 3.7291554888390706e-02
GC_3_97 ref NI_3 NS_97 0 -2.7992634470446609e-01
GC_3_98 ref NI_3 NS_98 0 7.8669586748299339e-02
GC_3_99 ref NI_3 NS_99 0 -1.8746233263800722e-02
GC_3_100 ref NI_3 NS_100 0 7.8978200354359276e-02
GC_3_101 ref NI_3 NS_101 0 1.3946716133074851e-04
GC_3_102 ref NI_3 NS_102 0 2.2503102290427561e-02
GC_3_103 ref NI_3 NS_103 0 -3.8534362609222533e-01
GC_3_104 ref NI_3 NS_104 0 2.1777187569807627e-01
GC_3_105 ref NI_3 NS_105 0 -2.7137112965222177e-01
GC_3_106 ref NI_3 NS_106 0 1.1496875828016985e-01
GC_3_107 ref NI_3 NS_107 0 6.6373291557790372e-05
GC_3_108 ref NI_3 NS_108 0 5.0000764618786636e-02
GC_3_109 ref NI_3 NS_109 0 -2.5486274193337616e-01
GC_3_110 ref NI_3 NS_110 0 1.3211325731557994e-01
GC_3_111 ref NI_3 NS_111 0 -1.2674673843184553e-01
GC_3_112 ref NI_3 NS_112 0 9.6502484368720692e-02
GC_3_113 ref NI_3 NS_113 0 1.1537945351572895e-04
GC_3_114 ref NI_3 NS_114 0 3.2263149970474483e-02
GC_3_115 ref NI_3 NS_115 0 -2.2646362862130145e-01
GC_3_116 ref NI_3 NS_116 0 1.6246638695405438e-01
GC_3_117 ref NI_3 NS_117 0 -1.4258862914604237e-01
GC_3_118 ref NI_3 NS_118 0 1.0715523742466537e-01
GC_3_119 ref NI_3 NS_119 0 1.5128243807363412e-04
GC_3_120 ref NI_3 NS_120 0 2.6810993421651847e-02
GC_3_121 ref NI_3 NS_121 0 -2.3149637468685383e-01
GC_3_122 ref NI_3 NS_122 0 1.7667053461377827e-01
GC_3_123 ref NI_3 NS_123 0 -1.6975706615149708e-01
GC_3_124 ref NI_3 NS_124 0 1.2345430398933691e-01
GC_3_125 ref NI_3 NS_125 0 1.8584237417863843e-04
GC_3_126 ref NI_3 NS_126 0 2.4933104843868684e-02
GD_3_1 ref NI_3 NA_1 0 -1.4522238443483190e-01
GD_3_2 ref NI_3 NA_2 0 -3.2044557893589248e-01
GD_3_3 ref NI_3 NA_3 0 4.3242633380759790e+00
GD_3_4 ref NI_3 NA_4 0 6.0118252032447639e-02
GD_3_5 ref NI_3 NA_5 0 3.6363628560415827e-02
GD_3_6 ref NI_3 NA_6 0 -5.2802527098232757e-02
GD_3_7 ref NI_3 NA_7 0 -5.5202605507499475e-02
GD_3_8 ref NI_3 NA_8 0 7.7440320261166845e-02
GD_3_9 ref NI_3 NA_9 0 1.4860199748121777e-02
GD_3_10 ref NI_3 NA_10 0 -1.9934830393790877e-04
GD_3_11 ref NI_3 NA_11 0 -1.2867823213203212e-03
GD_3_12 ref NI_3 NA_12 0 -3.9235356307932776e-03
GD_3_13 ref NI_3 NA_13 0 -4.0106984206247184e-02
GD_3_14 ref NI_3 NA_14 0 7.5119992203744532e-02
GD_3_15 ref NI_3 NA_15 0 7.2786921402837601e-02
GD_3_16 ref NI_3 NA_16 0 6.6696156039155352e-02
GD_3_17 ref NI_3 NA_17 0 4.7011179828252023e-02
GD_3_18 ref NI_3 NA_18 0 7.6978016076992950e-02
GD_3_19 ref NI_3 NA_19 0 5.3599300433175262e-02
GD_3_20 ref NI_3 NA_20 0 5.1649495984914272e-02
GD_3_21 ref NI_3 NA_21 0 5.3030592555146486e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 3.0152200652649484e-02
GC_4_2 ref NI_4 NS_2 0 1.5480089906884869e+00
GC_4_3 ref NI_4 NS_3 0 2.7851931971033025e-02
GC_4_4 ref NI_4 NS_4 0 -1.8933768575132165e-01
GC_4_5 ref NI_4 NS_5 0 -2.6902070255298429e-04
GC_4_6 ref NI_4 NS_6 0 -7.1362885688412508e-02
GC_4_7 ref NI_4 NS_7 0 -6.4968019725473558e-01
GC_4_8 ref NI_4 NS_8 0 1.3819797077037497e+00
GC_4_9 ref NI_4 NS_9 0 -5.7767743742905163e-03
GC_4_10 ref NI_4 NS_10 0 -1.1304708313131732e-01
GC_4_11 ref NI_4 NS_11 0 1.0164270020614967e-04
GC_4_12 ref NI_4 NS_12 0 -5.6123129258222430e-02
GC_4_13 ref NI_4 NS_13 0 2.5788203157037497e+00
GC_4_14 ref NI_4 NS_14 0 8.2674182862744694e-01
GC_4_15 ref NI_4 NS_15 0 7.9793917181368579e-02
GC_4_16 ref NI_4 NS_16 0 -2.5208510147861002e-01
GC_4_17 ref NI_4 NS_17 0 -2.0575669117123122e-04
GC_4_18 ref NI_4 NS_18 0 -7.5957464905451924e-02
GC_4_19 ref NI_4 NS_19 0 5.4462809369299245e+00
GC_4_20 ref NI_4 NS_20 0 -6.4982007722624298e+00
GC_4_21 ref NI_4 NS_21 0 1.0786727384411225e+00
GC_4_22 ref NI_4 NS_22 0 -8.9993303254915513e-01
GC_4_23 ref NI_4 NS_23 0 -4.3492537770347950e-03
GC_4_24 ref NI_4 NS_24 0 -1.4018296705043248e-01
GC_4_25 ref NI_4 NS_25 0 -6.7825071389129618e-02
GC_4_26 ref NI_4 NS_26 0 2.1541511991686839e+00
GC_4_27 ref NI_4 NS_27 0 4.1013362683653654e-01
GC_4_28 ref NI_4 NS_28 0 -5.0436942637280002e-01
GC_4_29 ref NI_4 NS_29 0 -1.0133884816417831e-03
GC_4_30 ref NI_4 NS_30 0 -1.2255996858195214e-01
GC_4_31 ref NI_4 NS_31 0 -4.4057409230188677e-01
GC_4_32 ref NI_4 NS_32 0 -2.9647501478668697e-01
GC_4_33 ref NI_4 NS_33 0 3.4883683542062255e-01
GC_4_34 ref NI_4 NS_34 0 6.4866815365679883e-02
GC_4_35 ref NI_4 NS_35 0 3.3812666258615663e-04
GC_4_36 ref NI_4 NS_36 0 -6.4352770387957389e-03
GC_4_37 ref NI_4 NS_37 0 -3.2571744221670190e-01
GC_4_38 ref NI_4 NS_38 0 -4.3605557339183476e-01
GC_4_39 ref NI_4 NS_39 0 4.4859413236640228e-01
GC_4_40 ref NI_4 NS_40 0 8.4114984954241009e-02
GC_4_41 ref NI_4 NS_41 0 4.5847223571792605e-04
GC_4_42 ref NI_4 NS_42 0 -2.1947931845277865e-02
GC_4_43 ref NI_4 NS_43 0 -5.5420005296813646e-01
GC_4_44 ref NI_4 NS_44 0 3.4595809949456535e-01
GC_4_45 ref NI_4 NS_45 0 -3.9610722705723678e-01
GC_4_46 ref NI_4 NS_46 0 1.2728446551993333e-01
GC_4_47 ref NI_4 NS_47 0 2.9221820086629843e-04
GC_4_48 ref NI_4 NS_48 0 5.8931183261720158e-02
GC_4_49 ref NI_4 NS_49 0 -2.8542416351742605e-01
GC_4_50 ref NI_4 NS_50 0 -1.3169430911750857e-01
GC_4_51 ref NI_4 NS_51 0 5.5903800972787743e-02
GC_4_52 ref NI_4 NS_52 0 1.1680641598351925e-01
GC_4_53 ref NI_4 NS_53 0 3.5589402267160991e-04
GC_4_54 ref NI_4 NS_54 0 1.5252116557541474e-02
GC_4_55 ref NI_4 NS_55 0 -3.2927603510681075e-01
GC_4_56 ref NI_4 NS_56 0 -2.2566437399587330e-02
GC_4_57 ref NI_4 NS_57 0 -1.0392647232807184e-01
GC_4_58 ref NI_4 NS_58 0 2.0001253694743421e-01
GC_4_59 ref NI_4 NS_59 0 6.1568481371124381e-04
GC_4_60 ref NI_4 NS_60 0 5.6810049702252178e-03
GC_4_61 ref NI_4 NS_61 0 -3.3142708010887378e-01
GC_4_62 ref NI_4 NS_62 0 -1.6663621773795531e-01
GC_4_63 ref NI_4 NS_63 0 1.1943213009050403e-01
GC_4_64 ref NI_4 NS_64 0 1.2497911944537181e-01
GC_4_65 ref NI_4 NS_65 0 5.2201662285402350e-04
GC_4_66 ref NI_4 NS_66 0 2.3227350834796497e-03
GC_4_67 ref NI_4 NS_67 0 -3.4613799330197914e-01
GC_4_68 ref NI_4 NS_68 0 -2.2226052457054271e-01
GC_4_69 ref NI_4 NS_69 0 1.6874462097339216e-01
GC_4_70 ref NI_4 NS_70 0 1.0389470730006306e-01
GC_4_71 ref NI_4 NS_71 0 3.9289680972879237e-04
GC_4_72 ref NI_4 NS_72 0 7.0696393848541468e-03
GC_4_73 ref NI_4 NS_73 0 -2.1749501547772115e-01
GC_4_74 ref NI_4 NS_74 0 -2.5730767283910366e-01
GC_4_75 ref NI_4 NS_75 0 8.8636465357479835e-02
GC_4_76 ref NI_4 NS_76 0 2.3418372191659753e-01
GC_4_77 ref NI_4 NS_77 0 5.2044592629670321e-04
GC_4_78 ref NI_4 NS_78 0 -2.3383149052656871e-02
GC_4_79 ref NI_4 NS_79 0 -5.1865622849786841e-01
GC_4_80 ref NI_4 NS_80 0 2.9774153757294736e-01
GC_4_81 ref NI_4 NS_81 0 -3.4115253829860964e-01
GC_4_82 ref NI_4 NS_82 0 1.1039057472136445e-01
GC_4_83 ref NI_4 NS_83 0 2.5369673682354812e-04
GC_4_84 ref NI_4 NS_84 0 5.8235856467015124e-02
GC_4_85 ref NI_4 NS_85 0 -5.1197095320363384e-01
GC_4_86 ref NI_4 NS_86 0 3.1743618503671561e-01
GC_4_87 ref NI_4 NS_87 0 -3.3489022241522898e-01
GC_4_88 ref NI_4 NS_88 0 7.3735260983258596e-02
GC_4_89 ref NI_4 NS_89 0 1.9693208259477093e-04
GC_4_90 ref NI_4 NS_90 0 6.9091355272130353e-02
GC_4_91 ref NI_4 NS_91 0 -4.0639137154463878e-01
GC_4_92 ref NI_4 NS_92 0 2.2021948003188779e-01
GC_4_93 ref NI_4 NS_93 0 -2.9651354222047915e-01
GC_4_94 ref NI_4 NS_94 0 1.0756456034419414e-01
GC_4_95 ref NI_4 NS_95 0 2.7775873871860394e-04
GC_4_96 ref NI_4 NS_96 0 5.6612693695947562e-02
GC_4_97 ref NI_4 NS_97 0 -2.5721360860194925e-01
GC_4_98 ref NI_4 NS_98 0 3.6800706175720399e-02
GC_4_99 ref NI_4 NS_99 0 -1.8603349421440782e-01
GC_4_100 ref NI_4 NS_100 0 1.5100568173299900e-01
GC_4_101 ref NI_4 NS_101 0 3.2762668986194765e-04
GC_4_102 ref NI_4 NS_102 0 3.4762228860721729e-02
GC_4_103 ref NI_4 NS_103 0 -5.1865282829668125e-01
GC_4_104 ref NI_4 NS_104 0 3.2507288777144666e-01
GC_4_105 ref NI_4 NS_105 0 -3.2102934088586166e-01
GC_4_106 ref NI_4 NS_106 0 4.7415846842059052e-02
GC_4_107 ref NI_4 NS_107 0 1.9566281683786364e-04
GC_4_108 ref NI_4 NS_108 0 7.5270846286496038e-02
GC_4_109 ref NI_4 NS_109 0 -3.7666788377082155e-01
GC_4_110 ref NI_4 NS_110 0 1.6848307408728902e-01
GC_4_111 ref NI_4 NS_111 0 -2.4886442440521037e-01
GC_4_112 ref NI_4 NS_112 0 1.1375295684292533e-01
GC_4_113 ref NI_4 NS_113 0 2.8488369657696954e-04
GC_4_114 ref NI_4 NS_114 0 4.9678974072334105e-02
GC_4_115 ref NI_4 NS_115 0 -4.2265045553157204e-01
GC_4_116 ref NI_4 NS_116 0 1.7706196730936305e-01
GC_4_117 ref NI_4 NS_117 0 -2.5273861991655400e-01
GC_4_118 ref NI_4 NS_118 0 1.3153158218741409e-01
GC_4_119 ref NI_4 NS_119 0 3.1939957467216749e-04
GC_4_120 ref NI_4 NS_120 0 4.3466682771235637e-02
GC_4_121 ref NI_4 NS_121 0 -4.7413518472882910e-01
GC_4_122 ref NI_4 NS_122 0 2.2210591664365834e-01
GC_4_123 ref NI_4 NS_123 0 -2.9996796270939902e-01
GC_4_124 ref NI_4 NS_124 0 1.5128128605499261e-01
GC_4_125 ref NI_4 NS_125 0 3.5007676489926155e-04
GC_4_126 ref NI_4 NS_126 0 4.1880690492904840e-02
GD_4_1 ref NI_4 NA_1 0 -1.5646550041211940e-01
GD_4_2 ref NI_4 NA_2 0 -7.2175435625232570e-02
GD_4_3 ref NI_4 NA_3 0 6.0118252032447639e-02
GD_4_4 ref NI_4 NA_4 0 4.7293141879863629e+00
GD_4_5 ref NI_4 NA_5 0 -1.1051460810519121e-02
GD_4_6 ref NI_4 NA_6 0 8.7884354738348824e-02
GD_4_7 ref NI_4 NA_7 0 7.2300984965456366e-02
GD_4_8 ref NI_4 NA_8 0 1.0934265553448508e-01
GD_4_9 ref NI_4 NA_9 0 6.8114531222464775e-02
GD_4_10 ref NI_4 NA_10 0 7.1513186283485145e-02
GD_4_11 ref NI_4 NA_11 0 7.3902426563663984e-02
GD_4_12 ref NI_4 NA_12 0 8.0031525721951338e-02
GD_4_13 ref NI_4 NA_13 0 5.5323530081425265e-02
GD_4_14 ref NI_4 NA_14 0 1.0430940777242804e-01
GD_4_15 ref NI_4 NA_15 0 1.0106247163169192e-01
GD_4_16 ref NI_4 NA_16 0 8.7356435138216379e-02
GD_4_17 ref NI_4 NA_17 0 6.5790186205889625e-02
GD_4_18 ref NI_4 NA_18 0 1.0217415444083071e-01
GD_4_19 ref NI_4 NA_19 0 8.0985386346204627e-02
GD_4_20 ref NI_4 NA_20 0 8.8103236111033448e-02
GD_4_21 ref NI_4 NA_21 0 9.6162907306720585e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -7.6746951483135331e-02
GC_5_2 ref NI_5 NS_2 0 1.5901740042001120e+00
GC_5_3 ref NI_5 NS_3 0 5.5779646313224462e-02
GC_5_4 ref NI_5 NS_4 0 -2.0541981247569013e-01
GC_5_5 ref NI_5 NS_5 0 -3.1916669859934858e-04
GC_5_6 ref NI_5 NS_6 0 -6.9914460692407226e-02
GC_5_7 ref NI_5 NS_7 0 -5.8049112660218904e-01
GC_5_8 ref NI_5 NS_8 0 1.3667827056397730e+00
GC_5_9 ref NI_5 NS_9 0 2.5220553223863903e-02
GC_5_10 ref NI_5 NS_10 0 -1.2954815282219420e-01
GC_5_11 ref NI_5 NS_11 0 4.2978295806736488e-05
GC_5_12 ref NI_5 NS_12 0 -5.4999761900190007e-02
GC_5_13 ref NI_5 NS_13 0 2.9370116871433387e+00
GC_5_14 ref NI_5 NS_14 0 7.4321237928677109e-01
GC_5_15 ref NI_5 NS_15 0 1.0524017868156961e-01
GC_5_16 ref NI_5 NS_16 0 -2.7039473004226838e-01
GC_5_17 ref NI_5 NS_17 0 -2.5910197100877135e-04
GC_5_18 ref NI_5 NS_18 0 -7.4130887723080033e-02
GC_5_19 ref NI_5 NS_19 0 -6.7825071389129535e-02
GC_5_20 ref NI_5 NS_20 0 2.1541511991686835e+00
GC_5_21 ref NI_5 NS_21 0 4.1013362683653704e-01
GC_5_22 ref NI_5 NS_22 0 -5.0436942637280036e-01
GC_5_23 ref NI_5 NS_23 0 -1.0133884816417981e-03
GC_5_24 ref NI_5 NS_24 0 -1.2255996858195203e-01
GC_5_25 ref NI_5 NS_25 0 4.6790123122146090e+00
GC_5_26 ref NI_5 NS_26 0 -6.2684471121255800e+00
GC_5_27 ref NI_5 NS_27 0 8.6987694276378558e-01
GC_5_28 ref NI_5 NS_28 0 -8.4068242685440608e-01
GC_5_29 ref NI_5 NS_29 0 -3.9641177556305352e-03
GC_5_30 ref NI_5 NS_30 0 -1.3619396587958701e-01
GC_5_31 ref NI_5 NS_31 0 -3.9848254671864841e-01
GC_5_32 ref NI_5 NS_32 0 -3.1679600399153224e-01
GC_5_33 ref NI_5 NS_33 0 3.7054271869897049e-01
GC_5_34 ref NI_5 NS_34 0 5.7920779854795289e-02
GC_5_35 ref NI_5 NS_35 0 3.1520720254319751e-04
GC_5_36 ref NI_5 NS_36 0 -6.5589622514637715e-03
GC_5_37 ref NI_5 NS_37 0 -2.8475505546867869e-01
GC_5_38 ref NI_5 NS_38 0 -4.5388471715253625e-01
GC_5_39 ref NI_5 NS_39 0 4.6972372237284954e-01
GC_5_40 ref NI_5 NS_40 0 7.6972335491636262e-02
GC_5_41 ref NI_5 NS_41 0 4.9008017991175189e-04
GC_5_42 ref NI_5 NS_42 0 -2.2464830341453614e-02
GC_5_43 ref NI_5 NS_43 0 -5.4318791174828829e-01
GC_5_44 ref NI_5 NS_44 0 3.4448955035717949e-01
GC_5_45 ref NI_5 NS_45 0 -3.9948031266032880e-01
GC_5_46 ref NI_5 NS_46 0 1.3164356235528635e-01
GC_5_47 ref NI_5 NS_47 0 2.8028399542387125e-04
GC_5_48 ref NI_5 NS_48 0 5.8111929386550278e-02
GC_5_49 ref NI_5 NS_49 0 -2.5308026626587382e-01
GC_5_50 ref NI_5 NS_50 0 -1.4580764200191568e-01
GC_5_51 ref NI_5 NS_51 0 6.8722814305546442e-02
GC_5_52 ref NI_5 NS_52 0 1.1391754242003700e-01
GC_5_53 ref NI_5 NS_53 0 3.3685796665237043e-04
GC_5_54 ref NI_5 NS_54 0 1.4888118838423670e-02
GC_5_55 ref NI_5 NS_55 0 -2.9910549250335278e-01
GC_5_56 ref NI_5 NS_56 0 -3.5519492968757706e-02
GC_5_57 ref NI_5 NS_57 0 -9.2073931403820947e-02
GC_5_58 ref NI_5 NS_58 0 1.9820742753047965e-01
GC_5_59 ref NI_5 NS_59 0 5.9136155129815762e-04
GC_5_60 ref NI_5 NS_60 0 5.0324929049834930e-03
GC_5_61 ref NI_5 NS_61 0 -2.9660844116724072e-01
GC_5_62 ref NI_5 NS_62 0 -1.7926457459615522e-01
GC_5_63 ref NI_5 NS_63 0 1.3291168652758664e-01
GC_5_64 ref NI_5 NS_64 0 1.2084026353416309e-01
GC_5_65 ref NI_5 NS_65 0 5.4198430736203233e-04
GC_5_66 ref NI_5 NS_66 0 1.8558713007435729e-03
GC_5_67 ref NI_5 NS_67 0 -3.0931321160508402e-01
GC_5_68 ref NI_5 NS_68 0 -2.4354245373125216e-01
GC_5_69 ref NI_5 NS_69 0 1.8717215043220536e-01
GC_5_70 ref NI_5 NS_70 0 9.9600366568472043e-02
GC_5_71 ref NI_5 NS_71 0 3.6798638853138827e-04
GC_5_72 ref NI_5 NS_72 0 6.8407943784287197e-03
GC_5_73 ref NI_5 NS_73 0 -1.7089682990652533e-01
GC_5_74 ref NI_5 NS_74 0 -2.8097672864620138e-01
GC_5_75 ref NI_5 NS_75 0 1.1217814287035989e-01
GC_5_76 ref NI_5 NS_76 0 2.2757794454751651e-01
GC_5_77 ref NI_5 NS_77 0 5.0252230968842501e-04
GC_5_78 ref NI_5 NS_78 0 -2.3763325235324966e-02
GC_5_79 ref NI_5 NS_79 0 -5.0758593213356074e-01
GC_5_80 ref NI_5 NS_80 0 2.9638462041263192e-01
GC_5_81 ref NI_5 NS_81 0 -3.4420871244550560e-01
GC_5_82 ref NI_5 NS_82 0 1.1443258984802328e-01
GC_5_83 ref NI_5 NS_83 0 2.4264278410630904e-04
GC_5_84 ref NI_5 NS_84 0 5.7450060652895894e-02
GC_5_85 ref NI_5 NS_85 0 -5.0405313863740853e-01
GC_5_86 ref NI_5 NS_86 0 3.1846643246796708e-01
GC_5_87 ref NI_5 NS_87 0 -3.4065150522583426e-01
GC_5_88 ref NI_5 NS_88 0 7.8664668846460131e-02
GC_5_89 ref NI_5 NS_89 0 1.8299595119266845e-04
GC_5_90 ref NI_5 NS_90 0 6.8345196161203881e-02
GC_5_91 ref NI_5 NS_91 0 -3.9175594579206829e-01
GC_5_92 ref NI_5 NS_92 0 2.1652394343677042e-01
GC_5_93 ref NI_5 NS_93 0 -2.9815095340641629e-01
GC_5_94 ref NI_5 NS_94 0 1.1105342603665933e-01
GC_5_95 ref NI_5 NS_95 0 2.6038942537375085e-04
GC_5_96 ref NI_5 NS_96 0 5.5989120712510838e-02
GC_5_97 ref NI_5 NS_97 0 -2.3243865256569751e-01
GC_5_98 ref NI_5 NS_98 0 2.5399198745513218e-02
GC_5_99 ref NI_5 NS_99 0 -1.8004053790203733e-01
GC_5_100 ref NI_5 NS_100 0 1.5188526487446688e-01
GC_5_101 ref NI_5 NS_101 0 3.0797449046169277e-04
GC_5_102 ref NI_5 NS_102 0 3.4236034294565829e-02
GC_5_103 ref NI_5 NS_103 0 -5.1174129471343566e-01
GC_5_104 ref NI_5 NS_104 0 3.2707384304436632e-01
GC_5_105 ref NI_5 NS_105 0 -3.2796865903746852e-01
GC_5_106 ref NI_5 NS_106 0 5.2586696506451307e-02
GC_5_107 ref NI_5 NS_107 0 1.7848426695384512e-04
GC_5_108 ref NI_5 NS_108 0 7.4612398296325433e-02
GC_5_109 ref NI_5 NS_109 0 -3.5976601118485085e-01
GC_5_110 ref NI_5 NS_110 0 1.6340022803250692e-01
GC_5_111 ref NI_5 NS_111 0 -2.4791377210514570e-01
GC_5_112 ref NI_5 NS_112 0 1.1608589845105528e-01
GC_5_113 ref NI_5 NS_113 0 2.6956473310355092e-04
GC_5_114 ref NI_5 NS_114 0 4.9051196426844940e-02
GC_5_115 ref NI_5 NS_115 0 -4.1150793037237804e-01
GC_5_116 ref NI_5 NS_116 0 1.7460286492340596e-01
GC_5_117 ref NI_5 NS_117 0 -2.5295269707976692e-01
GC_5_118 ref NI_5 NS_118 0 1.3427252902985734e-01
GC_5_119 ref NI_5 NS_119 0 2.9995797242482101e-04
GC_5_120 ref NI_5 NS_120 0 4.2728616056086514e-02
GC_5_121 ref NI_5 NS_121 0 -4.5666782821869484e-01
GC_5_122 ref NI_5 NS_122 0 2.1709700134105139e-01
GC_5_123 ref NI_5 NS_123 0 -2.9866629531257149e-01
GC_5_124 ref NI_5 NS_124 0 1.5373038186054716e-01
GC_5_125 ref NI_5 NS_125 0 3.3961982246821044e-04
GC_5_126 ref NI_5 NS_126 0 4.1084450635742648e-02
GD_5_1 ref NI_5 NA_1 0 -1.9049537932753779e-01
GD_5_2 ref NI_5 NA_2 0 -9.4227986858930177e-02
GD_5_3 ref NI_5 NA_3 0 3.6363628560415827e-02
GD_5_4 ref NI_5 NA_4 0 -1.1051460810519121e-02
GD_5_5 ref NI_5 NA_5 0 4.9129029505570312e+00
GD_5_6 ref NI_5 NA_6 0 7.7982249258609165e-02
GD_5_7 ref NI_5 NA_7 0 6.2296402870200475e-02
GD_5_8 ref NI_5 NA_8 0 1.0640577837477766e-01
GD_5_9 ref NI_5 NA_9 0 6.0580945920944186e-02
GD_5_10 ref NI_5 NA_10 0 6.4285338425662933e-02
GD_5_11 ref NI_5 NA_11 0 6.5557448922393347e-02
GD_5_12 ref NI_5 NA_12 0 7.1923833493285086e-02
GD_5_13 ref NI_5 NA_13 0 4.4825957920807534e-02
GD_5_14 ref NI_5 NA_14 0 1.0131751514175617e-01
GD_5_15 ref NI_5 NA_15 0 9.8678240682127397e-02
GD_5_16 ref NI_5 NA_16 0 8.3806769551184213e-02
GD_5_17 ref NI_5 NA_17 0 6.0344383649443931e-02
GD_5_18 ref NI_5 NA_18 0 1.0001350695469648e-01
GD_5_19 ref NI_5 NA_19 0 7.6831301746876232e-02
GD_5_20 ref NI_5 NA_20 0 8.5021538412108119e-02
GD_5_21 ref NI_5 NA_21 0 9.1760915535378712e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -2.2015962290526189e-01
GC_6_2 ref NI_6 NS_2 0 7.7807453742875843e-01
GC_6_3 ref NI_6 NS_3 0 -1.6105552018405092e-01
GC_6_4 ref NI_6 NS_4 0 2.0217739538097180e-02
GC_6_5 ref NI_6 NS_5 0 1.9770111859508611e-04
GC_6_6 ref NI_6 NS_6 0 -9.2007114117937435e-03
GC_6_7 ref NI_6 NS_7 0 9.3939391818188112e-01
GC_6_8 ref NI_6 NS_8 0 5.1556193317262178e-01
GC_6_9 ref NI_6 NS_9 0 -1.4281230611184645e-01
GC_6_10 ref NI_6 NS_10 0 -1.5780633487615100e-02
GC_6_11 ref NI_6 NS_11 0 5.3303964777752006e-05
GC_6_12 ref NI_6 NS_12 0 -8.0372966221779352e-03
GC_6_13 ref NI_6 NS_13 0 1.7062722206015815e-01
GC_6_14 ref NI_6 NS_14 0 4.2575651212423193e-01
GC_6_15 ref NI_6 NS_15 0 -1.7134054094385947e-03
GC_6_16 ref NI_6 NS_16 0 1.0015379689587024e-02
GC_6_17 ref NI_6 NS_17 0 1.3334049513765681e-04
GC_6_18 ref NI_6 NS_18 0 -8.1221356481600629e-03
GC_6_19 ref NI_6 NS_19 0 -4.4057409230188666e-01
GC_6_20 ref NI_6 NS_20 0 -2.9647501478668736e-01
GC_6_21 ref NI_6 NS_21 0 3.4883683542062316e-01
GC_6_22 ref NI_6 NS_22 0 6.4866815365679481e-02
GC_6_23 ref NI_6 NS_23 0 3.3812666258613722e-04
GC_6_24 ref NI_6 NS_24 0 -6.4352770387956426e-03
GC_6_25 ref NI_6 NS_25 0 -3.9848254671864808e-01
GC_6_26 ref NI_6 NS_26 0 -3.1679600399153351e-01
GC_6_27 ref NI_6 NS_27 0 3.7054271869897248e-01
GC_6_28 ref NI_6 NS_28 0 5.7920779854794026e-02
GC_6_29 ref NI_6 NS_29 0 3.1520720254312969e-04
GC_6_30 ref NI_6 NS_30 0 -6.5589622514634505e-03
GC_6_31 ref NI_6 NS_31 0 3.4214858163404491e+00
GC_6_32 ref NI_6 NS_32 0 -5.3267154705896109e+00
GC_6_33 ref NI_6 NS_33 0 -1.3083912867078424e+00
GC_6_34 ref NI_6 NS_34 0 -2.0694585854558367e-01
GC_6_35 ref NI_6 NS_35 0 -1.2696039518932212e-03
GC_6_36 ref NI_6 NS_36 0 -2.7952694004317748e-02
GC_6_37 ref NI_6 NS_37 0 -4.0574169366471846e-01
GC_6_38 ref NI_6 NS_38 0 6.5228921289019859e-01
GC_6_39 ref NI_6 NS_39 0 1.9340348922363915e-01
GC_6_40 ref NI_6 NS_40 0 -1.7070925023572547e-01
GC_6_41 ref NI_6 NS_41 0 -2.6490027183864249e-05
GC_6_42 ref NI_6 NS_42 0 -5.3552666423395965e-04
GC_6_43 ref NI_6 NS_43 0 -2.5138784725651686e-01
GC_6_44 ref NI_6 NS_44 0 7.9082038824931353e-02
GC_6_45 ref NI_6 NS_45 0 -2.1808026122435120e-01
GC_6_46 ref NI_6 NS_46 0 2.0550922872560129e-01
GC_6_47 ref NI_6 NS_47 0 2.3706494773247512e-05
GC_6_48 ref NI_6 NS_48 0 1.7024913709479842e-02
GC_6_49 ref NI_6 NS_49 0 3.9424905461253901e-01
GC_6_50 ref NI_6 NS_50 0 1.9556136495947343e+00
GC_6_51 ref NI_6 NS_51 0 -7.5256590225541109e-01
GC_6_52 ref NI_6 NS_52 0 -8.4619569261637148e-02
GC_6_53 ref NI_6 NS_53 0 -1.5410515246970619e-04
GC_6_54 ref NI_6 NS_54 0 -5.3645931897127516e-03
GC_6_55 ref NI_6 NS_55 0 -1.4603558774924949e-01
GC_6_56 ref NI_6 NS_56 0 -1.0325378198705503e-02
GC_6_57 ref NI_6 NS_57 0 1.5781888323177107e-01
GC_6_58 ref NI_6 NS_58 0 4.1035095208902368e-02
GC_6_59 ref NI_6 NS_59 0 1.0440684110518636e-04
GC_6_60 ref NI_6 NS_60 0 5.5698361891479056e-03
GC_6_61 ref NI_6 NS_61 0 -4.1281042545570512e-01
GC_6_62 ref NI_6 NS_62 0 5.3956309975953887e-01
GC_6_63 ref NI_6 NS_63 0 9.3186662748468541e-02
GC_6_64 ref NI_6 NS_64 0 -8.8258328261764829e-02
GC_6_65 ref NI_6 NS_65 0 2.3307256499247161e-05
GC_6_66 ref NI_6 NS_66 0 4.0872539571423063e-03
GC_6_67 ref NI_6 NS_67 0 -4.5668855283593607e-01
GC_6_68 ref NI_6 NS_68 0 1.0650015064075786e+00
GC_6_69 ref NI_6 NS_69 0 5.2759873374730773e-02
GC_6_70 ref NI_6 NS_70 0 -2.1935431023880569e-01
GC_6_71 ref NI_6 NS_71 0 -1.2371889582742627e-05
GC_6_72 ref NI_6 NS_72 0 -5.2548077245636350e-03
GC_6_73 ref NI_6 NS_73 0 -4.8898684959911926e-02
GC_6_74 ref NI_6 NS_74 0 -1.1671899188579954e-01
GC_6_75 ref NI_6 NS_75 0 3.6256351740209475e-01
GC_6_76 ref NI_6 NS_76 0 -2.8272980404606810e-02
GC_6_77 ref NI_6 NS_77 0 1.0395463693619674e-04
GC_6_78 ref NI_6 NS_78 0 -2.2096648348121826e-03
GC_6_79 ref NI_6 NS_79 0 -2.8022120470791839e-01
GC_6_80 ref NI_6 NS_80 0 5.8422679562376595e-02
GC_6_81 ref NI_6 NS_81 0 -9.6795224505870303e-02
GC_6_82 ref NI_6 NS_82 0 1.4799144722006161e-01
GC_6_83 ref NI_6 NS_83 0 1.6192778386426221e-05
GC_6_84 ref NI_6 NS_84 0 1.4425724630092372e-02
GC_6_85 ref NI_6 NS_85 0 -1.0699490503996073e-01
GC_6_86 ref NI_6 NS_86 0 -9.7548878968485603e-02
GC_6_87 ref NI_6 NS_87 0 4.7591218761554276e-02
GC_6_88 ref NI_6 NS_88 0 1.2500477709208618e-01
GC_6_89 ref NI_6 NS_89 0 1.4381703230920490e-05
GC_6_90 ref NI_6 NS_90 0 7.6025227243051710e-03
GC_6_91 ref NI_6 NS_91 0 -1.7794770363529669e-01
GC_6_92 ref NI_6 NS_92 0 -1.5067334338188829e-01
GC_6_93 ref NI_6 NS_93 0 3.5313728001287992e-01
GC_6_94 ref NI_6 NS_94 0 -1.7015966033175997e-02
GC_6_95 ref NI_6 NS_95 0 5.6523936263883311e-05
GC_6_96 ref NI_6 NS_96 0 -3.0805980671686411e-04
GC_6_97 ref NI_6 NS_97 0 -3.6017775543042924e-01
GC_6_98 ref NI_6 NS_98 0 1.6075634093754076e-01
GC_6_99 ref NI_6 NS_99 0 4.6212479209683804e-01
GC_6_100 ref NI_6 NS_100 0 -1.6881024629672847e-01
GC_6_101 ref NI_6 NS_101 0 -2.2179773069063950e-05
GC_6_102 ref NI_6 NS_102 0 -2.1893820080457066e-03
GC_6_103 ref NI_6 NS_103 0 1.1248527258074200e-03
GC_6_104 ref NI_6 NS_104 0 -1.8953847685554928e-01
GC_6_105 ref NI_6 NS_105 0 8.3755017303335830e-02
GC_6_106 ref NI_6 NS_106 0 1.4268911785626123e-01
GC_6_107 ref NI_6 NS_107 0 7.1404676950742460e-05
GC_6_108 ref NI_6 NS_108 0 9.8345865401783510e-04
GC_6_109 ref NI_6 NS_109 0 -3.9491685962781370e-01
GC_6_110 ref NI_6 NS_110 0 1.3544916363081791e-01
GC_6_111 ref NI_6 NS_111 0 2.1965799502483557e-01
GC_6_112 ref NI_6 NS_112 0 -3.2834065737274952e-02
GC_6_113 ref NI_6 NS_113 0 -1.5493234707454490e-05
GC_6_114 ref NI_6 NS_114 0 6.5181523893649198e-03
GC_6_115 ref NI_6 NS_115 0 -3.1544122450366907e-01
GC_6_116 ref NI_6 NS_116 0 9.4572690825838163e-02
GC_6_117 ref NI_6 NS_117 0 3.0404163326832163e-02
GC_6_118 ref NI_6 NS_118 0 7.1171329479620821e-02
GC_6_119 ref NI_6 NS_119 0 3.3560548127134593e-05
GC_6_120 ref NI_6 NS_120 0 1.1947385492786716e-02
GC_6_121 ref NI_6 NS_121 0 -2.3399566406660777e-01
GC_6_122 ref NI_6 NS_122 0 6.6807730936350299e-02
GC_6_123 ref NI_6 NS_123 0 -9.9917990080123670e-02
GC_6_124 ref NI_6 NS_124 0 1.4940905384404699e-01
GC_6_125 ref NI_6 NS_125 0 4.3544107203450519e-05
GC_6_126 ref NI_6 NS_126 0 1.3529373520085894e-02
GD_6_1 ref NI_6 NA_1 0 -4.6793287525228065e-02
GD_6_2 ref NI_6 NA_2 0 -1.8729458632691053e-02
GD_6_3 ref NI_6 NA_3 0 -5.2802527098232757e-02
GD_6_4 ref NI_6 NA_4 0 8.7884354738348824e-02
GD_6_5 ref NI_6 NA_5 0 7.7982249258609165e-02
GD_6_6 ref NI_6 NA_6 0 5.4822869731332560e+00
GD_6_7 ref NI_6 NA_7 0 5.2898982374254062e-02
GD_6_8 ref NI_6 NA_8 0 6.0062534225605653e-02
GD_6_9 ref NI_6 NA_9 0 -7.6803459453078565e-02
GD_6_10 ref NI_6 NA_10 0 2.8950849808650887e-02
GD_6_11 ref NI_6 NA_11 0 6.7003461395538699e-02
GD_6_12 ref NI_6 NA_12 0 7.7925820787802164e-02
GD_6_13 ref NI_6 NA_13 0 8.1904576564759898e-03
GD_6_14 ref NI_6 NA_14 0 6.6462103691385055e-02
GD_6_15 ref NI_6 NA_15 0 3.5610555746426811e-02
GD_6_16 ref NI_6 NA_16 0 5.3700386146675091e-02
GD_6_17 ref NI_6 NA_17 0 7.2386595872046558e-02
GD_6_18 ref NI_6 NA_18 0 2.3395356487483334e-02
GD_6_19 ref NI_6 NA_19 0 6.7579930126331789e-02
GD_6_20 ref NI_6 NA_20 0 6.5330366743946836e-02
GD_6_21 ref NI_6 NA_21 0 5.1945311406123428e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -3.3265845330829391e-01
GC_7_2 ref NI_7 NS_2 0 7.6333830441200123e-01
GC_7_3 ref NI_7 NS_3 0 -5.0134592032077381e-02
GC_7_4 ref NI_7 NS_4 0 -1.0396931533155580e-02
GC_7_5 ref NI_7 NS_5 0 2.6553759347741341e-04
GC_7_6 ref NI_7 NS_6 0 -1.8096667313377370e-02
GC_7_7 ref NI_7 NS_7 0 7.9513439787105233e-01
GC_7_8 ref NI_7 NS_8 0 5.5791793964709369e-01
GC_7_9 ref NI_7 NS_9 0 -6.7872836690181099e-02
GC_7_10 ref NI_7 NS_10 0 -4.6833744572276723e-02
GC_7_11 ref NI_7 NS_11 0 1.2717969809528278e-04
GC_7_12 ref NI_7 NS_12 0 -1.5224159064045367e-02
GC_7_13 ref NI_7 NS_13 0 2.2767612905402401e-01
GC_7_14 ref NI_7 NS_14 0 3.7823789198204677e-01
GC_7_15 ref NI_7 NS_15 0 1.0654262450096172e-01
GC_7_16 ref NI_7 NS_16 0 -1.8063654888374251e-02
GC_7_17 ref NI_7 NS_17 0 1.9705530350313559e-04
GC_7_18 ref NI_7 NS_18 0 -1.8073370271044140e-02
GC_7_19 ref NI_7 NS_19 0 -3.2571744221670196e-01
GC_7_20 ref NI_7 NS_20 0 -4.3605557339183448e-01
GC_7_21 ref NI_7 NS_21 0 4.4859413236640200e-01
GC_7_22 ref NI_7 NS_22 0 8.4114984954241218e-02
GC_7_23 ref NI_7 NS_23 0 4.5847223571793830e-04
GC_7_24 ref NI_7 NS_24 0 -2.1947931845277917e-02
GC_7_25 ref NI_7 NS_25 0 -2.8475505546867858e-01
GC_7_26 ref NI_7 NS_26 0 -4.5388471715253675e-01
GC_7_27 ref NI_7 NS_27 0 4.6972372237285043e-01
GC_7_28 ref NI_7 NS_28 0 7.6972335491635666e-02
GC_7_29 ref NI_7 NS_29 0 4.9008017991172207e-04
GC_7_30 ref NI_7 NS_30 0 -2.2464830341453471e-02
GC_7_31 ref NI_7 NS_31 0 -4.0574169366471813e-01
GC_7_32 ref NI_7 NS_32 0 6.5228921289019659e-01
GC_7_33 ref NI_7 NS_33 0 1.9340348922364228e-01
GC_7_34 ref NI_7 NS_34 0 -1.7070925023572750e-01
GC_7_35 ref NI_7 NS_35 0 -2.6490027183972184e-05
GC_7_36 ref NI_7 NS_36 0 -5.3552666423345387e-04
GC_7_37 ref NI_7 NS_37 0 3.0245589036531175e+00
GC_7_38 ref NI_7 NS_38 0 -2.7338463361443615e+00
GC_7_39 ref NI_7 NS_39 0 -2.7145540374272752e+00
GC_7_40 ref NI_7 NS_40 0 -2.4605455928957909e-01
GC_7_41 ref NI_7 NS_41 0 -1.2979918862906063e-03
GC_7_42 ref NI_7 NS_42 0 -3.2204360425850911e-02
GC_7_43 ref NI_7 NS_43 0 -3.7363255214862168e-02
GC_7_44 ref NI_7 NS_44 0 -1.0825603763352661e-01
GC_7_45 ref NI_7 NS_45 0 -2.9931130684528857e-02
GC_7_46 ref NI_7 NS_46 0 1.7076303992330877e-01
GC_7_47 ref NI_7 NS_47 0 1.8068483144873159e-05
GC_7_48 ref NI_7 NS_48 0 7.8085286967842791e-03
GC_7_49 ref NI_7 NS_49 0 -3.5752106412402102e-01
GC_7_50 ref NI_7 NS_50 0 2.7774147398974303e-01
GC_7_51 ref NI_7 NS_51 0 2.4903984505156029e-01
GC_7_52 ref NI_7 NS_52 0 -9.9405259506947063e-02
GC_7_53 ref NI_7 NS_53 0 -1.0190725928186610e-05
GC_7_54 ref NI_7 NS_54 0 6.4580983164428656e-03
GC_7_55 ref NI_7 NS_55 0 4.9140401471699915e-02
GC_7_56 ref NI_7 NS_56 0 -7.5668090103641797e-02
GC_7_57 ref NI_7 NS_57 0 5.3781811437292526e-01
GC_7_58 ref NI_7 NS_58 0 -1.3550787491748453e-01
GC_7_59 ref NI_7 NS_59 0 -4.3949196956819041e-05
GC_7_60 ref NI_7 NS_60 0 -6.7085074394808673e-03
GC_7_61 ref NI_7 NS_61 0 -4.3406602787014548e-01
GC_7_62 ref NI_7 NS_62 0 1.2936731074446945e+00
GC_7_63 ref NI_7 NS_63 0 -6.5635284959619261e-02
GC_7_64 ref NI_7 NS_64 0 -2.2847150201125274e-01
GC_7_65 ref NI_7 NS_65 0 -1.5027511208692395e-04
GC_7_66 ref NI_7 NS_66 0 -1.2916960768513050e-03
GC_7_67 ref NI_7 NS_67 0 -2.9987609322165315e-01
GC_7_68 ref NI_7 NS_68 0 -4.9958853496686745e-02
GC_7_69 ref NI_7 NS_69 0 3.2170844298583040e-01
GC_7_70 ref NI_7 NS_70 0 -3.6509036309113535e-02
GC_7_71 ref NI_7 NS_71 0 1.1520078558052010e-04
GC_7_72 ref NI_7 NS_72 0 5.5838201688878271e-03
GC_7_73 ref NI_7 NS_73 0 1.4197915729746632e-01
GC_7_74 ref NI_7 NS_74 0 -9.3339403685198580e-02
GC_7_75 ref NI_7 NS_75 0 8.2604148566677615e-01
GC_7_76 ref NI_7 NS_76 0 -2.8142306774042941e-01
GC_7_77 ref NI_7 NS_77 0 -1.4162969907661446e-04
GC_7_78 ref NI_7 NS_78 0 -1.4436492405921002e-02
GC_7_79 ref NI_7 NS_79 0 -1.3659799352428875e-01
GC_7_80 ref NI_7 NS_80 0 -3.6497231675269561e-02
GC_7_81 ref NI_7 NS_81 0 -2.4446019867112260e-02
GC_7_82 ref NI_7 NS_82 0 1.3800261995929228e-01
GC_7_83 ref NI_7 NS_83 0 -2.5836550073238269e-05
GC_7_84 ref NI_7 NS_84 0 1.2014732066358528e-02
GC_7_85 ref NI_7 NS_85 0 -2.1166445260583908e-01
GC_7_86 ref NI_7 NS_86 0 7.4152474684546957e-02
GC_7_87 ref NI_7 NS_87 0 -2.0100788520742841e-01
GC_7_88 ref NI_7 NS_88 0 1.8345072889785832e-01
GC_7_89 ref NI_7 NS_89 0 -2.5262637685975503e-05
GC_7_90 ref NI_7 NS_90 0 2.2232948141407940e-02
GC_7_91 ref NI_7 NS_91 0 -2.2921602212938061e-01
GC_7_92 ref NI_7 NS_92 0 3.5574737301068186e-02
GC_7_93 ref NI_7 NS_93 0 -1.4426578537900986e-01
GC_7_94 ref NI_7 NS_94 0 1.5901124706604200e-01
GC_7_95 ref NI_7 NS_95 0 4.6235568618606309e-05
GC_7_96 ref NI_7 NS_96 0 2.3134218660315519e-02
GC_7_97 ref NI_7 NS_97 0 -1.4326601374911094e-01
GC_7_98 ref NI_7 NS_98 0 -1.2517231592505446e-01
GC_7_99 ref NI_7 NS_99 0 1.0567043082800467e-01
GC_7_100 ref NI_7 NS_100 0 8.2594408064005961e-02
GC_7_101 ref NI_7 NS_101 0 8.1180365417679587e-05
GC_7_102 ref NI_7 NS_102 0 1.4813734596886651e-02
GC_7_103 ref NI_7 NS_103 0 -3.4141134017387703e-01
GC_7_104 ref NI_7 NS_104 0 2.1163842919280995e-01
GC_7_105 ref NI_7 NS_105 0 -3.6358900938960964e-01
GC_7_106 ref NI_7 NS_106 0 2.1840877498943889e-01
GC_7_107 ref NI_7 NS_107 0 -1.4850550958864906e-05
GC_7_108 ref NI_7 NS_108 0 3.0367014932401185e-02
GC_7_109 ref NI_7 NS_109 0 -2.0054068952732126e-01
GC_7_110 ref NI_7 NS_110 0 -7.8085678807502277e-03
GC_7_111 ref NI_7 NS_111 0 5.6278234853842417e-02
GC_7_112 ref NI_7 NS_112 0 7.3226985312299528e-02
GC_7_113 ref NI_7 NS_113 0 5.3238091312228179e-06
GC_7_114 ref NI_7 NS_114 0 1.6739461447197745e-02
GC_7_115 ref NI_7 NS_115 0 -1.7446082209924071e-01
GC_7_116 ref NI_7 NS_116 0 -1.3439909319531294e-02
GC_7_117 ref NI_7 NS_117 0 1.8120705837166123e-01
GC_7_118 ref NI_7 NS_118 0 2.3557262081130948e-02
GC_7_119 ref NI_7 NS_119 0 -4.9903242705332042e-05
GC_7_120 ref NI_7 NS_120 0 8.5735946582114371e-03
GC_7_121 ref NI_7 NS_121 0 -3.5570908081306377e-02
GC_7_122 ref NI_7 NS_122 0 -9.3702069831975071e-02
GC_7_123 ref NI_7 NS_123 0 1.6774574495481057e-01
GC_7_124 ref NI_7 NS_124 0 6.4225486492685904e-02
GC_7_125 ref NI_7 NS_125 0 1.4502980544946897e-06
GC_7_126 ref NI_7 NS_126 0 2.8924970923957156e-03
GD_7_1 ref NI_7 NA_1 0 -3.6793661117706343e-02
GD_7_2 ref NI_7 NA_2 0 -5.3241256590402389e-03
GD_7_3 ref NI_7 NA_3 0 -5.5202605507499475e-02
GD_7_4 ref NI_7 NA_4 0 7.2300984965456366e-02
GD_7_5 ref NI_7 NA_5 0 6.2296402870200475e-02
GD_7_6 ref NI_7 NA_6 0 5.2898982374254062e-02
GD_7_7 ref NI_7 NA_7 0 5.6011418223226954e+00
GD_7_8 ref NI_7 NA_8 0 2.3285971198213112e-02
GD_7_9 ref NI_7 NA_9 0 5.5925730304406153e-02
GD_7_10 ref NI_7 NA_10 0 -1.5221152292757016e-02
GD_7_11 ref NI_7 NA_11 0 4.9511181609775599e-02
GD_7_12 ref NI_7 NA_12 0 5.6941417940977630e-02
GD_7_13 ref NI_7 NA_13 0 -3.9632871414138439e-02
GD_7_14 ref NI_7 NA_14 0 3.9445007872687975e-02
GD_7_15 ref NI_7 NA_15 0 5.0053688710585700e-02
GD_7_16 ref NI_7 NA_16 0 5.7474592050582723e-02
GD_7_17 ref NI_7 NA_17 0 4.1894120544510326e-02
GD_7_18 ref NI_7 NA_18 0 7.2341716536126241e-02
GD_7_19 ref NI_7 NA_19 0 4.4357326321353509e-02
GD_7_20 ref NI_7 NA_20 0 3.4401946270257916e-02
GD_7_21 ref NI_7 NA_21 0 1.4362457314831040e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -4.3626548485697125e-01
GC_8_2 ref NI_8 NS_2 0 2.0214051487509996e-01
GC_8_3 ref NI_8 NS_3 0 -2.5759013070745812e-01
GC_8_4 ref NI_8 NS_4 0 1.5201067961112744e-01
GC_8_5 ref NI_8 NS_5 0 2.0383182033541054e-04
GC_8_6 ref NI_8 NS_6 0 3.4777037603863734e-02
GC_8_7 ref NI_8 NS_7 0 -3.5049503702205564e-01
GC_8_8 ref NI_8 NS_8 0 1.6498617635038515e-01
GC_8_9 ref NI_8 NS_9 0 -2.1154963071552843e-01
GC_8_10 ref NI_8 NS_10 0 1.4783098488604662e-01
GC_8_11 ref NI_8 NS_11 0 1.3942359108693201e-04
GC_8_12 ref NI_8 NS_12 0 2.8243042821293959e-02
GC_8_13 ref NI_8 NS_13 0 -3.7537350631524419e-01
GC_8_14 ref NI_8 NS_14 0 2.0840432640486189e-01
GC_8_15 ref NI_8 NS_15 0 -2.6112790994448476e-01
GC_8_16 ref NI_8 NS_16 0 1.4438088142364117e-01
GC_8_17 ref NI_8 NS_17 0 1.5556355372252467e-04
GC_8_18 ref NI_8 NS_18 0 3.6687906888999831e-02
GC_8_19 ref NI_8 NS_19 0 -5.5420005296813646e-01
GC_8_20 ref NI_8 NS_20 0 3.4595809949456535e-01
GC_8_21 ref NI_8 NS_21 0 -3.9610722705723694e-01
GC_8_22 ref NI_8 NS_22 0 1.2728446551993342e-01
GC_8_23 ref NI_8 NS_23 0 2.9221820086630440e-04
GC_8_24 ref NI_8 NS_24 0 5.8931183261720144e-02
GC_8_25 ref NI_8 NS_25 0 -5.4318791174828818e-01
GC_8_26 ref NI_8 NS_26 0 3.4448955035717882e-01
GC_8_27 ref NI_8 NS_27 0 -3.9948031266032774e-01
GC_8_28 ref NI_8 NS_28 0 1.3164356235528571e-01
GC_8_29 ref NI_8 NS_29 0 2.8028399542383704e-04
GC_8_30 ref NI_8 NS_30 0 5.8111929386550451e-02
GC_8_31 ref NI_8 NS_31 0 -2.5138784725651681e-01
GC_8_32 ref NI_8 NS_32 0 7.9082038824931061e-02
GC_8_33 ref NI_8 NS_33 0 -2.1808026122435081e-01
GC_8_34 ref NI_8 NS_34 0 2.0550922872560104e-01
GC_8_35 ref NI_8 NS_35 0 2.3706494773232611e-05
GC_8_36 ref NI_8 NS_36 0 1.7024913709479911e-02
GC_8_37 ref NI_8 NS_37 0 -3.7363255214862300e-02
GC_8_38 ref NI_8 NS_38 0 -1.0825603763352599e-01
GC_8_39 ref NI_8 NS_39 0 -2.9931130684529784e-02
GC_8_40 ref NI_8 NS_40 0 1.7076303992330935e-01
GC_8_41 ref NI_8 NS_41 0 1.8068483144904882e-05
GC_8_42 ref NI_8 NS_42 0 7.8085286967841307e-03
GC_8_43 ref NI_8 NS_43 0 3.7335321761342528e+00
GC_8_44 ref NI_8 NS_44 0 -4.5245464214699984e+00
GC_8_45 ref NI_8 NS_45 0 -4.7009392719275717e-01
GC_8_46 ref NI_8 NS_46 0 -8.3317368949592474e-01
GC_8_47 ref NI_8 NS_47 0 -8.1928543472268548e-04
GC_8_48 ref NI_8 NS_48 0 -9.2732994183318054e-02
GC_8_49 ref NI_8 NS_49 0 -1.8449642586114851e-01
GC_8_50 ref NI_8 NS_50 0 -4.0418719873139435e-02
GC_8_51 ref NI_8 NS_51 0 -4.0029228132182869e-02
GC_8_52 ref NI_8 NS_52 0 1.6313022059285881e-01
GC_8_53 ref NI_8 NS_53 0 -5.0746997415113253e-07
GC_8_54 ref NI_8 NS_54 0 6.6740579960048348e-03
GC_8_55 ref NI_8 NS_55 0 1.4443550014487077e-03
GC_8_56 ref NI_8 NS_56 0 -5.8349101841128859e-01
GC_8_57 ref NI_8 NS_57 0 1.0255165793433476e+00
GC_8_58 ref NI_8 NS_58 0 -2.0656775499952676e-01
GC_8_59 ref NI_8 NS_59 0 -6.2521882499278928e-05
GC_8_60 ref NI_8 NS_60 0 -2.6618951861318019e-02
GC_8_61 ref NI_8 NS_61 0 7.5192747742409624e-02
GC_8_62 ref NI_8 NS_62 0 -3.2237876459094211e-01
GC_8_63 ref NI_8 NS_63 0 4.9640215392835257e-01
GC_8_64 ref NI_8 NS_64 0 -2.2073393405052003e-02
GC_8_65 ref NI_8 NS_65 0 -8.0490464608731299e-05
GC_8_66 ref NI_8 NS_66 0 -1.1687138660584776e-02
GC_8_67 ref NI_8 NS_67 0 -5.3990527967171442e-01
GC_8_68 ref NI_8 NS_68 0 3.7348895463677745e-01
GC_8_69 ref NI_8 NS_69 0 -5.3209443380484522e-01
GC_8_70 ref NI_8 NS_70 0 2.7693533832587164e-01
GC_8_71 ref NI_8 NS_71 0 -1.9227197543253589e-05
GC_8_72 ref NI_8 NS_72 0 2.9003712771404677e-02
GC_8_73 ref NI_8 NS_73 0 9.6609949436508233e-02
GC_8_74 ref NI_8 NS_74 0 -1.9052136761629127e-01
GC_8_75 ref NI_8 NS_75 0 -1.6606122972488879e-03
GC_8_76 ref NI_8 NS_76 0 2.0033605092098719e-01
GC_8_77 ref NI_8 NS_77 0 3.7488454678194242e-05
GC_8_78 ref NI_8 NS_78 0 -2.2575156968493108e-03
GC_8_79 ref NI_8 NS_79 0 8.8041787712514497e-01
GC_8_80 ref NI_8 NS_80 0 1.6746835605834136e+00
GC_8_81 ref NI_8 NS_81 0 3.0640510863500298e-01
GC_8_82 ref NI_8 NS_82 0 -4.9396337468135065e-01
GC_8_83 ref NI_8 NS_83 0 -9.6111679188447700e-05
GC_8_84 ref NI_8 NS_84 0 -6.1307621406750133e-02
GC_8_85 ref NI_8 NS_85 0 -1.2919644218423895e-01
GC_8_86 ref NI_8 NS_86 0 -2.9621856975764327e-01
GC_8_87 ref NI_8 NS_87 0 5.4152987633879079e-01
GC_8_88 ref NI_8 NS_88 0 -2.4966590719513050e-02
GC_8_89 ref NI_8 NS_89 0 1.4258109442982881e-04
GC_8_90 ref NI_8 NS_90 0 -2.2301386275939406e-02
GC_8_91 ref NI_8 NS_91 0 -5.1310642472472057e-01
GC_8_92 ref NI_8 NS_92 0 3.0735605510954689e-01
GC_8_93 ref NI_8 NS_93 0 -4.6331630706009452e-01
GC_8_94 ref NI_8 NS_94 0 2.8284527930202336e-01
GC_8_95 ref NI_8 NS_95 0 -4.0969561045522188e-05
GC_8_96 ref NI_8 NS_96 0 1.8351523727696991e-02
GC_8_97 ref NI_8 NS_97 0 -5.8128536986852020e-01
GC_8_98 ref NI_8 NS_98 0 4.0360366231165778e-01
GC_8_99 ref NI_8 NS_99 0 -5.6600466645478631e-01
GC_8_100 ref NI_8 NS_100 0 2.9628163687106202e-01
GC_8_101 ref NI_8 NS_101 0 -5.8134522901501229e-05
GC_8_102 ref NI_8 NS_102 0 2.6066273341833573e-02
GC_8_103 ref NI_8 NS_103 0 -4.3527131602706171e-01
GC_8_104 ref NI_8 NS_104 0 1.9871523073204633e-01
GC_8_105 ref NI_8 NS_105 0 -3.3440162941606222e-01
GC_8_106 ref NI_8 NS_106 0 2.6125857636133887e-01
GC_8_107 ref NI_8 NS_107 0 8.8333199878538426e-06
GC_8_108 ref NI_8 NS_108 0 9.0642179391553050e-03
GC_8_109 ref NI_8 NS_109 0 -7.5400179635040060e-02
GC_8_110 ref NI_8 NS_110 0 -2.5503640520110515e-01
GC_8_111 ref NI_8 NS_111 0 2.8169870632192751e-01
GC_8_112 ref NI_8 NS_112 0 8.2245377897388339e-02
GC_8_113 ref NI_8 NS_113 0 4.4413832852681850e-05
GC_8_114 ref NI_8 NS_114 0 -1.0300215327493593e-02
GC_8_115 ref NI_8 NS_115 0 -7.0652296561975608e-02
GC_8_116 ref NI_8 NS_116 0 -1.8103261591488062e-01
GC_8_117 ref NI_8 NS_117 0 1.2353216724424978e+00
GC_8_118 ref NI_8 NS_118 0 -4.1616919037109601e-01
GC_8_119 ref NI_8 NS_119 0 -5.7623204516740769e-05
GC_8_120 ref NI_8 NS_120 0 -4.1123615937204226e-02
GC_8_121 ref NI_8 NS_121 0 3.6669367662797259e-01
GC_8_122 ref NI_8 NS_122 0 2.2063670733251697e+00
GC_8_123 ref NI_8 NS_123 0 2.7879141158022064e-01
GC_8_124 ref NI_8 NS_124 0 -6.3847339702553940e-01
GC_8_125 ref NI_8 NS_125 0 -9.1200702291808334e-05
GC_8_126 ref NI_8 NS_126 0 -6.2307281819634470e-02
GD_8_1 ref NI_8 NA_1 0 8.5274972026099599e-02
GD_8_2 ref NI_8 NA_2 0 8.0100134351473479e-02
GD_8_3 ref NI_8 NA_3 0 7.7440320261166845e-02
GD_8_4 ref NI_8 NA_4 0 1.0934265553448508e-01
GD_8_5 ref NI_8 NA_5 0 1.0640577837477766e-01
GD_8_6 ref NI_8 NA_6 0 6.0062534225605653e-02
GD_8_7 ref NI_8 NA_7 0 2.3285971198213112e-02
GD_8_8 ref NI_8 NA_8 0 5.4298639252241667e+00
GD_8_9 ref NI_8 NA_9 0 5.0570335636840671e-02
GD_8_10 ref NI_8 NA_10 0 1.5753709250437203e-02
GD_8_11 ref NI_8 NA_11 0 4.5679964240881075e-04
GD_8_12 ref NI_8 NA_12 0 1.0609936138220115e-01
GD_8_13 ref NI_8 NA_13 0 1.0147684631199856e-03
GD_8_14 ref NI_8 NA_14 0 -1.7263637171848109e-01
GD_8_15 ref NI_8 NA_15 0 4.1462923379213631e-02
GD_8_16 ref NI_8 NA_16 0 1.0572228359821884e-01
GD_8_17 ref NI_8 NA_17 0 1.1384442876501347e-01
GD_8_18 ref NI_8 NA_18 0 9.5961915709066301e-02
GD_8_19 ref NI_8 NA_19 0 3.3485478308684279e-02
GD_8_20 ref NI_8 NA_20 0 -1.5368450805815165e-03
GD_8_21 ref NI_8 NA_21 0 -7.1161878293102110e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -4.3989388361637721e-01
GC_9_2 ref NI_9 NS_2 0 3.7129886064116752e-01
GC_9_3 ref NI_9 NS_3 0 -2.1039872526106201e-02
GC_9_4 ref NI_9 NS_4 0 3.5011112697697834e-02
GC_9_5 ref NI_9 NS_5 0 2.0838590254607214e-04
GC_9_6 ref NI_9 NS_6 0 7.3714784675326115e-03
GC_9_7 ref NI_9 NS_7 0 5.4425246876769293e-02
GC_9_8 ref NI_9 NS_8 0 3.2146138307467570e-01
GC_9_9 ref NI_9 NS_9 0 -2.0311707602207674e-02
GC_9_10 ref NI_9 NS_10 0 9.7757294805863072e-03
GC_9_11 ref NI_9 NS_11 0 9.7688838053828499e-05
GC_9_12 ref NI_9 NS_12 0 5.6549277268422189e-03
GC_9_13 ref NI_9 NS_13 0 -6.1035047252663580e-02
GC_9_14 ref NI_9 NS_14 0 1.8885006460993728e-01
GC_9_15 ref NI_9 NS_15 0 2.1257621784491729e-02
GC_9_16 ref NI_9 NS_16 0 4.0697719772107697e-02
GC_9_17 ref NI_9 NS_17 0 1.4677857921358697e-04
GC_9_18 ref NI_9 NS_18 0 8.4775603756492221e-03
GC_9_19 ref NI_9 NS_19 0 -2.8542416351742605e-01
GC_9_20 ref NI_9 NS_20 0 -1.3169430911750854e-01
GC_9_21 ref NI_9 NS_21 0 5.5903800972787659e-02
GC_9_22 ref NI_9 NS_22 0 1.1680641598351930e-01
GC_9_23 ref NI_9 NS_23 0 3.5589402267161387e-04
GC_9_24 ref NI_9 NS_24 0 1.5252116557541462e-02
GC_9_25 ref NI_9 NS_25 0 -2.5308026626587377e-01
GC_9_26 ref NI_9 NS_26 0 -1.4580764200191626e-01
GC_9_27 ref NI_9 NS_27 0 6.8722814305547358e-02
GC_9_28 ref NI_9 NS_28 0 1.1391754242003639e-01
GC_9_29 ref NI_9 NS_29 0 3.3685796665233866e-04
GC_9_30 ref NI_9 NS_30 0 1.4888118838423819e-02
GC_9_31 ref NI_9 NS_31 0 3.9424905461253862e-01
GC_9_32 ref NI_9 NS_32 0 1.9556136495947360e+00
GC_9_33 ref NI_9 NS_33 0 -7.5256590225541409e-01
GC_9_34 ref NI_9 NS_34 0 -8.4619569261635233e-02
GC_9_35 ref NI_9 NS_35 0 -1.5410515246960238e-04
GC_9_36 ref NI_9 NS_36 0 -5.3645931897132390e-03
GC_9_37 ref NI_9 NS_37 0 -3.5752106412402163e-01
GC_9_38 ref NI_9 NS_38 0 2.7774147398974547e-01
GC_9_39 ref NI_9 NS_39 0 2.4903984505155652e-01
GC_9_40 ref NI_9 NS_40 0 -9.9405259506944676e-02
GC_9_41 ref NI_9 NS_41 0 -1.0190725928057362e-05
GC_9_42 ref NI_9 NS_42 0 6.4580983164422585e-03
GC_9_43 ref NI_9 NS_43 0 -1.8449642586114867e-01
GC_9_44 ref NI_9 NS_44 0 -4.0418719873138775e-02
GC_9_45 ref NI_9 NS_45 0 -4.0029228132183896e-02
GC_9_46 ref NI_9 NS_46 0 1.6313022059285945e-01
GC_9_47 ref NI_9 NS_47 0 -5.0746997411702294e-07
GC_9_48 ref NI_9 NS_48 0 6.6740579960046717e-03
GC_9_49 ref NI_9 NS_49 0 3.3830551698977991e+00
GC_9_50 ref NI_9 NS_50 0 -5.8308317529998215e+00
GC_9_51 ref NI_9 NS_51 0 -1.1765696415527716e+00
GC_9_52 ref NI_9 NS_52 0 -1.2359493382970299e-01
GC_9_53 ref NI_9 NS_53 0 -1.0263600127946818e-03
GC_9_54 ref NI_9 NS_54 0 -2.4994731467727960e-02
GC_9_55 ref NI_9 NS_55 0 -1.2691989771462028e-01
GC_9_56 ref NI_9 NS_56 0 1.5377856995293150e-02
GC_9_57 ref NI_9 NS_57 0 6.9251987778105747e-02
GC_9_58 ref NI_9 NS_58 0 7.8257608811077933e-02
GC_9_59 ref NI_9 NS_59 0 5.8189127723154408e-05
GC_9_60 ref NI_9 NS_60 0 7.5415382433713834e-03
GC_9_61 ref NI_9 NS_61 0 -2.7346562759004078e-01
GC_9_62 ref NI_9 NS_62 0 6.3639065542606543e-01
GC_9_63 ref NI_9 NS_63 0 -3.6657124384493998e-02
GC_9_64 ref NI_9 NS_64 0 -5.2852329753749074e-02
GC_9_65 ref NI_9 NS_65 0 -2.7837391378495515e-05
GC_9_66 ref NI_9 NS_66 0 4.4243499891343553e-03
GC_9_67 ref NI_9 NS_67 0 -4.8720796961081025e-01
GC_9_68 ref NI_9 NS_68 0 4.3338091648196447e-01
GC_9_69 ref NI_9 NS_69 0 3.4451644622818423e-01
GC_9_70 ref NI_9 NS_70 0 -1.7801275486331714e-01
GC_9_71 ref NI_9 NS_71 0 1.7482755852395779e-05
GC_9_72 ref NI_9 NS_72 0 -5.3861706354750146e-03
GC_9_73 ref NI_9 NS_73 0 -7.3546816519122246e-02
GC_9_74 ref NI_9 NS_74 0 -7.8153101610435899e-02
GC_9_75 ref NI_9 NS_75 0 1.7941387508063728e-01
GC_9_76 ref NI_9 NS_76 0 4.4560104809397337e-02
GC_9_77 ref NI_9 NS_77 0 7.8042340224132134e-05
GC_9_78 ref NI_9 NS_78 0 6.5718964501647178e-03
GC_9_79 ref NI_9 NS_79 0 -2.7868767638192610e-01
GC_9_80 ref NI_9 NS_80 0 1.1957274676747148e-01
GC_9_81 ref NI_9 NS_81 0 3.5523216751215524e-02
GC_9_82 ref NI_9 NS_82 0 7.5786900984652877e-02
GC_9_83 ref NI_9 NS_83 0 -2.1019981599086982e-07
GC_9_84 ref NI_9 NS_84 0 3.7484423816540814e-03
GC_9_85 ref NI_9 NS_85 0 -1.3496841156831879e-01
GC_9_86 ref NI_9 NS_86 0 8.8642421162365287e-03
GC_9_87 ref NI_9 NS_87 0 3.3237949813235479e-01
GC_9_88 ref NI_9 NS_88 0 -3.5269588419287901e-02
GC_9_89 ref NI_9 NS_89 0 -7.8691044774611599e-05
GC_9_90 ref NI_9 NS_90 0 -7.2456689833550365e-03
GC_9_91 ref NI_9 NS_91 0 -1.7432203052662187e-01
GC_9_92 ref NI_9 NS_92 0 1.3070428807171519e-01
GC_9_93 ref NI_9 NS_93 0 3.3805074483555592e-01
GC_9_94 ref NI_9 NS_94 0 -6.6535112986938955e-02
GC_9_95 ref NI_9 NS_95 0 7.5515120634799240e-05
GC_9_96 ref NI_9 NS_96 0 -1.5620998710832239e-02
GC_9_97 ref NI_9 NS_97 0 -2.3444033351573915e-01
GC_9_98 ref NI_9 NS_98 0 3.5529304147225693e-01
GC_9_99 ref NI_9 NS_99 0 3.3360626833022000e-01
GC_9_100 ref NI_9 NS_100 0 -1.4312582113303604e-01
GC_9_101 ref NI_9 NS_101 0 3.3253839937390936e-05
GC_9_102 ref NI_9 NS_102 0 -1.2522907222907841e-02
GC_9_103 ref NI_9 NS_103 0 1.7758198182797964e-02
GC_9_104 ref NI_9 NS_104 0 -2.5483257307258100e-01
GC_9_105 ref NI_9 NS_105 0 3.8949202629270480e-01
GC_9_106 ref NI_9 NS_106 0 3.1312556601910298e-02
GC_9_107 ref NI_9 NS_107 0 8.0963943017383613e-05
GC_9_108 ref NI_9 NS_108 0 -1.8419034128610609e-02
GC_9_109 ref NI_9 NS_109 0 2.0099202224494822e-01
GC_9_110 ref NI_9 NS_110 0 1.3257006547226722e+00
GC_9_111 ref NI_9 NS_111 0 -3.4511351592864009e-01
GC_9_112 ref NI_9 NS_112 0 -8.7907655756340242e-02
GC_9_113 ref NI_9 NS_113 0 -2.0120612064645580e-04
GC_9_114 ref NI_9 NS_114 0 -8.6337200764827655e-03
GC_9_115 ref NI_9 NS_115 0 -3.1782993318914349e-01
GC_9_116 ref NI_9 NS_116 0 3.3910137793531320e-01
GC_9_117 ref NI_9 NS_117 0 -1.8006439063385229e-03
GC_9_118 ref NI_9 NS_118 0 2.6856159838125827e-02
GC_9_119 ref NI_9 NS_119 0 1.9616529444867888e-05
GC_9_120 ref NI_9 NS_120 0 3.9423256823972958e-03
GC_9_121 ref NI_9 NS_121 0 -1.6292792558832614e-01
GC_9_122 ref NI_9 NS_122 0 3.8527707208073411e-03
GC_9_123 ref NI_9 NS_123 0 -2.4013622948436231e-02
GC_9_124 ref NI_9 NS_124 0 1.3837875522659643e-01
GC_9_125 ref NI_9 NS_125 0 1.6027745831381444e-05
GC_9_126 ref NI_9 NS_126 0 6.9820045106179698e-03
GD_9_1 ref NI_9 NA_1 0 3.6658771983289269e-02
GD_9_2 ref NI_9 NA_2 0 4.4533557548509892e-02
GD_9_3 ref NI_9 NA_3 0 1.4860199748121777e-02
GD_9_4 ref NI_9 NA_4 0 6.8114531222464775e-02
GD_9_5 ref NI_9 NA_5 0 6.0580945920944186e-02
GD_9_6 ref NI_9 NA_6 0 -7.6803459453078565e-02
GD_9_7 ref NI_9 NA_7 0 5.5925730304406153e-02
GD_9_8 ref NI_9 NA_8 0 5.0570335636840671e-02
GD_9_9 ref NI_9 NA_9 0 5.5026822489832092e+00
GD_9_10 ref NI_9 NA_10 0 2.8508314960072906e-02
GD_9_11 ref NI_9 NA_11 0 4.5281163567497958e-02
GD_9_12 ref NI_9 NA_12 0 9.3690777507978454e-02
GD_9_13 ref NI_9 NA_13 0 1.8898129428903204e-02
GD_9_14 ref NI_9 NA_14 0 6.6637959490773821e-02
GD_9_15 ref NI_9 NA_15 0 2.7742381758451496e-02
GD_9_16 ref NI_9 NA_16 0 5.5588555676228141e-02
GD_9_17 ref NI_9 NA_17 0 6.0375847975292281e-02
GD_9_18 ref NI_9 NA_18 0 2.3285814705944933e-02
GD_9_19 ref NI_9 NA_19 0 -5.6578466202029006e-02
GD_9_20 ref NI_9 NA_20 0 6.7390795289966818e-02
GD_9_21 ref NI_9 NA_21 0 4.1658174671290689e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -3.0826261026378698e-01
GC_10_2 ref NI_10 NS_2 0 2.5772162631569950e-01
GC_10_3 ref NI_10 NS_3 0 -1.0637579134888881e-02
GC_10_4 ref NI_10 NS_4 0 7.7936035102867091e-02
GC_10_5 ref NI_10 NS_5 0 3.7359777113647323e-04
GC_10_6 ref NI_10 NS_6 0 3.2817991045955019e-05
GC_10_7 ref NI_10 NS_7 0 9.6735916920530240e-02
GC_10_8 ref NI_10 NS_8 0 1.9099155192381326e-01
GC_10_9 ref NI_10 NS_9 0 2.6457221320327254e-02
GC_10_10 ref NI_10 NS_10 0 4.1833648890560474e-02
GC_10_11 ref NI_10 NS_11 0 2.6791723074172873e-04
GC_10_12 ref NI_10 NS_12 0 -4.3221024342560930e-04
GC_10_13 ref NI_10 NS_13 0 7.1707819266379799e-02
GC_10_14 ref NI_10 NS_14 0 1.2433429209074487e-01
GC_10_15 ref NI_10 NS_15 0 9.2874463812847169e-03
GC_10_16 ref NI_10 NS_16 0 8.1313526667550082e-02
GC_10_17 ref NI_10 NS_17 0 3.2013966509358008e-04
GC_10_18 ref NI_10 NS_18 0 2.6389669558330066e-04
GC_10_19 ref NI_10 NS_19 0 -3.2927603510681069e-01
GC_10_20 ref NI_10 NS_20 0 -2.2566437399587500e-02
GC_10_21 ref NI_10 NS_21 0 -1.0392647232807158e-01
GC_10_22 ref NI_10 NS_22 0 2.0001253694743404e-01
GC_10_23 ref NI_10 NS_23 0 6.1568481371123709e-04
GC_10_24 ref NI_10 NS_24 0 5.6810049702252542e-03
GC_10_25 ref NI_10 NS_25 0 -2.9910549250335272e-01
GC_10_26 ref NI_10 NS_26 0 -3.5519492968757588e-02
GC_10_27 ref NI_10 NS_27 0 -9.2073931403821155e-02
GC_10_28 ref NI_10 NS_28 0 1.9820742753047979e-01
GC_10_29 ref NI_10 NS_29 0 5.9136155129816564e-04
GC_10_30 ref NI_10 NS_30 0 5.0324929049834575e-03
GC_10_31 ref NI_10 NS_31 0 -1.4603558774924894e-01
GC_10_32 ref NI_10 NS_32 0 -1.0325378198707951e-02
GC_10_33 ref NI_10 NS_33 0 1.5781888323177498e-01
GC_10_34 ref NI_10 NS_34 0 4.1035095208899898e-02
GC_10_35 ref NI_10 NS_35 0 1.0440684110505308e-04
GC_10_36 ref NI_10 NS_36 0 5.5698361891485292e-03
GC_10_37 ref NI_10 NS_37 0 4.9140401471700006e-02
GC_10_38 ref NI_10 NS_38 0 -7.5668090103642255e-02
GC_10_39 ref NI_10 NS_39 0 5.3781811437292615e-01
GC_10_40 ref NI_10 NS_40 0 -1.3550787491748498e-01
GC_10_41 ref NI_10 NS_41 0 -4.3949196956844391e-05
GC_10_42 ref NI_10 NS_42 0 -6.7085074394807494e-03
GC_10_43 ref NI_10 NS_43 0 1.4443550014486605e-03
GC_10_44 ref NI_10 NS_44 0 -5.8349101841128836e-01
GC_10_45 ref NI_10 NS_45 0 1.0255165793433474e+00
GC_10_46 ref NI_10 NS_46 0 -2.0656775499952654e-01
GC_10_47 ref NI_10 NS_47 0 -6.2521882499268303e-05
GC_10_48 ref NI_10 NS_48 0 -2.6618951861318074e-02
GC_10_49 ref NI_10 NS_49 0 -1.2691989771461995e-01
GC_10_50 ref NI_10 NS_50 0 1.5377856995291726e-02
GC_10_51 ref NI_10 NS_51 0 6.9251987778107996e-02
GC_10_52 ref NI_10 NS_52 0 7.8257608811076504e-02
GC_10_53 ref NI_10 NS_53 0 5.8189127723078039e-05
GC_10_54 ref NI_10 NS_54 0 7.5415382433717442e-03
GC_10_55 ref NI_10 NS_55 0 2.7919401448651304e+00
GC_10_56 ref NI_10 NS_56 0 -2.0160113695330923e+00
GC_10_57 ref NI_10 NS_57 0 -2.5442004521822890e+00
GC_10_58 ref NI_10 NS_58 0 -5.4463474407148682e-01
GC_10_59 ref NI_10 NS_59 0 -1.5146141755156739e-03
GC_10_60 ref NI_10 NS_60 0 -4.8403394396567212e-02
GC_10_61 ref NI_10 NS_61 0 6.5792251626855675e-02
GC_10_62 ref NI_10 NS_62 0 1.8090023098652405e-01
GC_10_63 ref NI_10 NS_63 0 4.5837769573677822e-01
GC_10_64 ref NI_10 NS_64 0 -1.6437891842434005e-01
GC_10_65 ref NI_10 NS_65 0 -1.0500600944572216e-04
GC_10_66 ref NI_10 NS_66 0 -1.0461910469717525e-02
GC_10_67 ref NI_10 NS_67 0 -3.2155146232532394e-01
GC_10_68 ref NI_10 NS_68 0 9.6210968622365001e-02
GC_10_69 ref NI_10 NS_69 0 -1.5549335321245245e-01
GC_10_70 ref NI_10 NS_70 0 1.6189079459313291e-01
GC_10_71 ref NI_10 NS_71 0 1.3955263593169964e-04
GC_10_72 ref NI_10 NS_72 0 1.9325255352874045e-02
GC_10_73 ref NI_10 NS_73 0 -9.6639004758868681e-05
GC_10_74 ref NI_10 NS_74 0 2.9325700737190863e-01
GC_10_75 ref NI_10 NS_75 0 9.7551233366206325e-01
GC_10_76 ref NI_10 NS_76 0 -4.9199270178945398e-01
GC_10_77 ref NI_10 NS_77 0 -2.5837302283512984e-04
GC_10_78 ref NI_10 NS_78 0 -1.5953306296124983e-02
GC_10_79 ref NI_10 NS_79 0 2.0651005237724337e-01
GC_10_80 ref NI_10 NS_80 0 -4.4225688315264955e-01
GC_10_81 ref NI_10 NS_81 0 5.8017401893685139e-01
GC_10_82 ref NI_10 NS_82 0 -2.6779112877670572e-02
GC_10_83 ref NI_10 NS_83 0 -4.6618150189354795e-05
GC_10_84 ref NI_10 NS_84 0 -1.7133469796905901e-02
GC_10_85 ref NI_10 NS_85 0 -1.3412595181261672e-01
GC_10_86 ref NI_10 NS_86 0 9.2119096767018394e-03
GC_10_87 ref NI_10 NS_87 0 -1.8636003743686044e-01
GC_10_88 ref NI_10 NS_88 0 2.1882476464677161e-01
GC_10_89 ref NI_10 NS_89 0 8.9822264492476536e-08
GC_10_90 ref NI_10 NS_90 0 1.1596024550098432e-02
GC_10_91 ref NI_10 NS_91 0 -5.1589126945399932e-01
GC_10_92 ref NI_10 NS_92 0 3.4669435829106948e-01
GC_10_93 ref NI_10 NS_93 0 -4.7141449459664386e-01
GC_10_94 ref NI_10 NS_94 0 2.3550774207569000e-01
GC_10_95 ref NI_10 NS_95 0 -2.4666940824274187e-05
GC_10_96 ref NI_10 NS_96 0 3.4784408005401966e-02
GC_10_97 ref NI_10 NS_97 0 -4.1820089122771448e-01
GC_10_98 ref NI_10 NS_98 0 2.4519929500881427e-01
GC_10_99 ref NI_10 NS_99 0 -3.6840660193726382e-01
GC_10_100 ref NI_10 NS_100 0 2.1739803669783281e-01
GC_10_101 ref NI_10 NS_101 0 2.6813171948384129e-05
GC_10_102 ref NI_10 NS_102 0 2.9441874523926752e-02
GC_10_103 ref NI_10 NS_103 0 -5.7981374505348571e-01
GC_10_104 ref NI_10 NS_104 0 4.1730999876179198e-01
GC_10_105 ref NI_10 NS_105 0 -5.4362249456516121e-01
GC_10_106 ref NI_10 NS_106 0 2.5055125511072923e-01
GC_10_107 ref NI_10 NS_107 0 -7.1403436908834667e-05
GC_10_108 ref NI_10 NS_108 0 3.7883004245894782e-02
GC_10_109 ref NI_10 NS_109 0 -1.3597152079302655e-01
GC_10_110 ref NI_10 NS_110 0 4.7187018852149340e-03
GC_10_111 ref NI_10 NS_111 0 -9.9042273978640114e-02
GC_10_112 ref NI_10 NS_112 0 1.7056107495983633e-01
GC_10_113 ref NI_10 NS_113 0 5.5482707998741299e-06
GC_10_114 ref NI_10 NS_114 0 1.1461130240816245e-02
GC_10_115 ref NI_10 NS_115 0 2.3739595566040325e-01
GC_10_116 ref NI_10 NS_116 0 -2.1942121639165171e-01
GC_10_117 ref NI_10 NS_117 0 5.3685439950296665e-01
GC_10_118 ref NI_10 NS_118 0 -7.4073284880766629e-02
GC_10_119 ref NI_10 NS_119 0 -1.2992852470644620e-04
GC_10_120 ref NI_10 NS_120 0 -1.6004626000084742e-02
GC_10_121 ref NI_10 NS_121 0 -1.6004663526925592e-02
GC_10_122 ref NI_10 NS_122 0 1.2279721903224323e+00
GC_10_123 ref NI_10 NS_123 0 1.9073692116143734e-01
GC_10_124 ref NI_10 NS_124 0 -3.2224538756230037e-01
GC_10_125 ref NI_10 NS_125 0 -1.8451220398506892e-04
GC_10_126 ref NI_10 NS_126 0 -2.7747421180367545e-02
GD_10_1 ref NI_10 NA_1 0 1.8684524276388993e-02
GD_10_2 ref NI_10 NA_2 0 2.6763041248504222e-02
GD_10_3 ref NI_10 NA_3 0 -1.9934830393790877e-04
GD_10_4 ref NI_10 NA_4 0 7.1513186283485145e-02
GD_10_5 ref NI_10 NA_5 0 6.4285338425662933e-02
GD_10_6 ref NI_10 NA_6 0 2.8950849808650887e-02
GD_10_7 ref NI_10 NA_7 0 -1.5221152292757016e-02
GD_10_8 ref NI_10 NA_8 0 1.5753709250437203e-02
GD_10_9 ref NI_10 NA_9 0 2.8508314960072906e-02
GD_10_10 ref NI_10 NA_10 0 5.6473984517288205e+00
GD_10_11 ref NI_10 NA_11 0 -2.4753556576438390e-02
GD_10_12 ref NI_10 NA_12 0 6.5855356988156449e-02
GD_10_13 ref NI_10 NA_13 0 -1.1200206066889378e-02
GD_10_14 ref NI_10 NA_14 0 -1.5491680803554101e-02
GD_10_15 ref NI_10 NA_15 0 3.9375966491761123e-02
GD_10_16 ref NI_10 NA_16 0 1.0017142898762622e-01
GD_10_17 ref NI_10 NA_17 0 8.3400333403772578e-02
GD_10_18 ref NI_10 NA_18 0 1.0976892370529040e-01
GD_10_19 ref NI_10 NA_19 0 3.5620895326260740e-02
GD_10_20 ref NI_10 NA_20 0 -3.9756589958509510e-02
GD_10_21 ref NI_10 NA_21 0 5.6206771428438454e-03
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -3.9816136934549118e-01
GC_11_2 ref NI_11 NS_2 0 4.4326718189838604e-01
GC_11_3 ref NI_11 NS_3 0 -2.3024162270652078e-02
GC_11_4 ref NI_11 NS_4 0 3.2715468459170172e-02
GC_11_5 ref NI_11 NS_5 0 3.2837335983377657e-04
GC_11_6 ref NI_11 NS_6 0 -1.2394829364571580e-03
GC_11_7 ref NI_11 NS_7 0 1.4630793223694519e-01
GC_11_8 ref NI_11 NS_8 0 3.6252752640342284e-01
GC_11_9 ref NI_11 NS_9 0 -1.9590749376494857e-02
GC_11_10 ref NI_11 NS_10 0 4.6310816814496801e-03
GC_11_11 ref NI_11 NS_11 0 2.2122891881467622e-04
GC_11_12 ref NI_11 NS_12 0 -1.2273100555516463e-03
GC_11_13 ref NI_11 NS_13 0 1.0497246151095194e-01
GC_11_14 ref NI_11 NS_14 0 2.1538395734539281e-01
GC_11_15 ref NI_11 NS_15 0 3.7984974717080656e-02
GC_11_16 ref NI_11 NS_16 0 3.2576406234718948e-02
GC_11_17 ref NI_11 NS_17 0 2.6433737068396688e-04
GC_11_18 ref NI_11 NS_18 0 -8.2874508376610558e-04
GC_11_19 ref NI_11 NS_19 0 -3.3142708010887384e-01
GC_11_20 ref NI_11 NS_20 0 -1.6663621773795531e-01
GC_11_21 ref NI_11 NS_21 0 1.1943213009050394e-01
GC_11_22 ref NI_11 NS_22 0 1.2497911944537185e-01
GC_11_23 ref NI_11 NS_23 0 5.2201662285402740e-04
GC_11_24 ref NI_11 NS_24 0 2.3227350834796371e-03
GC_11_25 ref NI_11 NS_25 0 -2.9660844116724056e-01
GC_11_26 ref NI_11 NS_26 0 -1.7926457459615594e-01
GC_11_27 ref NI_11 NS_27 0 1.3291168652758778e-01
GC_11_28 ref NI_11 NS_28 0 1.2084026353416238e-01
GC_11_29 ref NI_11 NS_29 0 5.4198430736199406e-04
GC_11_30 ref NI_11 NS_30 0 1.8558713007437550e-03
GC_11_31 ref NI_11 NS_31 0 -4.1281042545570468e-01
GC_11_32 ref NI_11 NS_32 0 5.3956309975953676e-01
GC_11_33 ref NI_11 NS_33 0 9.3186662748471927e-02
GC_11_34 ref NI_11 NS_34 0 -8.8258328261766980e-02
GC_11_35 ref NI_11 NS_35 0 2.3307256499130819e-05
GC_11_36 ref NI_11 NS_36 0 4.0872539571428501e-03
GC_11_37 ref NI_11 NS_37 0 -4.3406602787014564e-01
GC_11_38 ref NI_11 NS_38 0 1.2936731074446954e+00
GC_11_39 ref NI_11 NS_39 0 -6.5635284959620482e-02
GC_11_40 ref NI_11 NS_40 0 -2.2847150201125196e-01
GC_11_41 ref NI_11 NS_41 0 -1.5027511208688161e-04
GC_11_42 ref NI_11 NS_42 0 -1.2916960768515032e-03
GC_11_43 ref NI_11 NS_43 0 7.5192747742410262e-02
GC_11_44 ref NI_11 NS_44 0 -3.2237876459094494e-01
GC_11_45 ref NI_11 NS_45 0 4.9640215392835713e-01
GC_11_46 ref NI_11 NS_46 0 -2.2073393405054875e-02
GC_11_47 ref NI_11 NS_47 0 -8.0490464608887750e-05
GC_11_48 ref NI_11 NS_48 0 -1.1687138660584045e-02
GC_11_49 ref NI_11 NS_49 0 -2.7346562759004067e-01
GC_11_50 ref NI_11 NS_50 0 6.3639065542606521e-01
GC_11_51 ref NI_11 NS_51 0 -3.6657124384493533e-02
GC_11_52 ref NI_11 NS_52 0 -5.2852329753749358e-02
GC_11_53 ref NI_11 NS_53 0 -2.7837391378510497e-05
GC_11_54 ref NI_11 NS_54 0 4.4243499891344273e-03
GC_11_55 ref NI_11 NS_55 0 6.5792251626855827e-02
GC_11_56 ref NI_11 NS_56 0 1.8090023098652333e-01
GC_11_57 ref NI_11 NS_57 0 4.5837769573677928e-01
GC_11_58 ref NI_11 NS_58 0 -1.6437891842434074e-01
GC_11_59 ref NI_11 NS_59 0 -1.0500600944576025e-04
GC_11_60 ref NI_11 NS_60 0 -1.0461910469717346e-02
GC_11_61 ref NI_11 NS_61 0 3.4421402198342501e+00
GC_11_62 ref NI_11 NS_62 0 -4.1549688951167489e+00
GC_11_63 ref NI_11 NS_63 0 -2.3166285436830960e+00
GC_11_64 ref NI_11 NS_64 0 -3.6879161751438808e-02
GC_11_65 ref NI_11 NS_65 0 -9.8133276289489235e-04
GC_11_66 ref NI_11 NS_66 0 -2.8982736338218271e-02
GC_11_67 ref NI_11 NS_67 0 -3.1743746903282422e-01
GC_11_68 ref NI_11 NS_68 0 -5.2005206418415696e-02
GC_11_69 ref NI_11 NS_69 0 1.7387392812174732e-01
GC_11_70 ref NI_11 NS_70 0 4.0145986754280660e-02
GC_11_71 ref NI_11 NS_71 0 1.2766308105976453e-04
GC_11_72 ref NI_11 NS_72 0 9.5555725984679731e-03
GC_11_73 ref NI_11 NS_73 0 9.7253655080737314e-02
GC_11_74 ref NI_11 NS_74 0 -9.8374073118339220e-02
GC_11_75 ref NI_11 NS_75 0 5.9942339519464971e-01
GC_11_76 ref NI_11 NS_76 0 -1.6098495268928303e-01
GC_11_77 ref NI_11 NS_77 0 -2.2279134863835317e-05
GC_11_78 ref NI_11 NS_78 0 -9.4969732674876819e-03
GC_11_79 ref NI_11 NS_79 0 -1.3690413752361946e-01
GC_11_80 ref NI_11 NS_80 0 3.9198127126984290e-02
GC_11_81 ref NI_11 NS_81 0 2.8202529845680546e-01
GC_11_82 ref NI_11 NS_82 0 -2.2926100349349908e-02
GC_11_83 ref NI_11 NS_83 0 -1.2575426128858062e-04
GC_11_84 ref NI_11 NS_84 0 -4.8600218876134541e-03
GC_11_85 ref NI_11 NS_85 0 -1.7625298535982992e-01
GC_11_86 ref NI_11 NS_86 0 -3.9113778957679653e-02
GC_11_87 ref NI_11 NS_87 0 8.0684009587960084e-02
GC_11_88 ref NI_11 NS_88 0 8.9712214732868348e-02
GC_11_89 ref NI_11 NS_89 0 -5.2218602941706579e-05
GC_11_90 ref NI_11 NS_90 0 7.8068751794671438e-03
GC_11_91 ref NI_11 NS_91 0 -2.7649371056763850e-01
GC_11_92 ref NI_11 NS_92 0 4.9805727396062156e-02
GC_11_93 ref NI_11 NS_93 0 -1.3670762516979557e-01
GC_11_94 ref NI_11 NS_94 0 1.6736350983149340e-01
GC_11_95 ref NI_11 NS_95 0 1.8783418351769059e-05
GC_11_96 ref NI_11 NS_96 0 1.6913898343748394e-02
GC_11_97 ref NI_11 NS_97 0 -2.3190526277559462e-01
GC_11_98 ref NI_11 NS_98 0 -3.9897480407773217e-02
GC_11_99 ref NI_11 NS_99 0 2.2207458155262066e-03
GC_11_100 ref NI_11 NS_100 0 1.2134590672547660e-01
GC_11_101 ref NI_11 NS_101 0 6.4128414334457674e-05
GC_11_102 ref NI_11 NS_102 0 1.3796509851615634e-02
GC_11_103 ref NI_11 NS_103 0 -2.9757074990915305e-01
GC_11_104 ref NI_11 NS_104 0 1.1806585045762168e-01
GC_11_105 ref NI_11 NS_105 0 -2.5334550413223700e-01
GC_11_106 ref NI_11 NS_106 0 2.1062573791368211e-01
GC_11_107 ref NI_11 NS_107 0 -1.3623529245228590e-05
GC_11_108 ref NI_11 NS_108 0 1.8650168815473125e-02
GC_11_109 ref NI_11 NS_109 0 -2.7438275083307462e-01
GC_11_110 ref NI_11 NS_110 0 2.2337039472192735e-01
GC_11_111 ref NI_11 NS_111 0 7.0526700980152748e-02
GC_11_112 ref NI_11 NS_112 0 1.4628904443492786e-02
GC_11_113 ref NI_11 NS_113 0 -6.1058059321559990e-05
GC_11_114 ref NI_11 NS_114 0 7.7338462496242370e-03
GC_11_115 ref NI_11 NS_115 0 4.6518359344548121e-02
GC_11_116 ref NI_11 NS_116 0 9.0604979415160514e-01
GC_11_117 ref NI_11 NS_117 0 -7.8226837907973565e-02
GC_11_118 ref NI_11 NS_118 0 -1.0137670775800427e-01
GC_11_119 ref NI_11 NS_119 0 -3.0733870960691098e-04
GC_11_120 ref NI_11 NS_120 0 -5.6824918508119257e-03
GC_11_121 ref NI_11 NS_121 0 1.4426864814025583e-01
GC_11_122 ref NI_11 NS_122 0 5.0346431141847364e-02
GC_11_123 ref NI_11 NS_123 0 3.7613579837168187e-01
GC_11_124 ref NI_11 NS_124 0 -7.4369738615281247e-02
GC_11_125 ref NI_11 NS_125 0 -9.7022799114961317e-05
GC_11_126 ref NI_11 NS_126 0 -1.2651519380834343e-02
GD_11_1 ref NI_11 NA_1 0 1.8719262507332756e-02
GD_11_2 ref NI_11 NA_2 0 3.8553784104467435e-02
GD_11_3 ref NI_11 NA_3 0 -1.2867823213203212e-03
GD_11_4 ref NI_11 NA_4 0 7.3902426563663984e-02
GD_11_5 ref NI_11 NA_5 0 6.5557448922393347e-02
GD_11_6 ref NI_11 NA_6 0 6.7003461395538699e-02
GD_11_7 ref NI_11 NA_7 0 4.9511181609775599e-02
GD_11_8 ref NI_11 NA_8 0 4.5679964240881075e-04
GD_11_9 ref NI_11 NA_9 0 4.5281163567497958e-02
GD_11_10 ref NI_11 NA_10 0 -2.4753556576438390e-02
GD_11_11 ref NI_11 NA_11 0 5.5570128539560368e+00
GD_11_12 ref NI_11 NA_12 0 6.8437850258704858e-02
GD_11_13 ref NI_11 NA_13 0 -2.0039938406650155e-02
GD_11_14 ref NI_11 NA_14 0 3.1943649120020873e-02
GD_11_15 ref NI_11 NA_15 0 4.4835909444126916e-02
GD_11_16 ref NI_11 NA_16 0 6.7449967817635778e-02
GD_11_17 ref NI_11 NA_17 0 5.9129519598591869e-02
GD_11_18 ref NI_11 NA_18 0 6.9382177762910974e-02
GD_11_19 ref NI_11 NA_19 0 5.0702767012420165e-02
GD_11_20 ref NI_11 NA_20 0 -3.1364864856718792e-02
GD_11_21 ref NI_11 NA_21 0 -2.6115303790661716e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -3.4534909917071255e-01
GC_12_2 ref NI_12 NS_2 0 5.6315502498543568e-01
GC_12_3 ref NI_12 NS_3 0 -9.7689732457711398e-02
GC_12_4 ref NI_12 NS_4 0 2.9274304755601922e-02
GC_12_5 ref NI_12 NS_5 0 2.2773975297422054e-04
GC_12_6 ref NI_12 NS_6 0 7.7865809677240736e-04
GC_12_7 ref NI_12 NS_7 0 6.2151300423620548e-01
GC_12_8 ref NI_12 NS_8 0 3.9046902479313139e-01
GC_12_9 ref NI_12 NS_9 0 -8.2324612896551574e-02
GC_12_10 ref NI_12 NS_10 0 -8.2247905817510077e-03
GC_12_11 ref NI_12 NS_11 0 6.7469608749666331e-05
GC_12_12 ref NI_12 NS_12 0 -3.4387684510010702e-06
GC_12_13 ref NI_12 NS_13 0 -2.0071081390218259e-01
GC_12_14 ref NI_12 NS_14 0 3.3079564377003262e-01
GC_12_15 ref NI_12 NS_15 0 3.4068826216825587e-03
GC_12_16 ref NI_12 NS_16 0 3.5503437384553332e-02
GC_12_17 ref NI_12 NS_17 0 1.9824571076221544e-04
GC_12_18 ref NI_12 NS_18 0 2.0627643793260119e-03
GC_12_19 ref NI_12 NS_19 0 -3.4613799330197936e-01
GC_12_20 ref NI_12 NS_20 0 -2.2226052457054166e-01
GC_12_21 ref NI_12 NS_21 0 1.6874462097339052e-01
GC_12_22 ref NI_12 NS_22 0 1.0389470730006409e-01
GC_12_23 ref NI_12 NS_23 0 3.9289680972884935e-04
GC_12_24 ref NI_12 NS_24 0 7.0696393848538822e-03
GC_12_25 ref NI_12 NS_25 0 -3.0931321160508413e-01
GC_12_26 ref NI_12 NS_26 0 -2.4354245373125125e-01
GC_12_27 ref NI_12 NS_27 0 1.8717215043220403e-01
GC_12_28 ref NI_12 NS_28 0 9.9600366568472917e-02
GC_12_29 ref NI_12 NS_29 0 3.6798638853143489e-04
GC_12_30 ref NI_12 NS_30 0 6.8407943784285002e-03
GC_12_31 ref NI_12 NS_31 0 -4.5668855283593685e-01
GC_12_32 ref NI_12 NS_32 0 1.0650015064075820e+00
GC_12_33 ref NI_12 NS_33 0 5.2759873374725118e-02
GC_12_34 ref NI_12 NS_34 0 -2.1935431023880211e-01
GC_12_35 ref NI_12 NS_35 0 -1.2371889582549858e-05
GC_12_36 ref NI_12 NS_36 0 -5.2548077245645414e-03
GC_12_37 ref NI_12 NS_37 0 -2.9987609322165310e-01
GC_12_38 ref NI_12 NS_38 0 -4.9958853496687237e-02
GC_12_39 ref NI_12 NS_39 0 3.2170844298583112e-01
GC_12_40 ref NI_12 NS_40 0 -3.6509036309114055e-02
GC_12_41 ref NI_12 NS_41 0 1.1520078558049086e-04
GC_12_42 ref NI_12 NS_42 0 5.5838201688879581e-03
GC_12_43 ref NI_12 NS_43 0 -5.3990527967171487e-01
GC_12_44 ref NI_12 NS_44 0 3.7348895463677928e-01
GC_12_45 ref NI_12 NS_45 0 -5.3209443380484800e-01
GC_12_46 ref NI_12 NS_46 0 2.7693533832587336e-01
GC_12_47 ref NI_12 NS_47 0 -1.9227197543158007e-05
GC_12_48 ref NI_12 NS_48 0 2.9003712771404219e-02
GC_12_49 ref NI_12 NS_49 0 -4.8720796961081086e-01
GC_12_50 ref NI_12 NS_50 0 4.3338091648196808e-01
GC_12_51 ref NI_12 NS_51 0 3.4451644622817856e-01
GC_12_52 ref NI_12 NS_52 0 -1.7801275486331355e-01
GC_12_53 ref NI_12 NS_53 0 1.7482755852590447e-05
GC_12_54 ref NI_12 NS_54 0 -5.3861706354759262e-03
GC_12_55 ref NI_12 NS_55 0 -3.2155146232532339e-01
GC_12_56 ref NI_12 NS_56 0 9.6210968622362600e-02
GC_12_57 ref NI_12 NS_57 0 -1.5549335321244862e-01
GC_12_58 ref NI_12 NS_58 0 1.6189079459313049e-01
GC_12_59 ref NI_12 NS_59 0 1.3955263593156669e-04
GC_12_60 ref NI_12 NS_60 0 1.9325255352874660e-02
GC_12_61 ref NI_12 NS_61 0 -3.1743746903282444e-01
GC_12_62 ref NI_12 NS_62 0 -5.2005206418414808e-02
GC_12_63 ref NI_12 NS_63 0 1.7387392812174593e-01
GC_12_64 ref NI_12 NS_64 0 4.0145986754281542e-02
GC_12_65 ref NI_12 NS_65 0 1.2766308105981140e-04
GC_12_66 ref NI_12 NS_66 0 9.5555725984677511e-03
GC_12_67 ref NI_12 NS_67 0 3.9172862616366420e+00
GC_12_68 ref NI_12 NS_68 0 -3.5322525542851237e+00
GC_12_69 ref NI_12 NS_69 0 -1.9261125120052851e+00
GC_12_70 ref NI_12 NS_70 0 -4.4109538707794632e-01
GC_12_71 ref NI_12 NS_71 0 -1.3892071840493480e-03
GC_12_72 ref NI_12 NS_72 0 -4.2283956269606258e-02
GC_12_73 ref NI_12 NS_73 0 -1.8550007697986684e-01
GC_12_74 ref NI_12 NS_74 0 -5.4319433548248058e-02
GC_12_75 ref NI_12 NS_75 0 3.9722728247189858e-02
GC_12_76 ref NI_12 NS_76 0 1.1162786629367022e-01
GC_12_77 ref NI_12 NS_77 0 1.7818623491874376e-04
GC_12_78 ref NI_12 NS_78 0 1.0963953998049074e-02
GC_12_79 ref NI_12 NS_79 0 -3.7640939420169212e-01
GC_12_80 ref NI_12 NS_80 0 1.7000972832726594e-01
GC_12_81 ref NI_12 NS_81 0 -3.0428049611267588e-01
GC_12_82 ref NI_12 NS_82 0 2.2846300965517335e-01
GC_12_83 ref NI_12 NS_83 0 1.9612579263801241e-05
GC_12_84 ref NI_12 NS_84 0 1.7617244100763582e-02
GC_12_85 ref NI_12 NS_85 0 1.0134381095016907e-01
GC_12_86 ref NI_12 NS_86 0 -2.4175992781957978e-01
GC_12_87 ref NI_12 NS_87 0 9.0325693050252565e-02
GC_12_88 ref NI_12 NS_88 0 1.7948102516705947e-01
GC_12_89 ref NI_12 NS_89 0 3.1076133781561294e-05
GC_12_90 ref NI_12 NS_90 0 -9.4987328696861592e-03
GC_12_91 ref NI_12 NS_91 0 1.2249895343805838e-02
GC_12_92 ref NI_12 NS_92 0 -1.5525788967668702e-01
GC_12_93 ref NI_12 NS_93 0 9.3417883149481051e-01
GC_12_94 ref NI_12 NS_94 0 -2.9287617775849623e-01
GC_12_95 ref NI_12 NS_95 0 -8.6922984807654891e-05
GC_12_96 ref NI_12 NS_96 0 -2.6252888223119494e-02
GC_12_97 ref NI_12 NS_97 0 6.4125389758109566e-02
GC_12_98 ref NI_12 NS_98 0 1.6091735010409052e+00
GC_12_99 ref NI_12 NS_99 0 3.6895361201807464e-01
GC_12_100 ref NI_12 NS_100 0 -5.4864887137388607e-01
GC_12_101 ref NI_12 NS_101 0 -4.9963385642137986e-04
GC_12_102 ref NI_12 NS_102 0 -2.3323660696756024e-02
GC_12_103 ref NI_12 NS_103 0 5.1514011217078615e-01
GC_12_104 ref NI_12 NS_104 0 -6.2195977672535763e-01
GC_12_105 ref NI_12 NS_105 0 6.1750085176015412e-01
GC_12_106 ref NI_12 NS_106 0 3.4046782469191926e-02
GC_12_107 ref NI_12 NS_107 0 1.6380376552531732e-05
GC_12_108 ref NI_12 NS_108 0 -3.1415850702160061e-02
GC_12_109 ref NI_12 NS_109 0 -7.0599741657757786e-02
GC_12_110 ref NI_12 NS_110 0 -2.1954659112838545e-01
GC_12_111 ref NI_12 NS_111 0 3.7800021717950677e-01
GC_12_112 ref NI_12 NS_112 0 8.2172674422299544e-03
GC_12_113 ref NI_12 NS_113 0 7.0800417981340321e-05
GC_12_114 ref NI_12 NS_114 0 -8.7196702979107244e-03
GC_12_115 ref NI_12 NS_115 0 -3.3134497386249967e-01
GC_12_116 ref NI_12 NS_116 0 8.6390252995901862e-02
GC_12_117 ref NI_12 NS_117 0 -1.7470216916793083e-01
GC_12_118 ref NI_12 NS_118 0 1.8300904871668078e-01
GC_12_119 ref NI_12 NS_119 0 8.4615437376159056e-05
GC_12_120 ref NI_12 NS_120 0 1.5641222911603102e-02
GC_12_121 ref NI_12 NS_121 0 -4.8541357191483619e-01
GC_12_122 ref NI_12 NS_122 0 2.9639848611417724e-01
GC_12_123 ref NI_12 NS_123 0 -4.1822250693650509e-01
GC_12_124 ref NI_12 NS_124 0 2.3909612789685852e-01
GC_12_125 ref NI_12 NS_125 0 1.6797988730853716e-05
GC_12_126 ref NI_12 NS_126 0 2.6791327132199071e-02
GD_12_1 ref NI_12 NA_1 0 6.3550081972131925e-03
GD_12_2 ref NI_12 NA_2 0 1.5121405068715963e-02
GD_12_3 ref NI_12 NA_3 0 -3.9235356307932776e-03
GD_12_4 ref NI_12 NA_4 0 8.0031525721951338e-02
GD_12_5 ref NI_12 NA_5 0 7.1923833493285086e-02
GD_12_6 ref NI_12 NA_6 0 7.7925820787802164e-02
GD_12_7 ref NI_12 NA_7 0 5.6941417940977630e-02
GD_12_8 ref NI_12 NA_8 0 1.0609936138220115e-01
GD_12_9 ref NI_12 NA_9 0 9.3690777507978454e-02
GD_12_10 ref NI_12 NA_10 0 6.5855356988156449e-02
GD_12_11 ref NI_12 NA_11 0 6.8437850258704858e-02
GD_12_12 ref NI_12 NA_12 0 5.3973024100522506e+00
GD_12_13 ref NI_12 NA_13 0 4.0782315605158694e-02
GD_12_14 ref NI_12 NA_14 0 8.4586765564848274e-02
GD_12_15 ref NI_12 NA_15 0 4.6957957226882088e-03
GD_12_16 ref NI_12 NA_16 0 -9.2289589374497524e-04
GD_12_17 ref NI_12 NA_17 0 -6.6778815626470617e-02
GD_12_18 ref NI_12 NA_18 0 -7.0207516744478907e-02
GD_12_19 ref NI_12 NA_19 0 3.3189826333629824e-02
GD_12_20 ref NI_12 NA_20 0 7.6321664140692011e-02
GD_12_21 ref NI_12 NA_21 0 9.5295365999258669e-02
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -2.4153579580052778e-01
GC_13_2 ref NI_13 NS_2 0 3.4430016176778749e-01
GC_13_3 ref NI_13 NS_3 0 1.0052657569360245e-01
GC_13_4 ref NI_13 NS_4 0 3.4712631483698041e-02
GC_13_5 ref NI_13 NS_5 0 3.3684954115942046e-04
GC_13_6 ref NI_13 NS_6 0 -1.9469096744134006e-02
GC_13_7 ref NI_13 NS_7 0 4.9136585340656996e-01
GC_13_8 ref NI_13 NS_8 0 2.3352430132577470e-01
GC_13_9 ref NI_13 NS_9 0 1.3027797918941125e-01
GC_13_10 ref NI_13 NS_10 0 -2.1985072545666721e-02
GC_13_11 ref NI_13 NS_11 0 2.0945451346592774e-04
GC_13_12 ref NI_13 NS_12 0 -1.6636185310530714e-02
GC_13_13 ref NI_13 NS_13 0 2.2091224558132752e-01
GC_13_14 ref NI_13 NS_14 0 1.1820484419264417e-01
GC_13_15 ref NI_13 NS_15 0 1.5450707319506085e-01
GC_13_16 ref NI_13 NS_16 0 4.4711392634083656e-02
GC_13_17 ref NI_13 NS_17 0 2.7904187014257675e-04
GC_13_18 ref NI_13 NS_18 0 -2.0111443018217549e-02
GC_13_19 ref NI_13 NS_19 0 -2.1749501547772110e-01
GC_13_20 ref NI_13 NS_20 0 -2.5730767283910394e-01
GC_13_21 ref NI_13 NS_21 0 8.8636465357480154e-02
GC_13_22 ref NI_13 NS_22 0 2.3418372191659723e-01
GC_13_23 ref NI_13 NS_23 0 5.2044592629669443e-04
GC_13_24 ref NI_13 NS_24 0 -2.3383149052656822e-02
GC_13_25 ref NI_13 NS_25 0 -1.7089682990652549e-01
GC_13_26 ref NI_13 NS_26 0 -2.8097672864620060e-01
GC_13_27 ref NI_13 NS_27 0 1.1217814287035857e-01
GC_13_28 ref NI_13 NS_28 0 2.2757794454751734e-01
GC_13_29 ref NI_13 NS_29 0 5.0252230968847130e-04
GC_13_30 ref NI_13 NS_30 0 -2.3763325235325185e-02
GC_13_31 ref NI_13 NS_31 0 -4.8898684959911544e-02
GC_13_32 ref NI_13 NS_32 0 -1.1671899188580127e-01
GC_13_33 ref NI_13 NS_33 0 3.6256351740209752e-01
GC_13_34 ref NI_13 NS_34 0 -2.8272980404608565e-02
GC_13_35 ref NI_13 NS_35 0 1.0395463693610153e-04
GC_13_36 ref NI_13 NS_36 0 -2.2096648348117380e-03
GC_13_37 ref NI_13 NS_37 0 1.4197915729746666e-01
GC_13_38 ref NI_13 NS_38 0 -9.3339403685199759e-02
GC_13_39 ref NI_13 NS_39 0 8.2604148566677793e-01
GC_13_40 ref NI_13 NS_40 0 -2.8142306774043058e-01
GC_13_41 ref NI_13 NS_41 0 -1.4162969907667998e-04
GC_13_42 ref NI_13 NS_42 0 -1.4436492405920695e-02
GC_13_43 ref NI_13 NS_43 0 9.6609949436508191e-02
GC_13_44 ref NI_13 NS_44 0 -1.9052136761629113e-01
GC_13_45 ref NI_13 NS_45 0 -1.6606122972490267e-03
GC_13_46 ref NI_13 NS_46 0 2.0033605092098725e-01
GC_13_47 ref NI_13 NS_47 0 3.7488454678198552e-05
GC_13_48 ref NI_13 NS_48 0 -2.2575156968493324e-03
GC_13_49 ref NI_13 NS_49 0 -7.3546816519121885e-02
GC_13_50 ref NI_13 NS_50 0 -7.8153101610437467e-02
GC_13_51 ref NI_13 NS_51 0 1.7941387508063975e-01
GC_13_52 ref NI_13 NS_52 0 4.4560104809395762e-02
GC_13_53 ref NI_13 NS_53 0 7.8042340224047376e-05
GC_13_54 ref NI_13 NS_54 0 6.5718964501651151e-03
GC_13_55 ref NI_13 NS_55 0 -9.6639004758910816e-05
GC_13_56 ref NI_13 NS_56 0 2.9325700737190880e-01
GC_13_57 ref NI_13 NS_57 0 9.7551233366206291e-01
GC_13_58 ref NI_13 NS_58 0 -4.9199270178945370e-01
GC_13_59 ref NI_13 NS_59 0 -2.5837302283511927e-04
GC_13_60 ref NI_13 NS_60 0 -1.5953306296125035e-02
GC_13_61 ref NI_13 NS_61 0 9.7253655080737411e-02
GC_13_62 ref NI_13 NS_62 0 -9.8374073118339650e-02
GC_13_63 ref NI_13 NS_63 0 5.9942339519465038e-01
GC_13_64 ref NI_13 NS_64 0 -1.6098495268928351e-01
GC_13_65 ref NI_13 NS_65 0 -2.2279134863858597e-05
GC_13_66 ref NI_13 NS_66 0 -9.4969732674875709e-03
GC_13_67 ref NI_13 NS_67 0 -1.8550007697986765e-01
GC_13_68 ref NI_13 NS_68 0 -5.4319433548244415e-02
GC_13_69 ref NI_13 NS_69 0 3.9722728247184071e-02
GC_13_70 ref NI_13 NS_70 0 1.1162786629367391e-01
GC_13_71 ref NI_13 NS_71 0 1.7818623491894442e-04
GC_13_72 ref NI_13 NS_72 0 1.0963953998048141e-02
GC_13_73 ref NI_13 NS_73 0 1.9431078882806878e+00
GC_13_74 ref NI_13 NS_74 0 -6.0267570882748289e-01
GC_13_75 ref NI_13 NS_75 0 -2.1954546748896258e+00
GC_13_76 ref NI_13 NS_76 0 -1.2166545341313069e+00
GC_13_77 ref NI_13 NS_77 0 -1.6529701029930246e-03
GC_13_78 ref NI_13 NS_78 0 -3.7796668402973521e-02
GC_13_79 ref NI_13 NS_79 0 -5.7632652623386335e-02
GC_13_80 ref NI_13 NS_80 0 -3.3047372104730216e-02
GC_13_81 ref NI_13 NS_81 0 -1.1568557847943853e-01
GC_13_82 ref NI_13 NS_82 0 2.0120884964353181e-01
GC_13_83 ref NI_13 NS_83 0 7.9928014298991534e-06
GC_13_84 ref NI_13 NS_84 0 6.3353927372582254e-03
GC_13_85 ref NI_13 NS_85 0 -3.7788144922328920e-01
GC_13_86 ref NI_13 NS_86 0 2.6741021052221498e-01
GC_13_87 ref NI_13 NS_87 0 -4.1504736702340994e-01
GC_13_88 ref NI_13 NS_88 0 2.3444980542968075e-01
GC_13_89 ref NI_13 NS_89 0 -6.2431334270755009e-05
GC_13_90 ref NI_13 NS_90 0 3.0541995685990034e-02
GC_13_91 ref NI_13 NS_91 0 -4.5560838314760688e-01
GC_13_92 ref NI_13 NS_92 0 2.9397798929799579e-01
GC_13_93 ref NI_13 NS_93 0 -4.0490897775537948e-01
GC_13_94 ref NI_13 NS_94 0 2.0074445859002782e-01
GC_13_95 ref NI_13 NS_95 0 -1.5596713000482919e-05
GC_13_96 ref NI_13 NS_96 0 3.8984939989824607e-02
GC_13_97 ref NI_13 NS_97 0 -2.8517803260134117e-01
GC_13_98 ref NI_13 NS_98 0 1.2123177822866066e-01
GC_13_99 ref NI_13 NS_99 0 -2.4239496545844652e-01
GC_13_100 ref NI_13 NS_100 0 1.8416790382312348e-01
GC_13_101 ref NI_13 NS_101 0 6.3170717297031024e-05
GC_13_102 ref NI_13 NS_102 0 2.6903726609383397e-02
GC_13_103 ref NI_13 NS_103 0 -5.9980393007003874e-01
GC_13_104 ref NI_13 NS_104 0 4.3565678113641226e-01
GC_13_105 ref NI_13 NS_105 0 -5.2455292088582328e-01
GC_13_106 ref NI_13 NS_106 0 2.0828906538359060e-01
GC_13_107 ref NI_13 NS_107 0 -9.7823728920423995e-05
GC_13_108 ref NI_13 NS_108 0 4.8717201665207356e-02
GC_13_109 ref NI_13 NS_109 0 -2.2561655701603747e-01
GC_13_110 ref NI_13 NS_110 0 9.8945300039704240e-02
GC_13_111 ref NI_13 NS_111 0 -1.9426717934588905e-01
GC_13_112 ref NI_13 NS_112 0 1.7359420688142158e-01
GC_13_113 ref NI_13 NS_113 0 2.1256653780382620e-06
GC_13_114 ref NI_13 NS_114 0 2.2197524599290034e-02
GC_13_115 ref NI_13 NS_115 0 6.1066816712511005e-02
GC_13_116 ref NI_13 NS_116 0 -1.2993971225736942e-01
GC_13_117 ref NI_13 NS_117 0 1.2013632381631080e-01
GC_13_118 ref NI_13 NS_118 0 1.0475644905018687e-01
GC_13_119 ref NI_13 NS_119 0 -1.8608591816951804e-05
GC_13_120 ref NI_13 NS_120 0 1.1543966827103692e-03
GC_13_121 ref NI_13 NS_121 0 1.0161305211376313e-01
GC_13_122 ref NI_13 NS_122 0 -2.6316181310001924e-01
GC_13_123 ref NI_13 NS_123 0 4.0350338246177753e-01
GC_13_124 ref NI_13 NS_124 0 1.7815411300295646e-03
GC_13_125 ref NI_13 NS_125 0 -1.0438098395024239e-05
GC_13_126 ref NI_13 NS_126 0 -7.6563550526777746e-03
GD_13_1 ref NI_13 NA_1 0 -1.9141153603652566e-02
GD_13_2 ref NI_13 NA_2 0 -4.0325096426256203e-03
GD_13_3 ref NI_13 NA_3 0 -4.0106984206247184e-02
GD_13_4 ref NI_13 NA_4 0 5.5323530081425265e-02
GD_13_5 ref NI_13 NA_5 0 4.4825957920807534e-02
GD_13_6 ref NI_13 NA_6 0 8.1904576564759898e-03
GD_13_7 ref NI_13 NA_7 0 -3.9632871414138439e-02
GD_13_8 ref NI_13 NA_8 0 1.0147684631199856e-03
GD_13_9 ref NI_13 NA_9 0 1.8898129428903204e-02
GD_13_10 ref NI_13 NA_10 0 -1.1200206066889378e-02
GD_13_11 ref NI_13 NA_11 0 -2.0039938406650155e-02
GD_13_12 ref NI_13 NA_12 0 4.0782315605158694e-02
GD_13_13 ref NI_13 NA_13 0 5.7829321979856196e+00
GD_13_14 ref NI_13 NA_14 0 2.4309562831818614e-02
GD_13_15 ref NI_13 NA_15 0 7.3778067676507075e-02
GD_13_16 ref NI_13 NA_16 0 8.9237600330919889e-02
GD_13_17 ref NI_13 NA_17 0 6.0962543802259968e-02
GD_13_18 ref NI_13 NA_18 0 1.1063651324114303e-01
GD_13_19 ref NI_13 NA_19 0 4.7978435205350799e-02
GD_13_20 ref NI_13 NA_20 0 -3.0168213989213242e-03
GD_13_21 ref NI_13 NA_21 0 -8.0737665429089518e-03
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 -4.3094853828890478e-01
GC_14_2 ref NI_14 NS_2 0 2.0127814123373564e-01
GC_14_3 ref NI_14 NS_3 0 -2.2596816885223558e-01
GC_14_4 ref NI_14 NS_4 0 1.3293966072511285e-01
GC_14_5 ref NI_14 NS_5 0 1.6135117123456972e-04
GC_14_6 ref NI_14 NS_6 0 3.4894764810464780e-02
GC_14_7 ref NI_14 NS_7 0 -3.3286017237369325e-01
GC_14_8 ref NI_14 NS_8 0 1.6672073284833999e-01
GC_14_9 ref NI_14 NS_9 0 -1.8530844382450995e-01
GC_14_10 ref NI_14 NS_10 0 1.2928919311787743e-01
GC_14_11 ref NI_14 NS_11 0 9.8007632957646567e-05
GC_14_12 ref NI_14 NS_12 0 2.8367617494206521e-02
GC_14_13 ref NI_14 NS_13 0 -3.5308134440105593e-01
GC_14_14 ref NI_14 NS_14 0 1.9973017504018695e-01
GC_14_15 ref NI_14 NS_15 0 -2.3144540524708046e-01
GC_14_16 ref NI_14 NS_16 0 1.2730908268529731e-01
GC_14_17 ref NI_14 NS_17 0 1.1511265009969140e-04
GC_14_18 ref NI_14 NS_18 0 3.6896839540180991e-02
GC_14_19 ref NI_14 NS_19 0 -5.1865622849786819e-01
GC_14_20 ref NI_14 NS_20 0 2.9774153757294652e-01
GC_14_21 ref NI_14 NS_21 0 -3.4115253829860853e-01
GC_14_22 ref NI_14 NS_22 0 1.1039057472136370e-01
GC_14_23 ref NI_14 NS_23 0 2.5369673682350968e-04
GC_14_24 ref NI_14 NS_24 0 5.8235856467015290e-02
GC_14_25 ref NI_14 NS_25 0 -5.0758593213356051e-01
GC_14_26 ref NI_14 NS_26 0 2.9638462041263114e-01
GC_14_27 ref NI_14 NS_27 0 -3.4420871244550444e-01
GC_14_28 ref NI_14 NS_28 0 1.1443258984802256e-01
GC_14_29 ref NI_14 NS_29 0 2.4264278410627082e-04
GC_14_30 ref NI_14 NS_30 0 5.7450060652896082e-02
GC_14_31 ref NI_14 NS_31 0 -2.8022120470791867e-01
GC_14_32 ref NI_14 NS_32 0 5.8422679562377948e-02
GC_14_33 ref NI_14 NS_33 0 -9.6795224505872426e-02
GC_14_34 ref NI_14 NS_34 0 1.4799144722006297e-01
GC_14_35 ref NI_14 NS_35 0 1.6192778386500214e-05
GC_14_36 ref NI_14 NS_36 0 1.4425724630092026e-02
GC_14_37 ref NI_14 NS_37 0 -1.3659799352428884e-01
GC_14_38 ref NI_14 NS_38 0 -3.6497231675269283e-02
GC_14_39 ref NI_14 NS_39 0 -2.4446019867112697e-02
GC_14_40 ref NI_14 NS_40 0 1.3800261995929253e-01
GC_14_41 ref NI_14 NS_41 0 -2.5836550073223416e-05
GC_14_42 ref NI_14 NS_42 0 1.2014732066358459e-02
GC_14_43 ref NI_14 NS_43 0 8.8041787712514508e-01
GC_14_44 ref NI_14 NS_44 0 1.6746835605834125e+00
GC_14_45 ref NI_14 NS_45 0 3.0640510863500442e-01
GC_14_46 ref NI_14 NS_46 0 -4.9396337468135160e-01
GC_14_47 ref NI_14 NS_47 0 -9.6111679188496285e-05
GC_14_48 ref NI_14 NS_48 0 -6.1307621406749911e-02
GC_14_49 ref NI_14 NS_49 0 -2.7868767638192615e-01
GC_14_50 ref NI_14 NS_50 0 1.1957274676747172e-01
GC_14_51 ref NI_14 NS_51 0 3.5523216751215121e-02
GC_14_52 ref NI_14 NS_52 0 7.5786900984653127e-02
GC_14_53 ref NI_14 NS_53 0 -2.1019981597628121e-07
GC_14_54 ref NI_14 NS_54 0 3.7484423816540168e-03
GC_14_55 ref NI_14 NS_55 0 2.0651005237724346e-01
GC_14_56 ref NI_14 NS_56 0 -4.4225688315265016e-01
GC_14_57 ref NI_14 NS_57 0 5.8017401893685228e-01
GC_14_58 ref NI_14 NS_58 0 -2.6779112877671114e-02
GC_14_59 ref NI_14 NS_59 0 -4.6618150189384407e-05
GC_14_60 ref NI_14 NS_60 0 -1.7133469796905762e-02
GC_14_61 ref NI_14 NS_61 0 -1.3690413752361941e-01
GC_14_62 ref NI_14 NS_62 0 3.9198127126983895e-02
GC_14_63 ref NI_14 NS_63 0 2.8202529845680607e-01
GC_14_64 ref NI_14 NS_64 0 -2.2926100349350300e-02
GC_14_65 ref NI_14 NS_65 0 -1.2575426128860179e-04
GC_14_66 ref NI_14 NS_66 0 -4.8600218876133543e-03
GC_14_67 ref NI_14 NS_67 0 -3.7640939420169167e-01
GC_14_68 ref NI_14 NS_68 0 1.7000972832726419e-01
GC_14_69 ref NI_14 NS_69 0 -3.0428049611267305e-01
GC_14_70 ref NI_14 NS_70 0 2.2846300965517155e-01
GC_14_71 ref NI_14 NS_71 0 1.9612579263707867e-05
GC_14_72 ref NI_14 NS_72 0 1.7617244100764019e-02
GC_14_73 ref NI_14 NS_73 0 -5.7632652623386162e-02
GC_14_74 ref NI_14 NS_74 0 -3.3047372104730972e-02
GC_14_75 ref NI_14 NS_75 0 -1.1568557847943732e-01
GC_14_76 ref NI_14 NS_76 0 2.0120884964353106e-01
GC_14_77 ref NI_14 NS_77 0 7.9928014298568305e-06
GC_14_78 ref NI_14 NS_78 0 6.3353927372584240e-03
GC_14_79 ref NI_14 NS_79 0 3.6680844466645497e+00
GC_14_80 ref NI_14 NS_80 0 -6.1624892233843358e+00
GC_14_81 ref NI_14 NS_81 0 -2.8068714844671533e-01
GC_14_82 ref NI_14 NS_82 0 -4.3935007439408530e-01
GC_14_83 ref NI_14 NS_83 0 -8.5279090399929651e-04
GC_14_84 ref NI_14 NS_84 0 -6.4056439174576540e-02
GC_14_85 ref NI_14 NS_85 0 -1.8342865919807766e-01
GC_14_86 ref NI_14 NS_86 0 9.9422884565946523e-01
GC_14_87 ref NI_14 NS_87 0 6.9061790186800365e-02
GC_14_88 ref NI_14 NS_88 0 -1.6600655091641359e-01
GC_14_89 ref NI_14 NS_89 0 1.1665184436532110e-04
GC_14_90 ref NI_14 NS_90 0 -2.8395598919825429e-02
GC_14_91 ref NI_14 NS_91 0 -3.7131303814389810e-01
GC_14_92 ref NI_14 NS_92 0 8.9922130363516900e-02
GC_14_93 ref NI_14 NS_93 0 -8.9908349479062247e-02
GC_14_94 ref NI_14 NS_94 0 1.6912692342692034e-01
GC_14_95 ref NI_14 NS_95 0 4.6255976541507045e-05
GC_14_96 ref NI_14 NS_96 0 6.0262002793795436e-04
GC_14_97 ref NI_14 NS_97 0 -3.8056523739530623e-01
GC_14_98 ref NI_14 NS_98 0 1.4258523567693512e-01
GC_14_99 ref NI_14 NS_99 0 -2.4698711899987527e-01
GC_14_100 ref NI_14 NS_100 0 2.2275227823816104e-01
GC_14_101 ref NI_14 NS_101 0 2.5120834880441321e-05
GC_14_102 ref NI_14 NS_102 0 9.7599140878132078e-03
GC_14_103 ref NI_14 NS_103 0 -3.5721641836144280e-01
GC_14_104 ref NI_14 NS_104 0 7.6792617575705616e-02
GC_14_105 ref NI_14 NS_105 0 6.2700461329358761e-02
GC_14_106 ref NI_14 NS_106 0 1.0538354498567649e-01
GC_14_107 ref NI_14 NS_107 0 1.2148941857665092e-04
GC_14_108 ref NI_14 NS_108 0 -9.2416244905051455e-03
GC_14_109 ref NI_14 NS_109 0 -2.8930853472267209e-01
GC_14_110 ref NI_14 NS_110 0 3.8886588034242714e-01
GC_14_111 ref NI_14 NS_111 0 2.0083092877219250e-01
GC_14_112 ref NI_14 NS_112 0 -6.5201883150938056e-02
GC_14_113 ref NI_14 NS_113 0 3.3510832008887929e-05
GC_14_114 ref NI_14 NS_114 0 -1.4816002671905302e-02
GC_14_115 ref NI_14 NS_115 0 4.1516070651657289e-01
GC_14_116 ref NI_14 NS_116 0 1.5829715260886681e+00
GC_14_117 ref NI_14 NS_117 0 -1.3080399606960949e-01
GC_14_118 ref NI_14 NS_118 0 -2.4938307002702037e-01
GC_14_119 ref NI_14 NS_119 0 -1.5896174515745671e-05
GC_14_120 ref NI_14 NS_120 0 -3.7427557219767441e-02
GC_14_121 ref NI_14 NS_121 0 -7.9822583215533774e-02
GC_14_122 ref NI_14 NS_122 0 1.7416154560682975e-01
GC_14_123 ref NI_14 NS_123 0 1.0744422668760167e+00
GC_14_124 ref NI_14 NS_124 0 -4.3702593003350543e-01
GC_14_125 ref NI_14 NS_125 0 -1.2487669160500886e-04
GC_14_126 ref NI_14 NS_126 0 -4.2158576238347942e-02
GD_14_1 ref NI_14 NA_1 0 8.2982718289383250e-02
GD_14_2 ref NI_14 NA_2 0 8.0567733577184913e-02
GD_14_3 ref NI_14 NA_3 0 7.5119992203744532e-02
GD_14_4 ref NI_14 NA_4 0 1.0430940777242804e-01
GD_14_5 ref NI_14 NA_5 0 1.0131751514175617e-01
GD_14_6 ref NI_14 NA_6 0 6.6462103691385055e-02
GD_14_7 ref NI_14 NA_7 0 3.9445007872687975e-02
GD_14_8 ref NI_14 NA_8 0 -1.7263637171848109e-01
GD_14_9 ref NI_14 NA_9 0 6.6637959490773821e-02
GD_14_10 ref NI_14 NA_10 0 -1.5491680803554101e-02
GD_14_11 ref NI_14 NA_11 0 3.1943649120020873e-02
GD_14_12 ref NI_14 NA_12 0 8.4586765564848274e-02
GD_14_13 ref NI_14 NA_13 0 2.4309562831818614e-02
GD_14_14 ref NI_14 NA_14 0 5.4121346044764129e+00
GD_14_15 ref NI_14 NA_15 0 4.5583102967451064e-02
GD_14_16 ref NI_14 NA_16 0 8.9475439198241066e-02
GD_14_17 ref NI_14 NA_17 0 8.8079396561500850e-02
GD_14_18 ref NI_14 NA_18 0 9.0865325641627692e-02
GD_14_19 ref NI_14 NA_19 0 6.2539282762083218e-02
GD_14_20 ref NI_14 NA_20 0 -6.4497561037727788e-02
GD_14_21 ref NI_14 NA_21 0 -9.2798711421358902e-03
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -4.0060407580561580e-01
GC_15_2 ref NI_15 NS_2 0 1.9371025818222723e-01
GC_15_3 ref NI_15 NS_3 0 -2.4603213007114064e-01
GC_15_4 ref NI_15 NS_4 0 1.2840178585037471e-01
GC_15_5 ref NI_15 NS_5 0 1.1096114234544890e-04
GC_15_6 ref NI_15 NS_6 0 4.2025041252757966e-02
GC_15_7 ref NI_15 NS_7 0 -3.0764560668154295e-01
GC_15_8 ref NI_15 NS_8 0 1.4977167824201090e-01
GC_15_9 ref NI_15 NS_9 0 -1.9899471782330558e-01
GC_15_10 ref NI_15 NS_10 0 1.2936053897961997e-01
GC_15_11 ref NI_15 NS_11 0 3.7227488902315416e-05
GC_15_12 ref NI_15 NS_12 0 3.4195203030893601e-02
GC_15_13 ref NI_15 NS_13 0 -3.5984196002636620e-01
GC_15_14 ref NI_15 NS_14 0 2.0669013219286589e-01
GC_15_15 ref NI_15 NS_15 0 -2.5734423144253898e-01
GC_15_16 ref NI_15 NS_16 0 1.2183896385490472e-01
GC_15_17 ref NI_15 NS_17 0 7.1095990017753212e-05
GC_15_18 ref NI_15 NS_18 0 4.5007776537221537e-02
GC_15_19 ref NI_15 NS_19 0 -5.1197095320363395e-01
GC_15_20 ref NI_15 NS_20 0 3.1743618503671633e-01
GC_15_21 ref NI_15 NS_21 0 -3.3489022241523014e-01
GC_15_22 ref NI_15 NS_22 0 7.3735260983259332e-02
GC_15_23 ref NI_15 NS_23 0 1.9693208259481096e-04
GC_15_24 ref NI_15 NS_24 0 6.9091355272130159e-02
GC_15_25 ref NI_15 NS_25 0 -5.0405313863740853e-01
GC_15_26 ref NI_15 NS_26 0 3.1846643246796713e-01
GC_15_27 ref NI_15 NS_27 0 -3.4065150522583432e-01
GC_15_28 ref NI_15 NS_28 0 7.8664668846460187e-02
GC_15_29 ref NI_15 NS_29 0 1.8299595119267059e-04
GC_15_30 ref NI_15 NS_30 0 6.8345196161203881e-02
GC_15_31 ref NI_15 NS_31 0 -1.0699490503996113e-01
GC_15_32 ref NI_15 NS_32 0 -9.7548878968483715e-02
GC_15_33 ref NI_15 NS_33 0 4.7591218761551292e-02
GC_15_34 ref NI_15 NS_34 0 1.2500477709208810e-01
GC_15_35 ref NI_15 NS_35 0 1.4381703231022275e-05
GC_15_36 ref NI_15 NS_36 0 7.6025227243046939e-03
GC_15_37 ref NI_15 NS_37 0 -2.1166445260583869e-01
GC_15_38 ref NI_15 NS_38 0 7.4152474684544875e-02
GC_15_39 ref NI_15 NS_39 0 -2.0100788520742507e-01
GC_15_40 ref NI_15 NS_40 0 1.8345072889785621e-01
GC_15_41 ref NI_15 NS_41 0 -2.5262637686091512e-05
GC_15_42 ref NI_15 NS_42 0 2.2232948141408474e-02
GC_15_43 ref NI_15 NS_43 0 -1.2919644218423945e-01
GC_15_44 ref NI_15 NS_44 0 -2.9621856975764094e-01
GC_15_45 ref NI_15 NS_45 0 5.4152987633878702e-01
GC_15_46 ref NI_15 NS_46 0 -2.4966590719510719e-02
GC_15_47 ref NI_15 NS_47 0 1.4258109442995395e-04
GC_15_48 ref NI_15 NS_48 0 -2.2301386275939993e-02
GC_15_49 ref NI_15 NS_49 0 -1.3496841156831965e-01
GC_15_50 ref NI_15 NS_50 0 8.8642421162403676e-03
GC_15_51 ref NI_15 NS_51 0 3.3237949813234857e-01
GC_15_52 ref NI_15 NS_52 0 -3.5269588419284029e-02
GC_15_53 ref NI_15 NS_53 0 -7.8691044774402104e-05
GC_15_54 ref NI_15 NS_54 0 -7.2456689833560184e-03
GC_15_55 ref NI_15 NS_55 0 -1.3412595181261622e-01
GC_15_56 ref NI_15 NS_56 0 9.2119096766991506e-03
GC_15_57 ref NI_15 NS_57 0 -1.8636003743685614e-01
GC_15_58 ref NI_15 NS_58 0 2.1882476464676889e-01
GC_15_59 ref NI_15 NS_59 0 8.9822264342657094e-08
GC_15_60 ref NI_15 NS_60 0 1.1596024550099131e-02
GC_15_61 ref NI_15 NS_61 0 -1.7625298535982950e-01
GC_15_62 ref NI_15 NS_62 0 -3.9113778957681727e-02
GC_15_63 ref NI_15 NS_63 0 8.0684009587963401e-02
GC_15_64 ref NI_15 NS_64 0 8.9712214732866252e-02
GC_15_65 ref NI_15 NS_65 0 -5.2218602941822630e-05
GC_15_66 ref NI_15 NS_66 0 7.8068751794676842e-03
GC_15_67 ref NI_15 NS_67 0 1.0134381095016874e-01
GC_15_68 ref NI_15 NS_68 0 -2.4175992781957825e-01
GC_15_69 ref NI_15 NS_69 0 9.0325693050250094e-02
GC_15_70 ref NI_15 NS_70 0 1.7948102516706102e-01
GC_15_71 ref NI_15 NS_71 0 3.1076133781645889e-05
GC_15_72 ref NI_15 NS_72 0 -9.4987328696865547e-03
GC_15_73 ref NI_15 NS_73 0 -3.7788144922328859e-01
GC_15_74 ref NI_15 NS_74 0 2.6741021052221181e-01
GC_15_75 ref NI_15 NS_75 0 -4.1504736702340489e-01
GC_15_76 ref NI_15 NS_76 0 2.3444980542967753e-01
GC_15_77 ref NI_15 NS_77 0 -6.2431334270930271e-05
GC_15_78 ref NI_15 NS_78 0 3.0541995685990843e-02
GC_15_79 ref NI_15 NS_79 0 -1.8342865919807805e-01
GC_15_80 ref NI_15 NS_80 0 9.9422884565946679e-01
GC_15_81 ref NI_15 NS_81 0 6.9061790186797756e-02
GC_15_82 ref NI_15 NS_82 0 -1.6600655091641189e-01
GC_15_83 ref NI_15 NS_83 0 1.1665184436541022e-04
GC_15_84 ref NI_15 NS_84 0 -2.8395598919825842e-02
GC_15_85 ref NI_15 NS_85 0 3.5128040007061863e+00
GC_15_86 ref NI_15 NS_86 0 -2.4647142916730074e+00
GC_15_87 ref NI_15 NS_87 0 -2.3501653992284477e+00
GC_15_88 ref NI_15 NS_88 0 -4.7177576433603741e-01
GC_15_89 ref NI_15 NS_89 0 -8.6142589461942322e-04
GC_15_90 ref NI_15 NS_90 0 -7.1194825501460210e-02
GC_15_91 ref NI_15 NS_91 0 1.7709927056318203e-01
GC_15_92 ref NI_15 NS_92 0 -2.5346988079493993e-01
GC_15_93 ref NI_15 NS_93 0 7.8000089276915152e-01
GC_15_94 ref NI_15 NS_94 0 -1.2798478576696762e-01
GC_15_95 ref NI_15 NS_95 0 9.7434370105633141e-05
GC_15_96 ref NI_15 NS_96 0 -4.8127134659993874e-02
GC_15_97 ref NI_15 NS_97 0 2.1017191230101759e-01
GC_15_98 ref NI_15 NS_98 0 -4.1124946867291390e-01
GC_15_99 ref NI_15 NS_99 0 4.5064854102252938e-01
GC_15_100 ref NI_15 NS_100 0 7.4851954076041255e-02
GC_15_101 ref NI_15 NS_101 0 1.2870035054030705e-04
GC_15_102 ref NI_15 NS_102 0 -3.2296638470047559e-02
GC_15_103 ref NI_15 NS_103 0 2.0551428236619072e-02
GC_15_104 ref NI_15 NS_104 0 2.2167500944890156e-01
GC_15_105 ref NI_15 NS_105 0 9.9391968101787775e-01
GC_15_106 ref NI_15 NS_106 0 -3.7142125650847785e-01
GC_15_107 ref NI_15 NS_107 0 1.5500306818723756e-04
GC_15_108 ref NI_15 NS_108 0 -6.1695057100029232e-02
GC_15_109 ref NI_15 NS_109 0 3.1969938112165572e-02
GC_15_110 ref NI_15 NS_110 0 1.1983444017260196e+00
GC_15_111 ref NI_15 NS_111 0 3.8338312338892111e-01
GC_15_112 ref NI_15 NS_112 0 -3.9686735339059692e-01
GC_15_113 ref NI_15 NS_113 0 -3.7831664641626119e-04
GC_15_114 ref NI_15 NS_114 0 -3.0695292446929364e-02
GC_15_115 ref NI_15 NS_115 0 -4.8577128413788406e-01
GC_15_116 ref NI_15 NS_116 0 2.1426898873625905e-01
GC_15_117 ref NI_15 NS_117 0 4.2162669548909548e-01
GC_15_118 ref NI_15 NS_118 0 -1.2826185919740321e-01
GC_15_119 ref NI_15 NS_119 0 8.6471980474027779e-05
GC_15_120 ref NI_15 NS_120 0 -1.4614389199336603e-02
GC_15_121 ref NI_15 NS_121 0 4.0278553728063611e-02
GC_15_122 ref NI_15 NS_122 0 -3.6366622312161773e-01
GC_15_123 ref NI_15 NS_123 0 3.2563018197272864e-01
GC_15_124 ref NI_15 NS_124 0 9.0125878336636323e-02
GC_15_125 ref NI_15 NS_125 0 9.6741164729578639e-05
GC_15_126 ref NI_15 NS_126 0 -1.1968767026920289e-02
GD_15_1 ref NI_15 NA_1 0 7.9078668910924813e-02
GD_15_2 ref NI_15 NA_2 0 7.1356486623297674e-02
GD_15_3 ref NI_15 NA_3 0 7.2786921402837601e-02
GD_15_4 ref NI_15 NA_4 0 1.0106247163169192e-01
GD_15_5 ref NI_15 NA_5 0 9.8678240682127397e-02
GD_15_6 ref NI_15 NA_6 0 3.5610555746426811e-02
GD_15_7 ref NI_15 NA_7 0 5.0053688710585700e-02
GD_15_8 ref NI_15 NA_8 0 4.1462923379213631e-02
GD_15_9 ref NI_15 NA_9 0 2.7742381758451496e-02
GD_15_10 ref NI_15 NA_10 0 3.9375966491761123e-02
GD_15_11 ref NI_15 NA_11 0 4.4835909444126916e-02
GD_15_12 ref NI_15 NA_12 0 4.6957957226882088e-03
GD_15_13 ref NI_15 NA_13 0 7.3778067676507075e-02
GD_15_14 ref NI_15 NA_14 0 4.5583102967451064e-02
GD_15_15 ref NI_15 NA_15 0 5.4830505916015042e+00
GD_15_16 ref NI_15 NA_16 0 -1.7283120529705501e-02
GD_15_17 ref NI_15 NA_17 0 -1.2855207135389540e-02
GD_15_18 ref NI_15 NA_18 0 -8.5193022818727657e-04
GD_15_19 ref NI_15 NA_19 0 -6.2469289030160254e-02
GD_15_20 ref NI_15 NA_20 0 1.0202610014397365e-01
GD_15_21 ref NI_15 NA_21 0 1.6478077186480145e-02
*
* Port 16
VI_16 a_16 NI_16 0
RI_16 NI_16 ref 1.0000000000000001e-01
GC_16_1 ref NI_16 NS_1 0 -3.8411075831491998e-01
GC_16_2 ref NI_16 NS_2 0 1.2128887160890880e-01
GC_16_3 ref NI_16 NS_3 0 -1.2000462202983134e-01
GC_16_4 ref NI_16 NS_4 0 9.5596899746191344e-02
GC_16_5 ref NI_16 NS_5 0 1.5346171689326770e-04
GC_16_6 ref NI_16 NS_6 0 3.4541680193868905e-02
GC_16_7 ref NI_16 NS_7 0 -2.5066966343675479e-01
GC_16_8 ref NI_16 NS_8 0 9.4224948783430892e-02
GC_16_9 ref NI_16 NS_9 0 -6.8788442333111460e-02
GC_16_10 ref NI_16 NS_10 0 8.1720518290561289e-02
GC_16_11 ref NI_16 NS_11 0 6.3500718207856630e-05
GC_16_12 ref NI_16 NS_12 0 2.7775534013417827e-02
GC_16_13 ref NI_16 NS_13 0 -3.2990359118858570e-01
GC_16_14 ref NI_16 NS_14 0 1.2960449954569359e-01
GC_16_15 ref NI_16 NS_15 0 -1.5432154065006018e-01
GC_16_16 ref NI_16 NS_16 0 1.0415423563879080e-01
GC_16_17 ref NI_16 NS_17 0 1.2667311677401496e-04
GC_16_18 ref NI_16 NS_18 0 3.7291554888390824e-02
GC_16_19 ref NI_16 NS_19 0 -4.0639137154463889e-01
GC_16_20 ref NI_16 NS_20 0 2.2021948003188807e-01
GC_16_21 ref NI_16 NS_21 0 -2.9651354222047960e-01
GC_16_22 ref NI_16 NS_22 0 1.0756456034419443e-01
GC_16_23 ref NI_16 NS_23 0 2.7775873871861879e-04
GC_16_24 ref NI_16 NS_24 0 5.6612693695947493e-02
GC_16_25 ref NI_16 NS_25 0 -3.9175594579206818e-01
GC_16_26 ref NI_16 NS_26 0 2.1652394343676964e-01
GC_16_27 ref NI_16 NS_27 0 -2.9815095340641495e-01
GC_16_28 ref NI_16 NS_28 0 1.1105342603665849e-01
GC_16_29 ref NI_16 NS_29 0 2.6038942537370455e-04
GC_16_30 ref NI_16 NS_30 0 5.5989120712511053e-02
GC_16_31 ref NI_16 NS_31 0 -1.7794770363529655e-01
GC_16_32 ref NI_16 NS_32 0 -1.5067334338188912e-01
GC_16_33 ref NI_16 NS_33 0 3.5313728001288125e-01
GC_16_34 ref NI_16 NS_34 0 -1.7015966033176861e-02
GC_16_35 ref NI_16 NS_35 0 5.6523936263835098e-05
GC_16_36 ref NI_16 NS_36 0 -3.0805980671664402e-04
GC_16_37 ref NI_16 NS_37 0 -2.2921602212938066e-01
GC_16_38 ref NI_16 NS_38 0 3.5574737301068263e-02
GC_16_39 ref NI_16 NS_39 0 -1.4426578537900991e-01
GC_16_40 ref NI_16 NS_40 0 1.5901124706604208e-01
GC_16_41 ref NI_16 NS_41 0 4.6235568618606783e-05
GC_16_42 ref NI_16 NS_42 0 2.3134218660315516e-02
GC_16_43 ref NI_16 NS_43 0 -5.1310642472472046e-01
GC_16_44 ref NI_16 NS_44 0 3.0735605510954672e-01
GC_16_45 ref NI_16 NS_45 0 -4.6331630706009408e-01
GC_16_46 ref NI_16 NS_46 0 2.8284527930202308e-01
GC_16_47 ref NI_16 NS_47 0 -4.0969561045538600e-05
GC_16_48 ref NI_16 NS_48 0 1.8351523727697064e-02
GC_16_49 ref NI_16 NS_49 0 -1.7432203052662135e-01
GC_16_50 ref NI_16 NS_50 0 1.3070428807171292e-01
GC_16_51 ref NI_16 NS_51 0 3.3805074483555952e-01
GC_16_52 ref NI_16 NS_52 0 -6.6535112986941272e-02
GC_16_53 ref NI_16 NS_53 0 7.5515120634672591e-05
GC_16_54 ref NI_16 NS_54 0 -1.5620998710831649e-02
GC_16_55 ref NI_16 NS_55 0 -5.1589126945399943e-01
GC_16_56 ref NI_16 NS_56 0 3.4669435829107015e-01
GC_16_57 ref NI_16 NS_57 0 -4.7141449459664475e-01
GC_16_58 ref NI_16 NS_58 0 2.3550774207569058e-01
GC_16_59 ref NI_16 NS_59 0 -2.4666940824244111e-05
GC_16_60 ref NI_16 NS_60 0 3.4784408005401821e-02
GC_16_61 ref NI_16 NS_61 0 -2.7649371056763855e-01
GC_16_62 ref NI_16 NS_62 0 4.9805727396062309e-02
GC_16_63 ref NI_16 NS_63 0 -1.3670762516979573e-01
GC_16_64 ref NI_16 NS_64 0 1.6736350983149348e-01
GC_16_65 ref NI_16 NS_65 0 1.8783418351773725e-05
GC_16_66 ref NI_16 NS_66 0 1.6913898343748367e-02
GC_16_67 ref NI_16 NS_67 0 1.2249895343805951e-02
GC_16_68 ref NI_16 NS_68 0 -1.5525788967668755e-01
GC_16_69 ref NI_16 NS_69 0 9.3417883149481140e-01
GC_16_70 ref NI_16 NS_70 0 -2.9287617775849684e-01
GC_16_71 ref NI_16 NS_71 0 -8.6922984807686495e-05
GC_16_72 ref NI_16 NS_72 0 -2.6252888223119351e-02
GC_16_73 ref NI_16 NS_73 0 -4.5560838314760688e-01
GC_16_74 ref NI_16 NS_74 0 2.9397798929799596e-01
GC_16_75 ref NI_16 NS_75 0 -4.0490897775537976e-01
GC_16_76 ref NI_16 NS_76 0 2.0074445859002799e-01
GC_16_77 ref NI_16 NS_77 0 -1.5596713000476139e-05
GC_16_78 ref NI_16 NS_78 0 3.8984939989824566e-02
GC_16_79 ref NI_16 NS_79 0 -3.7131303814389799e-01
GC_16_80 ref NI_16 NS_80 0 8.9922130363516151e-02
GC_16_81 ref NI_16 NS_81 0 -8.9908349479061039e-02
GC_16_82 ref NI_16 NS_82 0 1.6912692342691957e-01
GC_16_83 ref NI_16 NS_83 0 4.6255976541463108e-05
GC_16_84 ref NI_16 NS_84 0 6.0262002793815364e-04
GC_16_85 ref NI_16 NS_85 0 1.7709927056318164e-01
GC_16_86 ref NI_16 NS_86 0 -2.5346988079493826e-01
GC_16_87 ref NI_16 NS_87 0 7.8000089276914875e-01
GC_16_88 ref NI_16 NS_88 0 -1.2798478576696593e-01
GC_16_89 ref NI_16 NS_89 0 9.7434370105726329e-05
GC_16_90 ref NI_16 NS_90 0 -4.8127134659994297e-02
GC_16_91 ref NI_16 NS_91 0 4.3721361217368377e+00
GC_16_92 ref NI_16 NS_92 0 -4.1612043902713429e+00
GC_16_93 ref NI_16 NS_93 0 -1.3545983871790261e+00
GC_16_94 ref NI_16 NS_94 0 -4.3702476293436282e-01
GC_16_95 ref NI_16 NS_95 0 -8.5460345395510018e-04
GC_16_96 ref NI_16 NS_96 0 -1.0665264896715554e-01
GC_16_97 ref NI_16 NS_97 0 2.1963261455185984e-01
GC_16_98 ref NI_16 NS_98 0 1.4185320951257070e+00
GC_16_99 ref NI_16 NS_99 0 4.6333471417521382e-01
GC_16_100 ref NI_16 NS_100 0 -4.7385978008095941e-01
GC_16_101 ref NI_16 NS_101 0 -8.5019947621383903e-06
GC_16_102 ref NI_16 NS_102 0 -5.7041364247960399e-02
GC_16_103 ref NI_16 NS_103 0 6.8403948856158681e-01
GC_16_104 ref NI_16 NS_104 0 6.8120996033711201e-01
GC_16_105 ref NI_16 NS_105 0 1.2437044710003051e+00
GC_16_106 ref NI_16 NS_106 0 -6.2414268502335413e-01
GC_16_107 ref NI_16 NS_107 0 -3.3510547817846377e-04
GC_16_108 ref NI_16 NS_108 0 -8.4024904276686227e-02
GC_16_109 ref NI_16 NS_109 0 -4.2078638194930601e-02
GC_16_110 ref NI_16 NS_110 0 1.8035538278973184e-01
GC_16_111 ref NI_16 NS_111 0 5.0198553814798130e-01
GC_16_112 ref NI_16 NS_112 0 -1.2766327853088819e-01
GC_16_113 ref NI_16 NS_113 0 1.3883682909431069e-04
GC_16_114 ref NI_16 NS_114 0 -3.8380468088407983e-02
GC_16_115 ref NI_16 NS_115 0 -3.5674811572664578e-01
GC_16_116 ref NI_16 NS_116 0 6.6782411101324005e-02
GC_16_117 ref NI_16 NS_117 0 -1.2174808574991977e-01
GC_16_118 ref NI_16 NS_118 0 1.8116025677949668e-01
GC_16_119 ref NI_16 NS_119 0 9.6145581419930100e-05
GC_16_120 ref NI_16 NS_120 0 5.9759132795150745e-03
GC_16_121 ref NI_16 NS_121 0 -5.2971093581332040e-01
GC_16_122 ref NI_16 NS_122 0 3.5169529358016993e-01
GC_16_123 ref NI_16 NS_123 0 -5.1097274138126392e-01
GC_16_124 ref NI_16 NS_124 0 2.8153458685280042e-01
GC_16_125 ref NI_16 NS_125 0 -4.6182585722338306e-05
GC_16_126 ref NI_16 NS_126 0 2.4922568793794224e-02
GD_16_1 ref NI_16 NA_1 0 7.5947466665961777e-02
GD_16_2 ref NI_16 NA_2 0 7.0158374520636113e-02
GD_16_3 ref NI_16 NA_3 0 6.6696156039155352e-02
GD_16_4 ref NI_16 NA_4 0 8.7356435138216379e-02
GD_16_5 ref NI_16 NA_5 0 8.3806769551184213e-02
GD_16_6 ref NI_16 NA_6 0 5.3700386146675091e-02
GD_16_7 ref NI_16 NA_7 0 5.7474592050582723e-02
GD_16_8 ref NI_16 NA_8 0 1.0572228359821884e-01
GD_16_9 ref NI_16 NA_9 0 5.5588555676228141e-02
GD_16_10 ref NI_16 NA_10 0 1.0017142898762622e-01
GD_16_11 ref NI_16 NA_11 0 6.7449967817635778e-02
GD_16_12 ref NI_16 NA_12 0 -9.2289589374497524e-04
GD_16_13 ref NI_16 NA_13 0 8.9237600330919889e-02
GD_16_14 ref NI_16 NA_14 0 8.9475439198241066e-02
GD_16_15 ref NI_16 NA_15 0 -1.7283120529705501e-02
GD_16_16 ref NI_16 NA_16 0 5.3414903587866007e+00
GD_16_17 ref NI_16 NA_17 0 -6.8624829749791047e-02
GD_16_18 ref NI_16 NA_18 0 -1.8282794679333295e-01
GD_16_19 ref NI_16 NA_19 0 2.5353405854847164e-02
GD_16_20 ref NI_16 NA_20 0 8.7752604763283851e-02
GD_16_21 ref NI_16 NA_21 0 1.0535554663586769e-01
*
* Port 17
VI_17 a_17 NI_17 0
RI_17 NI_17 ref 1.0000000000000001e-01
GC_17_1 ref NI_17 NS_1 0 -4.0353006435981187e-01
GC_17_2 ref NI_17 NS_2 0 1.2438011171070557e-01
GC_17_3 ref NI_17 NS_3 0 7.9787864530047031e-03
GC_17_4 ref NI_17 NS_4 0 5.8425618503246450e-02
GC_17_5 ref NI_17 NS_5 0 1.5680327219765405e-04
GC_17_6 ref NI_17 NS_6 0 2.0859612526452107e-02
GC_17_7 ref NI_17 NS_7 0 -1.1985913449538049e-01
GC_17_8 ref NI_17 NS_8 0 1.1599297778816592e-01
GC_17_9 ref NI_17 NS_9 0 4.1852962068142575e-02
GC_17_10 ref NI_17 NS_10 0 2.8714857288072822e-02
GC_17_11 ref NI_17 NS_11 0 3.7166869818254847e-05
GC_17_12 ref NI_17 NS_12 0 1.6614420628179669e-02
GC_17_13 ref NI_17 NS_13 0 -2.7992634470446587e-01
GC_17_14 ref NI_17 NS_14 0 7.8669586748298298e-02
GC_17_15 ref NI_17 NS_15 0 -1.8746233263799147e-02
GC_17_16 ref NI_17 NS_16 0 7.8978200354358305e-02
GC_17_17 ref NI_17 NS_17 0 1.3946716133070254e-04
GC_17_18 ref NI_17 NS_18 0 2.2503102290427797e-02
GC_17_19 ref NI_17 NS_19 0 -2.5721360860194953e-01
GC_17_20 ref NI_17 NS_20 0 3.6800706175721398e-02
GC_17_21 ref NI_17 NS_21 0 -1.8603349421440937e-01
GC_17_22 ref NI_17 NS_22 0 1.5100568173300000e-01
GC_17_23 ref NI_17 NS_23 0 3.2762668986200267e-04
GC_17_24 ref NI_17 NS_24 0 3.4762228860721466e-02
GC_17_25 ref NI_17 NS_25 0 -2.3243865256569754e-01
GC_17_26 ref NI_17 NS_26 0 2.5399198745513503e-02
GC_17_27 ref NI_17 NS_27 0 -1.8004053790203775e-01
GC_17_28 ref NI_17 NS_28 0 1.5188526487446719e-01
GC_17_29 ref NI_17 NS_29 0 3.0797449046170779e-04
GC_17_30 ref NI_17 NS_30 0 3.4236034294565745e-02
GC_17_31 ref NI_17 NS_31 0 -3.6017775543042968e-01
GC_17_32 ref NI_17 NS_32 0 1.6075634093754235e-01
GC_17_33 ref NI_17 NS_33 0 4.6212479209683549e-01
GC_17_34 ref NI_17 NS_34 0 -1.6881024629672689e-01
GC_17_35 ref NI_17 NS_35 0 -2.2179773068978962e-05
GC_17_36 ref NI_17 NS_36 0 -2.1893820080461086e-03
GC_17_37 ref NI_17 NS_37 0 -1.4326601374911077e-01
GC_17_38 ref NI_17 NS_38 0 -1.2517231592505540e-01
GC_17_39 ref NI_17 NS_39 0 1.0567043082800615e-01
GC_17_40 ref NI_17 NS_40 0 8.2594408064005018e-02
GC_17_41 ref NI_17 NS_41 0 8.1180365417627179e-05
GC_17_42 ref NI_17 NS_42 0 1.4813734596886891e-02
GC_17_43 ref NI_17 NS_43 0 -5.8128536986852020e-01
GC_17_44 ref NI_17 NS_44 0 4.0360366231165862e-01
GC_17_45 ref NI_17 NS_45 0 -5.6600466645478786e-01
GC_17_46 ref NI_17 NS_46 0 2.9628163687106296e-01
GC_17_47 ref NI_17 NS_47 0 -5.8134522901454229e-05
GC_17_48 ref NI_17 NS_48 0 2.6066273341833340e-02
GC_17_49 ref NI_17 NS_49 0 -2.3444033351573967e-01
GC_17_50 ref NI_17 NS_50 0 3.5529304147225887e-01
GC_17_51 ref NI_17 NS_51 0 3.3360626833021684e-01
GC_17_52 ref NI_17 NS_52 0 -1.4312582113303401e-01
GC_17_53 ref NI_17 NS_53 0 3.3253839937501118e-05
GC_17_54 ref NI_17 NS_54 0 -1.2522907222908356e-02
GC_17_55 ref NI_17 NS_55 0 -4.1820089122771409e-01
GC_17_56 ref NI_17 NS_56 0 2.4519929500881260e-01
GC_17_57 ref NI_17 NS_57 0 -3.6840660193726105e-01
GC_17_58 ref NI_17 NS_58 0 2.1739803669783100e-01
GC_17_59 ref NI_17 NS_59 0 2.6813171948287259e-05
GC_17_60 ref NI_17 NS_60 0 2.9441874523927197e-02
GC_17_61 ref NI_17 NS_61 0 -2.3190526277559428e-01
GC_17_62 ref NI_17 NS_62 0 -3.9897480407774757e-02
GC_17_63 ref NI_17 NS_63 0 2.2207458155286603e-03
GC_17_64 ref NI_17 NS_64 0 1.2134590672547498e-01
GC_17_65 ref NI_17 NS_65 0 6.4128414334371344e-05
GC_17_66 ref NI_17 NS_66 0 1.3796509851616031e-02
GC_17_67 ref NI_17 NS_67 0 6.4125389758109441e-02
GC_17_68 ref NI_17 NS_68 0 1.6091735010409058e+00
GC_17_69 ref NI_17 NS_69 0 3.6895361201807403e-01
GC_17_70 ref NI_17 NS_70 0 -5.4864887137388563e-01
GC_17_71 ref NI_17 NS_71 0 -4.9963385642135655e-04
GC_17_72 ref NI_17 NS_72 0 -2.3323660696756135e-02
GC_17_73 ref NI_17 NS_73 0 -2.8517803260134056e-01
GC_17_74 ref NI_17 NS_74 0 1.2123177822865785e-01
GC_17_75 ref NI_17 NS_75 0 -2.4239496545844205e-01
GC_17_76 ref NI_17 NS_76 0 1.8416790382312068e-01
GC_17_77 ref NI_17 NS_77 0 6.3170717296874912e-05
GC_17_78 ref NI_17 NS_78 0 2.6903726609384122e-02
GC_17_79 ref NI_17 NS_79 0 -3.8056523739530640e-01
GC_17_80 ref NI_17 NS_80 0 1.4258523567693573e-01
GC_17_81 ref NI_17 NS_81 0 -2.4698711899987624e-01
GC_17_82 ref NI_17 NS_82 0 2.2275227823816163e-01
GC_17_83 ref NI_17 NS_83 0 2.5120834880473440e-05
GC_17_84 ref NI_17 NS_84 0 9.7599140878130517e-03
GC_17_85 ref NI_17 NS_85 0 2.1017191230101812e-01
GC_17_86 ref NI_17 NS_86 0 -4.1124946867291601e-01
GC_17_87 ref NI_17 NS_87 0 4.5064854102253282e-01
GC_17_88 ref NI_17 NS_88 0 7.4851954076039090e-02
GC_17_89 ref NI_17 NS_89 0 1.2870035054018877e-04
GC_17_90 ref NI_17 NS_90 0 -3.2296638470046997e-02
GC_17_91 ref NI_17 NS_91 0 2.1963261455186001e-01
GC_17_92 ref NI_17 NS_92 0 1.4185320951257065e+00
GC_17_93 ref NI_17 NS_93 0 4.6333471417521488e-01
GC_17_94 ref NI_17 NS_94 0 -4.7385978008096002e-01
GC_17_95 ref NI_17 NS_95 0 -8.5019947621723038e-06
GC_17_96 ref NI_17 NS_96 0 -5.7041364247960240e-02
GC_17_97 ref NI_17 NS_97 0 3.8893063570365722e+00
GC_17_98 ref NI_17 NS_98 0 -3.9577745014417496e+00
GC_17_99 ref NI_17 NS_99 0 -1.4643137347532322e+00
GC_17_100 ref NI_17 NS_100 0 -5.0247058156308988e-01
GC_17_101 ref NI_17 NS_101 0 -1.0009677296798076e-03
GC_17_102 ref NI_17 NS_102 0 -7.3190462733566039e-02
GC_17_103 ref NI_17 NS_103 0 5.7651639375528840e-01
GC_17_104 ref NI_17 NS_104 0 -6.8801163077736771e-01
GC_17_105 ref NI_17 NS_105 0 1.2634189291568023e+00
GC_17_106 ref NI_17 NS_106 0 -2.4149351751586362e-01
GC_17_107 ref NI_17 NS_107 0 9.4218597908201233e-05
GC_17_108 ref NI_17 NS_108 0 -6.3939008400393821e-02
GC_17_109 ref NI_17 NS_109 0 -5.6681383433906773e-02
GC_17_110 ref NI_17 NS_110 0 -8.3772001739666896e-02
GC_17_111 ref NI_17 NS_111 0 4.8408764629512180e-01
GC_17_112 ref NI_17 NS_112 0 -5.8155869820933230e-02
GC_17_113 ref NI_17 NS_113 0 1.4701372125763222e-04
GC_17_114 ref NI_17 NS_114 0 -2.6113059722865668e-02
GC_17_115 ref NI_17 NS_115 0 -3.4389094856351649e-01
GC_17_116 ref NI_17 NS_116 0 9.8083960651813171e-02
GC_17_117 ref NI_17 NS_117 0 -1.9661683897656496e-01
GC_17_118 ref NI_17 NS_118 0 2.0159200793753904e-01
GC_17_119 ref NI_17 NS_119 0 6.9583198258959950e-05
GC_17_120 ref NI_17 NS_120 0 1.1629167074762881e-02
GC_17_121 ref NI_17 NS_121 0 -5.5046511475025883e-01
GC_17_122 ref NI_17 NS_122 0 3.7833900932916625e-01
GC_17_123 ref NI_17 NS_123 0 -5.2757186439843673e-01
GC_17_124 ref NI_17 NS_124 0 2.7553801120585791e-01
GC_17_125 ref NI_17 NS_125 0 -4.5240948798860334e-05
GC_17_126 ref NI_17 NS_126 0 2.8401937780060067e-02
GD_17_1 ref NI_17 NA_1 0 6.4072875497113768e-02
GD_17_2 ref NI_17 NA_2 0 5.7876170224360791e-02
GD_17_3 ref NI_17 NA_3 0 4.7011179828252023e-02
GD_17_4 ref NI_17 NA_4 0 6.5790186205889625e-02
GD_17_5 ref NI_17 NA_5 0 6.0344383649443931e-02
GD_17_6 ref NI_17 NA_6 0 7.2386595872046558e-02
GD_17_7 ref NI_17 NA_7 0 4.1894120544510326e-02
GD_17_8 ref NI_17 NA_8 0 1.1384442876501347e-01
GD_17_9 ref NI_17 NA_9 0 6.0375847975292281e-02
GD_17_10 ref NI_17 NA_10 0 8.3400333403772578e-02
GD_17_11 ref NI_17 NA_11 0 5.9129519598591869e-02
GD_17_12 ref NI_17 NA_12 0 -6.6778815626470617e-02
GD_17_13 ref NI_17 NA_13 0 6.0962543802259968e-02
GD_17_14 ref NI_17 NA_14 0 8.8079396561500850e-02
GD_17_15 ref NI_17 NA_15 0 -1.2855207135389540e-02
GD_17_16 ref NI_17 NA_16 0 -6.8624829749791047e-02
GD_17_17 ref NI_17 NA_17 0 5.4311633672645545e+00
GD_17_18 ref NI_17 NA_18 0 -9.6011787393105244e-02
GD_17_19 ref NI_17 NA_19 0 2.9523003627047198e-02
GD_17_20 ref NI_17 NA_20 0 8.1829781648415423e-02
GD_17_21 ref NI_17 NA_21 0 1.0667601673653725e-01
*
* Port 18
VI_18 a_18 NI_18 0
RI_18 NI_18 ref 1.0000000000000001e-01
GC_18_1 ref NI_18 NS_1 0 -3.9622125965680788e-01
GC_18_2 ref NI_18 NS_2 0 1.9579874171744513e-01
GC_18_3 ref NI_18 NS_3 0 -2.5263362311660648e-01
GC_18_4 ref NI_18 NS_4 0 1.1986337377845424e-01
GC_18_5 ref NI_18 NS_5 0 9.9797504325197997e-05
GC_18_6 ref NI_18 NS_6 0 4.6346943772216716e-02
GC_18_7 ref NI_18 NS_7 0 -2.9971443016858268e-01
GC_18_8 ref NI_18 NS_8 0 1.4510734736334388e-01
GC_18_9 ref NI_18 NS_9 0 -2.0128622937525364e-01
GC_18_10 ref NI_18 NS_10 0 1.2301891661978585e-01
GC_18_11 ref NI_18 NS_11 0 1.0063198190146074e-05
GC_18_12 ref NI_18 NS_12 0 3.7710781538528033e-02
GC_18_13 ref NI_18 NS_13 0 -3.8534362609222500e-01
GC_18_14 ref NI_18 NS_14 0 2.1777187569807552e-01
GC_18_15 ref NI_18 NS_15 0 -2.7137112965222054e-01
GC_18_16 ref NI_18 NS_16 0 1.1496875828016917e-01
GC_18_17 ref NI_18 NS_17 0 6.6373291557759323e-05
GC_18_18 ref NI_18 NS_18 0 5.0000764618786803e-02
GC_18_19 ref NI_18 NS_19 0 -5.1865282829668113e-01
GC_18_20 ref NI_18 NS_20 0 3.2507288777144616e-01
GC_18_21 ref NI_18 NS_21 0 -3.2102934088586099e-01
GC_18_22 ref NI_18 NS_22 0 4.7415846842058587e-02
GC_18_23 ref NI_18 NS_23 0 1.9566281683783835e-04
GC_18_24 ref NI_18 NS_24 0 7.5270846286496149e-02
GC_18_25 ref NI_18 NS_25 0 -5.1174129471343566e-01
GC_18_26 ref NI_18 NS_26 0 3.2707384304436637e-01
GC_18_27 ref NI_18 NS_27 0 -3.2796865903746869e-01
GC_18_28 ref NI_18 NS_28 0 5.2586696506451397e-02
GC_18_29 ref NI_18 NS_29 0 1.7848426695384962e-04
GC_18_30 ref NI_18 NS_30 0 7.4612398296325405e-02
GC_18_31 ref NI_18 NS_31 0 1.1248527258086211e-03
GC_18_32 ref NI_18 NS_32 0 -1.8953847685555486e-01
GC_18_33 ref NI_18 NS_33 0 8.3755017303344753e-02
GC_18_34 ref NI_18 NS_34 0 1.4268911785625549e-01
GC_18_35 ref NI_18 NS_35 0 7.1404676950432081e-05
GC_18_36 ref NI_18 NS_36 0 9.8345865401927926e-04
GC_18_37 ref NI_18 NS_37 0 -3.4141134017387709e-01
GC_18_38 ref NI_18 NS_38 0 2.1163842919281003e-01
GC_18_39 ref NI_18 NS_39 0 -3.6358900938960964e-01
GC_18_40 ref NI_18 NS_40 0 2.1840877498943895e-01
GC_18_41 ref NI_18 NS_41 0 -1.4850550958864349e-05
GC_18_42 ref NI_18 NS_42 0 3.0367014932401175e-02
GC_18_43 ref NI_18 NS_43 0 -4.3527131602706159e-01
GC_18_44 ref NI_18 NS_44 0 1.9871523073204558e-01
GC_18_45 ref NI_18 NS_45 0 -3.3440162941606116e-01
GC_18_46 ref NI_18 NS_46 0 2.6125857636133815e-01
GC_18_47 ref NI_18 NS_47 0 8.8333199878121212e-06
GC_18_48 ref NI_18 NS_48 0 9.0642179391554924e-03
GC_18_49 ref NI_18 NS_49 0 1.7758198182799011e-02
GC_18_50 ref NI_18 NS_50 0 -2.5483257307258583e-01
GC_18_51 ref NI_18 NS_51 0 3.8949202629271257e-01
GC_18_52 ref NI_18 NS_52 0 3.1312556601905378e-02
GC_18_53 ref NI_18 NS_53 0 8.0963943017115341e-05
GC_18_54 ref NI_18 NS_54 0 -1.8419034128609360e-02
GC_18_55 ref NI_18 NS_55 0 -5.7981374505348660e-01
GC_18_56 ref NI_18 NS_56 0 4.1730999876179498e-01
GC_18_57 ref NI_18 NS_57 0 -5.4362249456516576e-01
GC_18_58 ref NI_18 NS_58 0 2.5055125511073234e-01
GC_18_59 ref NI_18 NS_59 0 -7.1403436908671291e-05
GC_18_60 ref NI_18 NS_60 0 3.7883004245894011e-02
GC_18_61 ref NI_18 NS_61 0 -2.9757074990915328e-01
GC_18_62 ref NI_18 NS_62 0 1.1806585045762277e-01
GC_18_63 ref NI_18 NS_63 0 -2.5334550413223866e-01
GC_18_64 ref NI_18 NS_64 0 2.1062573791368322e-01
GC_18_65 ref NI_18 NS_65 0 -1.3623529245173104e-05
GC_18_66 ref NI_18 NS_66 0 1.8650168815472858e-02
GC_18_67 ref NI_18 NS_67 0 5.1514011217078615e-01
GC_18_68 ref NI_18 NS_68 0 -6.2195977672535752e-01
GC_18_69 ref NI_18 NS_69 0 6.1750085176015401e-01
GC_18_70 ref NI_18 NS_70 0 3.4046782469192016e-02
GC_18_71 ref NI_18 NS_71 0 1.6380376552536157e-05
GC_18_72 ref NI_18 NS_72 0 -3.1415850702160082e-02
GC_18_73 ref NI_18 NS_73 0 -5.9980393007003963e-01
GC_18_74 ref NI_18 NS_74 0 4.3565678113641532e-01
GC_18_75 ref NI_18 NS_75 0 -5.2455292088582828e-01
GC_18_76 ref NI_18 NS_76 0 2.0828906538359368e-01
GC_18_77 ref NI_18 NS_77 0 -9.7823728920260646e-05
GC_18_78 ref NI_18 NS_78 0 4.8717201665206579e-02
GC_18_79 ref NI_18 NS_79 0 -3.5721641836144230e-01
GC_18_80 ref NI_18 NS_80 0 7.6792617575703326e-02
GC_18_81 ref NI_18 NS_81 0 6.2700461329362425e-02
GC_18_82 ref NI_18 NS_82 0 1.0538354498567416e-01
GC_18_83 ref NI_18 NS_83 0 1.2148941857652244e-04
GC_18_84 ref NI_18 NS_84 0 -9.2416244905045523e-03
GC_18_85 ref NI_18 NS_85 0 2.0551428236618360e-02
GC_18_86 ref NI_18 NS_86 0 2.2167500944890481e-01
GC_18_87 ref NI_18 NS_87 0 9.9391968101787265e-01
GC_18_88 ref NI_18 NS_88 0 -3.7142125650847457e-01
GC_18_89 ref NI_18 NS_89 0 1.5500306818741328e-04
GC_18_90 ref NI_18 NS_90 0 -6.1695057100030051e-02
GC_18_91 ref NI_18 NS_91 0 6.8403948856158669e-01
GC_18_92 ref NI_18 NS_92 0 6.8120996033711256e-01
GC_18_93 ref NI_18 NS_93 0 1.2437044710003047e+00
GC_18_94 ref NI_18 NS_94 0 -6.2414268502335390e-01
GC_18_95 ref NI_18 NS_95 0 -3.3510547817844046e-04
GC_18_96 ref NI_18 NS_96 0 -8.4024904276686324e-02
GC_18_97 ref NI_18 NS_97 0 5.7651639375528829e-01
GC_18_98 ref NI_18 NS_98 0 -6.8801163077736627e-01
GC_18_99 ref NI_18 NS_99 0 1.2634189291567997e+00
GC_18_100 ref NI_18 NS_100 0 -2.4149351751586204e-01
GC_18_101 ref NI_18 NS_101 0 9.4218597908285950e-05
GC_18_102 ref NI_18 NS_102 0 -6.3939008400394209e-02
GC_18_103 ref NI_18 NS_103 0 3.7120999825295060e+00
GC_18_104 ref NI_18 NS_104 0 -1.9175789266920076e+00
GC_18_105 ref NI_18 NS_105 0 -1.6517669226180529e+00
GC_18_106 ref NI_18 NS_106 0 -9.2280583355122059e-01
GC_18_107 ref NI_18 NS_107 0 -7.8527802176349133e-04
GC_18_108 ref NI_18 NS_108 0 -1.3133718751309417e-01
GC_18_109 ref NI_18 NS_109 0 5.5391459544085898e-02
GC_18_110 ref NI_18 NS_110 0 -1.7468272609161620e-01
GC_18_111 ref NI_18 NS_111 0 8.5734204004508063e-01
GC_18_112 ref NI_18 NS_112 0 -1.9747828541834017e-01
GC_18_113 ref NI_18 NS_113 0 1.2300917762283188e-04
GC_18_114 ref NI_18 NS_114 0 -4.8017234490372804e-02
GC_18_115 ref NI_18 NS_115 0 -3.1869458177565924e-01
GC_18_116 ref NI_18 NS_116 0 -9.9847493949148363e-03
GC_18_117 ref NI_18 NS_117 0 -1.9265846794431184e-02
GC_18_118 ref NI_18 NS_118 0 1.5993935972944928e-01
GC_18_119 ref NI_18 NS_119 0 1.3324253311477980e-04
GC_18_120 ref NI_18 NS_120 0 -6.7151751237494255e-04
GC_18_121 ref NI_18 NS_121 0 -4.7919352635889240e-01
GC_18_122 ref NI_18 NS_122 0 2.9478247225016529e-01
GC_18_123 ref NI_18 NS_123 0 -4.6406812578143414e-01
GC_18_124 ref NI_18 NS_124 0 2.8321207398787829e-01
GC_18_125 ref NI_18 NS_125 0 -2.9106425738424375e-05
GC_18_126 ref NI_18 NS_126 0 1.9542273662677162e-02
GD_18_1 ref NI_18 NA_1 0 8.0253263425422328e-02
GD_18_2 ref NI_18 NA_2 0 7.0515563284834479e-02
GD_18_3 ref NI_18 NA_3 0 7.6978016076992950e-02
GD_18_4 ref NI_18 NA_4 0 1.0217415444083071e-01
GD_18_5 ref NI_18 NA_5 0 1.0001350695469648e-01
GD_18_6 ref NI_18 NA_6 0 2.3395356487483334e-02
GD_18_7 ref NI_18 NA_7 0 7.2341716536126241e-02
GD_18_8 ref NI_18 NA_8 0 9.5961915709066301e-02
GD_18_9 ref NI_18 NA_9 0 2.3285814705944933e-02
GD_18_10 ref NI_18 NA_10 0 1.0976892370529040e-01
GD_18_11 ref NI_18 NA_11 0 6.9382177762910974e-02
GD_18_12 ref NI_18 NA_12 0 -7.0207516744478907e-02
GD_18_13 ref NI_18 NA_13 0 1.1063651324114303e-01
GD_18_14 ref NI_18 NA_14 0 9.0865325641627692e-02
GD_18_15 ref NI_18 NA_15 0 -8.5193022818727657e-04
GD_18_16 ref NI_18 NA_16 0 -1.8282794679333295e-01
GD_18_17 ref NI_18 NA_17 0 -9.6011787393105244e-02
GD_18_18 ref NI_18 NA_18 0 5.4279063890600199e+00
GD_18_19 ref NI_18 NA_19 0 1.0139181368712254e-02
GD_18_20 ref NI_18 NA_20 0 8.4846281599829765e-02
GD_18_21 ref NI_18 NA_21 0 9.8660980929637140e-02
*
* Port 19
VI_19 a_19 NI_19 0
RI_19 NI_19 ref 1.0000000000000001e-01
GC_19_1 ref NI_19 NS_1 0 -3.8517808682201266e-01
GC_19_2 ref NI_19 NS_2 0 1.4783842578429363e-01
GC_19_3 ref NI_19 NS_3 0 -1.0724382000955543e-01
GC_19_4 ref NI_19 NS_4 0 9.2898995290152664e-02
GC_19_5 ref NI_19 NS_5 0 1.5935065368462601e-04
GC_19_6 ref NI_19 NS_6 0 3.0132486206672821e-02
GC_19_7 ref NI_19 NS_7 0 -2.3395566179440416e-01
GC_19_8 ref NI_19 NS_8 0 1.2474732288258608e-01
GC_19_9 ref NI_19 NS_9 0 -6.9044793903875259e-02
GC_19_10 ref NI_19 NS_10 0 8.0307641104355537e-02
GC_19_11 ref NI_19 NS_11 0 7.6797734140826313e-05
GC_19_12 ref NI_19 NS_12 0 2.4444915674503808e-02
GC_19_13 ref NI_19 NS_13 0 -2.5486274193337599e-01
GC_19_14 ref NI_19 NS_14 0 1.3211325731557988e-01
GC_19_15 ref NI_19 NS_15 0 -1.2674673843184553e-01
GC_19_16 ref NI_19 NS_16 0 9.6502484368720720e-02
GC_19_17 ref NI_19 NS_17 0 1.1537945351573778e-04
GC_19_18 ref NI_19 NS_18 0 3.2263149970474456e-02
GC_19_19 ref NI_19 NS_19 0 -3.7666788377082178e-01
GC_19_20 ref NI_19 NS_20 0 1.6848307408729019e-01
GC_19_21 ref NI_19 NS_21 0 -2.4886442440521231e-01
GC_19_22 ref NI_19 NS_22 0 1.1375295684292654e-01
GC_19_23 ref NI_19 NS_23 0 2.8488369657703503e-04
GC_19_24 ref NI_19 NS_24 0 4.9678974072333806e-02
GC_19_25 ref NI_19 NS_25 0 -3.5976601118485085e-01
GC_19_26 ref NI_19 NS_26 0 1.6340022803250687e-01
GC_19_27 ref NI_19 NS_27 0 -2.4791377210514565e-01
GC_19_28 ref NI_19 NS_28 0 1.1608589845105520e-01
GC_19_29 ref NI_19 NS_29 0 2.6956473310354675e-04
GC_19_30 ref NI_19 NS_30 0 4.9051196426844960e-02
GC_19_31 ref NI_19 NS_31 0 -3.9491685962781437e-01
GC_19_32 ref NI_19 NS_32 0 1.3544916363082049e-01
GC_19_33 ref NI_19 NS_33 0 2.1965799502483141e-01
GC_19_34 ref NI_19 NS_34 0 -3.2834065737272315e-02
GC_19_35 ref NI_19 NS_35 0 -1.5493234707312585e-05
GC_19_36 ref NI_19 NS_36 0 6.5181523893642537e-03
GC_19_37 ref NI_19 NS_37 0 -2.0054068952732126e-01
GC_19_38 ref NI_19 NS_38 0 -7.8085678807500395e-03
GC_19_39 ref NI_19 NS_39 0 5.6278234853842125e-02
GC_19_40 ref NI_19 NS_40 0 7.3226985312299681e-02
GC_19_41 ref NI_19 NS_41 0 5.3238091312315313e-06
GC_19_42 ref NI_19 NS_42 0 1.6739461447197700e-02
GC_19_43 ref NI_19 NS_43 0 -7.5400179635040213e-02
GC_19_44 ref NI_19 NS_44 0 -2.5503640520110471e-01
GC_19_45 ref NI_19 NS_45 0 2.8169870632192667e-01
GC_19_46 ref NI_19 NS_46 0 8.2245377897388838e-02
GC_19_47 ref NI_19 NS_47 0 4.4413832852707525e-05
GC_19_48 ref NI_19 NS_48 0 -1.0300215327493716e-02
GC_19_49 ref NI_19 NS_49 0 2.0099202224494786e-01
GC_19_50 ref NI_19 NS_50 0 1.3257006547226740e+00
GC_19_51 ref NI_19 NS_51 0 -3.4511351592864281e-01
GC_19_52 ref NI_19 NS_52 0 -8.7907655756338549e-02
GC_19_53 ref NI_19 NS_53 0 -2.0120612064636486e-04
GC_19_54 ref NI_19 NS_54 0 -8.6337200764831906e-03
GC_19_55 ref NI_19 NS_55 0 -1.3597152079302635e-01
GC_19_56 ref NI_19 NS_56 0 4.7187018852139712e-03
GC_19_57 ref NI_19 NS_57 0 -9.9042273978638559e-02
GC_19_58 ref NI_19 NS_58 0 1.7056107495983536e-01
GC_19_59 ref NI_19 NS_59 0 5.5482707998193980e-06
GC_19_60 ref NI_19 NS_60 0 1.1461130240816495e-02
GC_19_61 ref NI_19 NS_61 0 -2.7438275083307467e-01
GC_19_62 ref NI_19 NS_62 0 2.2337039472192777e-01
GC_19_63 ref NI_19 NS_63 0 7.0526700980152165e-02
GC_19_64 ref NI_19 NS_64 0 1.4628904443493159e-02
GC_19_65 ref NI_19 NS_65 0 -6.1058059321540759e-05
GC_19_66 ref NI_19 NS_66 0 7.7338462496241425e-03
GC_19_67 ref NI_19 NS_67 0 -7.0599741657757634e-02
GC_19_68 ref NI_19 NS_68 0 -2.1954659112838615e-01
GC_19_69 ref NI_19 NS_69 0 3.7800021717950782e-01
GC_19_70 ref NI_19 NS_70 0 8.2172674422292483e-03
GC_19_71 ref NI_19 NS_71 0 7.0800417981302198e-05
GC_19_72 ref NI_19 NS_72 0 -8.7196702979105457e-03
GC_19_73 ref NI_19 NS_73 0 -2.2561655701603689e-01
GC_19_74 ref NI_19 NS_74 0 9.8945300039701922e-02
GC_19_75 ref NI_19 NS_75 0 -1.9426717934588536e-01
GC_19_76 ref NI_19 NS_76 0 1.7359420688141922e-01
GC_19_77 ref NI_19 NS_77 0 2.1256653779094706e-06
GC_19_78 ref NI_19 NS_78 0 2.2197524599290634e-02
GC_19_79 ref NI_19 NS_79 0 -2.8930853472267254e-01
GC_19_80 ref NI_19 NS_80 0 3.8886588034242892e-01
GC_19_81 ref NI_19 NS_81 0 2.0083092877218978e-01
GC_19_82 ref NI_19 NS_82 0 -6.5201883150936391e-02
GC_19_83 ref NI_19 NS_83 0 3.3510832008979137e-05
GC_19_84 ref NI_19 NS_84 0 -1.4816002671905732e-02
GC_19_85 ref NI_19 NS_85 0 3.1969938112165780e-02
GC_19_86 ref NI_19 NS_86 0 1.1983444017260187e+00
GC_19_87 ref NI_19 NS_87 0 3.8338312338892261e-01
GC_19_88 ref NI_19 NS_88 0 -3.9686735339059792e-01
GC_19_89 ref NI_19 NS_89 0 -3.7831664641631209e-04
GC_19_90 ref NI_19 NS_90 0 -3.0695292446929128e-02
GC_19_91 ref NI_19 NS_91 0 -4.2078638194930448e-02
GC_19_92 ref NI_19 NS_92 0 1.8035538278973121e-01
GC_19_93 ref NI_19 NS_93 0 5.0198553814798219e-01
GC_19_94 ref NI_19 NS_94 0 -1.2766327853088880e-01
GC_19_95 ref NI_19 NS_95 0 1.3883682909427664e-04
GC_19_96 ref NI_19 NS_96 0 -3.8380468088407817e-02
GC_19_97 ref NI_19 NS_97 0 -5.6681383433906718e-02
GC_19_98 ref NI_19 NS_98 0 -8.3772001739667132e-02
GC_19_99 ref NI_19 NS_99 0 4.8408764629512208e-01
GC_19_100 ref NI_19 NS_100 0 -5.8155869820933466e-02
GC_19_101 ref NI_19 NS_101 0 1.4701372125762140e-04
GC_19_102 ref NI_19 NS_102 0 -2.6113059722865612e-02
GC_19_103 ref NI_19 NS_103 0 5.5391459544085732e-02
GC_19_104 ref NI_19 NS_104 0 -1.7468272609161545e-01
GC_19_105 ref NI_19 NS_105 0 8.5734204004507930e-01
GC_19_106 ref NI_19 NS_106 0 -1.9747828541833939e-01
GC_19_107 ref NI_19 NS_107 0 1.2300917762287600e-04
GC_19_108 ref NI_19 NS_108 0 -4.8017234490373019e-02
GC_19_109 ref NI_19 NS_109 0 3.6239323678164368e+00
GC_19_110 ref NI_19 NS_110 0 -3.8894321832739593e+00
GC_19_111 ref NI_19 NS_111 0 -2.2277566381706841e+00
GC_19_112 ref NI_19 NS_112 0 -1.1956200924703299e-01
GC_19_113 ref NI_19 NS_113 0 -8.6127440664513443e-04
GC_19_114 ref NI_19 NS_114 0 -5.3662324237655587e-02
GC_19_115 ref NI_19 NS_115 0 -4.1918742519044377e-01
GC_19_116 ref NI_19 NS_116 0 5.3951294796109117e-01
GC_19_117 ref NI_19 NS_117 0 8.5028641904840219e-02
GC_19_118 ref NI_19 NS_118 0 -5.9549259059946839e-02
GC_19_119 ref NI_19 NS_119 0 4.8620519204778006e-05
GC_19_120 ref NI_19 NS_120 0 -7.6199741693698600e-03
GC_19_121 ref NI_19 NS_121 0 -2.6061461454301459e-02
GC_19_122 ref NI_19 NS_122 0 -1.9469353647850357e-01
GC_19_123 ref NI_19 NS_123 0 1.3374426018475291e-01
GC_19_124 ref NI_19 NS_124 0 1.3038910699000891e-01
GC_19_125 ref NI_19 NS_125 0 2.6325896245703804e-05
GC_19_126 ref NI_19 NS_126 0 -3.4628462369711002e-03
GD_19_1 ref NI_19 NA_1 0 6.6908232584826491e-02
GD_19_2 ref NI_19 NA_2 0 6.3538987979909811e-02
GD_19_3 ref NI_19 NA_3 0 5.3599300433175262e-02
GD_19_4 ref NI_19 NA_4 0 8.0985386346204627e-02
GD_19_5 ref NI_19 NA_5 0 7.6831301746876232e-02
GD_19_6 ref NI_19 NA_6 0 6.7579930126331789e-02
GD_19_7 ref NI_19 NA_7 0 4.4357326321353509e-02
GD_19_8 ref NI_19 NA_8 0 3.3485478308684279e-02
GD_19_9 ref NI_19 NA_9 0 -5.6578466202029006e-02
GD_19_10 ref NI_19 NA_10 0 3.5620895326260740e-02
GD_19_11 ref NI_19 NA_11 0 5.0702767012420165e-02
GD_19_12 ref NI_19 NA_12 0 3.3189826333629824e-02
GD_19_13 ref NI_19 NA_13 0 4.7978435205350799e-02
GD_19_14 ref NI_19 NA_14 0 6.2539282762083218e-02
GD_19_15 ref NI_19 NA_15 0 -6.2469289030160254e-02
GD_19_16 ref NI_19 NA_16 0 2.5353405854847164e-02
GD_19_17 ref NI_19 NA_17 0 2.9523003627047198e-02
GD_19_18 ref NI_19 NA_18 0 1.0139181368712254e-02
GD_19_19 ref NI_19 NA_19 0 5.5089975384862484e+00
GD_19_20 ref NI_19 NA_20 0 8.6252528680712648e-02
GD_19_21 ref NI_19 NA_21 0 2.2868085896834447e-02
*
* Port 20
VI_20 a_20 NI_20 0
RI_20 NI_20 ref 1.0000000000000001e-01
GC_20_1 ref NI_20 NS_1 0 -4.0021669345301542e-01
GC_20_2 ref NI_20 NS_2 0 2.0056607624231887e-01
GC_20_3 ref NI_20 NS_3 0 -1.4092969549940668e-01
GC_20_4 ref NI_20 NS_4 0 1.0900473972698421e-01
GC_20_5 ref NI_20 NS_5 0 2.0752096479278507e-04
GC_20_6 ref NI_20 NS_6 0 2.5238356889656834e-02
GC_20_7 ref NI_20 NS_7 0 -2.2301936168106781e-01
GC_20_8 ref NI_20 NS_8 0 1.6597698710351169e-01
GC_20_9 ref NI_20 NS_9 0 -1.0453432825711857e-01
GC_20_10 ref NI_20 NS_10 0 9.5756821158696229e-02
GC_20_11 ref NI_20 NS_11 0 1.3204167160183161e-04
GC_20_12 ref NI_20 NS_12 0 2.0486128849045826e-02
GC_20_13 ref NI_20 NS_13 0 -2.2646362862130115e-01
GC_20_14 ref NI_20 NS_14 0 1.6246638695405352e-01
GC_20_15 ref NI_20 NS_15 0 -1.4258862914604109e-01
GC_20_16 ref NI_20 NS_16 0 1.0715523742466460e-01
GC_20_17 ref NI_20 NS_17 0 1.5128243807360046e-04
GC_20_18 ref NI_20 NS_18 0 2.6810993421652028e-02
GC_20_19 ref NI_20 NS_19 0 -4.2265045553157204e-01
GC_20_20 ref NI_20 NS_20 0 1.7706196730936261e-01
GC_20_21 ref NI_20 NS_21 0 -2.5273861991655339e-01
GC_20_22 ref NI_20 NS_22 0 1.3153158218741368e-01
GC_20_23 ref NI_20 NS_23 0 3.1939957467214591e-04
GC_20_24 ref NI_20 NS_24 0 4.3466682771235735e-02
GC_20_25 ref NI_20 NS_25 0 -4.1150793037237804e-01
GC_20_26 ref NI_20 NS_26 0 1.7460286492340599e-01
GC_20_27 ref NI_20 NS_27 0 -2.5295269707976697e-01
GC_20_28 ref NI_20 NS_28 0 1.3427252902985740e-01
GC_20_29 ref NI_20 NS_29 0 2.9995797242482502e-04
GC_20_30 ref NI_20 NS_30 0 4.2728616056086501e-02
GC_20_31 ref NI_20 NS_31 0 -3.1544122450366890e-01
GC_20_32 ref NI_20 NS_32 0 9.4572690825837358e-02
GC_20_33 ref NI_20 NS_33 0 3.0404163326833451e-02
GC_20_34 ref NI_20 NS_34 0 7.1171329479620002e-02
GC_20_35 ref NI_20 NS_35 0 3.3560548127090175e-05
GC_20_36 ref NI_20 NS_36 0 1.1947385492786924e-02
GC_20_37 ref NI_20 NS_37 0 -1.7446082209924066e-01
GC_20_38 ref NI_20 NS_38 0 -1.3439909319531370e-02
GC_20_39 ref NI_20 NS_39 0 1.8120705837166132e-01
GC_20_40 ref NI_20 NS_40 0 2.3557262081130872e-02
GC_20_41 ref NI_20 NS_41 0 -4.9903242705336250e-05
GC_20_42 ref NI_20 NS_42 0 8.5735946582114562e-03
GC_20_43 ref NI_20 NS_43 0 -7.0652296561975303e-02
GC_20_44 ref NI_20 NS_44 0 -1.8103261591488209e-01
GC_20_45 ref NI_20 NS_45 0 1.2353216724425000e+00
GC_20_46 ref NI_20 NS_46 0 -4.1616919037109751e-01
GC_20_47 ref NI_20 NS_47 0 -5.7623204516823148e-05
GC_20_48 ref NI_20 NS_48 0 -4.1123615937203838e-02
GC_20_49 ref NI_20 NS_49 0 -3.1782993318914349e-01
GC_20_50 ref NI_20 NS_50 0 3.3910137793531331e-01
GC_20_51 ref NI_20 NS_51 0 -1.8006439063386237e-03
GC_20_52 ref NI_20 NS_52 0 2.6856159838125893e-02
GC_20_53 ref NI_20 NS_53 0 1.9616529444871947e-05
GC_20_54 ref NI_20 NS_54 0 3.9423256823972784e-03
GC_20_55 ref NI_20 NS_55 0 2.3739595566040306e-01
GC_20_56 ref NI_20 NS_56 0 -2.1942121639165119e-01
GC_20_57 ref NI_20 NS_57 0 5.3685439950296576e-01
GC_20_58 ref NI_20 NS_58 0 -7.4073284880766074e-02
GC_20_59 ref NI_20 NS_59 0 -1.2992852470641655e-04
GC_20_60 ref NI_20 NS_60 0 -1.6004626000084874e-02
GC_20_61 ref NI_20 NS_61 0 4.6518359344548045e-02
GC_20_62 ref NI_20 NS_62 0 9.0604979415160547e-01
GC_20_63 ref NI_20 NS_63 0 -7.8226837907974189e-02
GC_20_64 ref NI_20 NS_64 0 -1.0137670775800389e-01
GC_20_65 ref NI_20 NS_65 0 -3.0733870960688973e-04
GC_20_66 ref NI_20 NS_66 0 -5.6824918508120237e-03
GC_20_67 ref NI_20 NS_67 0 -3.3134497386249956e-01
GC_20_68 ref NI_20 NS_68 0 8.6390252995901487e-02
GC_20_69 ref NI_20 NS_69 0 -1.7470216916793022e-01
GC_20_70 ref NI_20 NS_70 0 1.8300904871668039e-01
GC_20_71 ref NI_20 NS_71 0 8.4615437376139743e-05
GC_20_72 ref NI_20 NS_72 0 1.5641222911603195e-02
GC_20_73 ref NI_20 NS_73 0 6.1066816712511067e-02
GC_20_74 ref NI_20 NS_74 0 -1.2993971225736967e-01
GC_20_75 ref NI_20 NS_75 0 1.2013632381631124e-01
GC_20_76 ref NI_20 NS_76 0 1.0475644905018661e-01
GC_20_77 ref NI_20 NS_77 0 -1.8608591816966607e-05
GC_20_78 ref NI_20 NS_78 0 1.1543966827104381e-03
GC_20_79 ref NI_20 NS_79 0 4.1516070651657294e-01
GC_20_80 ref NI_20 NS_80 0 1.5829715260886674e+00
GC_20_81 ref NI_20 NS_81 0 -1.3080399606960885e-01
GC_20_82 ref NI_20 NS_82 0 -2.4938307002702081e-01
GC_20_83 ref NI_20 NS_83 0 -1.5896174515766833e-05
GC_20_84 ref NI_20 NS_84 0 -3.7427557219767343e-02
GC_20_85 ref NI_20 NS_85 0 -4.8577128413788428e-01
GC_20_86 ref NI_20 NS_86 0 2.1426898873626002e-01
GC_20_87 ref NI_20 NS_87 0 4.2162669548909398e-01
GC_20_88 ref NI_20 NS_88 0 -1.2826185919740221e-01
GC_20_89 ref NI_20 NS_89 0 8.6471980474082491e-05
GC_20_90 ref NI_20 NS_90 0 -1.4614389199336853e-02
GC_20_91 ref NI_20 NS_91 0 -3.5674811572664600e-01
GC_20_92 ref NI_20 NS_92 0 6.6782411101325392e-02
GC_20_93 ref NI_20 NS_93 0 -1.2174808574992198e-01
GC_20_94 ref NI_20 NS_94 0 1.8116025677949807e-01
GC_20_95 ref NI_20 NS_95 0 9.6145581420007932e-05
GC_20_96 ref NI_20 NS_96 0 5.9759132795147154e-03
GC_20_97 ref NI_20 NS_97 0 -3.4389094856351626e-01
GC_20_98 ref NI_20 NS_98 0 9.8083960651811825e-02
GC_20_99 ref NI_20 NS_99 0 -1.9661683897656287e-01
GC_20_100 ref NI_20 NS_100 0 2.0159200793753773e-01
GC_20_101 ref NI_20 NS_101 0 6.9583198258889775e-05
GC_20_102 ref NI_20 NS_102 0 1.1629167074763216e-02
GC_20_103 ref NI_20 NS_103 0 -3.1869458177565918e-01
GC_20_104 ref NI_20 NS_104 0 -9.9847493949149456e-03
GC_20_105 ref NI_20 NS_105 0 -1.9265846794431031e-02
GC_20_106 ref NI_20 NS_106 0 1.5993935972944917e-01
GC_20_107 ref NI_20 NS_107 0 1.3324253311477715e-04
GC_20_108 ref NI_20 NS_108 0 -6.7151751237492325e-04
GC_20_109 ref NI_20 NS_109 0 -4.1918742519044366e-01
GC_20_110 ref NI_20 NS_110 0 5.3951294796109073e-01
GC_20_111 ref NI_20 NS_111 0 8.5028641904840746e-02
GC_20_112 ref NI_20 NS_112 0 -5.9549259059947172e-02
GC_20_113 ref NI_20 NS_113 0 4.8620519204760869e-05
GC_20_114 ref NI_20 NS_114 0 -7.6199741693697767e-03
GC_20_115 ref NI_20 NS_115 0 3.7504820626343727e+00
GC_20_116 ref NI_20 NS_116 0 -4.2273545113876843e+00
GC_20_117 ref NI_20 NS_117 0 -1.8944000206363236e+00
GC_20_118 ref NI_20 NS_118 0 -1.9231826266373975e-01
GC_20_119 ref NI_20 NS_119 0 -1.0352178795246683e-03
GC_20_120 ref NI_20 NS_120 0 -5.8006744080165672e-02
GC_20_121 ref NI_20 NS_121 0 4.2483470256295164e-01
GC_20_122 ref NI_20 NS_122 0 -2.6107196664599867e-02
GC_20_123 ref NI_20 NS_123 0 8.9342680409937503e-01
GC_20_124 ref NI_20 NS_124 0 -3.0410747552888512e-01
GC_20_125 ref NI_20 NS_125 0 -4.8824560337971666e-05
GC_20_126 ref NI_20 NS_126 0 -3.6279620966598938e-02
GD_20_1 ref NI_20 NA_1 0 6.4891453674361568e-02
GD_20_2 ref NI_20 NA_2 0 6.4758209340663578e-02
GD_20_3 ref NI_20 NA_3 0 5.1649495984914272e-02
GD_20_4 ref NI_20 NA_4 0 8.8103236111033448e-02
GD_20_5 ref NI_20 NA_5 0 8.5021538412108119e-02
GD_20_6 ref NI_20 NA_6 0 6.5330366743946836e-02
GD_20_7 ref NI_20 NA_7 0 3.4401946270257916e-02
GD_20_8 ref NI_20 NA_8 0 -1.5368450805815165e-03
GD_20_9 ref NI_20 NA_9 0 6.7390795289966818e-02
GD_20_10 ref NI_20 NA_10 0 -3.9756589958509510e-02
GD_20_11 ref NI_20 NA_11 0 -3.1364864856718792e-02
GD_20_12 ref NI_20 NA_12 0 7.6321664140692011e-02
GD_20_13 ref NI_20 NA_13 0 -3.0168213989213242e-03
GD_20_14 ref NI_20 NA_14 0 -6.4497561037727788e-02
GD_20_15 ref NI_20 NA_15 0 1.0202610014397365e-01
GD_20_16 ref NI_20 NA_16 0 8.7752604763283851e-02
GD_20_17 ref NI_20 NA_17 0 8.1829781648415423e-02
GD_20_18 ref NI_20 NA_18 0 8.4846281599829765e-02
GD_20_19 ref NI_20 NA_19 0 8.6252528680712648e-02
GD_20_20 ref NI_20 NA_20 0 5.4594482621833498e+00
GD_20_21 ref NI_20 NA_21 0 -8.7699388112049997e-02
*
* Port 21
VI_21 a_21 NI_21 0
RI_21 NI_21 ref 1.0000000000000001e-01
GC_21_1 ref NI_21 NS_1 0 -3.9953022987332298e-01
GC_21_2 ref NI_21 NS_2 0 2.1406197746227693e-01
GC_21_3 ref NI_21 NS_3 0 -1.7202202602733757e-01
GC_21_4 ref NI_21 NS_4 0 1.2711910509535637e-01
GC_21_5 ref NI_21 NS_5 0 2.3852227579220929e-04
GC_21_6 ref NI_21 NS_6 0 2.3606790642567398e-02
GC_21_7 ref NI_21 NS_7 0 -2.1955211729355681e-01
GC_21_8 ref NI_21 NS_8 0 1.7154568700056508e-01
GC_21_9 ref NI_21 NS_9 0 -1.3003709692343401e-01
GC_21_10 ref NI_21 NS_10 0 1.1272782836471587e-01
GC_21_11 ref NI_21 NS_11 0 1.6434966656079375e-04
GC_21_12 ref NI_21 NS_12 0 1.9023069394457689e-02
GC_21_13 ref NI_21 NS_13 0 -2.3149637468685361e-01
GC_21_14 ref NI_21 NS_14 0 1.7667053461377791e-01
GC_21_15 ref NI_21 NS_15 0 -1.6975706615149652e-01
GC_21_16 ref NI_21 NS_16 0 1.2345430398933660e-01
GC_21_17 ref NI_21 NS_17 0 1.8584237417863011e-04
GC_21_18 ref NI_21 NS_18 0 2.4933104843868757e-02
GC_21_19 ref NI_21 NS_19 0 -4.7413518472882921e-01
GC_21_20 ref NI_21 NS_20 0 2.2210591664365850e-01
GC_21_21 ref NI_21 NS_21 0 -2.9996796270939940e-01
GC_21_22 ref NI_21 NS_22 0 1.5128128605499286e-01
GC_21_23 ref NI_21 NS_23 0 3.5007676489927592e-04
GC_21_24 ref NI_21 NS_24 0 4.1880690492904785e-02
GC_21_25 ref NI_21 NS_25 0 -4.5666782821869495e-01
GC_21_26 ref NI_21 NS_26 0 2.1709700134105192e-01
GC_21_27 ref NI_21 NS_27 0 -2.9866629531257227e-01
GC_21_28 ref NI_21 NS_28 0 1.5373038186054766e-01
GC_21_29 ref NI_21 NS_29 0 3.3961982246823766e-04
GC_21_30 ref NI_21 NS_30 0 4.1084450635742523e-02
GC_21_31 ref NI_21 NS_31 0 -2.3399566406660741e-01
GC_21_32 ref NI_21 NS_32 0 6.6807730936348689e-02
GC_21_33 ref NI_21 NS_33 0 -9.9917990080121144e-02
GC_21_34 ref NI_21 NS_34 0 1.4940905384404538e-01
GC_21_35 ref NI_21 NS_35 0 4.3544107203363769e-05
GC_21_36 ref NI_21 NS_36 0 1.3529373520086299e-02
GC_21_37 ref NI_21 NS_37 0 -3.5570908081306231e-02
GC_21_38 ref NI_21 NS_38 0 -9.3702069831975709e-02
GC_21_39 ref NI_21 NS_39 0 1.6774574495481162e-01
GC_21_40 ref NI_21 NS_40 0 6.4225486492685238e-02
GC_21_41 ref NI_21 NS_41 0 1.4502980544587635e-06
GC_21_42 ref NI_21 NS_42 0 2.8924970923958834e-03
GC_21_43 ref NI_21 NS_43 0 3.6669367662797281e-01
GC_21_44 ref NI_21 NS_44 0 2.2063670733251692e+00
GC_21_45 ref NI_21 NS_45 0 2.7879141158022214e-01
GC_21_46 ref NI_21 NS_46 0 -6.3847339702554029e-01
GC_21_47 ref NI_21 NS_47 0 -9.1200702291859007e-05
GC_21_48 ref NI_21 NS_48 0 -6.2307281819634228e-02
GC_21_49 ref NI_21 NS_49 0 -1.6292792558832583e-01
GC_21_50 ref NI_21 NS_50 0 3.8527707208059619e-03
GC_21_51 ref NI_21 NS_51 0 -2.4013622948434048e-02
GC_21_52 ref NI_21 NS_52 0 1.3837875522659507e-01
GC_21_53 ref NI_21 NS_53 0 1.6027745831307230e-05
GC_21_54 ref NI_21 NS_54 0 6.9820045106183193e-03
GC_21_55 ref NI_21 NS_55 0 -1.6004663526925641e-02
GC_21_56 ref NI_21 NS_56 0 1.2279721903224325e+00
GC_21_57 ref NI_21 NS_57 0 1.9073692116143703e-01
GC_21_58 ref NI_21 NS_58 0 -3.2224538756230026e-01
GC_21_59 ref NI_21 NS_59 0 -1.8451220398505832e-04
GC_21_60 ref NI_21 NS_60 0 -2.7747421180367594e-02
GC_21_61 ref NI_21 NS_61 0 1.4426864814025617e-01
GC_21_62 ref NI_21 NS_62 0 5.0346431141845741e-02
GC_21_63 ref NI_21 NS_63 0 3.7613579837168448e-01
GC_21_64 ref NI_21 NS_64 0 -7.4369738615282871e-02
GC_21_65 ref NI_21 NS_65 0 -9.7022799115050181e-05
GC_21_66 ref NI_21 NS_66 0 -1.2651519380833929e-02
GC_21_67 ref NI_21 NS_67 0 -4.8541357191483658e-01
GC_21_68 ref NI_21 NS_68 0 2.9639848611417829e-01
GC_21_69 ref NI_21 NS_69 0 -4.1822250693650698e-01
GC_21_70 ref NI_21 NS_70 0 2.3909612789685961e-01
GC_21_71 ref NI_21 NS_71 0 1.6797988730914747e-05
GC_21_72 ref NI_21 NS_72 0 2.6791327132198790e-02
GC_21_73 ref NI_21 NS_73 0 1.0161305211376329e-01
GC_21_74 ref NI_21 NS_74 0 -2.6316181310002001e-01
GC_21_75 ref NI_21 NS_75 0 4.0350338246177864e-01
GC_21_76 ref NI_21 NS_76 0 1.7815411300288223e-03
GC_21_77 ref NI_21 NS_77 0 -1.0438098395064421e-05
GC_21_78 ref NI_21 NS_78 0 -7.6563550526775890e-03
GC_21_79 ref NI_21 NS_79 0 -7.9822583215533899e-02
GC_21_80 ref NI_21 NS_80 0 1.7416154560683025e-01
GC_21_81 ref NI_21 NS_81 0 1.0744422668760159e+00
GC_21_82 ref NI_21 NS_82 0 -4.3702593003350482e-01
GC_21_83 ref NI_21 NS_83 0 -1.2487669160498129e-04
GC_21_84 ref NI_21 NS_84 0 -4.2158576238348081e-02
GC_21_85 ref NI_21 NS_85 0 4.0278553728063583e-02
GC_21_86 ref NI_21 NS_86 0 -3.6366622312161750e-01
GC_21_87 ref NI_21 NS_87 0 3.2563018197272825e-01
GC_21_88 ref NI_21 NS_88 0 9.0125878336636558e-02
GC_21_89 ref NI_21 NS_89 0 9.6741164729593167e-05
GC_21_90 ref NI_21 NS_90 0 -1.1968767026920351e-02
GC_21_91 ref NI_21 NS_91 0 -5.2971093581332018e-01
GC_21_92 ref NI_21 NS_92 0 3.5169529358016960e-01
GC_21_93 ref NI_21 NS_93 0 -5.1097274138126358e-01
GC_21_94 ref NI_21 NS_94 0 2.8153458685280019e-01
GC_21_95 ref NI_21 NS_95 0 -4.6182585722349331e-05
GC_21_96 ref NI_21 NS_96 0 2.4922568793794279e-02
GC_21_97 ref NI_21 NS_97 0 -5.5046511475025872e-01
GC_21_98 ref NI_21 NS_98 0 3.7833900932916575e-01
GC_21_99 ref NI_21 NS_99 0 -5.2757186439843606e-01
GC_21_100 ref NI_21 NS_100 0 2.7553801120585741e-01
GC_21_101 ref NI_21 NS_101 0 -4.5240948798884010e-05
GC_21_102 ref NI_21 NS_102 0 2.8401937780060175e-02
GC_21_103 ref NI_21 NS_103 0 -4.7919352635889212e-01
GC_21_104 ref NI_21 NS_104 0 2.9478247225016491e-01
GC_21_105 ref NI_21 NS_105 0 -4.6406812578143364e-01
GC_21_106 ref NI_21 NS_106 0 2.8321207398787790e-01
GC_21_107 ref NI_21 NS_107 0 -2.9106425738441793e-05
GC_21_108 ref NI_21 NS_108 0 1.9542273662677252e-02
GC_21_109 ref NI_21 NS_109 0 -2.6061461454301590e-02
GC_21_110 ref NI_21 NS_110 0 -1.9469353647850288e-01
GC_21_111 ref NI_21 NS_111 0 1.3374426018475180e-01
GC_21_112 ref NI_21 NS_112 0 1.3038910699000958e-01
GC_21_113 ref NI_21 NS_113 0 2.6325896245741660e-05
GC_21_114 ref NI_21 NS_114 0 -3.4628462369712737e-03
GC_21_115 ref NI_21 NS_115 0 4.2483470256295158e-01
GC_21_116 ref NI_21 NS_116 0 -2.6107196664599517e-02
GC_21_117 ref NI_21 NS_117 0 8.9342680409937469e-01
GC_21_118 ref NI_21 NS_118 0 -3.0410747552888479e-01
GC_21_119 ref NI_21 NS_119 0 -4.8824560337952618e-05
GC_21_120 ref NI_21 NS_120 0 -3.6279620966599022e-02
GC_21_121 ref NI_21 NS_121 0 3.4097723811069893e+00
GC_21_122 ref NI_21 NS_122 0 -5.1045900384584852e+00
GC_21_123 ref NI_21 NS_123 0 -7.4100475831564905e-01
GC_21_124 ref NI_21 NS_124 0 -5.3931398805207720e-01
GC_21_125 ref NI_21 NS_125 0 -7.7883670935858075e-04
GC_21_126 ref NI_21 NS_126 0 -6.9401210215492434e-02
GD_21_1 ref NI_21 NA_1 0 6.4840372047732922e-02
GD_21_2 ref NI_21 NA_2 0 6.3774973564370521e-02
GD_21_3 ref NI_21 NA_3 0 5.3030592555146486e-02
GD_21_4 ref NI_21 NA_4 0 9.6162907306720585e-02
GD_21_5 ref NI_21 NA_5 0 9.1760915535378712e-02
GD_21_6 ref NI_21 NA_6 0 5.1945311406123428e-02
GD_21_7 ref NI_21 NA_7 0 1.4362457314831040e-02
GD_21_8 ref NI_21 NA_8 0 -7.1161878293102110e-02
GD_21_9 ref NI_21 NA_9 0 4.1658174671290689e-02
GD_21_10 ref NI_21 NA_10 0 5.6206771428438454e-03
GD_21_11 ref NI_21 NA_11 0 -2.6115303790661716e-02
GD_21_12 ref NI_21 NA_12 0 9.5295365999258669e-02
GD_21_13 ref NI_21 NA_13 0 -8.0737665429089518e-03
GD_21_14 ref NI_21 NA_14 0 -9.2798711421358902e-03
GD_21_15 ref NI_21 NA_15 0 1.6478077186480145e-02
GD_21_16 ref NI_21 NA_16 0 1.0535554663586769e-01
GD_21_17 ref NI_21 NA_17 0 1.0667601673653725e-01
GD_21_18 ref NI_21 NA_18 0 9.8660980929637140e-02
GD_21_19 ref NI_21 NA_19 0 2.2868085896834447e-02
GD_21_20 ref NI_21 NA_20 0 -8.7699388112049997e-02
GD_21_21 ref NI_21 NA_21 0 5.5484162105997781e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
* Impinging wave, port 16
RA_16 NA_16 0 1.5811388300841897e-01
FA_16 0 NA_16 VI_16 1.0
GA_16 0 NA_16 a_16 ref 1.0000000000000000e+01
*
* Impinging wave, port 17
RA_17 NA_17 0 1.5811388300841897e-01
FA_17 0 NA_17 VI_17 1.0
GA_17 0 NA_17 a_17 ref 1.0000000000000000e+01
*
* Impinging wave, port 18
RA_18 NA_18 0 1.5811388300841897e-01
FA_18 0 NA_18 VI_18 1.0
GA_18 0 NA_18 a_18 ref 1.0000000000000000e+01
*
* Impinging wave, port 19
RA_19 NA_19 0 1.5811388300841897e-01
FA_19 0 NA_19 VI_19 1.0
GA_19 0 NA_19 a_19 ref 1.0000000000000000e+01
*
* Impinging wave, port 20
RA_20 NA_20 0 1.5811388300841897e-01
FA_20 0 NA_20 VI_20 1.0
GA_20 0 NA_20 a_20 ref 1.0000000000000000e+01
*
* Impinging wave, port 21
RA_21 NA_21 0 1.5811388300841897e-01
FA_21 0 NA_21 VI_21 1.0
GA_21 0 NA_21 a_21 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 5.2781771048560112e-02
GS_1_1 0 NS_1 NA_1 0 7.6145114046469891e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 1.9346813034984914e-01
GS_2_1 0 NS_2 NA_1 0 7.6145114046469891e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 3.3370492667012319e-01
GS_3_1 0 NS_3 NA_1 0 7.6145114046469891e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 5.5799051228031860e-01
GS_4_1 0 NS_4 NA_1 0 7.6145114046469891e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 7.8703160061889195e+00
GS_5_1 0 NS_5 NA_1 0 7.6145114046469891e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 1.3585326524647612e+00
GS_6_1 0 NS_6 NA_1 0 7.6145114046469891e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 5.2781771048560112e-02
GS_7_2 0 NS_7 NA_2 0 7.6145114046469891e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 1.9346813034984914e-01
GS_8_2 0 NS_8 NA_2 0 7.6145114046469891e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 3.3370492667012319e-01
GS_9_2 0 NS_9 NA_2 0 7.6145114046469891e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 5.5799051228031860e-01
GS_10_2 0 NS_10 NA_2 0 7.6145114046469891e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 7.8703160061889195e+00
GS_11_2 0 NS_11 NA_2 0 7.6145114046469891e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 1.3585326524647612e+00
GS_12_2 0 NS_12 NA_2 0 7.6145114046469891e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 5.2781771048560112e-02
GS_13_3 0 NS_13 NA_3 0 7.6145114046469891e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 1.9346813034984914e-01
GS_14_3 0 NS_14 NA_3 0 7.6145114046469891e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 3.3370492667012319e-01
GS_15_3 0 NS_15 NA_3 0 7.6145114046469891e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 5.5799051228031860e-01
GS_16_3 0 NS_16 NA_3 0 7.6145114046469891e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 7.8703160061889195e+00
GS_17_3 0 NS_17 NA_3 0 7.6145114046469891e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 1.3585326524647612e+00
GS_18_3 0 NS_18 NA_3 0 7.6145114046469891e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 5.2781771048560112e-02
GS_19_4 0 NS_19 NA_4 0 7.6145114046469891e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 1.9346813034984914e-01
GS_20_4 0 NS_20 NA_4 0 7.6145114046469891e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 3.3370492667012319e-01
GS_21_4 0 NS_21 NA_4 0 7.6145114046469891e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 5.5799051228031860e-01
GS_22_4 0 NS_22 NA_4 0 7.6145114046469891e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 7.8703160061889195e+00
GS_23_4 0 NS_23 NA_4 0 7.6145114046469891e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 1.3585326524647612e+00
GS_24_4 0 NS_24 NA_4 0 7.6145114046469891e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 5.2781771048560112e-02
GS_25_5 0 NS_25 NA_5 0 7.6145114046469891e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 1.9346813034984914e-01
GS_26_5 0 NS_26 NA_5 0 7.6145114046469891e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 3.3370492667012319e-01
GS_27_5 0 NS_27 NA_5 0 7.6145114046469891e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 5.5799051228031860e-01
GS_28_5 0 NS_28 NA_5 0 7.6145114046469891e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 7.8703160061889195e+00
GS_29_5 0 NS_29 NA_5 0 7.6145114046469891e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 1.3585326524647612e+00
GS_30_5 0 NS_30 NA_5 0 7.6145114046469891e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 5.2781771048560112e-02
GS_31_6 0 NS_31 NA_6 0 7.6145114046469891e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 1.9346813034984914e-01
GS_32_6 0 NS_32 NA_6 0 7.6145114046469891e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 3.3370492667012319e-01
GS_33_6 0 NS_33 NA_6 0 7.6145114046469891e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 5.5799051228031860e-01
GS_34_6 0 NS_34 NA_6 0 7.6145114046469891e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 7.8703160061889195e+00
GS_35_6 0 NS_35 NA_6 0 7.6145114046469891e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 1.3585326524647612e+00
GS_36_6 0 NS_36 NA_6 0 7.6145114046469891e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 5.2781771048560112e-02
GS_37_7 0 NS_37 NA_7 0 7.6145114046469891e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 1.9346813034984914e-01
GS_38_7 0 NS_38 NA_7 0 7.6145114046469891e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 3.3370492667012319e-01
GS_39_7 0 NS_39 NA_7 0 7.6145114046469891e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 5.5799051228031860e-01
GS_40_7 0 NS_40 NA_7 0 7.6145114046469891e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 7.8703160061889195e+00
GS_41_7 0 NS_41 NA_7 0 7.6145114046469891e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 1.3585326524647612e+00
GS_42_7 0 NS_42 NA_7 0 7.6145114046469891e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 5.2781771048560112e-02
GS_43_8 0 NS_43 NA_8 0 7.6145114046469891e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 1.9346813034984914e-01
GS_44_8 0 NS_44 NA_8 0 7.6145114046469891e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 3.3370492667012319e-01
GS_45_8 0 NS_45 NA_8 0 7.6145114046469891e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 5.5799051228031860e-01
GS_46_8 0 NS_46 NA_8 0 7.6145114046469891e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 7.8703160061889195e+00
GS_47_8 0 NS_47 NA_8 0 7.6145114046469891e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 1.3585326524647612e+00
GS_48_8 0 NS_48 NA_8 0 7.6145114046469891e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 5.2781771048560112e-02
GS_49_9 0 NS_49 NA_9 0 7.6145114046469891e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 1.9346813034984914e-01
GS_50_9 0 NS_50 NA_9 0 7.6145114046469891e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 3.3370492667012319e-01
GS_51_9 0 NS_51 NA_9 0 7.6145114046469891e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 5.5799051228031860e-01
GS_52_9 0 NS_52 NA_9 0 7.6145114046469891e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 7.8703160061889195e+00
GS_53_9 0 NS_53 NA_9 0 7.6145114046469891e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 1.3585326524647612e+00
GS_54_9 0 NS_54 NA_9 0 7.6145114046469891e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 5.2781771048560112e-02
GS_55_10 0 NS_55 NA_10 0 7.6145114046469891e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 1.9346813034984914e-01
GS_56_10 0 NS_56 NA_10 0 7.6145114046469891e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 3.3370492667012319e-01
GS_57_10 0 NS_57 NA_10 0 7.6145114046469891e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 5.5799051228031860e-01
GS_58_10 0 NS_58 NA_10 0 7.6145114046469891e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 7.8703160061889195e+00
GS_59_10 0 NS_59 NA_10 0 7.6145114046469891e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 1.3585326524647612e+00
GS_60_10 0 NS_60 NA_10 0 7.6145114046469891e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 5.2781771048560112e-02
GS_61_11 0 NS_61 NA_11 0 7.6145114046469891e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 1.9346813034984914e-01
GS_62_11 0 NS_62 NA_11 0 7.6145114046469891e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 3.3370492667012319e-01
GS_63_11 0 NS_63 NA_11 0 7.6145114046469891e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 5.5799051228031860e-01
GS_64_11 0 NS_64 NA_11 0 7.6145114046469891e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 7.8703160061889195e+00
GS_65_11 0 NS_65 NA_11 0 7.6145114046469891e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 1.3585326524647612e+00
GS_66_11 0 NS_66 NA_11 0 7.6145114046469891e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 5.2781771048560112e-02
GS_67_12 0 NS_67 NA_12 0 7.6145114046469891e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 1.9346813034984914e-01
GS_68_12 0 NS_68 NA_12 0 7.6145114046469891e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 3.3370492667012319e-01
GS_69_12 0 NS_69 NA_12 0 7.6145114046469891e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 5.5799051228031860e-01
GS_70_12 0 NS_70 NA_12 0 7.6145114046469891e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 7.8703160061889195e+00
GS_71_12 0 NS_71 NA_12 0 7.6145114046469891e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 1.3585326524647612e+00
GS_72_12 0 NS_72 NA_12 0 7.6145114046469891e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 5.2781771048560112e-02
GS_73_13 0 NS_73 NA_13 0 7.6145114046469891e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 1.9346813034984914e-01
GS_74_13 0 NS_74 NA_13 0 7.6145114046469891e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 3.3370492667012319e-01
GS_75_13 0 NS_75 NA_13 0 7.6145114046469891e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 5.5799051228031860e-01
GS_76_13 0 NS_76 NA_13 0 7.6145114046469891e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 7.8703160061889195e+00
GS_77_13 0 NS_77 NA_13 0 7.6145114046469891e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 1.3585326524647612e+00
GS_78_13 0 NS_78 NA_13 0 7.6145114046469891e+00
*
* Real pole n. 79
CS_79 NS_79 0 1.0000000000000001e-09
RS_79 NS_79 0 5.2781771048560112e-02
GS_79_14 0 NS_79 NA_14 0 7.6145114046469891e+00
*
* Real pole n. 80
CS_80 NS_80 0 1.0000000000000001e-09
RS_80 NS_80 0 1.9346813034984914e-01
GS_80_14 0 NS_80 NA_14 0 7.6145114046469891e+00
*
* Real pole n. 81
CS_81 NS_81 0 1.0000000000000001e-09
RS_81 NS_81 0 3.3370492667012319e-01
GS_81_14 0 NS_81 NA_14 0 7.6145114046469891e+00
*
* Real pole n. 82
CS_82 NS_82 0 1.0000000000000001e-09
RS_82 NS_82 0 5.5799051228031860e-01
GS_82_14 0 NS_82 NA_14 0 7.6145114046469891e+00
*
* Real pole n. 83
CS_83 NS_83 0 1.0000000000000001e-09
RS_83 NS_83 0 7.8703160061889195e+00
GS_83_14 0 NS_83 NA_14 0 7.6145114046469891e+00
*
* Real pole n. 84
CS_84 NS_84 0 1.0000000000000001e-09
RS_84 NS_84 0 1.3585326524647612e+00
GS_84_14 0 NS_84 NA_14 0 7.6145114046469891e+00
*
* Real pole n. 85
CS_85 NS_85 0 1.0000000000000001e-09
RS_85 NS_85 0 5.2781771048560112e-02
GS_85_15 0 NS_85 NA_15 0 7.6145114046469891e+00
*
* Real pole n. 86
CS_86 NS_86 0 1.0000000000000001e-09
RS_86 NS_86 0 1.9346813034984914e-01
GS_86_15 0 NS_86 NA_15 0 7.6145114046469891e+00
*
* Real pole n. 87
CS_87 NS_87 0 1.0000000000000001e-09
RS_87 NS_87 0 3.3370492667012319e-01
GS_87_15 0 NS_87 NA_15 0 7.6145114046469891e+00
*
* Real pole n. 88
CS_88 NS_88 0 1.0000000000000001e-09
RS_88 NS_88 0 5.5799051228031860e-01
GS_88_15 0 NS_88 NA_15 0 7.6145114046469891e+00
*
* Real pole n. 89
CS_89 NS_89 0 1.0000000000000001e-09
RS_89 NS_89 0 7.8703160061889195e+00
GS_89_15 0 NS_89 NA_15 0 7.6145114046469891e+00
*
* Real pole n. 90
CS_90 NS_90 0 1.0000000000000001e-09
RS_90 NS_90 0 1.3585326524647612e+00
GS_90_15 0 NS_90 NA_15 0 7.6145114046469891e+00
*
* Real pole n. 91
CS_91 NS_91 0 1.0000000000000001e-09
RS_91 NS_91 0 5.2781771048560112e-02
GS_91_16 0 NS_91 NA_16 0 7.6145114046469891e+00
*
* Real pole n. 92
CS_92 NS_92 0 1.0000000000000001e-09
RS_92 NS_92 0 1.9346813034984914e-01
GS_92_16 0 NS_92 NA_16 0 7.6145114046469891e+00
*
* Real pole n. 93
CS_93 NS_93 0 1.0000000000000001e-09
RS_93 NS_93 0 3.3370492667012319e-01
GS_93_16 0 NS_93 NA_16 0 7.6145114046469891e+00
*
* Real pole n. 94
CS_94 NS_94 0 1.0000000000000001e-09
RS_94 NS_94 0 5.5799051228031860e-01
GS_94_16 0 NS_94 NA_16 0 7.6145114046469891e+00
*
* Real pole n. 95
CS_95 NS_95 0 1.0000000000000001e-09
RS_95 NS_95 0 7.8703160061889195e+00
GS_95_16 0 NS_95 NA_16 0 7.6145114046469891e+00
*
* Real pole n. 96
CS_96 NS_96 0 1.0000000000000001e-09
RS_96 NS_96 0 1.3585326524647612e+00
GS_96_16 0 NS_96 NA_16 0 7.6145114046469891e+00
*
* Real pole n. 97
CS_97 NS_97 0 1.0000000000000001e-09
RS_97 NS_97 0 5.2781771048560112e-02
GS_97_17 0 NS_97 NA_17 0 7.6145114046469891e+00
*
* Real pole n. 98
CS_98 NS_98 0 1.0000000000000001e-09
RS_98 NS_98 0 1.9346813034984914e-01
GS_98_17 0 NS_98 NA_17 0 7.6145114046469891e+00
*
* Real pole n. 99
CS_99 NS_99 0 1.0000000000000001e-09
RS_99 NS_99 0 3.3370492667012319e-01
GS_99_17 0 NS_99 NA_17 0 7.6145114046469891e+00
*
* Real pole n. 100
CS_100 NS_100 0 1.0000000000000001e-09
RS_100 NS_100 0 5.5799051228031860e-01
GS_100_17 0 NS_100 NA_17 0 7.6145114046469891e+00
*
* Real pole n. 101
CS_101 NS_101 0 1.0000000000000001e-09
RS_101 NS_101 0 7.8703160061889195e+00
GS_101_17 0 NS_101 NA_17 0 7.6145114046469891e+00
*
* Real pole n. 102
CS_102 NS_102 0 1.0000000000000001e-09
RS_102 NS_102 0 1.3585326524647612e+00
GS_102_17 0 NS_102 NA_17 0 7.6145114046469891e+00
*
* Real pole n. 103
CS_103 NS_103 0 1.0000000000000001e-09
RS_103 NS_103 0 5.2781771048560112e-02
GS_103_18 0 NS_103 NA_18 0 7.6145114046469891e+00
*
* Real pole n. 104
CS_104 NS_104 0 1.0000000000000001e-09
RS_104 NS_104 0 1.9346813034984914e-01
GS_104_18 0 NS_104 NA_18 0 7.6145114046469891e+00
*
* Real pole n. 105
CS_105 NS_105 0 1.0000000000000001e-09
RS_105 NS_105 0 3.3370492667012319e-01
GS_105_18 0 NS_105 NA_18 0 7.6145114046469891e+00
*
* Real pole n. 106
CS_106 NS_106 0 1.0000000000000001e-09
RS_106 NS_106 0 5.5799051228031860e-01
GS_106_18 0 NS_106 NA_18 0 7.6145114046469891e+00
*
* Real pole n. 107
CS_107 NS_107 0 1.0000000000000001e-09
RS_107 NS_107 0 7.8703160061889195e+00
GS_107_18 0 NS_107 NA_18 0 7.6145114046469891e+00
*
* Real pole n. 108
CS_108 NS_108 0 1.0000000000000001e-09
RS_108 NS_108 0 1.3585326524647612e+00
GS_108_18 0 NS_108 NA_18 0 7.6145114046469891e+00
*
* Real pole n. 109
CS_109 NS_109 0 1.0000000000000001e-09
RS_109 NS_109 0 5.2781771048560112e-02
GS_109_19 0 NS_109 NA_19 0 7.6145114046469891e+00
*
* Real pole n. 110
CS_110 NS_110 0 1.0000000000000001e-09
RS_110 NS_110 0 1.9346813034984914e-01
GS_110_19 0 NS_110 NA_19 0 7.6145114046469891e+00
*
* Real pole n. 111
CS_111 NS_111 0 1.0000000000000001e-09
RS_111 NS_111 0 3.3370492667012319e-01
GS_111_19 0 NS_111 NA_19 0 7.6145114046469891e+00
*
* Real pole n. 112
CS_112 NS_112 0 1.0000000000000001e-09
RS_112 NS_112 0 5.5799051228031860e-01
GS_112_19 0 NS_112 NA_19 0 7.6145114046469891e+00
*
* Real pole n. 113
CS_113 NS_113 0 1.0000000000000001e-09
RS_113 NS_113 0 7.8703160061889195e+00
GS_113_19 0 NS_113 NA_19 0 7.6145114046469891e+00
*
* Real pole n. 114
CS_114 NS_114 0 1.0000000000000001e-09
RS_114 NS_114 0 1.3585326524647612e+00
GS_114_19 0 NS_114 NA_19 0 7.6145114046469891e+00
*
* Real pole n. 115
CS_115 NS_115 0 1.0000000000000001e-09
RS_115 NS_115 0 5.2781771048560112e-02
GS_115_20 0 NS_115 NA_20 0 7.6145114046469891e+00
*
* Real pole n. 116
CS_116 NS_116 0 1.0000000000000001e-09
RS_116 NS_116 0 1.9346813034984914e-01
GS_116_20 0 NS_116 NA_20 0 7.6145114046469891e+00
*
* Real pole n. 117
CS_117 NS_117 0 1.0000000000000001e-09
RS_117 NS_117 0 3.3370492667012319e-01
GS_117_20 0 NS_117 NA_20 0 7.6145114046469891e+00
*
* Real pole n. 118
CS_118 NS_118 0 1.0000000000000001e-09
RS_118 NS_118 0 5.5799051228031860e-01
GS_118_20 0 NS_118 NA_20 0 7.6145114046469891e+00
*
* Real pole n. 119
CS_119 NS_119 0 1.0000000000000001e-09
RS_119 NS_119 0 7.8703160061889195e+00
GS_119_20 0 NS_119 NA_20 0 7.6145114046469891e+00
*
* Real pole n. 120
CS_120 NS_120 0 1.0000000000000001e-09
RS_120 NS_120 0 1.3585326524647612e+00
GS_120_20 0 NS_120 NA_20 0 7.6145114046469891e+00
*
* Real pole n. 121
CS_121 NS_121 0 1.0000000000000001e-09
RS_121 NS_121 0 5.2781771048560112e-02
GS_121_21 0 NS_121 NA_21 0 7.6145114046469891e+00
*
* Real pole n. 122
CS_122 NS_122 0 1.0000000000000001e-09
RS_122 NS_122 0 1.9346813034984914e-01
GS_122_21 0 NS_122 NA_21 0 7.6145114046469891e+00
*
* Real pole n. 123
CS_123 NS_123 0 1.0000000000000001e-09
RS_123 NS_123 0 3.3370492667012319e-01
GS_123_21 0 NS_123 NA_21 0 7.6145114046469891e+00
*
* Real pole n. 124
CS_124 NS_124 0 1.0000000000000001e-09
RS_124 NS_124 0 5.5799051228031860e-01
GS_124_21 0 NS_124 NA_21 0 7.6145114046469891e+00
*
* Real pole n. 125
CS_125 NS_125 0 1.0000000000000001e-09
RS_125 NS_125 0 7.8703160061889195e+00
GS_125_21 0 NS_125 NA_21 0 7.6145114046469891e+00
*
* Real pole n. 126
CS_126 NS_126 0 1.0000000000000001e-09
RS_126 NS_126 0 1.3585326524647612e+00
GS_126_21 0 NS_126 NA_21 0 7.6145114046469891e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
