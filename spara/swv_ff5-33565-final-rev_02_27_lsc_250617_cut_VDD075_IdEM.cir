**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 17-Jun-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Tue Jun 17 18:13:01 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Tue Jun 17 18:13:01 2025
**
**  Modal data exported
**  Port[1] = PORT_1_BGA1_GRP_1_1_VDD_075_BGA1_GRP_1_1_VSS
**  Port[2] = PORT_2_DIE1_GRP_0_0_VDD_075_DIE1_GRP_0_0_VSS
**  Port[3] = PORT_3_DIE1_GRP_0_1_VDD_075_DIE1_GRP_0_1_VSS
**  Port[4] = PORT_4_DIE1_GRP_1_0_VDD_075_DIE1_GRP_1_0_VSS
**  Port[5] = PORT_5_DIE1_GRP_1_1_VDD_075_DIE1_GRP_1_1_VSS
**  Port[6] = PORT_6_DIE1_GRP_2_0_VDD_075_DIE1_GRP_2_0_VSS
**  Port[7] = PORT_7_DIE1_GRP_2_1_VDD_075_DIE1_GRP_2_1_VSS
**  Port[8] = VDD_075_B3_2
**  Port[9] = VDD_075_B4_2
**  Port[10] = VDD_075_C37_2
**  Port[11] = VDD_075_C38_2
**  Port[12] = VDD_075_C78_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5-33565-final-rev_02_27_lsc_250617_cut_VDD075_IdEM
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 3.0988402598136817e+00
GC_1_2 ref NI_1 NS_2 0 -2.1306527844110721e+00
GC_1_3 ref NI_1 NS_3 0 -2.0563992628267167e+00
GC_1_4 ref NI_1 NS_4 0 -6.2665673574907577e-01
GC_1_5 ref NI_1 NS_5 0 -5.4625185546637164e-03
GC_1_6 ref NI_1 NS_6 0 -1.8164925839605144e-02
GC_1_7 ref NI_1 NS_7 0 -9.9927249894813996e-02
GC_1_8 ref NI_1 NS_8 0 -2.8319592992002662e-01
GC_1_9 ref NI_1 NS_9 0 2.6202538802691372e-01
GC_1_10 ref NI_1 NS_10 0 1.2321530373301499e-01
GC_1_11 ref NI_1 NS_11 0 6.2230889112247737e-04
GC_1_12 ref NI_1 NS_12 0 -1.4239710804448521e-02
GC_1_13 ref NI_1 NS_13 0 4.4189903697046001e-01
GC_1_14 ref NI_1 NS_14 0 1.9082772515964697e+00
GC_1_15 ref NI_1 NS_15 0 -1.8303043236334379e-01
GC_1_16 ref NI_1 NS_16 0 -9.7477635670235291e-02
GC_1_17 ref NI_1 NS_17 0 3.4766746599091265e-04
GC_1_18 ref NI_1 NS_18 0 -5.0584421207147271e-03
GC_1_19 ref NI_1 NS_19 0 -5.7371929972688973e-01
GC_1_20 ref NI_1 NS_20 0 7.8077233723974251e-02
GC_1_21 ref NI_1 NS_21 0 4.9414497922069794e-01
GC_1_22 ref NI_1 NS_22 0 -2.9069840714441693e-02
GC_1_23 ref NI_1 NS_23 0 2.4657033088602186e-04
GC_1_24 ref NI_1 NS_24 0 -1.1968023401123776e-03
GC_1_25 ref NI_1 NS_25 0 5.6055193687792571e-01
GC_1_26 ref NI_1 NS_26 0 5.8890287628477367e-01
GC_1_27 ref NI_1 NS_27 0 3.0177574685512215e-01
GC_1_28 ref NI_1 NS_28 0 -1.1379885137141520e-01
GC_1_29 ref NI_1 NS_29 0 -9.5336688990244371e-05
GC_1_30 ref NI_1 NS_30 0 -2.6505760536920083e-03
GC_1_31 ref NI_1 NS_31 0 -3.8487425734460345e-01
GC_1_32 ref NI_1 NS_32 0 -5.3409676937429607e-01
GC_1_33 ref NI_1 NS_33 0 7.3753871225998513e-01
GC_1_34 ref NI_1 NS_34 0 -4.8829426848711513e-02
GC_1_35 ref NI_1 NS_35 0 2.3629910443670029e-04
GC_1_36 ref NI_1 NS_36 0 -4.2232586716418343e-04
GC_1_37 ref NI_1 NS_37 0 -1.2767041878847163e+00
GC_1_38 ref NI_1 NS_38 0 6.2573575551994653e-01
GC_1_39 ref NI_1 NS_39 0 5.9250650266303373e-01
GC_1_40 ref NI_1 NS_40 0 -1.0856703257092638e-01
GC_1_41 ref NI_1 NS_41 0 3.3465927806488382e-05
GC_1_42 ref NI_1 NS_42 0 -2.3229095952296630e-03
GC_1_43 ref NI_1 NS_43 0 1.6961367978700234e-01
GC_1_44 ref NI_1 NS_44 0 -2.6872557080612419e-01
GC_1_45 ref NI_1 NS_45 0 -3.0172906335568062e-02
GC_1_46 ref NI_1 NS_46 0 2.1228869965409600e-01
GC_1_47 ref NI_1 NS_47 0 5.4132789000580395e-04
GC_1_48 ref NI_1 NS_48 0 1.1283833207393033e-04
GC_1_49 ref NI_1 NS_49 0 -2.8876162800437150e-01
GC_1_50 ref NI_1 NS_50 0 1.6995208339338752e-01
GC_1_51 ref NI_1 NS_51 0 -3.1700208031426308e-01
GC_1_52 ref NI_1 NS_52 0 2.7672932080609214e-01
GC_1_53 ref NI_1 NS_53 0 3.9815838423021179e-04
GC_1_54 ref NI_1 NS_54 0 7.1229548109520910e-03
GC_1_55 ref NI_1 NS_55 0 -2.0887708185290310e-01
GC_1_56 ref NI_1 NS_56 0 -4.3376945520242113e-02
GC_1_57 ref NI_1 NS_57 0 -4.0994815822160198e-02
GC_1_58 ref NI_1 NS_58 0 1.4160949146754290e-01
GC_1_59 ref NI_1 NS_59 0 1.1589853923996939e-03
GC_1_60 ref NI_1 NS_60 0 2.4987233064408778e-02
GC_1_61 ref NI_1 NS_61 0 -3.6694345000824719e-01
GC_1_62 ref NI_1 NS_62 0 -4.7987245317860902e-02
GC_1_63 ref NI_1 NS_63 0 1.0039465541502862e-01
GC_1_64 ref NI_1 NS_64 0 1.0021112488722500e-01
GC_1_65 ref NI_1 NS_65 0 1.0856379974240780e-03
GC_1_66 ref NI_1 NS_66 0 2.0327793033766882e-02
GC_1_67 ref NI_1 NS_67 0 -1.3507646527591044e-01
GC_1_68 ref NI_1 NS_68 0 -2.6830577719672333e-01
GC_1_69 ref NI_1 NS_69 0 1.7430488999466662e-01
GC_1_70 ref NI_1 NS_70 0 1.6236749071557446e-01
GC_1_71 ref NI_1 NS_71 0 8.8647881324495912e-04
GC_1_72 ref NI_1 NS_72 0 -7.6467569642735813e-03
GD_1_1 ref NI_1 NA_1 0 5.5215869802342414e+00
GD_1_2 ref NI_1 NA_2 0 5.8590620561641910e-02
GD_1_3 ref NI_1 NA_3 0 -6.6434091081576038e-02
GD_1_4 ref NI_1 NA_4 0 8.2599829655768855e-02
GD_1_5 ref NI_1 NA_5 0 5.1367225602411436e-02
GD_1_6 ref NI_1 NA_6 0 8.9506270457763631e-02
GD_1_7 ref NI_1 NA_7 0 7.4217560307404729e-02
GD_1_8 ref NI_1 NA_8 0 1.2322485905214954e-02
GD_1_9 ref NI_1 NA_9 0 6.0318720084725247e-02
GD_1_10 ref NI_1 NA_10 0 4.4421832406569606e-02
GD_1_11 ref NI_1 NA_11 0 6.1092868782986066e-02
GD_1_12 ref NI_1 NA_12 0 3.3663046581058752e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -9.9927249894814302e-02
GC_2_2 ref NI_2 NS_2 0 -2.8319592992002607e-01
GC_2_3 ref NI_2 NS_3 0 2.6202538802691305e-01
GC_2_4 ref NI_2 NS_4 0 1.2321530373301551e-01
GC_2_5 ref NI_2 NS_5 0 6.2230889112255099e-04
GC_2_6 ref NI_2 NS_6 0 -1.4239710804448785e-02
GC_2_7 ref NI_2 NS_7 0 4.5921389111645041e+00
GC_2_8 ref NI_2 NS_8 0 -1.8280168342729837e+00
GC_2_9 ref NI_2 NS_9 0 -5.0612407714707852e-01
GC_2_10 ref NI_2 NS_10 0 -1.0691630746846772e+00
GC_2_11 ref NI_2 NS_11 0 -3.2265632019462713e-03
GC_2_12 ref NI_2 NS_12 0 -1.1944452699274954e-01
GC_2_13 ref NI_2 NS_13 0 -4.3644069577801931e-01
GC_2_14 ref NI_2 NS_14 0 6.7702493608093839e-01
GC_2_15 ref NI_2 NS_15 0 8.6790803358239008e-02
GC_2_16 ref NI_2 NS_16 0 1.6957161407441603e-02
GC_2_17 ref NI_2 NS_17 0 4.3086206721954450e-04
GC_2_18 ref NI_2 NS_18 0 -1.8834479524160314e-03
GC_2_19 ref NI_2 NS_19 0 -7.8431550406053796e-01
GC_2_20 ref NI_2 NS_20 0 5.3915690641187008e-01
GC_2_21 ref NI_2 NS_21 0 2.9183819725604110e-01
GC_2_22 ref NI_2 NS_22 0 -2.0227908196594493e-02
GC_2_23 ref NI_2 NS_23 0 3.5954274669151604e-04
GC_2_24 ref NI_2 NS_24 0 -4.1644343004110232e-03
GC_2_25 ref NI_2 NS_25 0 4.7245601599412913e-02
GC_2_26 ref NI_2 NS_26 0 1.6339011555064722e-01
GC_2_27 ref NI_2 NS_27 0 2.2260711683502474e-01
GC_2_28 ref NI_2 NS_28 0 2.9859690323074232e-02
GC_2_29 ref NI_2 NS_29 0 3.3573728669639738e-04
GC_2_30 ref NI_2 NS_30 0 -8.8946657329935438e-03
GC_2_31 ref NI_2 NS_31 0 -1.1472055465907140e-01
GC_2_32 ref NI_2 NS_32 0 -3.8065949848279734e-01
GC_2_33 ref NI_2 NS_33 0 2.5622600292901654e-01
GC_2_34 ref NI_2 NS_34 0 1.1918793319012212e-01
GC_2_35 ref NI_2 NS_35 0 3.6339728855980073e-04
GC_2_36 ref NI_2 NS_36 0 -4.5895008808614643e-03
GC_2_37 ref NI_2 NS_37 0 -5.2720903300258393e-01
GC_2_38 ref NI_2 NS_38 0 2.9254527256823069e-02
GC_2_39 ref NI_2 NS_39 0 2.9555229090748114e-01
GC_2_40 ref NI_2 NS_40 0 7.2261623942228903e-02
GC_2_41 ref NI_2 NS_41 0 3.6678092603045407e-04
GC_2_42 ref NI_2 NS_42 0 -9.1655584905157850e-03
GC_2_43 ref NI_2 NS_43 0 -3.4010806718947867e-01
GC_2_44 ref NI_2 NS_44 0 1.2420583702000930e-01
GC_2_45 ref NI_2 NS_45 0 -2.0888550130102237e-01
GC_2_46 ref NI_2 NS_46 0 2.1410703603193412e-01
GC_2_47 ref NI_2 NS_47 0 -3.8922946589189591e-05
GC_2_48 ref NI_2 NS_48 0 1.4179523422784914e-02
GC_2_49 ref NI_2 NS_49 0 -6.8512613943955114e-01
GC_2_50 ref NI_2 NS_50 0 4.4348414202550407e-01
GC_2_51 ref NI_2 NS_51 0 -3.8096346569298717e-01
GC_2_52 ref NI_2 NS_52 0 2.2492631715634556e-01
GC_2_53 ref NI_2 NS_53 0 -3.0155795566612955e-04
GC_2_54 ref NI_2 NS_54 0 2.8430191911627403e-02
GC_2_55 ref NI_2 NS_55 0 -3.9659915841495047e-01
GC_2_56 ref NI_2 NS_56 0 1.6861981884334803e-01
GC_2_57 ref NI_2 NS_57 0 -1.2378786169992320e-01
GC_2_58 ref NI_2 NS_58 0 6.4467312890857567e-02
GC_2_59 ref NI_2 NS_59 0 5.0266236102669776e-04
GC_2_60 ref NI_2 NS_60 0 5.4237074902502520e-02
GC_2_61 ref NI_2 NS_61 0 -4.0573558738039056e-01
GC_2_62 ref NI_2 NS_62 0 1.2064631888364305e-01
GC_2_63 ref NI_2 NS_63 0 -6.4992771961232876e-02
GC_2_64 ref NI_2 NS_64 0 6.7896252716272254e-02
GC_2_65 ref NI_2 NS_65 0 4.9117591795027357e-04
GC_2_66 ref NI_2 NS_66 0 4.5270369221429664e-02
GC_2_67 ref NI_2 NS_67 0 -4.7919278091586842e-01
GC_2_68 ref NI_2 NS_68 0 1.5263244145557053e-01
GC_2_69 ref NI_2 NS_69 0 -1.2146748974270957e-01
GC_2_70 ref NI_2 NS_70 0 1.5747344838660396e-01
GC_2_71 ref NI_2 NS_71 0 1.4726142096094989e-04
GC_2_72 ref NI_2 NS_72 0 1.9890373273750376e-02
GD_2_1 ref NI_2 NA_1 0 5.8590620561641910e-02
GD_2_2 ref NI_2 NA_2 0 5.1828297333651614e+00
GD_2_3 ref NI_2 NA_3 0 1.1062186841766843e-01
GD_2_4 ref NI_2 NA_4 0 1.5284215634667592e-01
GD_2_5 ref NI_2 NA_5 0 1.0304240861439957e-01
GD_2_6 ref NI_2 NA_6 0 6.7356036843722503e-02
GD_2_7 ref NI_2 NA_7 0 7.2440165221244759e-02
GD_2_8 ref NI_2 NA_8 0 7.4995918632782127e-02
GD_2_9 ref NI_2 NA_9 0 1.1112559454589789e-01
GD_2_10 ref NI_2 NA_10 0 7.8341590777468093e-02
GD_2_11 ref NI_2 NA_11 0 8.3137998829812848e-02
GD_2_12 ref NI_2 NA_12 0 9.7636806093789302e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 4.4189903697046012e-01
GC_3_2 ref NI_3 NS_2 0 1.9082772515964697e+00
GC_3_3 ref NI_3 NS_3 0 -1.8303043236334371e-01
GC_3_4 ref NI_3 NS_4 0 -9.7477635670235374e-02
GC_3_5 ref NI_3 NS_5 0 3.4766746599090343e-04
GC_3_6 ref NI_3 NS_6 0 -5.0584421207146932e-03
GC_3_7 ref NI_3 NS_7 0 -4.3644069577801908e-01
GC_3_8 ref NI_3 NS_8 0 6.7702493608093794e-01
GC_3_9 ref NI_3 NS_9 0 8.6790803358239493e-02
GC_3_10 ref NI_3 NS_10 0 1.6957161407441194e-02
GC_3_11 ref NI_3 NS_11 0 4.3086206721948921e-04
GC_3_12 ref NI_3 NS_12 0 -1.8834479524158327e-03
GC_3_13 ref NI_3 NS_13 0 -9.6710336425978882e-01
GC_3_14 ref NI_3 NS_14 0 -8.9337186380297808e+00
GC_3_15 ref NI_3 NS_15 0 1.7777840709407133e-01
GC_3_16 ref NI_3 NS_16 0 -1.4701310970186698e-01
GC_3_17 ref NI_3 NS_17 0 -1.7727603674581635e-03
GC_3_18 ref NI_3 NS_18 0 7.0996643323766344e-04
GC_3_19 ref NI_3 NS_19 0 -5.8304900131337778e-01
GC_3_20 ref NI_3 NS_20 0 1.2224076871075662e+00
GC_3_21 ref NI_3 NS_21 0 -3.0019200934923097e-02
GC_3_22 ref NI_3 NS_22 0 -1.0881248018642087e-02
GC_3_23 ref NI_3 NS_23 0 3.8801697752788392e-04
GC_3_24 ref NI_3 NS_24 0 5.5923070165055265e-03
GC_3_25 ref NI_3 NS_25 0 5.9313099554392901e+00
GC_3_26 ref NI_3 NS_26 0 -1.4221910422535764e+00
GC_3_27 ref NI_3 NS_27 0 -5.4088678474061319e-02
GC_3_28 ref NI_3 NS_28 0 -5.4222349735902807e-02
GC_3_29 ref NI_3 NS_29 0 -1.9907731239070344e-05
GC_3_30 ref NI_3 NS_30 0 2.1806177019647391e-03
GC_3_31 ref NI_3 NS_31 0 -2.7230126911043739e+00
GC_3_32 ref NI_3 NS_32 0 1.7606447213976595e+00
GC_3_33 ref NI_3 NS_33 0 1.3884557329389330e-01
GC_3_34 ref NI_3 NS_34 0 -5.5081415778005016e-02
GC_3_35 ref NI_3 NS_35 0 1.1458150688543881e-04
GC_3_36 ref NI_3 NS_36 0 1.2170577476408559e-02
GC_3_37 ref NI_3 NS_37 0 -4.6750408779281175e-02
GC_3_38 ref NI_3 NS_38 0 1.9636940489353414e+00
GC_3_39 ref NI_3 NS_39 0 -2.9756929147708489e-01
GC_3_40 ref NI_3 NS_40 0 2.8435313850158064e-03
GC_3_41 ref NI_3 NS_41 0 3.9570633878419146e-04
GC_3_42 ref NI_3 NS_42 0 -3.9042335352821983e-03
GC_3_43 ref NI_3 NS_43 0 -1.9625331905579674e-01
GC_3_44 ref NI_3 NS_44 0 -1.0430416198183026e-01
GC_3_45 ref NI_3 NS_45 0 1.5590708498901049e-01
GC_3_46 ref NI_3 NS_46 0 8.5094639234548977e-02
GC_3_47 ref NI_3 NS_47 0 3.6605541223443724e-04
GC_3_48 ref NI_3 NS_48 0 1.5864557896323944e-02
GC_3_49 ref NI_3 NS_49 0 -1.0532450421245262e-01
GC_3_50 ref NI_3 NS_50 0 -6.8514371926992917e-02
GC_3_51 ref NI_3 NS_51 0 -4.4237413367623997e-02
GC_3_52 ref NI_3 NS_52 0 1.5482532467646193e-01
GC_3_53 ref NI_3 NS_53 0 4.5384035529970812e-04
GC_3_54 ref NI_3 NS_54 0 1.8511250805167717e-02
GC_3_55 ref NI_3 NS_55 0 2.5645903222865973e-02
GC_3_56 ref NI_3 NS_56 0 4.8883202326138364e-01
GC_3_57 ref NI_3 NS_57 0 9.6737499862474388e-02
GC_3_58 ref NI_3 NS_58 0 6.3199984791820277e-02
GC_3_59 ref NI_3 NS_59 0 -2.3052928898479488e-04
GC_3_60 ref NI_3 NS_60 0 -7.5471871989527869e-03
GC_3_61 ref NI_3 NS_61 0 2.3050154776765752e-01
GC_3_62 ref NI_3 NS_62 0 1.0002841479249998e+00
GC_3_63 ref NI_3 NS_63 0 -9.1772648995564532e-02
GC_3_64 ref NI_3 NS_64 0 4.5446866777931264e-02
GC_3_65 ref NI_3 NS_65 0 -2.4870037282014051e-04
GC_3_66 ref NI_3 NS_66 0 -9.7979995064848106e-03
GC_3_67 ref NI_3 NS_67 0 5.1817292706128770e-01
GC_3_68 ref NI_3 NS_68 0 9.4093419401175971e-01
GC_3_69 ref NI_3 NS_69 0 1.2147716366396413e-01
GC_3_70 ref NI_3 NS_70 0 -2.2007410344538555e-02
GC_3_71 ref NI_3 NS_71 0 -2.8292843886689514e-04
GC_3_72 ref NI_3 NS_72 0 -2.4419270786887472e-02
GD_3_1 ref NI_3 NA_1 0 -6.6434091081576038e-02
GD_3_2 ref NI_3 NA_2 0 1.1062186841766843e-01
GD_3_3 ref NI_3 NA_3 0 5.6066785757544455e+00
GD_3_4 ref NI_3 NA_4 0 2.2903292734266441e-02
GD_3_5 ref NI_3 NA_5 0 9.3732909444003656e-02
GD_3_6 ref NI_3 NA_6 0 2.1287815112722283e-01
GD_3_7 ref NI_3 NA_7 0 -2.7521028668478870e-01
GD_3_8 ref NI_3 NA_8 0 3.6201857417163079e-02
GD_3_9 ref NI_3 NA_9 0 3.1980977313877217e-02
GD_3_10 ref NI_3 NA_10 0 2.2858755269967678e-02
GD_3_11 ref NI_3 NA_11 0 8.9437582989835632e-03
GD_3_12 ref NI_3 NA_12 0 -3.1715776272659126e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 -5.7371929972688984e-01
GC_4_2 ref NI_4 NS_2 0 7.8077233723974515e-02
GC_4_3 ref NI_4 NS_3 0 4.9414497922069761e-01
GC_4_4 ref NI_4 NS_4 0 -2.9069840714441450e-02
GC_4_5 ref NI_4 NS_5 0 2.4657033088605406e-04
GC_4_6 ref NI_4 NS_6 0 -1.1968023401124921e-03
GC_4_7 ref NI_4 NS_7 0 -7.8431550406053763e-01
GC_4_8 ref NI_4 NS_8 0 5.3915690641186975e-01
GC_4_9 ref NI_4 NS_9 0 2.9183819725604154e-01
GC_4_10 ref NI_4 NS_10 0 -2.0227908196594861e-02
GC_4_11 ref NI_4 NS_11 0 3.5954274669146552e-04
GC_4_12 ref NI_4 NS_12 0 -4.1644343004108419e-03
GC_4_13 ref NI_4 NS_13 0 -5.8304900131337789e-01
GC_4_14 ref NI_4 NS_14 0 1.2224076871075664e+00
GC_4_15 ref NI_4 NS_15 0 -3.0019200934923392e-02
GC_4_16 ref NI_4 NS_16 0 -1.0881248018641848e-02
GC_4_17 ref NI_4 NS_17 0 3.8801697752791612e-04
GC_4_18 ref NI_4 NS_18 0 5.5923070165054102e-03
GC_4_19 ref NI_4 NS_19 0 5.5208817399605463e+00
GC_4_20 ref NI_4 NS_20 0 -5.8207791078593321e+00
GC_4_21 ref NI_4 NS_21 0 -2.0366481769051292e+00
GC_4_22 ref NI_4 NS_22 0 -5.7263959460757234e-02
GC_4_23 ref NI_4 NS_23 0 -2.6734897752882856e-03
GC_4_24 ref NI_4 NS_24 0 -5.0645563883366176e-02
GC_4_25 ref NI_4 NS_25 0 1.9124823680705425e+00
GC_4_26 ref NI_4 NS_26 0 4.3403405733208739e-01
GC_4_27 ref NI_4 NS_27 0 2.1396666412295443e-02
GC_4_28 ref NI_4 NS_28 0 -7.0771132321544514e-02
GC_4_29 ref NI_4 NS_29 0 -2.6897037045675777e-04
GC_4_30 ref NI_4 NS_30 0 -4.9001205925265851e-03
GC_4_31 ref NI_4 NS_31 0 -1.5413946342853291e+00
GC_4_32 ref NI_4 NS_32 0 1.0843742786377915e+00
GC_4_33 ref NI_4 NS_33 0 5.0725639080880969e-01
GC_4_34 ref NI_4 NS_34 0 -1.2305123929280255e-01
GC_4_35 ref NI_4 NS_35 0 -4.1833097899727795e-04
GC_4_36 ref NI_4 NS_36 0 -5.1444729952130550e-03
GC_4_37 ref NI_4 NS_37 0 -2.0785182028180973e+00
GC_4_38 ref NI_4 NS_38 0 1.8790380161971323e+00
GC_4_39 ref NI_4 NS_39 0 2.4044008715314258e-01
GC_4_40 ref NI_4 NS_40 0 -9.6097079144237749e-02
GC_4_41 ref NI_4 NS_41 0 -1.6516137875323799e-04
GC_4_42 ref NI_4 NS_42 0 -4.7351695640179955e-03
GC_4_43 ref NI_4 NS_43 0 -2.9418760081217699e-01
GC_4_44 ref NI_4 NS_44 0 4.8446413812326444e-01
GC_4_45 ref NI_4 NS_45 0 3.1685936722461711e-01
GC_4_46 ref NI_4 NS_46 0 4.1170416194428988e-02
GC_4_47 ref NI_4 NS_47 0 -3.8888996741462682e-04
GC_4_48 ref NI_4 NS_48 0 -2.7978106501774649e-02
GC_4_49 ref NI_4 NS_49 0 8.4260574908772007e-02
GC_4_50 ref NI_4 NS_50 0 -8.4778220928690182e-02
GC_4_51 ref NI_4 NS_51 0 2.5430987547400541e-01
GC_4_52 ref NI_4 NS_52 0 1.6621246345983118e-01
GC_4_53 ref NI_4 NS_53 0 -1.8528845672030907e-04
GC_4_54 ref NI_4 NS_54 0 -3.7347278245788630e-02
GC_4_55 ref NI_4 NS_55 0 -2.0808349285659114e-01
GC_4_56 ref NI_4 NS_56 0 1.7994966353297896e-02
GC_4_57 ref NI_4 NS_57 0 -4.5642219810203548e-02
GC_4_58 ref NI_4 NS_58 0 4.2444253211297349e-02
GC_4_59 ref NI_4 NS_59 0 1.2962118385381422e-03
GC_4_60 ref NI_4 NS_60 0 5.5700908863060429e-02
GC_4_61 ref NI_4 NS_61 0 -2.7341680401399499e-01
GC_4_62 ref NI_4 NS_62 0 -8.8732314785505452e-03
GC_4_63 ref NI_4 NS_63 0 2.5291794268731453e-02
GC_4_64 ref NI_4 NS_64 0 3.7455334482253737e-02
GC_4_65 ref NI_4 NS_65 0 1.1881297718031260e-03
GC_4_66 ref NI_4 NS_66 0 4.8361744097183058e-02
GC_4_67 ref NI_4 NS_67 0 -3.1792458347583885e-01
GC_4_68 ref NI_4 NS_68 0 -3.6861410877000178e-03
GC_4_69 ref NI_4 NS_69 0 -1.1686172178644674e-02
GC_4_70 ref NI_4 NS_70 0 1.1389034872806945e-01
GC_4_71 ref NI_4 NS_71 0 6.1344292648439307e-04
GC_4_72 ref NI_4 NS_72 0 2.7252048426446761e-02
GD_4_1 ref NI_4 NA_1 0 8.2599829655768855e-02
GD_4_2 ref NI_4 NA_2 0 1.5284215634667592e-01
GD_4_3 ref NI_4 NA_3 0 2.2903292734266441e-02
GD_4_4 ref NI_4 NA_4 0 5.2561327354074310e+00
GD_4_5 ref NI_4 NA_5 0 1.1382193269895491e-01
GD_4_6 ref NI_4 NA_6 0 1.4309712308400038e-01
GD_4_7 ref NI_4 NA_7 0 6.0587825610467237e-02
GD_4_8 ref NI_4 NA_8 0 2.9009499682487550e-02
GD_4_9 ref NI_4 NA_9 0 4.5847019131320449e-03
GD_4_10 ref NI_4 NA_10 0 4.9137365749816649e-02
GD_4_11 ref NI_4 NA_11 0 5.9133401709791367e-02
GD_4_12 ref NI_4 NA_12 0 6.7503035242115345e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 5.6055193687792548e-01
GC_5_2 ref NI_5 NS_2 0 5.8890287628477445e-01
GC_5_3 ref NI_5 NS_3 0 3.0177574685512149e-01
GC_5_4 ref NI_5 NS_4 0 -1.1379885137141474e-01
GC_5_5 ref NI_5 NS_5 0 -9.5336688990180145e-05
GC_5_6 ref NI_5 NS_6 0 -2.6505760536922373e-03
GC_5_7 ref NI_5 NS_7 0 4.7245601599413101e-02
GC_5_8 ref NI_5 NS_8 0 1.6339011555064686e-01
GC_5_9 ref NI_5 NS_9 0 2.2260711683502515e-01
GC_5_10 ref NI_5 NS_10 0 2.9859690323073871e-02
GC_5_11 ref NI_5 NS_11 0 3.3573728669634691e-04
GC_5_12 ref NI_5 NS_12 0 -8.8946657329933652e-03
GC_5_13 ref NI_5 NS_13 0 5.9313099554392901e+00
GC_5_14 ref NI_5 NS_14 0 -1.4221910422535768e+00
GC_5_15 ref NI_5 NS_15 0 -5.4088678474060958e-02
GC_5_16 ref NI_5 NS_16 0 -5.4222349735903126e-02
GC_5_17 ref NI_5 NS_17 0 -1.9907731239115697e-05
GC_5_18 ref NI_5 NS_18 0 2.1806177019648965e-03
GC_5_19 ref NI_5 NS_19 0 1.9124823680705425e+00
GC_5_20 ref NI_5 NS_20 0 4.3403405733208766e-01
GC_5_21 ref NI_5 NS_21 0 2.1396666412295141e-02
GC_5_22 ref NI_5 NS_22 0 -7.0771132321544264e-02
GC_5_23 ref NI_5 NS_23 0 -2.6897037045672573e-04
GC_5_24 ref NI_5 NS_24 0 -4.9001205925266978e-03
GC_5_25 ref NI_5 NS_25 0 -1.5912804561343286e+01
GC_5_26 ref NI_5 NS_26 0 -2.9008141272974886e-01
GC_5_27 ref NI_5 NS_27 0 -3.0521718878444015e-01
GC_5_28 ref NI_5 NS_28 0 -7.3534941474961008e-02
GC_5_29 ref NI_5 NS_29 0 -9.2697275431626459e-04
GC_5_30 ref NI_5 NS_30 0 -1.2289205607379778e-02
GC_5_31 ref NI_5 NS_31 0 9.0349072062858116e-01
GC_5_32 ref NI_5 NS_32 0 2.1059470385825638e+00
GC_5_33 ref NI_5 NS_33 0 -4.2587789087405620e-01
GC_5_34 ref NI_5 NS_34 0 -5.6938616732450646e-02
GC_5_35 ref NI_5 NS_35 0 -2.1403374167858869e-04
GC_5_36 ref NI_5 NS_36 0 -1.1499530369969174e-02
GC_5_37 ref NI_5 NS_37 0 1.0801866674269723e+01
GC_5_38 ref NI_5 NS_38 0 -3.0417395570144716e+00
GC_5_39 ref NI_5 NS_39 0 -1.4686710548682555e-01
GC_5_40 ref NI_5 NS_40 0 -1.4618861916785705e-01
GC_5_41 ref NI_5 NS_41 0 -8.6705542349892997e-04
GC_5_42 ref NI_5 NS_42 0 -3.3889214857778021e-03
GC_5_43 ref NI_5 NS_43 0 1.0184158053017658e-01
GC_5_44 ref NI_5 NS_44 0 -3.1712844142238246e-02
GC_5_45 ref NI_5 NS_45 0 3.2643452131801176e-01
GC_5_46 ref NI_5 NS_46 0 5.2318243236041326e-02
GC_5_47 ref NI_5 NS_47 0 -2.1062289539350949e-04
GC_5_48 ref NI_5 NS_48 0 -1.2207231823993489e-02
GC_5_49 ref NI_5 NS_49 0 2.8760248419387108e-01
GC_5_50 ref NI_5 NS_50 0 -2.7594311138835992e-01
GC_5_51 ref NI_5 NS_51 0 1.6044415058808023e-01
GC_5_52 ref NI_5 NS_52 0 1.7522165210218768e-01
GC_5_53 ref NI_5 NS_53 0 -1.1327816838979315e-05
GC_5_54 ref NI_5 NS_54 0 -1.8391238708194250e-02
GC_5_55 ref NI_5 NS_55 0 -3.1872103740370455e-01
GC_5_56 ref NI_5 NS_56 0 1.3741312236547754e-01
GC_5_57 ref NI_5 NS_57 0 -6.6322679576211558e-03
GC_5_58 ref NI_5 NS_58 0 6.6517833871733406e-02
GC_5_59 ref NI_5 NS_59 0 8.4730361113054904e-04
GC_5_60 ref NI_5 NS_60 0 3.7049386746445256e-02
GC_5_61 ref NI_5 NS_61 0 -4.9205030165116032e-01
GC_5_62 ref NI_5 NS_62 0 2.9347144795769115e-01
GC_5_63 ref NI_5 NS_63 0 2.7029016143928945e-02
GC_5_64 ref NI_5 NS_64 0 4.9682884791749420e-02
GC_5_65 ref NI_5 NS_65 0 7.7463048102916399e-04
GC_5_66 ref NI_5 NS_66 0 3.1514701453481078e-02
GC_5_67 ref NI_5 NS_67 0 -4.6816835621047143e-01
GC_5_68 ref NI_5 NS_68 0 2.6417299171477943e-01
GC_5_69 ref NI_5 NS_69 0 5.8012482035592929e-02
GC_5_70 ref NI_5 NS_70 0 9.7113322159686363e-02
GC_5_71 ref NI_5 NS_71 0 4.2712641319334667e-04
GC_5_72 ref NI_5 NS_72 0 9.7697883631082862e-03
GD_5_1 ref NI_5 NA_1 0 5.1367225602411436e-02
GD_5_2 ref NI_5 NA_2 0 1.0304240861439957e-01
GD_5_3 ref NI_5 NA_3 0 9.3732909444003656e-02
GD_5_4 ref NI_5 NA_4 0 1.1382193269895491e-01
GD_5_5 ref NI_5 NA_5 0 4.5672261118796103e+00
GD_5_6 ref NI_5 NA_6 0 -6.2149510529826233e-03
GD_5_7 ref NI_5 NA_7 0 4.2804501459485877e-01
GD_5_8 ref NI_5 NA_8 0 4.4031531679603497e-02
GD_5_9 ref NI_5 NA_9 0 8.1969135802982280e-03
GD_5_10 ref NI_5 NA_10 0 4.1544026973363443e-02
GD_5_11 ref NI_5 NA_11 0 4.8395099987163341e-02
GD_5_12 ref NI_5 NA_12 0 4.1830999351424918e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -3.8487425734460373e-01
GC_6_2 ref NI_6 NS_2 0 -5.3409676937429562e-01
GC_6_3 ref NI_6 NS_3 0 7.3753871225998469e-01
GC_6_4 ref NI_6 NS_4 0 -4.8829426848711048e-02
GC_6_5 ref NI_6 NS_5 0 2.3629910443676420e-04
GC_6_6 ref NI_6 NS_6 0 -4.2232586716440781e-04
GC_6_7 ref NI_6 NS_7 0 -1.1472055465907131e-01
GC_6_8 ref NI_6 NS_8 0 -3.8065949848279745e-01
GC_6_9 ref NI_6 NS_9 0 2.5622600292901676e-01
GC_6_10 ref NI_6 NS_10 0 1.1918793319012204e-01
GC_6_11 ref NI_6 NS_11 0 3.6339728855978653e-04
GC_6_12 ref NI_6 NS_12 0 -4.5895008808614106e-03
GC_6_13 ref NI_6 NS_13 0 -2.7230126911043739e+00
GC_6_14 ref NI_6 NS_14 0 1.7606447213976595e+00
GC_6_15 ref NI_6 NS_15 0 1.3884557329389319e-01
GC_6_16 ref NI_6 NS_16 0 -5.5081415778004919e-02
GC_6_17 ref NI_6 NS_17 0 1.1458150688545251e-04
GC_6_18 ref NI_6 NS_18 0 1.2170577476408508e-02
GC_6_19 ref NI_6 NS_19 0 -1.5413946342853291e+00
GC_6_20 ref NI_6 NS_20 0 1.0843742786377915e+00
GC_6_21 ref NI_6 NS_21 0 5.0725639080880947e-01
GC_6_22 ref NI_6 NS_22 0 -1.2305123929280251e-01
GC_6_23 ref NI_6 NS_23 0 -4.1833097899727356e-04
GC_6_24 ref NI_6 NS_24 0 -5.1444729952130688e-03
GC_6_25 ref NI_6 NS_25 0 9.0349072062858149e-01
GC_6_26 ref NI_6 NS_26 0 2.1059470385825634e+00
GC_6_27 ref NI_6 NS_27 0 -4.2587789087405542e-01
GC_6_28 ref NI_6 NS_28 0 -5.6938616732451257e-02
GC_6_29 ref NI_6 NS_29 0 -2.1403374167867133e-04
GC_6_30 ref NI_6 NS_30 0 -1.1499530369968881e-02
GC_6_31 ref NI_6 NS_31 0 2.5150444855340135e+00
GC_6_32 ref NI_6 NS_32 0 -7.2755838131291259e+00
GC_6_33 ref NI_6 NS_33 0 -9.1303721320823783e-01
GC_6_34 ref NI_6 NS_34 0 -1.5265795506475807e-01
GC_6_35 ref NI_6 NS_35 0 -2.0780401498986011e-03
GC_6_36 ref NI_6 NS_36 0 -2.6311322711006949e-02
GC_6_37 ref NI_6 NS_37 0 2.0022761462033145e+00
GC_6_38 ref NI_6 NS_38 0 3.0542220348226032e+00
GC_6_39 ref NI_6 NS_39 0 -9.6320772912190800e-01
GC_6_40 ref NI_6 NS_40 0 -4.2632953192574312e-02
GC_6_41 ref NI_6 NS_41 0 -1.8413895385817580e-04
GC_6_42 ref NI_6 NS_42 0 -2.0511436989449249e-02
GC_6_43 ref NI_6 NS_43 0 5.9192730868298557e-02
GC_6_44 ref NI_6 NS_44 0 6.8611290412467729e-01
GC_6_45 ref NI_6 NS_45 0 3.5320258825922607e-01
GC_6_46 ref NI_6 NS_46 0 -8.4964167368064576e-03
GC_6_47 ref NI_6 NS_47 0 -3.2793123611681290e-04
GC_6_48 ref NI_6 NS_48 0 -3.5013575304465139e-02
GC_6_49 ref NI_6 NS_49 0 4.4937483604250184e-01
GC_6_50 ref NI_6 NS_50 0 -2.4675830499704746e-01
GC_6_51 ref NI_6 NS_51 0 4.0904611923318873e-01
GC_6_52 ref NI_6 NS_52 0 1.3595698073825493e-01
GC_6_53 ref NI_6 NS_53 0 2.5782205723891350e-05
GC_6_54 ref NI_6 NS_54 0 -4.8486645252352821e-02
GC_6_55 ref NI_6 NS_55 0 -5.6065515860717639e-02
GC_6_56 ref NI_6 NS_56 0 -7.4978366406286287e-02
GC_6_57 ref NI_6 NS_57 0 -5.6893111568766641e-02
GC_6_58 ref NI_6 NS_58 0 4.4692822484668847e-02
GC_6_59 ref NI_6 NS_59 0 1.0545137545218772e-03
GC_6_60 ref NI_6 NS_60 0 5.9648032672351990e-02
GC_6_61 ref NI_6 NS_61 0 -1.3763562329071709e-02
GC_6_62 ref NI_6 NS_62 0 -2.0691957823310811e-01
GC_6_63 ref NI_6 NS_63 0 4.2858743738226103e-02
GC_6_64 ref NI_6 NS_64 0 3.8436678654011111e-02
GC_6_65 ref NI_6 NS_65 0 9.5914064960487308e-04
GC_6_66 ref NI_6 NS_66 0 5.2068195347556606e-02
GC_6_67 ref NI_6 NS_67 0 -3.8218295195277037e-02
GC_6_68 ref NI_6 NS_68 0 -1.8597177870794060e-01
GC_6_69 ref NI_6 NS_69 0 -5.1823202829110154e-02
GC_6_70 ref NI_6 NS_70 0 1.4052495632741743e-01
GC_6_71 ref NI_6 NS_71 0 4.6286588963798049e-04
GC_6_72 ref NI_6 NS_72 0 2.9095702914699068e-02
GD_6_1 ref NI_6 NA_1 0 8.9506270457763631e-02
GD_6_2 ref NI_6 NA_2 0 6.7356036843722503e-02
GD_6_3 ref NI_6 NA_3 0 2.1287815112722283e-01
GD_6_4 ref NI_6 NA_4 0 1.4309712308400038e-01
GD_6_5 ref NI_6 NA_5 0 -6.2149510529826233e-03
GD_6_6 ref NI_6 NA_6 0 5.5076093229545702e+00
GD_6_7 ref NI_6 NA_7 0 -7.7057955736506714e-02
GD_6_8 ref NI_6 NA_8 0 -3.0538178772570309e-02
GD_6_9 ref NI_6 NA_9 0 -4.9780980602911556e-02
GD_6_10 ref NI_6 NA_10 0 3.5913358725211869e-02
GD_6_11 ref NI_6 NA_11 0 3.9331483985361883e-02
GD_6_12 ref NI_6 NA_12 0 4.5825016562476499e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -1.2767041878847158e+00
GC_7_2 ref NI_7 NS_2 0 6.2573575551994653e-01
GC_7_3 ref NI_7 NS_3 0 5.9250650266303373e-01
GC_7_4 ref NI_7 NS_4 0 -1.0856703257092629e-01
GC_7_5 ref NI_7 NS_5 0 3.3465927806501900e-05
GC_7_6 ref NI_7 NS_6 0 -2.3229095952297090e-03
GC_7_7 ref NI_7 NS_7 0 -5.2720903300258348e-01
GC_7_8 ref NI_7 NS_8 0 2.9254527256822087e-02
GC_7_9 ref NI_7 NS_9 0 2.9555229090748214e-01
GC_7_10 ref NI_7 NS_10 0 7.2261623942228057e-02
GC_7_11 ref NI_7 NS_11 0 3.6678092603033920e-04
GC_7_12 ref NI_7 NS_12 0 -9.1655584905153756e-03
GC_7_13 ref NI_7 NS_13 0 -4.6750408779280953e-02
GC_7_14 ref NI_7 NS_14 0 1.9636940489353407e+00
GC_7_15 ref NI_7 NS_15 0 -2.9756929147708444e-01
GC_7_16 ref NI_7 NS_16 0 2.8435313850154399e-03
GC_7_17 ref NI_7 NS_17 0 3.9570633878414105e-04
GC_7_18 ref NI_7 NS_18 0 -3.9042335352820188e-03
GC_7_19 ref NI_7 NS_19 0 -2.0785182028180968e+00
GC_7_20 ref NI_7 NS_20 0 1.8790380161971314e+00
GC_7_21 ref NI_7 NS_21 0 2.4044008715314313e-01
GC_7_22 ref NI_7 NS_22 0 -9.6097079144238207e-02
GC_7_23 ref NI_7 NS_23 0 -1.6516137875330233e-04
GC_7_24 ref NI_7 NS_24 0 -4.7351695640177674e-03
GC_7_25 ref NI_7 NS_25 0 1.0801866674269723e+01
GC_7_26 ref NI_7 NS_26 0 -3.0417395570144721e+00
GC_7_27 ref NI_7 NS_27 0 -1.4686710548682511e-01
GC_7_28 ref NI_7 NS_28 0 -1.4618861916785739e-01
GC_7_29 ref NI_7 NS_29 0 -8.6705542349897594e-04
GC_7_30 ref NI_7 NS_30 0 -3.3889214857776356e-03
GC_7_31 ref NI_7 NS_31 0 2.0022761462033145e+00
GC_7_32 ref NI_7 NS_32 0 3.0542220348226023e+00
GC_7_33 ref NI_7 NS_33 0 -9.6320772912190789e-01
GC_7_34 ref NI_7 NS_34 0 -4.2632953192574374e-02
GC_7_35 ref NI_7 NS_35 0 -1.8413895385818504e-04
GC_7_36 ref NI_7 NS_36 0 -2.0511436989449211e-02
GC_7_37 ref NI_7 NS_37 0 -5.4286817377059302e+00
GC_7_38 ref NI_7 NS_38 0 -4.5244571755275880e+00
GC_7_39 ref NI_7 NS_39 0 -5.0693161828268185e-01
GC_7_40 ref NI_7 NS_40 0 -1.7743989863927961e-01
GC_7_41 ref NI_7 NS_41 0 -1.6596089962036512e-03
GC_7_42 ref NI_7 NS_42 0 -1.2749269887141956e-02
GC_7_43 ref NI_7 NS_43 0 -7.9830198221811088e-01
GC_7_44 ref NI_7 NS_44 0 1.0416006692812381e-01
GC_7_45 ref NI_7 NS_45 0 4.7327803733698692e-01
GC_7_46 ref NI_7 NS_46 0 4.4921001476134523e-02
GC_7_47 ref NI_7 NS_47 0 -1.4853171245768592e-04
GC_7_48 ref NI_7 NS_48 0 -1.7323316594228890e-02
GC_7_49 ref NI_7 NS_49 0 7.2735881538781369e-02
GC_7_50 ref NI_7 NS_50 0 -3.9205942344472439e-01
GC_7_51 ref NI_7 NS_51 0 2.2967008507381145e-01
GC_7_52 ref NI_7 NS_52 0 2.0478193302009629e-01
GC_7_53 ref NI_7 NS_53 0 1.8747034448242036e-04
GC_7_54 ref NI_7 NS_54 0 -2.7411696254648964e-02
GC_7_55 ref NI_7 NS_55 0 -2.6518173331900835e-01
GC_7_56 ref NI_7 NS_56 0 -8.1306718622865433e-03
GC_7_57 ref NI_7 NS_57 0 -1.9017254157168890e-02
GC_7_58 ref NI_7 NS_58 0 6.7777503733978048e-02
GC_7_59 ref NI_7 NS_59 0 8.6894866064006146e-04
GC_7_60 ref NI_7 NS_60 0 4.5930288262324682e-02
GC_7_61 ref NI_7 NS_61 0 -4.5847926622860985e-01
GC_7_62 ref NI_7 NS_62 0 2.1847494859406597e-02
GC_7_63 ref NI_7 NS_63 0 7.1979498797724945e-02
GC_7_64 ref NI_7 NS_64 0 4.8407443794780049e-02
GC_7_65 ref NI_7 NS_65 0 7.7587644118492149e-04
GC_7_66 ref NI_7 NS_66 0 3.9996756652766696e-02
GC_7_67 ref NI_7 NS_67 0 -4.6902541713441348e-01
GC_7_68 ref NI_7 NS_68 0 -1.6320144253663453e-02
GC_7_69 ref NI_7 NS_69 0 6.4596696228034114e-02
GC_7_70 ref NI_7 NS_70 0 1.2066822497642163e-01
GC_7_71 ref NI_7 NS_71 0 3.9549530959612586e-04
GC_7_72 ref NI_7 NS_72 0 1.6636736255099829e-02
GD_7_1 ref NI_7 NA_1 0 7.4217560307404729e-02
GD_7_2 ref NI_7 NA_2 0 7.2440165221244759e-02
GD_7_3 ref NI_7 NA_3 0 -2.7521028668478870e-01
GD_7_4 ref NI_7 NA_4 0 6.0587825610467237e-02
GD_7_5 ref NI_7 NA_5 0 4.2804501459485877e-01
GD_7_6 ref NI_7 NA_6 0 -7.7057955736506714e-02
GD_7_7 ref NI_7 NA_7 0 5.2888833699016757e+00
GD_7_8 ref NI_7 NA_8 0 6.3375365476518675e-02
GD_7_9 ref NI_7 NA_9 0 -6.8049481814655356e-04
GD_7_10 ref NI_7 NA_10 0 5.4446440197383011e-02
GD_7_11 ref NI_7 NA_11 0 7.6088600823041017e-02
GD_7_12 ref NI_7 NA_12 0 7.8224968166934805e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 1.6961367978700223e-01
GC_8_2 ref NI_8 NS_2 0 -2.6872557080612391e-01
GC_8_3 ref NI_8 NS_3 0 -3.0172906335568340e-02
GC_8_4 ref NI_8 NS_4 0 2.1228869965409627e-01
GC_8_5 ref NI_8 NS_5 0 5.4132789000583593e-04
GC_8_6 ref NI_8 NS_6 0 1.1283833207381718e-04
GC_8_7 ref NI_8 NS_7 0 -3.4010806718947839e-01
GC_8_8 ref NI_8 NS_8 0 1.2420583702000873e-01
GC_8_9 ref NI_8 NS_9 0 -2.0888550130102176e-01
GC_8_10 ref NI_8 NS_10 0 2.1410703603193360e-01
GC_8_11 ref NI_8 NS_11 0 -3.8922946589258526e-05
GC_8_12 ref NI_8 NS_12 0 1.4179523422785155e-02
GC_8_13 ref NI_8 NS_13 0 -1.9625331905579677e-01
GC_8_14 ref NI_8 NS_14 0 -1.0430416198183025e-01
GC_8_15 ref NI_8 NS_15 0 1.5590708498901049e-01
GC_8_16 ref NI_8 NS_16 0 8.5094639234549019e-02
GC_8_17 ref NI_8 NS_17 0 3.6605541223444184e-04
GC_8_18 ref NI_8 NS_18 0 1.5864557896323930e-02
GC_8_19 ref NI_8 NS_19 0 -2.9418760081217682e-01
GC_8_20 ref NI_8 NS_20 0 4.8446413812326428e-01
GC_8_21 ref NI_8 NS_21 0 3.1685936722461727e-01
GC_8_22 ref NI_8 NS_22 0 4.1170416194428815e-02
GC_8_23 ref NI_8 NS_23 0 -3.8888996741464981e-04
GC_8_24 ref NI_8 NS_24 0 -2.7978106501774572e-02
GC_8_25 ref NI_8 NS_25 0 1.0184158053017647e-01
GC_8_26 ref NI_8 NS_26 0 -3.1712844142238031e-02
GC_8_27 ref NI_8 NS_27 0 3.2643452131801159e-01
GC_8_28 ref NI_8 NS_28 0 5.2318243236041548e-02
GC_8_29 ref NI_8 NS_29 0 -2.1062289539347770e-04
GC_8_30 ref NI_8 NS_30 0 -1.2207231823993600e-02
GC_8_31 ref NI_8 NS_31 0 5.9192730868298328e-02
GC_8_32 ref NI_8 NS_32 0 6.8611290412467763e-01
GC_8_33 ref NI_8 NS_33 0 3.5320258825922557e-01
GC_8_34 ref NI_8 NS_34 0 -8.4964167368060586e-03
GC_8_35 ref NI_8 NS_35 0 -3.2793123611675793e-04
GC_8_36 ref NI_8 NS_36 0 -3.5013575304465326e-02
GC_8_37 ref NI_8 NS_37 0 -7.9830198221811155e-01
GC_8_38 ref NI_8 NS_38 0 1.0416006692812484e-01
GC_8_39 ref NI_8 NS_39 0 4.7327803733698570e-01
GC_8_40 ref NI_8 NS_40 0 4.4921001476135418e-02
GC_8_41 ref NI_8 NS_41 0 -1.4853171245756230e-04
GC_8_42 ref NI_8 NS_42 0 -1.7323316594229324e-02
GC_8_43 ref NI_8 NS_43 0 3.4071197419019490e+00
GC_8_44 ref NI_8 NS_44 0 -2.6753527758475624e+00
GC_8_45 ref NI_8 NS_45 0 -2.5240420615841219e+00
GC_8_46 ref NI_8 NS_46 0 -1.9836599037740399e-01
GC_8_47 ref NI_8 NS_47 0 -1.6602087622273425e-03
GC_8_48 ref NI_8 NS_48 0 -9.9765608140188353e-02
GC_8_49 ref NI_8 NS_49 0 -1.0271237262692436e+00
GC_8_50 ref NI_8 NS_50 0 1.1809619285355963e+00
GC_8_51 ref NI_8 NS_51 0 1.5112393825402386e+00
GC_8_52 ref NI_8 NS_52 0 -4.1340459579220673e-01
GC_8_53 ref NI_8 NS_53 0 -8.0213171966398550e-04
GC_8_54 ref NI_8 NS_54 0 -8.9935549660905903e-02
GC_8_55 ref NI_8 NS_55 0 -1.5772025349089813e-01
GC_8_56 ref NI_8 NS_56 0 8.4833887414991080e-02
GC_8_57 ref NI_8 NS_57 0 -5.4549588761162573e-02
GC_8_58 ref NI_8 NS_58 0 -7.0216094011042701e-02
GC_8_59 ref NI_8 NS_59 0 1.2867858576105626e-03
GC_8_60 ref NI_8 NS_60 0 9.6906365477082090e-02
GC_8_61 ref NI_8 NS_61 0 -1.1008578912180847e-01
GC_8_62 ref NI_8 NS_62 0 4.1522928050632381e-02
GC_8_63 ref NI_8 NS_63 0 -6.6563171040599764e-02
GC_8_64 ref NI_8 NS_64 0 -3.1714827108859207e-02
GC_8_65 ref NI_8 NS_65 0 1.1865873209158568e-03
GC_8_66 ref NI_8 NS_66 0 8.5412388769700850e-02
GC_8_67 ref NI_8 NS_67 0 -4.3604030041008723e-01
GC_8_68 ref NI_8 NS_68 0 2.8971970177503492e-01
GC_8_69 ref NI_8 NS_69 0 -2.4157731137326105e-01
GC_8_70 ref NI_8 NS_70 0 7.2800548693856285e-02
GC_8_71 ref NI_8 NS_71 0 2.3534543311966679e-04
GC_8_72 ref NI_8 NS_72 0 6.9596662198907866e-02
GD_8_1 ref NI_8 NA_1 0 1.2322485905214954e-02
GD_8_2 ref NI_8 NA_2 0 7.4995918632782127e-02
GD_8_3 ref NI_8 NA_3 0 3.6201857417163079e-02
GD_8_4 ref NI_8 NA_4 0 2.9009499682487550e-02
GD_8_5 ref NI_8 NA_5 0 4.4031531679603497e-02
GD_8_6 ref NI_8 NA_6 0 -3.0538178772570309e-02
GD_8_7 ref NI_8 NA_7 0 6.3375365476518675e-02
GD_8_8 ref NI_8 NA_8 0 5.7106933299078815e+00
GD_8_9 ref NI_8 NA_9 0 1.1953898910527308e-01
GD_8_10 ref NI_8 NA_10 0 3.3822153861260418e-02
GD_8_11 ref NI_8 NA_11 0 3.0466907149253646e-02
GD_8_12 ref NI_8 NA_12 0 7.0994206727547179e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -2.8876162800437172e-01
GC_9_2 ref NI_9 NS_2 0 1.6995208339338783e-01
GC_9_3 ref NI_9 NS_3 0 -3.1700208031426341e-01
GC_9_4 ref NI_9 NS_4 0 2.7672932080609236e-01
GC_9_5 ref NI_9 NS_5 0 3.9815838423024839e-04
GC_9_6 ref NI_9 NS_6 0 7.1229548109519618e-03
GC_9_7 ref NI_9 NS_7 0 -6.8512613943955092e-01
GC_9_8 ref NI_9 NS_8 0 4.4348414202550346e-01
GC_9_9 ref NI_9 NS_9 0 -3.8096346569298656e-01
GC_9_10 ref NI_9 NS_10 0 2.2492631715634503e-01
GC_9_11 ref NI_9 NS_11 0 -3.0155795566619856e-04
GC_9_12 ref NI_9 NS_12 0 2.8430191911627656e-02
GC_9_13 ref NI_9 NS_13 0 -1.0532450421245246e-01
GC_9_14 ref NI_9 NS_14 0 -6.8514371926993251e-02
GC_9_15 ref NI_9 NS_15 0 -4.4237413367623678e-02
GC_9_16 ref NI_9 NS_16 0 1.5482532467646165e-01
GC_9_17 ref NI_9 NS_17 0 4.5384035529967147e-04
GC_9_18 ref NI_9 NS_18 0 1.8511250805167852e-02
GC_9_19 ref NI_9 NS_19 0 8.4260574908771854e-02
GC_9_20 ref NI_9 NS_20 0 -8.4778220928689904e-02
GC_9_21 ref NI_9 NS_21 0 2.5430987547400513e-01
GC_9_22 ref NI_9 NS_22 0 1.6621246345983143e-01
GC_9_23 ref NI_9 NS_23 0 -1.8528845672027274e-04
GC_9_24 ref NI_9 NS_24 0 -3.7347278245788755e-02
GC_9_25 ref NI_9 NS_25 0 2.8760248419387141e-01
GC_9_26 ref NI_9 NS_26 0 -2.7594311138836036e-01
GC_9_27 ref NI_9 NS_27 0 1.6044415058808079e-01
GC_9_28 ref NI_9 NS_28 0 1.7522165210218729e-01
GC_9_29 ref NI_9 NS_29 0 -1.1327816839034531e-05
GC_9_30 ref NI_9 NS_30 0 -1.8391238708194060e-02
GC_9_31 ref NI_9 NS_31 0 4.4937483604250184e-01
GC_9_32 ref NI_9 NS_32 0 -2.4675830499704765e-01
GC_9_33 ref NI_9 NS_33 0 4.0904611923318884e-01
GC_9_34 ref NI_9 NS_34 0 1.3595698073825482e-01
GC_9_35 ref NI_9 NS_35 0 2.5782205723877642e-05
GC_9_36 ref NI_9 NS_36 0 -4.8486645252352772e-02
GC_9_37 ref NI_9 NS_37 0 7.2735881538781397e-02
GC_9_38 ref NI_9 NS_38 0 -3.9205942344472444e-01
GC_9_39 ref NI_9 NS_39 0 2.2967008507381154e-01
GC_9_40 ref NI_9 NS_40 0 2.0478193302009620e-01
GC_9_41 ref NI_9 NS_41 0 1.8747034448241128e-04
GC_9_42 ref NI_9 NS_42 0 -2.7411696254648937e-02
GC_9_43 ref NI_9 NS_43 0 -1.0271237262692432e+00
GC_9_44 ref NI_9 NS_44 0 1.1809619285355957e+00
GC_9_45 ref NI_9 NS_45 0 1.5112393825402390e+00
GC_9_46 ref NI_9 NS_46 0 -4.1340459579220734e-01
GC_9_47 ref NI_9 NS_47 0 -8.0213171966407246e-04
GC_9_48 ref NI_9 NS_48 0 -8.9935549660905598e-02
GC_9_49 ref NI_9 NS_49 0 2.3433537794530013e+00
GC_9_50 ref NI_9 NS_50 0 -1.3617880535802214e+00
GC_9_51 ref NI_9 NS_51 0 -1.5216113483740534e+00
GC_9_52 ref NI_9 NS_52 0 -7.2736674632359799e-01
GC_9_53 ref NI_9 NS_53 0 -2.4401704714275552e-03
GC_9_54 ref NI_9 NS_54 0 -1.3391322622949040e-01
GC_9_55 ref NI_9 NS_55 0 -1.6199219175597590e-01
GC_9_56 ref NI_9 NS_56 0 8.8062475354678968e-02
GC_9_57 ref NI_9 NS_57 0 -9.2230538270463396e-03
GC_9_58 ref NI_9 NS_58 0 -1.2920921967791446e-01
GC_9_59 ref NI_9 NS_59 0 1.3768624090638385e-03
GC_9_60 ref NI_9 NS_60 0 1.1221875880434581e-01
GC_9_61 ref NI_9 NS_61 0 -1.8300279609968356e-01
GC_9_62 ref NI_9 NS_62 0 1.0196556435505846e-01
GC_9_63 ref NI_9 NS_63 0 -5.1390786505273900e-02
GC_9_64 ref NI_9 NS_64 0 -8.0935827098191249e-02
GC_9_65 ref NI_9 NS_65 0 1.2426007917614673e-03
GC_9_66 ref NI_9 NS_66 0 1.0000697605396983e-01
GC_9_67 ref NI_9 NS_67 0 -5.9046314229259178e-01
GC_9_68 ref NI_9 NS_68 0 4.0763723989308498e-01
GC_9_69 ref NI_9 NS_69 0 -2.4153474420187321e-01
GC_9_70 ref NI_9 NS_70 0 1.6613088072337068e-02
GC_9_71 ref NI_9 NS_71 0 1.1253179406858106e-04
GC_9_72 ref NI_9 NS_72 0 8.8593449005346034e-02
GD_9_1 ref NI_9 NA_1 0 6.0318720084725247e-02
GD_9_2 ref NI_9 NA_2 0 1.1112559454589789e-01
GD_9_3 ref NI_9 NA_3 0 3.1980977313877217e-02
GD_9_4 ref NI_9 NA_4 0 4.5847019131320449e-03
GD_9_5 ref NI_9 NA_5 0 8.1969135802982280e-03
GD_9_6 ref NI_9 NA_6 0 -4.9780980602911556e-02
GD_9_7 ref NI_9 NA_7 0 -6.8049481814655356e-04
GD_9_8 ref NI_9 NA_8 0 1.1953898910527308e-01
GD_9_9 ref NI_9 NA_9 0 5.8086647839027039e+00
GD_9_10 ref NI_9 NA_10 0 3.2706141878693674e-02
GD_9_11 ref NI_9 NA_11 0 3.6891430283748979e-02
GD_9_12 ref NI_9 NA_12 0 8.7520453587710031e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -2.0887708185290316e-01
GC_10_2 ref NI_10 NS_2 0 -4.3376945520242016e-02
GC_10_3 ref NI_10 NS_3 0 -4.0994815822160288e-02
GC_10_4 ref NI_10 NS_4 0 1.4160949146754295e-01
GC_10_5 ref NI_10 NS_5 0 1.1589853923997034e-03
GC_10_6 ref NI_10 NS_6 0 2.4987233064408740e-02
GC_10_7 ref NI_10 NS_7 0 -3.9659915841495025e-01
GC_10_8 ref NI_10 NS_8 0 1.6861981884334751e-01
GC_10_9 ref NI_10 NS_9 0 -1.2378786169992262e-01
GC_10_10 ref NI_10 NS_10 0 6.4467312890857123e-02
GC_10_11 ref NI_10 NS_11 0 5.0266236102663358e-04
GC_10_12 ref NI_10 NS_12 0 5.4237074902502749e-02
GC_10_13 ref NI_10 NS_13 0 2.5645903222865907e-02
GC_10_14 ref NI_10 NS_14 0 4.8883202326138370e-01
GC_10_15 ref NI_10 NS_15 0 9.6737499862474305e-02
GC_10_16 ref NI_10 NS_16 0 6.3199984791820360e-02
GC_10_17 ref NI_10 NS_17 0 -2.3052928898478528e-04
GC_10_18 ref NI_10 NS_18 0 -7.5471871989528242e-03
GC_10_19 ref NI_10 NS_19 0 -2.0808349285659100e-01
GC_10_20 ref NI_10 NS_20 0 1.7994966353297545e-02
GC_10_21 ref NI_10 NS_21 0 -4.5642219810203159e-02
GC_10_22 ref NI_10 NS_22 0 4.2444253211297016e-02
GC_10_23 ref NI_10 NS_23 0 1.2962118385380968e-03
GC_10_24 ref NI_10 NS_24 0 5.5700908863060596e-02
GC_10_25 ref NI_10 NS_25 0 -3.1872103740370417e-01
GC_10_26 ref NI_10 NS_26 0 1.3741312236547681e-01
GC_10_27 ref NI_10 NS_27 0 -6.6322679576203882e-03
GC_10_28 ref NI_10 NS_28 0 6.6517833871732782e-02
GC_10_29 ref NI_10 NS_29 0 8.4730361113046230e-04
GC_10_30 ref NI_10 NS_30 0 3.7049386746445562e-02
GC_10_31 ref NI_10 NS_31 0 -5.6065515860717688e-02
GC_10_32 ref NI_10 NS_32 0 -7.4978366406286190e-02
GC_10_33 ref NI_10 NS_33 0 -5.6893111568766724e-02
GC_10_34 ref NI_10 NS_34 0 4.4692822484668930e-02
GC_10_35 ref NI_10 NS_35 0 1.0545137545218870e-03
GC_10_36 ref NI_10 NS_36 0 5.9648032672351955e-02
GC_10_37 ref NI_10 NS_37 0 -2.6518173331900835e-01
GC_10_38 ref NI_10 NS_38 0 -8.1306718622865259e-03
GC_10_39 ref NI_10 NS_39 0 -1.9017254157168883e-02
GC_10_40 ref NI_10 NS_40 0 6.7777503733978048e-02
GC_10_41 ref NI_10 NS_41 0 8.6894866064005745e-04
GC_10_42 ref NI_10 NS_42 0 4.5930288262324682e-02
GC_10_43 ref NI_10 NS_43 0 -1.5772025349089791e-01
GC_10_44 ref NI_10 NS_44 0 8.4833887414990761e-02
GC_10_45 ref NI_10 NS_45 0 -5.4549588761162213e-02
GC_10_46 ref NI_10 NS_46 0 -7.0216094011043020e-02
GC_10_47 ref NI_10 NS_47 0 1.2867858576105214e-03
GC_10_48 ref NI_10 NS_48 0 9.6906365477082243e-02
GC_10_49 ref NI_10 NS_49 0 -1.6199219175597576e-01
GC_10_50 ref NI_10 NS_50 0 8.8062475354678690e-02
GC_10_51 ref NI_10 NS_51 0 -9.2230538270460030e-03
GC_10_52 ref NI_10 NS_52 0 -1.2920921967791477e-01
GC_10_53 ref NI_10 NS_53 0 1.3768624090637976e-03
GC_10_54 ref NI_10 NS_54 0 1.1221875880434595e-01
GC_10_55 ref NI_10 NS_55 0 2.7701069303820423e+00
GC_10_56 ref NI_10 NS_56 0 -1.4776739779990973e+00
GC_10_57 ref NI_10 NS_57 0 -1.4363280909077165e+00
GC_10_58 ref NI_10 NS_58 0 -2.8724456458031955e-01
GC_10_59 ref NI_10 NS_59 0 -4.3003854065000622e-03
GC_10_60 ref NI_10 NS_60 0 -3.1140396908412860e-01
GC_10_61 ref NI_10 NS_61 0 -3.9680972434999190e-01
GC_10_62 ref NI_10 NS_62 0 3.4727916849559565e-01
GC_10_63 ref NI_10 NS_63 0 1.9338645465910487e+00
GC_10_64 ref NI_10 NS_64 0 -2.2079396627398018e-01
GC_10_65 ref NI_10 NS_65 0 -2.8817517739875538e-03
GC_10_66 ref NI_10 NS_66 0 -1.9195064977795703e-01
GC_10_67 ref NI_10 NS_67 0 -5.5952863394631791e-01
GC_10_68 ref NI_10 NS_68 0 2.7465479074793320e-01
GC_10_69 ref NI_10 NS_69 0 -2.4615247808683169e-01
GC_10_70 ref NI_10 NS_70 0 2.2126723324443015e-01
GC_10_71 ref NI_10 NS_71 0 -9.1117365295915803e-04
GC_10_72 ref NI_10 NS_72 0 2.3662401566010481e-02
GD_10_1 ref NI_10 NA_1 0 4.4421832406569606e-02
GD_10_2 ref NI_10 NA_2 0 7.8341590777468093e-02
GD_10_3 ref NI_10 NA_3 0 2.2858755269967678e-02
GD_10_4 ref NI_10 NA_4 0 4.9137365749816649e-02
GD_10_5 ref NI_10 NA_5 0 4.1544026973363443e-02
GD_10_6 ref NI_10 NA_6 0 3.5913358725211869e-02
GD_10_7 ref NI_10 NA_7 0 5.4446440197383011e-02
GD_10_8 ref NI_10 NA_8 0 3.3822153861260418e-02
GD_10_9 ref NI_10 NA_9 0 3.2706141878693674e-02
GD_10_10 ref NI_10 NA_10 0 5.7235011509053706e+00
GD_10_11 ref NI_10 NA_11 0 8.1750752379283156e-02
GD_10_12 ref NI_10 NA_12 0 8.9561415805113023e-02
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -3.6694345000824735e-01
GC_11_2 ref NI_11 NS_2 0 -4.7987245317860722e-02
GC_11_3 ref NI_11 NS_3 0 1.0039465541502846e-01
GC_11_4 ref NI_11 NS_4 0 1.0021112488722515e-01
GC_11_5 ref NI_11 NS_5 0 1.0856379974240964e-03
GC_11_6 ref NI_11 NS_6 0 2.0327793033766809e-02
GC_11_7 ref NI_11 NS_7 0 -4.0573558738039028e-01
GC_11_8 ref NI_11 NS_8 0 1.2064631888364252e-01
GC_11_9 ref NI_11 NS_9 0 -6.4992771961232321e-02
GC_11_10 ref NI_11 NS_10 0 6.7896252716271782e-02
GC_11_11 ref NI_11 NS_11 0 4.9117591795020939e-04
GC_11_12 ref NI_11 NS_12 0 4.5270369221429879e-02
GC_11_13 ref NI_11 NS_13 0 2.3050154776765774e-01
GC_11_14 ref NI_11 NS_14 0 1.0002841479249991e+00
GC_11_15 ref NI_11 NS_15 0 -9.1772648995563935e-02
GC_11_16 ref NI_11 NS_16 0 4.5446866777930743e-02
GC_11_17 ref NI_11 NS_17 0 -2.4870037282021331e-04
GC_11_18 ref NI_11 NS_18 0 -9.7979995064845556e-03
GC_11_19 ref NI_11 NS_19 0 -2.7341680401399487e-01
GC_11_20 ref NI_11 NS_20 0 -8.8732314785506423e-03
GC_11_21 ref NI_11 NS_21 0 2.5291794268731568e-02
GC_11_22 ref NI_11 NS_22 0 3.7455334482253640e-02
GC_11_23 ref NI_11 NS_23 0 1.1881297718031127e-03
GC_11_24 ref NI_11 NS_24 0 4.8361744097183107e-02
GC_11_25 ref NI_11 NS_25 0 -4.9205030165116065e-01
GC_11_26 ref NI_11 NS_26 0 2.9347144795769176e-01
GC_11_27 ref NI_11 NS_27 0 2.7029016143928240e-02
GC_11_28 ref NI_11 NS_28 0 4.9682884791750009e-02
GC_11_29 ref NI_11 NS_29 0 7.7463048102924628e-04
GC_11_30 ref NI_11 NS_30 0 3.1514701453480794e-02
GC_11_31 ref NI_11 NS_31 0 -1.3763562329071331e-02
GC_11_32 ref NI_11 NS_32 0 -2.0691957823310880e-01
GC_11_33 ref NI_11 NS_33 0 4.2858743738226936e-02
GC_11_34 ref NI_11 NS_34 0 3.8436678654010424e-02
GC_11_35 ref NI_11 NS_35 0 9.5914064960477767e-04
GC_11_36 ref NI_11 NS_36 0 5.2068195347556960e-02
GC_11_37 ref NI_11 NS_37 0 -4.5847926622860985e-01
GC_11_38 ref NI_11 NS_38 0 2.1847494859406534e-02
GC_11_39 ref NI_11 NS_39 0 7.1979498797725014e-02
GC_11_40 ref NI_11 NS_40 0 4.8407443794779959e-02
GC_11_41 ref NI_11 NS_41 0 7.7587644118490816e-04
GC_11_42 ref NI_11 NS_42 0 3.9996756652766745e-02
GC_11_43 ref NI_11 NS_43 0 -1.1008578912180832e-01
GC_11_44 ref NI_11 NS_44 0 4.1522928050632089e-02
GC_11_45 ref NI_11 NS_45 0 -6.6563171040599445e-02
GC_11_46 ref NI_11 NS_46 0 -3.1714827108859457e-02
GC_11_47 ref NI_11 NS_47 0 1.1865873209158204e-03
GC_11_48 ref NI_11 NS_48 0 8.5412388769700975e-02
GC_11_49 ref NI_11 NS_49 0 -1.8300279609968334e-01
GC_11_50 ref NI_11 NS_50 0 1.0196556435505805e-01
GC_11_51 ref NI_11 NS_51 0 -5.1390786505273442e-02
GC_11_52 ref NI_11 NS_52 0 -8.0935827098191637e-02
GC_11_53 ref NI_11 NS_53 0 1.2426007917614129e-03
GC_11_54 ref NI_11 NS_54 0 1.0000697605396999e-01
GC_11_55 ref NI_11 NS_55 0 -3.9680972434999190e-01
GC_11_56 ref NI_11 NS_56 0 3.4727916849559543e-01
GC_11_57 ref NI_11 NS_57 0 1.9338645465910487e+00
GC_11_58 ref NI_11 NS_58 0 -2.2079396627398035e-01
GC_11_59 ref NI_11 NS_59 0 -2.8817517739875807e-03
GC_11_60 ref NI_11 NS_60 0 -1.9195064977795692e-01
GC_11_61 ref NI_11 NS_61 0 3.1220890690930876e+00
GC_11_62 ref NI_11 NS_62 0 -1.8492685631697694e+00
GC_11_63 ref NI_11 NS_63 0 -1.8256563330908295e+00
GC_11_64 ref NI_11 NS_64 0 -2.4595447366434839e-01
GC_11_65 ref NI_11 NS_65 0 -3.7246109106778493e-03
GC_11_66 ref NI_11 NS_66 0 -2.3578285457593598e-01
GC_11_67 ref NI_11 NS_67 0 -5.5510862353366697e-01
GC_11_68 ref NI_11 NS_68 0 1.8711286613411665e-01
GC_11_69 ref NI_11 NS_69 0 -1.0788546746022307e-01
GC_11_70 ref NI_11 NS_70 0 1.9599116720737125e-01
GC_11_71 ref NI_11 NS_71 0 -7.6984394908976889e-04
GC_11_72 ref NI_11 NS_72 0 1.3923752557311177e-02
GD_11_1 ref NI_11 NA_1 0 6.1092868782986066e-02
GD_11_2 ref NI_11 NA_2 0 8.3137998829812848e-02
GD_11_3 ref NI_11 NA_3 0 8.9437582989835632e-03
GD_11_4 ref NI_11 NA_4 0 5.9133401709791367e-02
GD_11_5 ref NI_11 NA_5 0 4.8395099987163341e-02
GD_11_6 ref NI_11 NA_6 0 3.9331483985361883e-02
GD_11_7 ref NI_11 NA_7 0 7.6088600823041017e-02
GD_11_8 ref NI_11 NA_8 0 3.0466907149253646e-02
GD_11_9 ref NI_11 NA_9 0 3.6891430283748979e-02
GD_11_10 ref NI_11 NA_10 0 8.1750752379283156e-02
GD_11_11 ref NI_11 NA_11 0 5.6586986068162339e+00
GD_11_12 ref NI_11 NA_12 0 8.9307110189892083e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -1.3507646527591063e-01
GC_12_2 ref NI_12 NS_2 0 -2.6830577719672305e-01
GC_12_3 ref NI_12 NS_3 0 1.7430488999466626e-01
GC_12_4 ref NI_12 NS_4 0 1.6236749071557474e-01
GC_12_5 ref NI_12 NS_5 0 8.8647881324499598e-04
GC_12_6 ref NI_12 NS_6 0 -7.6467569642737132e-03
GC_12_7 ref NI_12 NS_7 0 -4.7919278091586859e-01
GC_12_8 ref NI_12 NS_8 0 1.5263244145557062e-01
GC_12_9 ref NI_12 NS_9 0 -1.2146748974270966e-01
GC_12_10 ref NI_12 NS_10 0 1.5747344838660404e-01
GC_12_11 ref NI_12 NS_11 0 1.4726142096096342e-04
GC_12_12 ref NI_12 NS_12 0 1.9890373273750324e-02
GC_12_13 ref NI_12 NS_13 0 5.1817292706128770e-01
GC_12_14 ref NI_12 NS_14 0 9.4093419401175971e-01
GC_12_15 ref NI_12 NS_15 0 1.2147716366396404e-01
GC_12_16 ref NI_12 NS_16 0 -2.2007410344538479e-02
GC_12_17 ref NI_12 NS_17 0 -2.8292843886688581e-04
GC_12_18 ref NI_12 NS_18 0 -2.4419270786887506e-02
GC_12_19 ref NI_12 NS_19 0 -3.1792458347583885e-01
GC_12_20 ref NI_12 NS_20 0 -3.6861410876999766e-03
GC_12_21 ref NI_12 NS_21 0 -1.1686172178644713e-02
GC_12_22 ref NI_12 NS_22 0 1.1389034872806950e-01
GC_12_23 ref NI_12 NS_23 0 6.1344292648439762e-04
GC_12_24 ref NI_12 NS_24 0 2.7252048426446743e-02
GC_12_25 ref NI_12 NS_25 0 -4.6816835621047126e-01
GC_12_26 ref NI_12 NS_26 0 2.6417299171477909e-01
GC_12_27 ref NI_12 NS_27 0 5.8012482035593234e-02
GC_12_28 ref NI_12 NS_28 0 9.7113322159686141e-02
GC_12_29 ref NI_12 NS_29 0 4.2712641319331458e-04
GC_12_30 ref NI_12 NS_30 0 9.7697883631084025e-03
GC_12_31 ref NI_12 NS_31 0 -3.8218295195276974e-02
GC_12_32 ref NI_12 NS_32 0 -1.8597177870794074e-01
GC_12_33 ref NI_12 NS_33 0 -5.1823202829110009e-02
GC_12_34 ref NI_12 NS_34 0 1.4052495632741729e-01
GC_12_35 ref NI_12 NS_35 0 4.6286588963796255e-04
GC_12_36 ref NI_12 NS_36 0 2.9095702914699133e-02
GC_12_37 ref NI_12 NS_37 0 -4.6902541713441376e-01
GC_12_38 ref NI_12 NS_38 0 -1.6320144253663075e-02
GC_12_39 ref NI_12 NS_39 0 6.4596696228033740e-02
GC_12_40 ref NI_12 NS_40 0 1.2066822497642196e-01
GC_12_41 ref NI_12 NS_41 0 3.9549530959616744e-04
GC_12_42 ref NI_12 NS_42 0 1.6636736255099684e-02
GC_12_43 ref NI_12 NS_43 0 -4.3604030041008712e-01
GC_12_44 ref NI_12 NS_44 0 2.8971970177503464e-01
GC_12_45 ref NI_12 NS_45 0 -2.4157731137326083e-01
GC_12_46 ref NI_12 NS_46 0 7.2800548693856090e-02
GC_12_47 ref NI_12 NS_47 0 2.3534543311963950e-04
GC_12_48 ref NI_12 NS_48 0 6.9596662198907963e-02
GC_12_49 ref NI_12 NS_49 0 -5.9046314229259178e-01
GC_12_50 ref NI_12 NS_50 0 4.0763723989308531e-01
GC_12_51 ref NI_12 NS_51 0 -2.4153474420187343e-01
GC_12_52 ref NI_12 NS_52 0 1.6613088072337273e-02
GC_12_53 ref NI_12 NS_53 0 1.1253179406860878e-04
GC_12_54 ref NI_12 NS_54 0 8.8593449005345937e-02
GC_12_55 ref NI_12 NS_55 0 -5.5952863394631791e-01
GC_12_56 ref NI_12 NS_56 0 2.7465479074793320e-01
GC_12_57 ref NI_12 NS_57 0 -2.4615247808683177e-01
GC_12_58 ref NI_12 NS_58 0 2.2126723324443026e-01
GC_12_59 ref NI_12 NS_59 0 -9.1117365295914437e-04
GC_12_60 ref NI_12 NS_60 0 2.3662401566010436e-02
GC_12_61 ref NI_12 NS_61 0 -5.5510862353366730e-01
GC_12_62 ref NI_12 NS_62 0 1.8711286613411685e-01
GC_12_63 ref NI_12 NS_63 0 -1.0788546746022332e-01
GC_12_64 ref NI_12 NS_64 0 1.9599116720737145e-01
GC_12_65 ref NI_12 NS_65 0 -7.6984394908974146e-04
GC_12_66 ref NI_12 NS_66 0 1.3923752557311080e-02
GC_12_67 ref NI_12 NS_67 0 3.6766091681545952e+00
GC_12_68 ref NI_12 NS_68 0 -2.0546236477153372e+00
GC_12_69 ref NI_12 NS_69 0 6.0030029710534893e-01
GC_12_70 ref NI_12 NS_70 0 -1.2729663064150978e+00
GC_12_71 ref NI_12 NS_71 0 -1.2534141413147891e-03
GC_12_72 ref NI_12 NS_72 0 -2.6691952996068913e-01
GD_12_1 ref NI_12 NA_1 0 3.3663046581058752e-02
GD_12_2 ref NI_12 NA_2 0 9.7636806093789302e-02
GD_12_3 ref NI_12 NA_3 0 -3.1715776272659126e-02
GD_12_4 ref NI_12 NA_4 0 6.7503035242115345e-02
GD_12_5 ref NI_12 NA_5 0 4.1830999351424918e-02
GD_12_6 ref NI_12 NA_6 0 4.5825016562476499e-02
GD_12_7 ref NI_12 NA_7 0 7.8224968166934805e-02
GD_12_8 ref NI_12 NA_8 0 7.0994206727547179e-02
GD_12_9 ref NI_12 NA_9 0 8.7520453587710031e-02
GD_12_10 ref NI_12 NA_10 0 8.9561415805113023e-02
GD_12_11 ref NI_12 NA_11 0 8.9307110189892083e-02
GD_12_12 ref NI_12 NA_12 0 5.5858204174635908e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 8.3530968805597169e-02
GS_1_1 0 NS_1 NA_1 0 5.9669231537702379e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 1.8325348526259999e-01
GS_2_1 0 NS_2 NA_1 0 5.9669231537702379e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 4.5150568905439403e-01
GS_3_1 0 NS_3 NA_1 0 5.9669231537702379e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 9.8041536798675200e-01
GS_4_1 0 NS_4 NA_1 0 5.9669231537702379e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 1.0214347785653786e+01
GS_5_1 0 NS_5 NA_1 0 5.9669231537702379e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 2.2817206735086248e+00
GS_6_1 0 NS_6 NA_1 0 5.9669231537702379e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 8.3530968805597169e-02
GS_7_2 0 NS_7 NA_2 0 5.9669231537702379e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 1.8325348526259999e-01
GS_8_2 0 NS_8 NA_2 0 5.9669231537702379e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 4.5150568905439403e-01
GS_9_2 0 NS_9 NA_2 0 5.9669231537702379e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 9.8041536798675200e-01
GS_10_2 0 NS_10 NA_2 0 5.9669231537702379e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 1.0214347785653786e+01
GS_11_2 0 NS_11 NA_2 0 5.9669231537702379e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 2.2817206735086248e+00
GS_12_2 0 NS_12 NA_2 0 5.9669231537702379e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 8.3530968805597169e-02
GS_13_3 0 NS_13 NA_3 0 5.9669231537702379e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 1.8325348526259999e-01
GS_14_3 0 NS_14 NA_3 0 5.9669231537702379e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 4.5150568905439403e-01
GS_15_3 0 NS_15 NA_3 0 5.9669231537702379e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 9.8041536798675200e-01
GS_16_3 0 NS_16 NA_3 0 5.9669231537702379e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 1.0214347785653786e+01
GS_17_3 0 NS_17 NA_3 0 5.9669231537702379e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 2.2817206735086248e+00
GS_18_3 0 NS_18 NA_3 0 5.9669231537702379e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 8.3530968805597169e-02
GS_19_4 0 NS_19 NA_4 0 5.9669231537702379e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 1.8325348526259999e-01
GS_20_4 0 NS_20 NA_4 0 5.9669231537702379e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 4.5150568905439403e-01
GS_21_4 0 NS_21 NA_4 0 5.9669231537702379e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 9.8041536798675200e-01
GS_22_4 0 NS_22 NA_4 0 5.9669231537702379e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 1.0214347785653786e+01
GS_23_4 0 NS_23 NA_4 0 5.9669231537702379e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 2.2817206735086248e+00
GS_24_4 0 NS_24 NA_4 0 5.9669231537702379e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 8.3530968805597169e-02
GS_25_5 0 NS_25 NA_5 0 5.9669231537702379e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 1.8325348526259999e-01
GS_26_5 0 NS_26 NA_5 0 5.9669231537702379e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 4.5150568905439403e-01
GS_27_5 0 NS_27 NA_5 0 5.9669231537702379e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 9.8041536798675200e-01
GS_28_5 0 NS_28 NA_5 0 5.9669231537702379e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 1.0214347785653786e+01
GS_29_5 0 NS_29 NA_5 0 5.9669231537702379e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 2.2817206735086248e+00
GS_30_5 0 NS_30 NA_5 0 5.9669231537702379e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 8.3530968805597169e-02
GS_31_6 0 NS_31 NA_6 0 5.9669231537702379e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 1.8325348526259999e-01
GS_32_6 0 NS_32 NA_6 0 5.9669231537702379e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 4.5150568905439403e-01
GS_33_6 0 NS_33 NA_6 0 5.9669231537702379e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 9.8041536798675200e-01
GS_34_6 0 NS_34 NA_6 0 5.9669231537702379e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 1.0214347785653786e+01
GS_35_6 0 NS_35 NA_6 0 5.9669231537702379e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 2.2817206735086248e+00
GS_36_6 0 NS_36 NA_6 0 5.9669231537702379e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 8.3530968805597169e-02
GS_37_7 0 NS_37 NA_7 0 5.9669231537702379e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 1.8325348526259999e-01
GS_38_7 0 NS_38 NA_7 0 5.9669231537702379e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 4.5150568905439403e-01
GS_39_7 0 NS_39 NA_7 0 5.9669231537702379e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 9.8041536798675200e-01
GS_40_7 0 NS_40 NA_7 0 5.9669231537702379e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 1.0214347785653786e+01
GS_41_7 0 NS_41 NA_7 0 5.9669231537702379e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 2.2817206735086248e+00
GS_42_7 0 NS_42 NA_7 0 5.9669231537702379e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 8.3530968805597169e-02
GS_43_8 0 NS_43 NA_8 0 5.9669231537702379e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 1.8325348526259999e-01
GS_44_8 0 NS_44 NA_8 0 5.9669231537702379e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 4.5150568905439403e-01
GS_45_8 0 NS_45 NA_8 0 5.9669231537702379e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 9.8041536798675200e-01
GS_46_8 0 NS_46 NA_8 0 5.9669231537702379e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 1.0214347785653786e+01
GS_47_8 0 NS_47 NA_8 0 5.9669231537702379e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 2.2817206735086248e+00
GS_48_8 0 NS_48 NA_8 0 5.9669231537702379e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 8.3530968805597169e-02
GS_49_9 0 NS_49 NA_9 0 5.9669231537702379e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 1.8325348526259999e-01
GS_50_9 0 NS_50 NA_9 0 5.9669231537702379e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 4.5150568905439403e-01
GS_51_9 0 NS_51 NA_9 0 5.9669231537702379e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 9.8041536798675200e-01
GS_52_9 0 NS_52 NA_9 0 5.9669231537702379e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 1.0214347785653786e+01
GS_53_9 0 NS_53 NA_9 0 5.9669231537702379e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 2.2817206735086248e+00
GS_54_9 0 NS_54 NA_9 0 5.9669231537702379e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 8.3530968805597169e-02
GS_55_10 0 NS_55 NA_10 0 5.9669231537702379e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 1.8325348526259999e-01
GS_56_10 0 NS_56 NA_10 0 5.9669231537702379e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 4.5150568905439403e-01
GS_57_10 0 NS_57 NA_10 0 5.9669231537702379e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 9.8041536798675200e-01
GS_58_10 0 NS_58 NA_10 0 5.9669231537702379e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 1.0214347785653786e+01
GS_59_10 0 NS_59 NA_10 0 5.9669231537702379e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 2.2817206735086248e+00
GS_60_10 0 NS_60 NA_10 0 5.9669231537702379e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 8.3530968805597169e-02
GS_61_11 0 NS_61 NA_11 0 5.9669231537702379e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 1.8325348526259999e-01
GS_62_11 0 NS_62 NA_11 0 5.9669231537702379e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 4.5150568905439403e-01
GS_63_11 0 NS_63 NA_11 0 5.9669231537702379e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 9.8041536798675200e-01
GS_64_11 0 NS_64 NA_11 0 5.9669231537702379e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 1.0214347785653786e+01
GS_65_11 0 NS_65 NA_11 0 5.9669231537702379e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 2.2817206735086248e+00
GS_66_11 0 NS_66 NA_11 0 5.9669231537702379e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 8.3530968805597169e-02
GS_67_12 0 NS_67 NA_12 0 5.9669231537702379e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 1.8325348526259999e-01
GS_68_12 0 NS_68 NA_12 0 5.9669231537702379e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 4.5150568905439403e-01
GS_69_12 0 NS_69 NA_12 0 5.9669231537702379e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 9.8041536798675200e-01
GS_70_12 0 NS_70 NA_12 0 5.9669231537702379e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 1.0214347785653786e+01
GS_71_12 0 NS_71 NA_12 0 5.9669231537702379e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 2.2817206735086248e+00
GS_72_12 0 NS_72 NA_12 0 5.9669231537702379e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
