**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 12-Jun-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Thu Jun 12 21:02:40 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Thu Jun 12 21:02:40 2025
**
**  Modal data exported
**  Port[1] = BGA1_BGA1_GRP_1_1_VDD_075_BGA1_GRP_1_1_VSS
**  Port[2] = DIE1_DIE1_GRP_0_0_VDD_075_DIE1_GRP_0_0_VSS
**  Port[3] = DIE1_DIE1_GRP_0_1_VDD_075_DIE1_GRP_0_1_VSS
**  Port[4] = DIE1_DIE1_GRP_1_0_VDD_075_DIE1_GRP_1_0_VSS
**  Port[5] = DIE1_DIE1_GRP_1_1_VDD_075_DIE1_GRP_1_1_VSS
**  Port[6] = DIE1_DIE1_GRP_2_0_VDD_075_DIE1_GRP_2_0_VSS
**  Port[7] = DIE1_DIE1_GRP_2_1_VDD_075_DIE1_GRP_2_1_VSS
**  Port[8] = VDD_075_C37_2
**  Port[9] = VDD_075_C38_2
**  Port[10] = VDD_075_C78_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 4]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_VDD_075_cut_s10p_IdEM
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -1.3279846129859444e-02
GC_1_2 ref NI_1 NS_2 0 9.5826892573285787e-03
GC_1_3 ref NI_1 NS_3 0 -5.8224178937309495e-02
GC_1_4 ref NI_1 NS_4 0 -1.2816462560516323e-02
GC_1_5 ref NI_1 NS_5 0 -3.2315991849006238e-03
GC_1_6 ref NI_1 NS_6 0 -7.3947460346622642e-03
GC_1_7 ref NI_1 NS_7 0 9.8741483367820165e-03
GC_1_8 ref NI_1 NS_8 0 1.0350586128527670e-03
GC_1_9 ref NI_1 NS_9 0 2.7734857373667474e-02
GC_1_10 ref NI_1 NS_10 0 2.7058769334812723e-02
GC_1_11 ref NI_1 NS_11 0 -1.5822049540919368e-03
GC_1_12 ref NI_1 NS_12 0 -4.4327228141180508e-04
GC_1_13 ref NI_1 NS_13 0 1.9686811302549425e-02
GC_1_14 ref NI_1 NS_14 0 -1.7961965680837695e-02
GC_1_15 ref NI_1 NS_15 0 4.9080184132457728e-03
GC_1_16 ref NI_1 NS_16 0 3.3832943823903709e-03
GC_1_17 ref NI_1 NS_17 0 2.1751988690688439e-03
GC_1_18 ref NI_1 NS_18 0 1.1575585814328524e-02
GC_1_19 ref NI_1 NS_19 0 6.9257653546703655e-03
GC_1_20 ref NI_1 NS_20 0 -3.1676688394306090e-04
GC_1_21 ref NI_1 NS_21 0 -7.5101805393008730e-03
GC_1_22 ref NI_1 NS_22 0 -1.1354232871418242e-02
GC_1_23 ref NI_1 NS_23 0 1.3788630643682872e-02
GC_1_24 ref NI_1 NS_24 0 4.6539314973729860e-04
GC_1_25 ref NI_1 NS_25 0 -1.9112023528114946e-02
GC_1_26 ref NI_1 NS_26 0 6.1103361188822583e-03
GC_1_27 ref NI_1 NS_27 0 1.1206864905575020e-02
GC_1_28 ref NI_1 NS_28 0 -9.1818456652359773e-05
GC_1_29 ref NI_1 NS_29 0 1.1425567869272919e-03
GC_1_30 ref NI_1 NS_30 0 -6.2444310179425476e-03
GC_1_31 ref NI_1 NS_31 0 2.3128987377884634e-03
GC_1_32 ref NI_1 NS_32 0 3.5936508219707717e-03
GC_1_33 ref NI_1 NS_33 0 -5.7965562023813101e-03
GC_1_34 ref NI_1 NS_34 0 -2.2170373257362395e-03
GC_1_35 ref NI_1 NS_35 0 3.3004360046996672e-03
GC_1_36 ref NI_1 NS_36 0 3.0426505252549177e-03
GC_1_37 ref NI_1 NS_37 0 3.4152770243159806e-03
GC_1_38 ref NI_1 NS_38 0 -1.0285580946845055e-02
GC_1_39 ref NI_1 NS_39 0 7.5992844285747083e-03
GC_1_40 ref NI_1 NS_40 0 2.2072106244534770e-03
GD_1_1 ref NI_1 NA_1 0 6.2454325346501358e+00
GD_1_2 ref NI_1 NA_2 0 2.4300765397384794e-02
GD_1_3 ref NI_1 NA_3 0 -2.7647606906754756e-02
GD_1_4 ref NI_1 NA_4 0 -8.1284945623416482e-02
GD_1_5 ref NI_1 NA_5 0 7.0248174421452467e-03
GD_1_6 ref NI_1 NA_6 0 5.1738655203014218e-02
GD_1_7 ref NI_1 NA_7 0 2.0025723651127647e-02
GD_1_8 ref NI_1 NA_8 0 1.4835993198345583e-03
GD_1_9 ref NI_1 NA_9 0 2.2176404163650930e-02
GD_1_10 ref NI_1 NA_10 0 -1.6829491186839813e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 -3.2315991849006811e-03
GC_2_2 ref NI_2 NS_2 0 -7.3947460346622520e-03
GC_2_3 ref NI_2 NS_3 0 9.8741483367820234e-03
GC_2_4 ref NI_2 NS_4 0 1.0350586128527607e-03
GC_2_5 ref NI_2 NS_5 0 6.4535403276040570e-02
GC_2_6 ref NI_2 NS_6 0 -5.0727550163654531e-02
GC_2_7 ref NI_2 NS_7 0 -5.1935100873738413e-02
GC_2_8 ref NI_2 NS_8 0 -7.0024704240100851e-03
GC_2_9 ref NI_2 NS_9 0 1.6789494121514485e-02
GC_2_10 ref NI_2 NS_10 0 2.4573254407373062e-02
GC_2_11 ref NI_2 NS_11 0 -2.5638855743371092e-03
GC_2_12 ref NI_2 NS_12 0 1.5041664681533041e-04
GC_2_13 ref NI_2 NS_13 0 1.4652153579280010e-02
GC_2_14 ref NI_2 NS_14 0 -1.4871821856177693e-02
GC_2_15 ref NI_2 NS_15 0 1.0840774730689938e-02
GC_2_16 ref NI_2 NS_16 0 9.5400160580972997e-04
GC_2_17 ref NI_2 NS_17 0 4.5449707806933005e-03
GC_2_18 ref NI_2 NS_18 0 1.8809748732178833e-02
GC_2_19 ref NI_2 NS_19 0 2.8777271015701586e-03
GC_2_20 ref NI_2 NS_20 0 -5.8693685328116017e-04
GC_2_21 ref NI_2 NS_21 0 -2.8902308768745416e-02
GC_2_22 ref NI_2 NS_22 0 5.1088427268050438e-03
GC_2_23 ref NI_2 NS_23 0 1.2653327498737715e-02
GC_2_24 ref NI_2 NS_24 0 -5.7634054354329018e-04
GC_2_25 ref NI_2 NS_25 0 -3.4155917780585368e-02
GC_2_26 ref NI_2 NS_26 0 2.3215858213469959e-02
GC_2_27 ref NI_2 NS_27 0 7.4948742787113859e-03
GC_2_28 ref NI_2 NS_28 0 -6.3541995128601841e-04
GC_2_29 ref NI_2 NS_29 0 -5.2503385611796707e-03
GC_2_30 ref NI_2 NS_30 0 -1.7078394302983259e-03
GC_2_31 ref NI_2 NS_31 0 1.4137348805371005e-03
GC_2_32 ref NI_2 NS_32 0 3.0744468800528828e-03
GC_2_33 ref NI_2 NS_33 0 -1.1834511673420095e-02
GC_2_34 ref NI_2 NS_34 0 2.5576278320773383e-03
GC_2_35 ref NI_2 NS_35 0 1.8967917494149638e-03
GC_2_36 ref NI_2 NS_36 0 2.6416378529835333e-03
GC_2_37 ref NI_2 NS_37 0 -7.9420750381528973e-03
GC_2_38 ref NI_2 NS_38 0 -1.0322715922082431e-03
GC_2_39 ref NI_2 NS_39 0 7.5339692758095425e-03
GC_2_40 ref NI_2 NS_40 0 9.8185224298763052e-04
GD_2_1 ref NI_2 NA_1 0 2.4300765397385109e-02
GD_2_2 ref NI_2 NA_2 0 5.6686338855604292e+00
GD_2_3 ref NI_2 NA_3 0 3.0241906418434474e-02
GD_2_4 ref NI_2 NA_4 0 -5.0258015183954861e-02
GD_2_5 ref NI_2 NA_5 0 1.2564201001003103e-01
GD_2_6 ref NI_2 NA_6 0 1.4310972952873321e-01
GD_2_7 ref NI_2 NA_7 0 8.1326430595913990e-02
GD_2_8 ref NI_2 NA_8 0 4.5260839915112844e-02
GD_2_9 ref NI_2 NA_9 0 6.8911535231789098e-02
GD_2_10 ref NI_2 NA_10 0 6.1660856339128593e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 2.7734857373667231e-02
GC_3_2 ref NI_3 NS_2 0 2.7058769334812816e-02
GC_3_3 ref NI_3 NS_3 0 -1.5822049540919385e-03
GC_3_4 ref NI_3 NS_4 0 -4.4327228141181207e-04
GC_3_5 ref NI_3 NS_5 0 1.6789494121514800e-02
GC_3_6 ref NI_3 NS_6 0 2.4573254407372940e-02
GC_3_7 ref NI_3 NS_7 0 -2.5638855743370936e-03
GC_3_8 ref NI_3 NS_8 0 1.5041664681533367e-04
GC_3_9 ref NI_3 NS_9 0 -2.7935791444746022e-01
GC_3_10 ref NI_3 NS_10 0 -1.3761896075409027e-01
GC_3_11 ref NI_3 NS_11 0 7.4474791059739318e-03
GC_3_12 ref NI_3 NS_12 0 -1.9132635975346976e-03
GC_3_13 ref NI_3 NS_13 0 2.4716605247487836e-03
GC_3_14 ref NI_3 NS_14 0 -2.3439543472719374e-03
GC_3_15 ref NI_3 NS_15 0 7.8015084121526813e-03
GC_3_16 ref NI_3 NS_16 0 1.0233163977069542e-03
GC_3_17 ref NI_3 NS_17 0 1.7291074966763384e-01
GC_3_18 ref NI_3 NS_18 0 -5.2089129759523151e-02
GC_3_19 ref NI_3 NS_19 0 8.1332400985143557e-04
GC_3_20 ref NI_3 NS_20 0 -5.9945611911024700e-04
GC_3_21 ref NI_3 NS_21 0 -4.9512339467346039e-02
GC_3_22 ref NI_3 NS_22 0 5.6432743847236171e-02
GC_3_23 ref NI_3 NS_23 0 -4.2933992223930873e-03
GC_3_24 ref NI_3 NS_24 0 3.3091172518432939e-04
GC_3_25 ref NI_3 NS_25 0 6.5259655069917474e-02
GC_3_26 ref NI_3 NS_26 0 3.1827881938703395e-02
GC_3_27 ref NI_3 NS_27 0 -8.8242574022082462e-03
GC_3_28 ref NI_3 NS_28 0 5.1446003301777862e-04
GC_3_29 ref NI_3 NS_29 0 1.0379572200941382e-02
GC_3_30 ref NI_3 NS_30 0 1.3227691638512028e-02
GC_3_31 ref NI_3 NS_31 0 2.7392920248299002e-03
GC_3_32 ref NI_3 NS_32 0 4.6883601049536872e-04
GC_3_33 ref NI_3 NS_33 0 3.6921621092430378e-02
GC_3_34 ref NI_3 NS_34 0 1.3474588906674616e-02
GC_3_35 ref NI_3 NS_35 0 -1.1786218929425961e-03
GC_3_36 ref NI_3 NS_36 0 5.4470301788081825e-04
GC_3_37 ref NI_3 NS_37 0 2.6632040551629578e-02
GC_3_38 ref NI_3 NS_38 0 1.8400533642846582e-02
GC_3_39 ref NI_3 NS_39 0 3.1040474783939975e-04
GC_3_40 ref NI_3 NS_40 0 -1.4504733171506019e-04
GD_3_1 ref NI_3 NA_1 0 -2.7647606906752893e-02
GD_3_2 ref NI_3 NA_2 0 3.0241906418432166e-02
GD_3_3 ref NI_3 NA_3 0 6.0319131120065519e+00
GD_3_4 ref NI_3 NA_4 0 -8.7885159178518902e-03
GD_3_5 ref NI_3 NA_5 0 5.1567587510730850e-01
GD_3_6 ref NI_3 NA_6 0 1.0090003701567672e-02
GD_3_7 ref NI_3 NA_7 0 -4.9161401604510280e-01
GD_3_8 ref NI_3 NA_8 0 1.6300391155247018e-02
GD_3_9 ref NI_3 NA_9 0 -3.6505394485930077e-02
GD_3_10 ref NI_3 NA_10 0 -1.2698311197562357e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 1.9686811302549425e-02
GC_4_2 ref NI_4 NS_2 0 -1.7961965680837692e-02
GC_4_3 ref NI_4 NS_3 0 4.9080184132457710e-03
GC_4_4 ref NI_4 NS_4 0 3.3832943823903713e-03
GC_4_5 ref NI_4 NS_5 0 1.4652153579279487e-02
GC_4_6 ref NI_4 NS_6 0 -1.4871821856177445e-02
GC_4_7 ref NI_4 NS_7 0 1.0840774730689885e-02
GC_4_8 ref NI_4 NS_8 0 9.5400160580973777e-04
GC_4_9 ref NI_4 NS_9 0 2.4716605247487073e-03
GC_4_10 ref NI_4 NS_10 0 -2.3439543472719014e-03
GC_4_11 ref NI_4 NS_11 0 7.8015084121526770e-03
GC_4_12 ref NI_4 NS_12 0 1.0233163977069536e-03
GC_4_13 ref NI_4 NS_13 0 4.8449247961389157e-03
GC_4_14 ref NI_4 NS_14 0 2.4531122855487651e-03
GC_4_15 ref NI_4 NS_15 0 -5.2914038590492658e-02
GC_4_16 ref NI_4 NS_16 0 -1.4070182673385206e-02
GC_4_17 ref NI_4 NS_17 0 1.3710812912408248e-03
GC_4_18 ref NI_4 NS_18 0 8.6151254635604725e-04
GC_4_19 ref NI_4 NS_19 0 1.3174551575561994e-02
GC_4_20 ref NI_4 NS_20 0 -1.0944237977655363e-03
GC_4_21 ref NI_4 NS_21 0 1.1131173279162430e-03
GC_4_22 ref NI_4 NS_22 0 1.9243385748421483e-02
GC_4_23 ref NI_4 NS_23 0 1.4102975284054874e-02
GC_4_24 ref NI_4 NS_24 0 -3.2318626246975808e-03
GC_4_25 ref NI_4 NS_25 0 -2.3144542367645890e-02
GC_4_26 ref NI_4 NS_26 0 6.8308561466187681e-03
GC_4_27 ref NI_4 NS_27 0 1.6419051214168773e-02
GC_4_28 ref NI_4 NS_28 0 -1.6154967757793025e-03
GC_4_29 ref NI_4 NS_29 0 -8.7026143943324894e-03
GC_4_30 ref NI_4 NS_30 0 6.2856700886749287e-03
GC_4_31 ref NI_4 NS_31 0 -7.6590065364938089e-03
GC_4_32 ref NI_4 NS_32 0 5.4763809114873026e-03
GC_4_33 ref NI_4 NS_33 0 -6.6178154328520545e-03
GC_4_34 ref NI_4 NS_34 0 3.5790096142600605e-03
GC_4_35 ref NI_4 NS_35 0 -5.5617855673979330e-03
GC_4_36 ref NI_4 NS_36 0 5.0152846093489386e-03
GC_4_37 ref NI_4 NS_37 0 6.9632691469136499e-03
GC_4_38 ref NI_4 NS_38 0 -6.6199658080162756e-03
GC_4_39 ref NI_4 NS_39 0 -8.4110708649984224e-04
GC_4_40 ref NI_4 NS_40 0 4.1723131631767807e-03
GD_4_1 ref NI_4 NA_1 0 -8.1284945623416441e-02
GD_4_2 ref NI_4 NA_2 0 -5.0258015183951128e-02
GD_4_3 ref NI_4 NA_3 0 -8.7885159178513438e-03
GD_4_4 ref NI_4 NA_4 0 6.1715684636628954e+00
GD_4_5 ref NI_4 NA_5 0 4.3469599889288502e-02
GD_4_6 ref NI_4 NA_6 0 -8.6175973009160450e-03
GD_4_7 ref NI_4 NA_7 0 3.3774968743482667e-02
GD_4_8 ref NI_4 NA_8 0 5.0138304722743381e-02
GD_4_9 ref NI_4 NA_9 0 4.1937621882332465e-02
GD_4_10 ref NI_4 NA_10 0 -2.2359292084544898e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 2.1751988690688873e-03
GC_5_2 ref NI_5 NS_2 0 1.1575585814328515e-02
GC_5_3 ref NI_5 NS_3 0 6.9257653546703612e-03
GC_5_4 ref NI_5 NS_4 0 -3.1676688394305808e-04
GC_5_5 ref NI_5 NS_5 0 4.5449707806933517e-03
GC_5_6 ref NI_5 NS_6 0 1.8809748732178826e-02
GC_5_7 ref NI_5 NS_7 0 2.8777271015701543e-03
GC_5_8 ref NI_5 NS_8 0 -5.8693685328115649e-04
GC_5_9 ref NI_5 NS_9 0 1.7291074966763378e-01
GC_5_10 ref NI_5 NS_10 0 -5.2089129759523137e-02
GC_5_11 ref NI_5 NS_11 0 8.1332400985144348e-04
GC_5_12 ref NI_5 NS_12 0 -5.9945611911025264e-04
GC_5_13 ref NI_5 NS_13 0 1.3710812912409419e-03
GC_5_14 ref NI_5 NS_14 0 8.6151254635598274e-04
GC_5_15 ref NI_5 NS_15 0 1.3174551575562009e-02
GC_5_16 ref NI_5 NS_16 0 -1.0944237977655381e-03
GC_5_17 ref NI_5 NS_17 0 -4.3449461138352058e-01
GC_5_18 ref NI_5 NS_18 0 1.3475647924153525e-02
GC_5_19 ref NI_5 NS_19 0 -1.2862724238754160e-02
GC_5_20 ref NI_5 NS_20 0 -7.3787938272456253e-04
GC_5_21 ref NI_5 NS_21 0 6.9625126976797708e-02
GC_5_22 ref NI_5 NS_22 0 4.6588403259506056e-02
GC_5_23 ref NI_5 NS_23 0 -1.4128295748159641e-02
GC_5_24 ref NI_5 NS_24 0 -7.0528003913786219e-04
GC_5_25 ref NI_5 NS_25 0 2.5417458598773768e-01
GC_5_26 ref NI_5 NS_26 0 -7.2934584999003071e-02
GC_5_27 ref NI_5 NS_27 0 -3.8276801781493069e-03
GC_5_28 ref NI_5 NS_28 0 -1.9324857361568079e-03
GC_5_29 ref NI_5 NS_29 0 -5.9868199946949497e-03
GC_5_30 ref NI_5 NS_30 0 3.0525168630141245e-03
GC_5_31 ref NI_5 NS_31 0 2.4911905093645162e-03
GC_5_32 ref NI_5 NS_32 0 2.4759482110188915e-03
GC_5_33 ref NI_5 NS_33 0 -8.4836518523875720e-03
GC_5_34 ref NI_5 NS_34 0 9.4689214358814333e-03
GC_5_35 ref NI_5 NS_35 0 1.4569381687431727e-03
GC_5_36 ref NI_5 NS_36 0 2.1732530271381602e-03
GC_5_37 ref NI_5 NS_37 0 -4.1117281408244374e-03
GC_5_38 ref NI_5 NS_38 0 5.8502065475510836e-03
GC_5_39 ref NI_5 NS_39 0 5.3263802967638751e-03
GC_5_40 ref NI_5 NS_40 0 1.0738615957440007e-03
GD_5_1 ref NI_5 NA_1 0 7.0248174421450316e-03
GD_5_2 ref NI_5 NA_2 0 1.2564201001003067e-01
GD_5_3 ref NI_5 NA_3 0 5.1567587510730895e-01
GD_5_4 ref NI_5 NA_4 0 4.3469599889287287e-02
GD_5_5 ref NI_5 NA_5 0 4.2239470800737378e+00
GD_5_6 ref NI_5 NA_6 0 -1.0418394218580114e-01
GD_5_7 ref NI_5 NA_7 0 1.0504204334805141e+00
GD_5_8 ref NI_5 NA_8 0 1.1234873926655814e-02
GD_5_9 ref NI_5 NA_9 0 1.3901713561430039e-03
GD_5_10 ref NI_5 NA_10 0 -8.3339012166082967e-04
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -7.5101805393008722e-03
GC_6_2 ref NI_6 NS_2 0 -1.1354232871418258e-02
GC_6_3 ref NI_6 NS_3 0 1.3788630643682886e-02
GC_6_4 ref NI_6 NS_4 0 4.6539314973729112e-04
GC_6_5 ref NI_6 NS_5 0 -2.8902308768745992e-02
GC_6_6 ref NI_6 NS_6 0 5.1088427268053040e-03
GC_6_7 ref NI_6 NS_7 0 1.2653327498737659e-02
GC_6_8 ref NI_6 NS_8 0 -5.7634054354328422e-04
GC_6_9 ref NI_6 NS_9 0 -4.9512339467346095e-02
GC_6_10 ref NI_6 NS_10 0 5.6432743847236212e-02
GC_6_11 ref NI_6 NS_11 0 -4.2933992223931124e-03
GC_6_12 ref NI_6 NS_12 0 3.3091172518434018e-04
GC_6_13 ref NI_6 NS_13 0 1.1131173279161715e-03
GC_6_14 ref NI_6 NS_14 0 1.9243385748421535e-02
GC_6_15 ref NI_6 NS_15 0 1.4102975284054841e-02
GC_6_16 ref NI_6 NS_16 0 -3.2318626246975687e-03
GC_6_17 ref NI_6 NS_17 0 6.9625126976797416e-02
GC_6_18 ref NI_6 NS_18 0 4.6588403259506153e-02
GC_6_19 ref NI_6 NS_19 0 -1.4128295748159643e-02
GC_6_20 ref NI_6 NS_20 0 -7.0528003913786783e-04
GC_6_21 ref NI_6 NS_21 0 -8.2533854051631952e-02
GC_6_22 ref NI_6 NS_22 0 -1.4344963862562807e-01
GC_6_23 ref NI_6 NS_23 0 -1.2917686029269971e-02
GC_6_24 ref NI_6 NS_24 0 -3.8674433379498759e-03
GC_6_25 ref NI_6 NS_25 0 1.2666492479962305e-01
GC_6_26 ref NI_6 NS_26 0 4.5287441599005822e-02
GC_6_27 ref NI_6 NS_27 0 -2.0836965237025905e-02
GC_6_28 ref NI_6 NS_28 0 -1.0017613318335698e-03
GC_6_29 ref NI_6 NS_29 0 -3.6099540335024526e-04
GC_6_30 ref NI_6 NS_30 0 -6.4000635159323317e-03
GC_6_31 ref NI_6 NS_31 0 1.4042423603906134e-03
GC_6_32 ref NI_6 NS_32 0 3.5585404986562584e-03
GC_6_33 ref NI_6 NS_33 0 -8.6478022703807486e-03
GC_6_34 ref NI_6 NS_34 0 -3.2698297653338481e-03
GC_6_35 ref NI_6 NS_35 0 2.7419633504494577e-03
GC_6_36 ref NI_6 NS_36 0 3.0227965500796909e-03
GC_6_37 ref NI_6 NS_37 0 3.0126417425484865e-04
GC_6_38 ref NI_6 NS_38 0 -1.1657099300761897e-02
GC_6_39 ref NI_6 NS_39 0 7.8326749336134222e-03
GC_6_40 ref NI_6 NS_40 0 1.9830621199190351e-03
GD_6_1 ref NI_6 NA_1 0 5.1738655203014426e-02
GD_6_2 ref NI_6 NA_2 0 1.4310972952873754e-01
GD_6_3 ref NI_6 NA_3 0 1.0090003701567917e-02
GD_6_4 ref NI_6 NA_4 0 -8.6175973009156078e-03
GD_6_5 ref NI_6 NA_5 0 -1.0418394218579868e-01
GD_6_6 ref NI_6 NA_6 0 5.9992581340403417e+00
GD_6_7 ref NI_6 NA_7 0 -1.4338536357515796e-01
GD_6_8 ref NI_6 NA_8 0 2.9485622792123672e-02
GD_6_9 ref NI_6 NA_9 0 6.7599195759933409e-02
GD_6_10 ref NI_6 NA_10 0 2.8831823187676069e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 -1.9112023528114978e-02
GC_7_2 ref NI_7 NS_2 0 6.1103361188822808e-03
GC_7_3 ref NI_7 NS_3 0 1.1206864905575004e-02
GC_7_4 ref NI_7 NS_4 0 -9.1818456652352197e-05
GC_7_5 ref NI_7 NS_5 0 -3.4155917780585424e-02
GC_7_6 ref NI_7 NS_6 0 2.3215858213469991e-02
GC_7_7 ref NI_7 NS_7 0 7.4948742787113685e-03
GC_7_8 ref NI_7 NS_8 0 -6.3541995128601125e-04
GC_7_9 ref NI_7 NS_9 0 6.5259655069917488e-02
GC_7_10 ref NI_7 NS_10 0 3.1827881938703402e-02
GC_7_11 ref NI_7 NS_11 0 -8.8242574022082704e-03
GC_7_12 ref NI_7 NS_12 0 5.1446003301779044e-04
GC_7_13 ref NI_7 NS_13 0 -2.3144542367645758e-02
GC_7_14 ref NI_7 NS_14 0 6.8308561466187395e-03
GC_7_15 ref NI_7 NS_15 0 1.6419051214168773e-02
GC_7_16 ref NI_7 NS_16 0 -1.6154967757793007e-03
GC_7_17 ref NI_7 NS_17 0 2.5417458598773768e-01
GC_7_18 ref NI_7 NS_18 0 -7.2934584999003127e-02
GC_7_19 ref NI_7 NS_19 0 -3.8276801781492978e-03
GC_7_20 ref NI_7 NS_20 0 -1.9324857361568096e-03
GC_7_21 ref NI_7 NS_21 0 1.2666492479962313e-01
GC_7_22 ref NI_7 NS_22 0 4.5287441599005794e-02
GC_7_23 ref NI_7 NS_23 0 -2.0836965237025891e-02
GC_7_24 ref NI_7 NS_24 0 -1.0017613318335744e-03
GC_7_25 ref NI_7 NS_25 0 -3.0257696720574478e-01
GC_7_26 ref NI_7 NS_26 0 -4.8295071491847037e-02
GC_7_27 ref NI_7 NS_27 0 -1.4163017159096378e-02
GC_7_28 ref NI_7 NS_28 0 -2.1494184128401780e-03
GC_7_29 ref NI_7 NS_29 0 -7.0136812113264302e-03
GC_7_30 ref NI_7 NS_30 0 -2.2764168665981395e-03
GC_7_31 ref NI_7 NS_31 0 2.8558869943991960e-03
GC_7_32 ref NI_7 NS_32 0 2.9414190984385523e-03
GC_7_33 ref NI_7 NS_33 0 -1.7269772313863625e-02
GC_7_34 ref NI_7 NS_34 0 4.6409168162156221e-03
GC_7_35 ref NI_7 NS_35 0 2.8929297693856314e-03
GC_7_36 ref NI_7 NS_36 0 2.5074913769263692e-03
GC_7_37 ref NI_7 NS_37 0 -1.1472261592179046e-02
GC_7_38 ref NI_7 NS_38 0 -1.1626765877735137e-03
GC_7_39 ref NI_7 NS_39 0 7.5475361266135561e-03
GC_7_40 ref NI_7 NS_40 0 1.4143064075675669e-03
GD_7_1 ref NI_7 NA_1 0 2.0025723651127841e-02
GD_7_2 ref NI_7 NA_2 0 8.1326430595913907e-02
GD_7_3 ref NI_7 NA_3 0 -4.9161401604510319e-01
GD_7_4 ref NI_7 NA_4 0 3.3774968743481487e-02
GD_7_5 ref NI_7 NA_5 0 1.0504204334805136e+00
GD_7_6 ref NI_7 NA_6 0 -1.4338536357515869e-01
GD_7_7 ref NI_7 NA_7 0 5.2938313617258537e+00
GD_7_8 ref NI_7 NA_8 0 3.4625839414356353e-02
GD_7_9 ref NI_7 NA_9 0 6.1418566955501033e-02
GD_7_10 ref NI_7 NA_10 0 3.4834166045377063e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 1.1425567869272160e-03
GC_8_2 ref NI_8 NS_2 0 -6.2444310179425328e-03
GC_8_3 ref NI_8 NS_3 0 2.3128987377884734e-03
GC_8_4 ref NI_8 NS_4 0 3.5936508219707639e-03
GC_8_5 ref NI_8 NS_5 0 -5.2503385611797210e-03
GC_8_6 ref NI_8 NS_6 0 -1.7078394302983278e-03
GC_8_7 ref NI_8 NS_7 0 1.4137348805371226e-03
GC_8_8 ref NI_8 NS_8 0 3.0744468800528715e-03
GC_8_9 ref NI_8 NS_9 0 1.0379572200941373e-02
GC_8_10 ref NI_8 NS_10 0 1.3227691638512024e-02
GC_8_11 ref NI_8 NS_11 0 2.7392920248299067e-03
GC_8_12 ref NI_8 NS_12 0 4.6883601049536563e-04
GC_8_13 ref NI_8 NS_13 0 -8.7026143943325137e-03
GC_8_14 ref NI_8 NS_14 0 6.2856700886749642e-03
GC_8_15 ref NI_8 NS_15 0 -7.6590065364938089e-03
GC_8_16 ref NI_8 NS_16 0 5.4763809114872991e-03
GC_8_17 ref NI_8 NS_17 0 -5.9868199946949280e-03
GC_8_18 ref NI_8 NS_18 0 3.0525168630140993e-03
GC_8_19 ref NI_8 NS_19 0 2.4911905093645370e-03
GC_8_20 ref NI_8 NS_20 0 2.4759482110188816e-03
GC_8_21 ref NI_8 NS_21 0 -3.6099540335026548e-04
GC_8_22 ref NI_8 NS_22 0 -6.4000635159323230e-03
GC_8_23 ref NI_8 NS_23 0 1.4042423603906097e-03
GC_8_24 ref NI_8 NS_24 0 3.5585404986562589e-03
GC_8_25 ref NI_8 NS_25 0 -7.0136812113262602e-03
GC_8_26 ref NI_8 NS_26 0 -2.2764168665982232e-03
GC_8_27 ref NI_8 NS_27 0 2.8558869943992181e-03
GC_8_28 ref NI_8 NS_28 0 2.9414190984385470e-03
GC_8_29 ref NI_8 NS_29 0 7.6926478467022191e-02
GC_8_30 ref NI_8 NS_30 0 -9.4346538349992376e-02
GC_8_31 ref NI_8 NS_31 0 -2.6180357577755758e-02
GC_8_32 ref NI_8 NS_32 0 -1.3162386749810880e-02
GC_8_33 ref NI_8 NS_33 0 -6.3525049853697474e-02
GC_8_34 ref NI_8 NS_34 0 9.6368903664363625e-02
GC_8_35 ref NI_8 NS_35 0 1.6323429369773830e-02
GC_8_36 ref NI_8 NS_36 0 -1.1256259178092910e-02
GC_8_37 ref NI_8 NS_37 0 4.0257231115240870e-03
GC_8_38 ref NI_8 NS_38 0 -7.8896409375333217e-03
GC_8_39 ref NI_8 NS_39 0 4.0821874881054789e-03
GC_8_40 ref NI_8 NS_40 0 2.9172571951812921e-03
GD_8_1 ref NI_8 NA_1 0 1.4835993198352849e-03
GD_8_2 ref NI_8 NA_2 0 4.5260839915113267e-02
GD_8_3 ref NI_8 NA_3 0 1.6300391155247094e-02
GD_8_4 ref NI_8 NA_4 0 5.0138304722743103e-02
GD_8_5 ref NI_8 NA_5 0 1.1234873926655653e-02
GD_8_6 ref NI_8 NA_6 0 2.9485622792123901e-02
GD_8_7 ref NI_8 NA_7 0 3.4625839414355472e-02
GD_8_8 ref NI_8 NA_8 0 5.8361145524604012e+00
GD_8_9 ref NI_8 NA_9 0 2.7144289016466705e-01
GD_8_10 ref NI_8 NA_10 0 -8.0999734798516045e-03
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -5.7965562023812546e-03
GC_9_2 ref NI_9 NS_2 0 -2.2170373257362603e-03
GC_9_3 ref NI_9 NS_3 0 3.3004360046996676e-03
GC_9_4 ref NI_9 NS_4 0 3.0426505252549195e-03
GC_9_5 ref NI_9 NS_5 0 -1.1834511673419860e-02
GC_9_6 ref NI_9 NS_6 0 2.5576278320772233e-03
GC_9_7 ref NI_9 NS_7 0 1.8967917494150022e-03
GC_9_8 ref NI_9 NS_8 0 2.6416378529835224e-03
GC_9_9 ref NI_9 NS_9 0 3.6921621092430225e-02
GC_9_10 ref NI_9 NS_10 0 1.3474588906674682e-02
GC_9_11 ref NI_9 NS_11 0 -1.1786218929426074e-03
GC_9_12 ref NI_9 NS_12 0 5.4470301788081901e-04
GC_9_13 ref NI_9 NS_13 0 -6.6178154328519539e-03
GC_9_14 ref NI_9 NS_14 0 3.5790096142600102e-03
GC_9_15 ref NI_9 NS_15 0 -5.5617855673979165e-03
GC_9_16 ref NI_9 NS_16 0 5.0152846093489351e-03
GC_9_17 ref NI_9 NS_17 0 -8.4836518523874593e-03
GC_9_18 ref NI_9 NS_18 0 9.4689214358814073e-03
GC_9_19 ref NI_9 NS_19 0 1.4569381687431554e-03
GC_9_20 ref NI_9 NS_20 0 2.1732530271381732e-03
GC_9_21 ref NI_9 NS_21 0 -8.6478022703808787e-03
GC_9_22 ref NI_9 NS_22 0 -3.2698297653337557e-03
GC_9_23 ref NI_9 NS_23 0 2.7419633504494165e-03
GC_9_24 ref NI_9 NS_24 0 3.0227965500797078e-03
GC_9_25 ref NI_9 NS_25 0 -1.7269772313863639e-02
GC_9_26 ref NI_9 NS_26 0 4.6409168162156117e-03
GC_9_27 ref NI_9 NS_27 0 2.8929297693856409e-03
GC_9_28 ref NI_9 NS_28 0 2.5074913769263653e-03
GC_9_29 ref NI_9 NS_29 0 -6.3525049853697044e-02
GC_9_30 ref NI_9 NS_30 0 9.6368903664363445e-02
GC_9_31 ref NI_9 NS_31 0 1.6323429369773858e-02
GC_9_32 ref NI_9 NS_32 0 -1.1256259178092906e-02
GC_9_33 ref NI_9 NS_33 0 9.0632501023641676e-02
GC_9_34 ref NI_9 NS_34 0 -1.2143597782278678e-01
GC_9_35 ref NI_9 NS_35 0 -2.6787548090995386e-02
GC_9_36 ref NI_9 NS_36 0 -1.0004345900913002e-02
GC_9_37 ref NI_9 NS_37 0 -2.3970898754661967e-03
GC_9_38 ref NI_9 NS_38 0 -3.3942253435852773e-03
GC_9_39 ref NI_9 NS_39 0 4.7629127422062776e-03
GC_9_40 ref NI_9 NS_40 0 2.3918972569143670e-03
GD_9_1 ref NI_9 NA_1 0 2.2176404163650555e-02
GD_9_2 ref NI_9 NA_2 0 6.8911535231787654e-02
GD_9_3 ref NI_9 NA_3 0 -3.6505394485929057e-02
GD_9_4 ref NI_9 NA_4 0 4.1937621882331660e-02
GD_9_5 ref NI_9 NA_5 0 1.3901713561418263e-03
GD_9_6 ref NI_9 NA_6 0 6.7599195759933978e-02
GD_9_7 ref NI_9 NA_7 0 6.1418566955501339e-02
GD_9_8 ref NI_9 NA_8 0 2.7144289016466444e-01
GD_9_9 ref NI_9 NA_9 0 5.7605457417896124e+00
GD_9_10 ref NI_9 NA_10 0 1.2890180060664346e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 3.4152770243157222e-03
GC_10_2 ref NI_10 NS_2 0 -1.0285580946844975e-02
GC_10_3 ref NI_10 NS_3 0 7.5992844285747204e-03
GC_10_4 ref NI_10 NS_4 0 2.2072106244534644e-03
GC_10_5 ref NI_10 NS_5 0 -7.9420750381528123e-03
GC_10_6 ref NI_10 NS_6 0 -1.0322715922082759e-03
GC_10_7 ref NI_10 NS_7 0 7.5339692758095485e-03
GC_10_8 ref NI_10 NS_8 0 9.8185224298762944e-04
GC_10_9 ref NI_10 NS_9 0 2.6632040551629509e-02
GC_10_10 ref NI_10 NS_10 0 1.8400533642846616e-02
GC_10_11 ref NI_10 NS_11 0 3.1040474783939736e-04
GC_10_12 ref NI_10 NS_12 0 -1.4504733171506189e-04
GC_10_13 ref NI_10 NS_13 0 6.9632691469135449e-03
GC_10_14 ref NI_10 NS_14 0 -6.6199658080162383e-03
GC_10_15 ref NI_10 NS_15 0 -8.4110708649984376e-04
GC_10_16 ref NI_10 NS_16 0 4.1723131631767789e-03
GC_10_17 ref NI_10 NS_17 0 -4.1117281408244513e-03
GC_10_18 ref NI_10 NS_18 0 5.8502065475510966e-03
GC_10_19 ref NI_10 NS_19 0 5.3263802967638673e-03
GC_10_20 ref NI_10 NS_20 0 1.0738615957440038e-03
GC_10_21 ref NI_10 NS_21 0 3.0126417425463777e-04
GC_10_22 ref NI_10 NS_22 0 -1.1657099300761834e-02
GC_10_23 ref NI_10 NS_23 0 7.8326749336134240e-03
GC_10_24 ref NI_10 NS_24 0 1.9830621199190294e-03
GC_10_25 ref NI_10 NS_25 0 -1.1472261592179150e-02
GC_10_26 ref NI_10 NS_26 0 -1.1626765877734786e-03
GC_10_27 ref NI_10 NS_27 0 7.5475361266135492e-03
GC_10_28 ref NI_10 NS_28 0 1.4143064075675680e-03
GC_10_29 ref NI_10 NS_29 0 4.0257231115242501e-03
GC_10_30 ref NI_10 NS_30 0 -7.8896409375334049e-03
GC_10_31 ref NI_10 NS_31 0 4.0821874881054980e-03
GC_10_32 ref NI_10 NS_32 0 2.9172571951812903e-03
GC_10_33 ref NI_10 NS_33 0 -2.3970898754660870e-03
GC_10_34 ref NI_10 NS_34 0 -3.3942253435853193e-03
GC_10_35 ref NI_10 NS_35 0 4.7629127422062793e-03
GC_10_36 ref NI_10 NS_36 0 2.3918972569143692e-03
GC_10_37 ref NI_10 NS_37 0 -1.0795142680020233e-02
GC_10_38 ref NI_10 NS_38 0 1.7133747881247670e-02
GC_10_39 ref NI_10 NS_39 0 -4.4212602598148937e-02
GC_10_40 ref NI_10 NS_40 0 -1.6929582470277434e-02
GD_10_1 ref NI_10 NA_1 0 -1.6829491186838116e-02
GD_10_2 ref NI_10 NA_2 0 6.1660856339128045e-02
GD_10_3 ref NI_10 NA_3 0 -1.2698311197561768e-02
GD_10_4 ref NI_10 NA_4 0 -2.2359292084544118e-02
GD_10_5 ref NI_10 NA_5 0 -8.3339012166080550e-04
GD_10_6 ref NI_10 NA_6 0 2.8831823187677692e-02
GD_10_7 ref NI_10 NA_7 0 3.4834166045378000e-02
GD_10_8 ref NI_10 NA_8 0 -8.0999734798525673e-03
GD_10_9 ref NI_10 NA_9 0 1.2890180060663789e-02
GD_10_10 ref NI_10 NA_10 0 6.1762984592776853e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.2079593733952817e+02
GS_1_1 0 NS_1 NA_1 0 1.5145389302936735e-01
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 2.9182700740579787e+02
GS_2_1 0 NS_2 NA_1 0 1.5145389302936735e-01
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 7.8026227353026741e+02
GS_3_1 0 NS_3 NA_1 0 1.5145389302936735e-01
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 2.1917706758593927e+03
GS_4_1 0 NS_4 NA_1 0 1.5145389302936735e-01
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.2079593733952817e+02
GS_5_2 0 NS_5 NA_2 0 1.5145389302936735e-01
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 2.9182700740579787e+02
GS_6_2 0 NS_6 NA_2 0 1.5145389302936735e-01
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 7.8026227353026741e+02
GS_7_2 0 NS_7 NA_2 0 1.5145389302936735e-01
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 2.1917706758593927e+03
GS_8_2 0 NS_8 NA_2 0 1.5145389302936735e-01
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.2079593733952817e+02
GS_9_3 0 NS_9 NA_3 0 1.5145389302936735e-01
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 2.9182700740579787e+02
GS_10_3 0 NS_10 NA_3 0 1.5145389302936735e-01
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 7.8026227353026741e+02
GS_11_3 0 NS_11 NA_3 0 1.5145389302936735e-01
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 2.1917706758593927e+03
GS_12_3 0 NS_12 NA_3 0 1.5145389302936735e-01
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.2079593733952817e+02
GS_13_4 0 NS_13 NA_4 0 1.5145389302936735e-01
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 2.9182700740579787e+02
GS_14_4 0 NS_14 NA_4 0 1.5145389302936735e-01
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 7.8026227353026741e+02
GS_15_4 0 NS_15 NA_4 0 1.5145389302936735e-01
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 2.1917706758593927e+03
GS_16_4 0 NS_16 NA_4 0 1.5145389302936735e-01
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.2079593733952817e+02
GS_17_5 0 NS_17 NA_5 0 1.5145389302936735e-01
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 2.9182700740579787e+02
GS_18_5 0 NS_18 NA_5 0 1.5145389302936735e-01
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 7.8026227353026741e+02
GS_19_5 0 NS_19 NA_5 0 1.5145389302936735e-01
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 2.1917706758593927e+03
GS_20_5 0 NS_20 NA_5 0 1.5145389302936735e-01
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.2079593733952817e+02
GS_21_6 0 NS_21 NA_6 0 1.5145389302936735e-01
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 2.9182700740579787e+02
GS_22_6 0 NS_22 NA_6 0 1.5145389302936735e-01
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 7.8026227353026741e+02
GS_23_6 0 NS_23 NA_6 0 1.5145389302936735e-01
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 2.1917706758593927e+03
GS_24_6 0 NS_24 NA_6 0 1.5145389302936735e-01
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.2079593733952817e+02
GS_25_7 0 NS_25 NA_7 0 1.5145389302936735e-01
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 2.9182700740579787e+02
GS_26_7 0 NS_26 NA_7 0 1.5145389302936735e-01
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 7.8026227353026741e+02
GS_27_7 0 NS_27 NA_7 0 1.5145389302936735e-01
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 2.1917706758593927e+03
GS_28_7 0 NS_28 NA_7 0 1.5145389302936735e-01
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.2079593733952817e+02
GS_29_8 0 NS_29 NA_8 0 1.5145389302936735e-01
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 2.9182700740579787e+02
GS_30_8 0 NS_30 NA_8 0 1.5145389302936735e-01
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 7.8026227353026741e+02
GS_31_8 0 NS_31 NA_8 0 1.5145389302936735e-01
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 2.1917706758593927e+03
GS_32_8 0 NS_32 NA_8 0 1.5145389302936735e-01
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 1.2079593733952817e+02
GS_33_9 0 NS_33 NA_9 0 1.5145389302936735e-01
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 2.9182700740579787e+02
GS_34_9 0 NS_34 NA_9 0 1.5145389302936735e-01
*
* Real pole n. 35
CS_35 NS_35 0 9.9999999999999998e-13
RS_35 NS_35 0 7.8026227353026741e+02
GS_35_9 0 NS_35 NA_9 0 1.5145389302936735e-01
*
* Real pole n. 36
CS_36 NS_36 0 9.9999999999999998e-13
RS_36 NS_36 0 2.1917706758593927e+03
GS_36_9 0 NS_36 NA_9 0 1.5145389302936735e-01
*
* Real pole n. 37
CS_37 NS_37 0 9.9999999999999998e-13
RS_37 NS_37 0 1.2079593733952817e+02
GS_37_10 0 NS_37 NA_10 0 1.5145389302936735e-01
*
* Real pole n. 38
CS_38 NS_38 0 9.9999999999999998e-13
RS_38 NS_38 0 2.9182700740579787e+02
GS_38_10 0 NS_38 NA_10 0 1.5145389302936735e-01
*
* Real pole n. 39
CS_39 NS_39 0 9.9999999999999998e-13
RS_39 NS_39 0 7.8026227353026741e+02
GS_39_10 0 NS_39 NA_10 0 1.5145389302936735e-01
*
* Real pole n. 40
CS_40 NS_40 0 9.9999999999999998e-13
RS_40 NS_40 0 2.1917706758593927e+03
GS_40_10 0 NS_40 NA_10 0 1.5145389302936735e-01
*
******************************

.ends
*******************
* End of subcircuit
*******************
