**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 18-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Thu Apr 17 17:05:54 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Thu Apr 17 17:05:54 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_VDDCR_AIE_Group_DIE1_GRP_1_1_VSS
**  Port[2] = PORT_2_BGA1_VDDCR_AIE_Group_BGA1_GRP_1_1_VSS
**  Port[3] = VDDCR_AIE_C10_2
**  Port[4] = VDDCR_AIE_C32_2
**  Port[5] = VDDCR_AIE_C90_1
**  Port[6] = VDDCR_AIE_C91_1
**  Port[7] = VDDCR_AIE_C126_2
**  Port[8] = VDDCR_AIE_C127_1
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 4]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_AIE
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -4.0484555239832132e-01
GC_1_2 ref NI_1 NS_2 0 -1.2075026094142207e-02
GC_1_3 ref NI_1 NS_3 0 -2.2915776526145432e-02
GC_1_4 ref NI_1 NS_4 0 -2.5460076391788287e-03
GC_1_5 ref NI_1 NS_5 0 4.2495079091121329e-01
GC_1_6 ref NI_1 NS_6 0 -1.2807608155768289e-02
GC_1_7 ref NI_1 NS_7 0 -1.0412689264003631e-02
GC_1_8 ref NI_1 NS_8 0 -1.5023421109075487e-02
GC_1_9 ref NI_1 NS_9 0 1.2115832714250844e-02
GC_1_10 ref NI_1 NS_10 0 1.9105048112428487e-03
GC_1_11 ref NI_1 NS_11 0 4.5906836083308214e-03
GC_1_12 ref NI_1 NS_12 0 7.5132569138659589e-03
GC_1_13 ref NI_1 NS_13 0 7.1577506982755078e-03
GC_1_14 ref NI_1 NS_14 0 3.3570307397991122e-03
GC_1_15 ref NI_1 NS_15 0 2.5627273010043995e-04
GC_1_16 ref NI_1 NS_16 0 7.6829395137244768e-03
GC_1_17 ref NI_1 NS_17 0 2.3340658612379175e-03
GC_1_18 ref NI_1 NS_18 0 5.1674303418554647e-03
GC_1_19 ref NI_1 NS_19 0 -2.7137994438776658e-03
GC_1_20 ref NI_1 NS_20 0 6.3464837152966743e-03
GC_1_21 ref NI_1 NS_21 0 2.2832972720696225e-02
GC_1_22 ref NI_1 NS_22 0 1.9310956356943809e-03
GC_1_23 ref NI_1 NS_23 0 1.3021710762619100e-02
GC_1_24 ref NI_1 NS_24 0 2.9389453907913313e-05
GC_1_25 ref NI_1 NS_25 0 7.8628911549367565e-03
GC_1_26 ref NI_1 NS_26 0 4.1283307376668507e-03
GC_1_27 ref NI_1 NS_27 0 1.1034551632770309e-03
GC_1_28 ref NI_1 NS_28 0 5.0401798431761345e-03
GC_1_29 ref NI_1 NS_29 0 3.2369614985684478e-03
GC_1_30 ref NI_1 NS_30 0 7.3099507975480683e-03
GC_1_31 ref NI_1 NS_31 0 -5.0369306782449760e-03
GC_1_32 ref NI_1 NS_32 0 2.8103830633981592e-03
GD_1_1 ref NI_1 NA_1 0 5.3786263263493410e+00
GD_1_2 ref NI_1 NA_2 0 -5.4245916903920943e-02
GD_1_3 ref NI_1 NA_3 0 5.5140531246496698e-02
GD_1_4 ref NI_1 NA_4 0 5.9411586195697183e-02
GD_1_5 ref NI_1 NA_5 0 4.8691843062880671e-02
GD_1_6 ref NI_1 NA_6 0 5.6870099460886621e-02
GD_1_7 ref NI_1 NA_7 0 6.4017826162553429e-02
GD_1_8 ref NI_1 NA_8 0 3.4612415999725116e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 4.2495079091121318e-01
GC_2_2 ref NI_2 NS_2 0 -1.2807608155768188e-02
GC_2_3 ref NI_2 NS_3 0 -1.0412689264003303e-02
GC_2_4 ref NI_2 NS_4 0 -1.5023421109075842e-02
GC_2_5 ref NI_2 NS_5 0 -2.6340272664917352e-01
GC_2_6 ref NI_2 NS_6 0 -1.8476977159517499e-02
GC_2_7 ref NI_2 NS_7 0 -1.8006981789079949e-02
GC_2_8 ref NI_2 NS_8 0 -1.6455354938533017e-02
GC_2_9 ref NI_2 NS_9 0 -2.3115010594854955e-02
GC_2_10 ref NI_2 NS_10 0 2.6590165583940837e-03
GC_2_11 ref NI_2 NS_11 0 4.4190469310980548e-03
GC_2_12 ref NI_2 NS_12 0 1.1960580661726639e-02
GC_2_13 ref NI_2 NS_13 0 -1.6963905475583265e-02
GC_2_14 ref NI_2 NS_14 0 4.3917184128230979e-03
GC_2_15 ref NI_2 NS_15 0 -1.8633935070852508e-03
GC_2_16 ref NI_2 NS_16 0 1.0899358165986511e-02
GC_2_17 ref NI_2 NS_17 0 -1.1557539764450939e-02
GC_2_18 ref NI_2 NS_18 0 6.5253781645464339e-03
GC_2_19 ref NI_2 NS_19 0 -6.5055901137362829e-03
GC_2_20 ref NI_2 NS_20 0 8.0647652639802923e-03
GC_2_21 ref NI_2 NS_21 0 -2.9238669464053606e-02
GC_2_22 ref NI_2 NS_22 0 2.6584228914156628e-03
GC_2_23 ref NI_2 NS_23 0 2.3611207690162530e-02
GC_2_24 ref NI_2 NS_24 0 4.9786567283516226e-04
GC_2_25 ref NI_2 NS_25 0 -1.6094725733446329e-02
GC_2_26 ref NI_2 NS_26 0 5.3158834534019362e-03
GC_2_27 ref NI_2 NS_27 0 1.6516310719585702e-03
GC_2_28 ref NI_2 NS_28 0 6.2038381925942380e-03
GC_2_29 ref NI_2 NS_29 0 -5.2108309539533959e-03
GC_2_30 ref NI_2 NS_30 0 9.1639285457314097e-03
GC_2_31 ref NI_2 NS_31 0 -5.0194908201310574e-03
GC_2_32 ref NI_2 NS_32 0 8.3511684215926311e-06
GD_2_1 ref NI_2 NA_1 0 -5.4245916903920943e-02
GD_2_2 ref NI_2 NA_2 0 5.4725594095862871e+00
GD_2_3 ref NI_2 NA_3 0 5.7394235444375732e-02
GD_2_4 ref NI_2 NA_4 0 5.4771716149771887e-02
GD_2_5 ref NI_2 NA_5 0 4.9484650448292859e-02
GD_2_6 ref NI_2 NA_6 0 4.9750012632991954e-02
GD_2_7 ref NI_2 NA_7 0 5.2808549774006910e-02
GD_2_8 ref NI_2 NA_8 0 2.9593287408443587e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 1.2115832714250842e-02
GC_3_2 ref NI_3 NS_2 0 1.9105048112428489e-03
GC_3_3 ref NI_3 NS_3 0 4.5906836083308223e-03
GC_3_4 ref NI_3 NS_4 0 7.5132569138659563e-03
GC_3_5 ref NI_3 NS_5 0 -2.3115010594854928e-02
GC_3_6 ref NI_3 NS_6 0 2.6590165583940464e-03
GC_3_7 ref NI_3 NS_7 0 4.4190469310979308e-03
GC_3_8 ref NI_3 NS_8 0 1.1960580661726776e-02
GC_3_9 ref NI_3 NS_9 0 1.7751288742385619e-02
GC_3_10 ref NI_3 NS_10 0 -5.5370239501677564e-03
GC_3_11 ref NI_3 NS_11 0 -6.5209292872078758e-02
GC_3_12 ref NI_3 NS_12 0 -7.4125873769339989e-02
GC_3_13 ref NI_3 NS_13 0 -2.3907531287205826e-03
GC_3_14 ref NI_3 NS_14 0 -1.7774578520832480e-03
GC_3_15 ref NI_3 NS_15 0 6.7260812396138306e-02
GC_3_16 ref NI_3 NS_16 0 -2.0968834180556364e-02
GC_3_17 ref NI_3 NS_17 0 1.5297053121144375e-03
GC_3_18 ref NI_3 NS_18 0 1.2119453086212493e-03
GC_3_19 ref NI_3 NS_19 0 -1.6975149469411654e-02
GC_3_20 ref NI_3 NS_20 0 2.6824502042472768e-02
GC_3_21 ref NI_3 NS_21 0 4.2553223790584341e-04
GC_3_22 ref NI_3 NS_22 0 -3.7836623901388333e-04
GC_3_23 ref NI_3 NS_23 0 2.1801568384430647e-02
GC_3_24 ref NI_3 NS_24 0 5.4571752362794525e-03
GC_3_25 ref NI_3 NS_25 0 -1.3254587049516854e-02
GC_3_26 ref NI_3 NS_26 0 -6.9293124260912261e-04
GC_3_27 ref NI_3 NS_27 0 1.1844501330027431e-02
GC_3_28 ref NI_3 NS_28 0 1.3992612767548211e-02
GC_3_29 ref NI_3 NS_29 0 8.7114093026964563e-03
GC_3_30 ref NI_3 NS_30 0 2.8172802048952498e-03
GC_3_31 ref NI_3 NS_31 0 -2.6879690563725772e-02
GC_3_32 ref NI_3 NS_32 0 2.8518766113078704e-02
GD_3_1 ref NI_3 NA_1 0 5.5140531246496698e-02
GD_3_2 ref NI_3 NA_2 0 5.7394235444375732e-02
GD_3_3 ref NI_3 NA_3 0 6.1607232120507165e+00
GD_3_4 ref NI_3 NA_4 0 8.0903499612564843e-03
GD_3_5 ref NI_3 NA_5 0 -9.9813409720535349e-03
GD_3_6 ref NI_3 NA_6 0 -1.6866479196022688e-02
GD_3_7 ref NI_3 NA_7 0 5.9651986578871226e-02
GD_3_8 ref NI_3 NA_8 0 -3.4287309573504239e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 7.1577506982754887e-03
GC_4_2 ref NI_4 NS_2 0 3.3570307397991416e-03
GC_4_3 ref NI_4 NS_3 0 2.5627273010053606e-04
GC_4_4 ref NI_4 NS_4 0 7.6829395137243718e-03
GC_4_5 ref NI_4 NS_5 0 -1.6963905475583262e-02
GC_4_6 ref NI_4 NS_6 0 4.3917184128230893e-03
GC_4_7 ref NI_4 NS_7 0 -1.8633935070852818e-03
GC_4_8 ref NI_4 NS_8 0 1.0899358165986544e-02
GC_4_9 ref NI_4 NS_9 0 -2.3907531287206073e-03
GC_4_10 ref NI_4 NS_10 0 -1.7774578520832133e-03
GC_4_11 ref NI_4 NS_11 0 6.7260812396138417e-02
GC_4_12 ref NI_4 NS_12 0 -2.0968834180556485e-02
GC_4_13 ref NI_4 NS_13 0 1.0061842410879478e-03
GC_4_14 ref NI_4 NS_14 0 -5.4886947259854763e-03
GC_4_15 ref NI_4 NS_15 0 -1.5596033135311163e-01
GC_4_16 ref NI_4 NS_16 0 -1.2934384480550053e-02
GC_4_17 ref NI_4 NS_17 0 -1.0141118385502510e-03
GC_4_18 ref NI_4 NS_18 0 -2.5032781023723462e-05
GC_4_19 ref NI_4 NS_19 0 -6.7125359837059825e-03
GC_4_20 ref NI_4 NS_20 0 2.3478603264039288e-02
GC_4_21 ref NI_4 NS_21 0 -1.4909770018609132e-03
GC_4_22 ref NI_4 NS_22 0 -9.1963459041067988e-05
GC_4_23 ref NI_4 NS_23 0 2.0235121319841180e-02
GC_4_24 ref NI_4 NS_24 0 5.8120389435363917e-03
GC_4_25 ref NI_4 NS_25 0 1.5649632873201737e-02
GC_4_26 ref NI_4 NS_26 0 -1.6269554390290337e-04
GC_4_27 ref NI_4 NS_27 0 8.7570860293137764e-02
GC_4_28 ref NI_4 NS_28 0 -4.0181409400028581e-02
GC_4_29 ref NI_4 NS_29 0 -3.7533590134079174e-04
GC_4_30 ref NI_4 NS_30 0 2.0034755806855054e-05
GC_4_31 ref NI_4 NS_31 0 -9.9869822350113092e-03
GC_4_32 ref NI_4 NS_32 0 2.5357263580286383e-02
GD_4_1 ref NI_4 NA_1 0 5.9411586195697183e-02
GD_4_2 ref NI_4 NA_2 0 5.4771716149771887e-02
GD_4_3 ref NI_4 NA_3 0 8.0903499612564843e-03
GD_4_4 ref NI_4 NA_4 0 6.2172127031674194e+00
GD_4_5 ref NI_4 NA_5 0 3.1034279749179593e-04
GD_4_6 ref NI_4 NA_6 0 3.4161683546156041e-03
GD_4_7 ref NI_4 NA_7 0 -5.8017666475185199e-02
GD_4_8 ref NI_4 NA_8 0 7.9084803357729408e-04
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 2.3340658612378898e-03
GC_5_2 ref NI_5 NS_2 0 5.1674303418555046e-03
GC_5_3 ref NI_5 NS_3 0 -2.7137994438775378e-03
GC_5_4 ref NI_5 NS_4 0 6.3464837152965329e-03
GC_5_5 ref NI_5 NS_5 0 -1.1557539764450940e-02
GC_5_6 ref NI_5 NS_6 0 6.5253781645464382e-03
GC_5_7 ref NI_5 NS_7 0 -6.5055901137362733e-03
GC_5_8 ref NI_5 NS_8 0 8.0647652639802784e-03
GC_5_9 ref NI_5 NS_9 0 1.5297053121144262e-03
GC_5_10 ref NI_5 NS_10 0 1.2119453086212664e-03
GC_5_11 ref NI_5 NS_11 0 -1.6975149469411602e-02
GC_5_12 ref NI_5 NS_12 0 2.6824502042472706e-02
GC_5_13 ref NI_5 NS_13 0 -1.0141118385502640e-03
GC_5_14 ref NI_5 NS_14 0 -2.5032781023701523e-05
GC_5_15 ref NI_5 NS_15 0 -6.7125359837059166e-03
GC_5_16 ref NI_5 NS_16 0 2.3478603264039211e-02
GC_5_17 ref NI_5 NS_17 0 1.3777219922316109e-02
GC_5_18 ref NI_5 NS_18 0 -6.5924681200049875e-03
GC_5_19 ref NI_5 NS_19 0 -8.3050965492538542e-02
GC_5_20 ref NI_5 NS_20 0 -5.9912442023528682e-02
GC_5_21 ref NI_5 NS_21 0 6.3829620187783095e-03
GC_5_22 ref NI_5 NS_22 0 -1.1548111721486942e-05
GC_5_23 ref NI_5 NS_23 0 7.5160743043301531e-02
GC_5_24 ref NI_5 NS_24 0 -3.1460313374544302e-02
GC_5_25 ref NI_5 NS_25 0 -3.0436603476140878e-03
GC_5_26 ref NI_5 NS_26 0 -9.3965741838816655e-04
GC_5_27 ref NI_5 NS_27 0 2.8806934809730085e-03
GC_5_28 ref NI_5 NS_28 0 1.9456470888720538e-02
GC_5_29 ref NI_5 NS_29 0 -7.6988203167749200e-03
GC_5_30 ref NI_5 NS_30 0 -5.0909486892042229e-03
GC_5_31 ref NI_5 NS_31 0 3.8866604620409188e-02
GC_5_32 ref NI_5 NS_32 0 6.2077861807300948e-03
GD_5_1 ref NI_5 NA_1 0 4.8691843062880671e-02
GD_5_2 ref NI_5 NA_2 0 4.9484650448292859e-02
GD_5_3 ref NI_5 NA_3 0 -9.9813409720535349e-03
GD_5_4 ref NI_5 NA_4 0 3.1034279749179593e-04
GD_5_5 ref NI_5 NA_5 0 6.1833859906451298e+00
GD_5_6 ref NI_5 NA_6 0 -1.3587179441865858e-02
GD_5_7 ref NI_5 NA_7 0 1.0958578991447450e-02
GD_5_8 ref NI_5 NA_8 0 2.8721639247241647e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 2.2832972720696228e-02
GC_6_2 ref NI_6 NS_2 0 1.9310956356943735e-03
GC_6_3 ref NI_6 NS_3 0 1.3021710762619087e-02
GC_6_4 ref NI_6 NS_4 0 2.9389453907935916e-05
GC_6_5 ref NI_6 NS_5 0 -2.9238669464053593e-02
GC_6_6 ref NI_6 NS_6 0 2.6584228914156350e-03
GC_6_7 ref NI_6 NS_7 0 2.3611207690162436e-02
GC_6_8 ref NI_6 NS_8 0 4.9786567283526353e-04
GC_6_9 ref NI_6 NS_9 0 4.2553223790583403e-04
GC_6_10 ref NI_6 NS_10 0 -3.7836623901387145e-04
GC_6_11 ref NI_6 NS_11 0 2.1801568384430689e-02
GC_6_12 ref NI_6 NS_12 0 5.4571752362794100e-03
GC_6_13 ref NI_6 NS_13 0 -1.4909770018608948e-03
GC_6_14 ref NI_6 NS_14 0 -9.1963459041096083e-05
GC_6_15 ref NI_6 NS_15 0 2.0235121319841093e-02
GC_6_16 ref NI_6 NS_16 0 5.8120389435364897e-03
GC_6_17 ref NI_6 NS_17 0 6.3829620187783086e-03
GC_6_18 ref NI_6 NS_18 0 -1.1548111721486663e-05
GC_6_19 ref NI_6 NS_19 0 7.5160743043301531e-02
GC_6_20 ref NI_6 NS_20 0 -3.1460313374544309e-02
GC_6_21 ref NI_6 NS_21 0 8.9888753628779763e-03
GC_6_22 ref NI_6 NS_22 0 -4.2408576491212279e-03
GC_6_23 ref NI_6 NS_23 0 -1.6458494701312937e-01
GC_6_24 ref NI_6 NS_24 0 -1.0266046457271447e-02
GC_6_25 ref NI_6 NS_25 0 -6.8358941653858386e-04
GC_6_26 ref NI_6 NS_26 0 3.4563115775671535e-04
GC_6_27 ref NI_6 NS_27 0 2.0045453012008389e-02
GC_6_28 ref NI_6 NS_28 0 4.5287969125345400e-03
GC_6_29 ref NI_6 NS_29 0 -4.3452737526248611e-03
GC_6_30 ref NI_6 NS_30 0 -1.1312028737240533e-05
GC_6_31 ref NI_6 NS_31 0 -8.4485066346802629e-03
GC_6_32 ref NI_6 NS_32 0 2.4587409436944475e-02
GD_6_1 ref NI_6 NA_1 0 5.6870099460886621e-02
GD_6_2 ref NI_6 NA_2 0 4.9750012632991954e-02
GD_6_3 ref NI_6 NA_3 0 -1.6866479196022688e-02
GD_6_4 ref NI_6 NA_4 0 3.4161683546156041e-03
GD_6_5 ref NI_6 NA_5 0 -1.3587179441865858e-02
GD_6_6 ref NI_6 NA_6 0 6.1474217959715460e+00
GD_6_7 ref NI_6 NA_7 0 1.2108998965328292e-02
GD_6_8 ref NI_6 NA_8 0 2.6201390499547408e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 7.8628911549367408e-03
GC_7_2 ref NI_7 NS_2 0 4.1283307376668759e-03
GC_7_3 ref NI_7 NS_3 0 1.1034551632771135e-03
GC_7_4 ref NI_7 NS_4 0 5.0401798431760425e-03
GC_7_5 ref NI_7 NS_5 0 -1.6094725733446304e-02
GC_7_6 ref NI_7 NS_6 0 5.3158834534019163e-03
GC_7_7 ref NI_7 NS_7 0 1.6516310719584997e-03
GC_7_8 ref NI_7 NS_8 0 6.2038381925943135e-03
GC_7_9 ref NI_7 NS_9 0 -1.3254587049516873e-02
GC_7_10 ref NI_7 NS_10 0 -6.9293124260909171e-04
GC_7_11 ref NI_7 NS_11 0 1.1844501330027526e-02
GC_7_12 ref NI_7 NS_12 0 1.3992612767548101e-02
GC_7_13 ref NI_7 NS_13 0 1.5649632873201754e-02
GC_7_14 ref NI_7 NS_14 0 -1.6269554390293200e-04
GC_7_15 ref NI_7 NS_15 0 8.7570860293137667e-02
GC_7_16 ref NI_7 NS_16 0 -4.0181409400028470e-02
GC_7_17 ref NI_7 NS_17 0 -3.0436603476140856e-03
GC_7_18 ref NI_7 NS_18 0 -9.3965741838816677e-04
GC_7_19 ref NI_7 NS_19 0 2.8806934809730059e-03
GC_7_20 ref NI_7 NS_20 0 1.9456470888720542e-02
GC_7_21 ref NI_7 NS_21 0 -6.8358941653857074e-04
GC_7_22 ref NI_7 NS_22 0 3.4563115775669817e-04
GC_7_23 ref NI_7 NS_23 0 2.0045453012008333e-02
GC_7_24 ref NI_7 NS_24 0 4.5287969125345998e-03
GC_7_25 ref NI_7 NS_25 0 1.1613163996399108e-02
GC_7_26 ref NI_7 NS_26 0 -5.8155517535470862e-03
GC_7_27 ref NI_7 NS_27 0 -1.5016558749073713e-01
GC_7_28 ref NI_7 NS_28 0 -1.6583116951741535e-02
GC_7_29 ref NI_7 NS_29 0 -1.3115929100180931e-04
GC_7_30 ref NI_7 NS_30 0 -1.9564814936239212e-03
GC_7_31 ref NI_7 NS_31 0 2.5809107345477457e-02
GC_7_32 ref NI_7 NS_32 0 6.6947282975435927e-03
GD_7_1 ref NI_7 NA_1 0 6.4017826162553429e-02
GD_7_2 ref NI_7 NA_2 0 5.2808549774006910e-02
GD_7_3 ref NI_7 NA_3 0 5.9651986578871226e-02
GD_7_4 ref NI_7 NA_4 0 -5.8017666475185199e-02
GD_7_5 ref NI_7 NA_5 0 1.0958578991447450e-02
GD_7_6 ref NI_7 NA_6 0 1.2108998965328292e-02
GD_7_7 ref NI_7 NA_7 0 6.1452835015684526e+00
GD_7_8 ref NI_7 NA_8 0 -2.9926289914366760e-03
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 3.2369614985684244e-03
GC_8_2 ref NI_8 NS_2 0 7.3099507975480987e-03
GC_8_3 ref NI_8 NS_3 0 -5.0369306782448789e-03
GC_8_4 ref NI_8 NS_4 0 2.8103830633980525e-03
GC_8_5 ref NI_8 NS_5 0 -5.2108309539534003e-03
GC_8_6 ref NI_8 NS_6 0 9.1639285457314236e-03
GC_8_7 ref NI_8 NS_7 0 -5.0194908201310253e-03
GC_8_8 ref NI_8 NS_8 0 8.3511684215575640e-06
GC_8_9 ref NI_8 NS_9 0 8.7114093026964476e-03
GC_8_10 ref NI_8 NS_10 0 2.8172802048952558e-03
GC_8_11 ref NI_8 NS_11 0 -2.6879690563725744e-02
GC_8_12 ref NI_8 NS_12 0 2.8518766113078669e-02
GC_8_13 ref NI_8 NS_13 0 -3.7533590134079570e-04
GC_8_14 ref NI_8 NS_14 0 2.0034755806860770e-05
GC_8_15 ref NI_8 NS_15 0 -9.9869822350112901e-03
GC_8_16 ref NI_8 NS_16 0 2.5357263580286369e-02
GC_8_17 ref NI_8 NS_17 0 -7.6988203167749200e-03
GC_8_18 ref NI_8 NS_18 0 -5.0909486892042289e-03
GC_8_19 ref NI_8 NS_19 0 3.8866604620409168e-02
GC_8_20 ref NI_8 NS_20 0 6.2077861807301113e-03
GC_8_21 ref NI_8 NS_21 0 -4.3452737526248784e-03
GC_8_22 ref NI_8 NS_22 0 -1.1312028737215064e-05
GC_8_23 ref NI_8 NS_23 0 -8.4485066346801831e-03
GC_8_24 ref NI_8 NS_24 0 2.4587409436944384e-02
GC_8_25 ref NI_8 NS_25 0 -1.3115929100182260e-04
GC_8_26 ref NI_8 NS_26 0 -1.9564814936239043e-03
GC_8_27 ref NI_8 NS_27 0 2.5809107345477506e-02
GC_8_28 ref NI_8 NS_28 0 6.6947282975435311e-03
GC_8_29 ref NI_8 NS_29 0 6.2889783724283674e-03
GC_8_30 ref NI_8 NS_30 0 -1.1988107264225615e-02
GC_8_31 ref NI_8 NS_31 0 -8.2611749963121869e-03
GC_8_32 ref NI_8 NS_32 0 -9.5307267976588297e-02
GD_8_1 ref NI_8 NA_1 0 3.4612415999725116e-02
GD_8_2 ref NI_8 NA_2 0 2.9593287408443587e-02
GD_8_3 ref NI_8 NA_3 0 -3.4287309573504239e-02
GD_8_4 ref NI_8 NA_4 0 7.9084803357729408e-04
GD_8_5 ref NI_8 NA_5 0 2.8721639247241647e-02
GD_8_6 ref NI_8 NA_6 0 2.6201390499547408e-02
GD_8_7 ref NI_8 NA_7 0 -2.9926289914366760e-03
GD_8_8 ref NI_8 NA_8 0 6.2207631788883342e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.0540617962060398e+02
GS_1_1 0 NS_1 NA_1 0 1.3998404205757811e-01
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 1.3767322420194214e+03
GS_2_1 0 NS_2 NA_1 0 1.3998404205757811e-01
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 3.9640015345489076e+02
GS_3_1 0 NS_3 NA_1 0 1.3998404205757811e-01
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 6.0255070774094349e+02
GS_4_1 0 NS_4 NA_1 0 1.3998404205757811e-01
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.0540617962060398e+02
GS_5_2 0 NS_5 NA_2 0 1.3998404205757811e-01
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 1.3767322420194214e+03
GS_6_2 0 NS_6 NA_2 0 1.3998404205757811e-01
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 3.9640015345489076e+02
GS_7_2 0 NS_7 NA_2 0 1.3998404205757811e-01
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 6.0255070774094349e+02
GS_8_2 0 NS_8 NA_2 0 1.3998404205757811e-01
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.0540617962060398e+02
GS_9_3 0 NS_9 NA_3 0 1.3998404205757811e-01
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 1.3767322420194214e+03
GS_10_3 0 NS_10 NA_3 0 1.3998404205757811e-01
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 3.9640015345489076e+02
GS_11_3 0 NS_11 NA_3 0 1.3998404205757811e-01
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 6.0255070774094349e+02
GS_12_3 0 NS_12 NA_3 0 1.3998404205757811e-01
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.0540617962060398e+02
GS_13_4 0 NS_13 NA_4 0 1.3998404205757811e-01
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 1.3767322420194214e+03
GS_14_4 0 NS_14 NA_4 0 1.3998404205757811e-01
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 3.9640015345489076e+02
GS_15_4 0 NS_15 NA_4 0 1.3998404205757811e-01
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 6.0255070774094349e+02
GS_16_4 0 NS_16 NA_4 0 1.3998404205757811e-01
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.0540617962060398e+02
GS_17_5 0 NS_17 NA_5 0 1.3998404205757811e-01
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 1.3767322420194214e+03
GS_18_5 0 NS_18 NA_5 0 1.3998404205757811e-01
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 3.9640015345489076e+02
GS_19_5 0 NS_19 NA_5 0 1.3998404205757811e-01
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 6.0255070774094349e+02
GS_20_5 0 NS_20 NA_5 0 1.3998404205757811e-01
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.0540617962060398e+02
GS_21_6 0 NS_21 NA_6 0 1.3998404205757811e-01
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 1.3767322420194214e+03
GS_22_6 0 NS_22 NA_6 0 1.3998404205757811e-01
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 3.9640015345489076e+02
GS_23_6 0 NS_23 NA_6 0 1.3998404205757811e-01
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 6.0255070774094349e+02
GS_24_6 0 NS_24 NA_6 0 1.3998404205757811e-01
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.0540617962060398e+02
GS_25_7 0 NS_25 NA_7 0 1.3998404205757811e-01
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 1.3767322420194214e+03
GS_26_7 0 NS_26 NA_7 0 1.3998404205757811e-01
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 3.9640015345489076e+02
GS_27_7 0 NS_27 NA_7 0 1.3998404205757811e-01
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 6.0255070774094349e+02
GS_28_7 0 NS_28 NA_7 0 1.3998404205757811e-01
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.0540617962060398e+02
GS_29_8 0 NS_29 NA_8 0 1.3998404205757811e-01
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 1.3767322420194214e+03
GS_30_8 0 NS_30 NA_8 0 1.3998404205757811e-01
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 3.9640015345489076e+02
GS_31_8 0 NS_31 NA_8 0 1.3998404205757811e-01
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 6.0255070774094349e+02
GS_32_8 0 NS_32 NA_8 0 1.3998404205757811e-01
*
******************************

.ends
*******************
* End of subcircuit
*******************
