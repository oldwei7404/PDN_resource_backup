**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 18-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Fri Apr 18 11:24:56 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Fri Apr 18 11:24:56 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_VDDCR_ECCX02_Group_DIE1_GRP_1_0_VSS
**  Port[2] = PORT_2_BGA1_VDDCR_ECCX02_Group_BGA1_GRP_1_1_VSS
**  Port[3] = VDDCR_ECCX02_C16_1
**  Port[4] = VDDCR_ECCX02_C17_1
**  Port[5] = VDDCR_ECCX02_C23_1
**  Port[6] = VDDCR_ECCX02_C24_1
**  Port[7] = VDDCR_ECCX02_C62_1
**  Port[8] = VDDCR_ECCX02_C98_1
**  Port[9] = VDDCR_ECCX02_C99_1
**  Port[10] = VDDCR_ECCX02_C109_1
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 4]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_ECCX02
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -4.3987288441408950e-01
GC_1_2 ref NI_1 NS_2 0 4.7699521622244577e-02
GC_1_3 ref NI_1 NS_3 0 -8.4005188564474781e-03
GC_1_4 ref NI_1 NS_4 0 -1.6286410685870324e-03
GC_1_5 ref NI_1 NS_5 0 1.0486298409112965e-01
GC_1_6 ref NI_1 NS_6 0 -4.7960334549698993e-03
GC_1_7 ref NI_1 NS_7 0 -7.0266986214067946e-03
GC_1_8 ref NI_1 NS_8 0 -2.4726302721170680e-03
GC_1_9 ref NI_1 NS_9 0 4.7430115537701309e-02
GC_1_10 ref NI_1 NS_10 0 -1.1953308401730183e-02
GC_1_11 ref NI_1 NS_11 0 3.6682541495305066e-03
GC_1_12 ref NI_1 NS_12 0 5.1343211106696994e-04
GC_1_13 ref NI_1 NS_13 0 8.2356843066137986e-03
GC_1_14 ref NI_1 NS_14 0 1.2896025478776538e-02
GC_1_15 ref NI_1 NS_15 0 2.5775374010085102e-03
GC_1_16 ref NI_1 NS_16 0 7.3175863270155141e-04
GC_1_17 ref NI_1 NS_17 0 6.6952878507171472e-03
GC_1_18 ref NI_1 NS_18 0 7.4670689011471147e-03
GC_1_19 ref NI_1 NS_19 0 5.2416221551295373e-03
GC_1_20 ref NI_1 NS_20 0 7.9859731615372891e-04
GC_1_21 ref NI_1 NS_21 0 1.6038843534533592e-02
GC_1_22 ref NI_1 NS_22 0 1.0242054811535964e-03
GC_1_23 ref NI_1 NS_23 0 5.6957884264274405e-03
GC_1_24 ref NI_1 NS_24 0 8.1652925848059367e-04
GC_1_25 ref NI_1 NS_25 0 1.5673628918650323e-01
GC_1_26 ref NI_1 NS_26 0 -5.4422240748697823e-02
GC_1_27 ref NI_1 NS_27 0 -4.5558330472525556e-03
GC_1_28 ref NI_1 NS_28 0 -4.8255496919648392e-04
GC_1_29 ref NI_1 NS_29 0 4.2388831347213267e-02
GC_1_30 ref NI_1 NS_30 0 -5.7072665363311612e-05
GC_1_31 ref NI_1 NS_31 0 -1.8712654210436015e-04
GC_1_32 ref NI_1 NS_32 0 4.2660241190155013e-04
GC_1_33 ref NI_1 NS_33 0 9.4766406843071097e-02
GC_1_34 ref NI_1 NS_34 0 -2.6301358439356871e-02
GC_1_35 ref NI_1 NS_35 0 -1.6996999742964036e-03
GC_1_36 ref NI_1 NS_36 0 -5.7163478466568985e-06
GC_1_37 ref NI_1 NS_37 0 -3.0816328969552535e-03
GC_1_38 ref NI_1 NS_38 0 5.7046937816704222e-03
GC_1_39 ref NI_1 NS_39 0 8.4189203549593031e-03
GC_1_40 ref NI_1 NS_40 0 1.0026149523033729e-03
GD_1_1 ref NI_1 NA_1 0 5.5845164553363080e+00
GD_1_2 ref NI_1 NA_2 0 8.6612191888528769e-02
GD_1_3 ref NI_1 NA_3 0 5.8973433792348540e-02
GD_1_4 ref NI_1 NA_4 0 5.4974078919798865e-02
GD_1_5 ref NI_1 NA_5 0 5.6355133684796561e-02
GD_1_6 ref NI_1 NA_6 0 5.0471637227204741e-02
GD_1_7 ref NI_1 NA_7 0 6.5163080021274966e-02
GD_1_8 ref NI_1 NA_8 0 5.9289726184005034e-02
GD_1_9 ref NI_1 NA_9 0 7.6065124805223122e-02
GD_1_10 ref NI_1 NA_10 0 4.3436854442796276e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 1.0486298409112967e-01
GC_2_2 ref NI_2 NS_2 0 -4.7960334549698967e-03
GC_2_3 ref NI_2 NS_3 0 -7.0266986214067980e-03
GC_2_4 ref NI_2 NS_4 0 -2.4726302721170667e-03
GC_2_5 ref NI_2 NS_5 0 7.1069534041832659e-03
GC_2_6 ref NI_2 NS_6 0 -8.2345800506782047e-03
GC_2_7 ref NI_2 NS_7 0 -6.9165289598730570e-02
GC_2_8 ref NI_2 NS_8 0 -1.7343887592785701e-02
GC_2_9 ref NI_2 NS_9 0 -8.3082678379968918e-03
GC_2_10 ref NI_2 NS_10 0 -1.9790677121695856e-03
GC_2_11 ref NI_2 NS_11 0 9.4012185353290062e-03
GC_2_12 ref NI_2 NS_12 0 2.6677268483399300e-03
GC_2_13 ref NI_2 NS_13 0 -7.6384700358016731e-04
GC_2_14 ref NI_2 NS_14 0 -1.3025517229950011e-02
GC_2_15 ref NI_2 NS_15 0 1.1549928377818843e-02
GC_2_16 ref NI_2 NS_16 0 2.8923878088984120e-03
GC_2_17 ref NI_2 NS_17 0 5.6634794848743437e-03
GC_2_18 ref NI_2 NS_18 0 -1.8189573294329995e-02
GC_2_19 ref NI_2 NS_19 0 1.1022482202438488e-02
GC_2_20 ref NI_2 NS_20 0 3.3084720432864125e-03
GC_2_21 ref NI_2 NS_21 0 4.2497259074504648e-03
GC_2_22 ref NI_2 NS_22 0 -1.5741510167784651e-02
GC_2_23 ref NI_2 NS_23 0 1.0208696270172528e-02
GC_2_24 ref NI_2 NS_24 0 3.3861162419889352e-03
GC_2_25 ref NI_2 NS_25 0 -5.4757353472088294e-02
GC_2_26 ref NI_2 NS_26 0 4.8432721002467351e-02
GC_2_27 ref NI_2 NS_27 0 6.3193530027691432e-03
GC_2_28 ref NI_2 NS_28 0 1.0980268473046310e-04
GC_2_29 ref NI_2 NS_29 0 -1.5822475902383823e-02
GC_2_30 ref NI_2 NS_30 0 3.1653286958344021e-03
GC_2_31 ref NI_2 NS_31 0 1.0574769492320391e-02
GC_2_32 ref NI_2 NS_32 0 2.0708252231318529e-03
GC_2_33 ref NI_2 NS_33 0 -3.2596088039927813e-02
GC_2_34 ref NI_2 NS_34 0 2.3126113919842418e-02
GC_2_35 ref NI_2 NS_35 0 8.5900926470023706e-03
GC_2_36 ref NI_2 NS_36 0 1.2042834365308577e-03
GC_2_37 ref NI_2 NS_37 0 1.5493410662131444e-02
GC_2_38 ref NI_2 NS_38 0 -2.7105334790442415e-02
GC_2_39 ref NI_2 NS_39 0 1.0614652217690866e-02
GC_2_40 ref NI_2 NS_40 0 4.0100582230260112e-03
GD_2_1 ref NI_2 NA_1 0 8.6612191888528769e-02
GD_2_2 ref NI_2 NA_2 0 5.9238526476198077e+00
GD_2_3 ref NI_2 NA_3 0 9.0927533781248043e-03
GD_2_4 ref NI_2 NA_4 0 1.7609469634381775e-02
GD_2_5 ref NI_2 NA_5 0 5.3600824967539630e-03
GD_2_6 ref NI_2 NA_6 0 1.9555793346000445e-03
GD_2_7 ref NI_2 NA_7 0 3.8224227635124522e-02
GD_2_8 ref NI_2 NA_8 0 2.8448913567763662e-02
GD_2_9 ref NI_2 NA_9 0 3.1506159389301520e-02
GD_2_10 ref NI_2 NA_10 0 -1.0361725855051292e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 4.7430115537701330e-02
GC_3_2 ref NI_3 NS_2 0 -1.1953308401730220e-02
GC_3_3 ref NI_3 NS_3 0 3.6682541495305283e-03
GC_3_4 ref NI_3 NS_4 0 5.1343211106696289e-04
GC_3_5 ref NI_3 NS_5 0 -8.3082678379969317e-03
GC_3_6 ref NI_3 NS_6 0 -1.9790677121695180e-03
GC_3_7 ref NI_3 NS_7 0 9.4012185353289628e-03
GC_3_8 ref NI_3 NS_8 0 2.6677268483399439e-03
GC_3_9 ref NI_3 NS_9 0 -6.5061428543956176e-02
GC_3_10 ref NI_3 NS_10 0 -2.1567150891636130e-01
GC_3_11 ref NI_3 NS_11 0 3.0732939054057083e-03
GC_3_12 ref NI_3 NS_12 0 -2.2915376388234986e-03
GC_3_13 ref NI_3 NS_13 0 1.0659443985437951e-03
GC_3_14 ref NI_3 NS_14 0 3.6259568469054308e-02
GC_3_15 ref NI_3 NS_15 0 -3.1405971549580206e-03
GC_3_16 ref NI_3 NS_16 0 -1.2431850216209671e-04
GC_3_17 ref NI_3 NS_17 0 3.1580746247460139e-03
GC_3_18 ref NI_3 NS_18 0 3.8930405887443155e-02
GC_3_19 ref NI_3 NS_19 0 -4.5407483224430591e-03
GC_3_20 ref NI_3 NS_20 0 -2.6439336598691962e-04
GC_3_21 ref NI_3 NS_21 0 8.7622699374896015e-02
GC_3_22 ref NI_3 NS_22 0 -5.7987010788282658e-03
GC_3_23 ref NI_3 NS_23 0 -6.4668086169735609e-03
GC_3_24 ref NI_3 NS_24 0 -4.5564489713372322e-04
GC_3_25 ref NI_3 NS_25 0 -2.2960144719277542e-02
GC_3_26 ref NI_3 NS_26 0 3.3759717648248311e-02
GC_3_27 ref NI_3 NS_27 0 3.3743486241537600e-03
GC_3_28 ref NI_3 NS_28 0 3.1254140906203690e-04
GC_3_29 ref NI_3 NS_29 0 4.3275404060015808e-03
GC_3_30 ref NI_3 NS_30 0 3.0033589221368968e-02
GC_3_31 ref NI_3 NS_31 0 -1.6360144432542116e-03
GC_3_32 ref NI_3 NS_32 0 1.7537452515322256e-05
GC_3_33 ref NI_3 NS_33 0 -9.0289894699766404e-03
GC_3_34 ref NI_3 NS_34 0 3.2900124511295849e-02
GC_3_35 ref NI_3 NS_35 0 3.1795988702960600e-04
GC_3_36 ref NI_3 NS_36 0 1.6393562014069092e-04
GC_3_37 ref NI_3 NS_37 0 -3.3805215504509933e-02
GC_3_38 ref NI_3 NS_38 0 6.1598141976597708e-02
GC_3_39 ref NI_3 NS_39 0 -4.0336686224232083e-03
GC_3_40 ref NI_3 NS_40 0 -4.8571089692193948e-04
GD_3_1 ref NI_3 NA_1 0 5.8973433792348540e-02
GD_3_2 ref NI_3 NA_2 0 9.0927533781248043e-03
GD_3_3 ref NI_3 NA_3 0 6.1430662260824613e+00
GD_3_4 ref NI_3 NA_4 0 1.7007258444049701e-02
GD_3_5 ref NI_3 NA_5 0 9.9904469068208841e-03
GD_3_6 ref NI_3 NA_6 0 -3.8120430899299444e-02
GD_3_7 ref NI_3 NA_7 0 2.0806132777250325e-02
GD_3_8 ref NI_3 NA_8 0 1.5283203179337724e-02
GD_3_9 ref NI_3 NA_9 0 1.5316715881942491e-02
GD_3_10 ref NI_3 NA_10 0 2.4761776691655059e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 8.2356843066138576e-03
GC_4_2 ref NI_4 NS_2 0 1.2896025478776444e-02
GC_4_3 ref NI_4 NS_3 0 2.5775374010085688e-03
GC_4_4 ref NI_4 NS_4 0 7.3175863270153244e-04
GC_4_5 ref NI_4 NS_5 0 -7.6384700358017772e-04
GC_4_6 ref NI_4 NS_6 0 -1.3025517229949993e-02
GC_4_7 ref NI_4 NS_7 0 1.1549928377818834e-02
GC_4_8 ref NI_4 NS_8 0 2.8923878088984146e-03
GC_4_9 ref NI_4 NS_9 0 1.0659443985438014e-03
GC_4_10 ref NI_4 NS_10 0 3.6259568469054301e-02
GC_4_11 ref NI_4 NS_11 0 -3.1405971549580145e-03
GC_4_12 ref NI_4 NS_12 0 -1.2431850216209852e-04
GC_4_13 ref NI_4 NS_13 0 -8.1242243265862421e-02
GC_4_14 ref NI_4 NS_14 0 -1.9230770665452179e-01
GC_4_15 ref NI_4 NS_15 0 -2.0152042034225683e-03
GC_4_16 ref NI_4 NS_16 0 -2.4594639580689478e-03
GC_4_17 ref NI_4 NS_17 0 8.1641448432762581e-02
GC_4_18 ref NI_4 NS_18 0 -2.2866372599715111e-03
GC_4_19 ref NI_4 NS_19 0 -6.4796514711138410e-03
GC_4_20 ref NI_4 NS_20 0 -4.1112273210508222e-04
GC_4_21 ref NI_4 NS_21 0 -1.2296107328806491e-02
GC_4_22 ref NI_4 NS_22 0 4.0559559022967172e-02
GC_4_23 ref NI_4 NS_23 0 -1.0421700133798808e-03
GC_4_24 ref NI_4 NS_24 0 -3.0671471620195975e-04
GC_4_25 ref NI_4 NS_25 0 -3.5087144044085493e-02
GC_4_26 ref NI_4 NS_26 0 3.6481814077924661e-02
GC_4_27 ref NI_4 NS_27 0 5.3140391880611522e-03
GC_4_28 ref NI_4 NS_28 0 2.1260212166352056e-04
GC_4_29 ref NI_4 NS_29 0 9.8237636307620571e-02
GC_4_30 ref NI_4 NS_30 0 -1.3500073932005148e-02
GC_4_31 ref NI_4 NS_31 0 -6.9919212594823808e-03
GC_4_32 ref NI_4 NS_32 0 -1.3208538042501955e-04
GC_4_33 ref NI_4 NS_33 0 -1.6118534311936626e-02
GC_4_34 ref NI_4 NS_34 0 4.4102749175031312e-02
GC_4_35 ref NI_4 NS_35 0 -2.9298356793683094e-03
GC_4_36 ref NI_4 NS_36 0 2.0640564552851495e-04
GC_4_37 ref NI_4 NS_37 0 -4.1121727907133067e-02
GC_4_38 ref NI_4 NS_38 0 5.0062412625052427e-02
GC_4_39 ref NI_4 NS_39 0 2.9903280190848283e-03
GC_4_40 ref NI_4 NS_40 0 -5.3750832522691107e-04
GD_4_1 ref NI_4 NA_1 0 5.4974078919798865e-02
GD_4_2 ref NI_4 NA_2 0 1.7609469634381775e-02
GD_4_3 ref NI_4 NA_3 0 1.7007258444049701e-02
GD_4_4 ref NI_4 NA_4 0 6.0926002385192453e+00
GD_4_5 ref NI_4 NA_5 0 -3.5418385477685894e-02
GD_4_6 ref NI_4 NA_6 0 3.4257919791530804e-02
GD_4_7 ref NI_4 NA_7 0 6.0083579010503652e-02
GD_4_8 ref NI_4 NA_8 0 -2.6594784861370145e-02
GD_4_9 ref NI_4 NA_9 0 1.0921862159842498e-02
GD_4_10 ref NI_4 NA_10 0 6.2703557515954786e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 6.6952878507171732e-03
GC_5_2 ref NI_5 NS_2 0 7.4670689011470722e-03
GC_5_3 ref NI_5 NS_3 0 5.2416221551295642e-03
GC_5_4 ref NI_5 NS_4 0 7.9859731615372002e-04
GC_5_5 ref NI_5 NS_5 0 5.6634794848743003e-03
GC_5_6 ref NI_5 NS_6 0 -1.8189573294329922e-02
GC_5_7 ref NI_5 NS_7 0 1.1022482202438443e-02
GC_5_8 ref NI_5 NS_8 0 3.3084720432864276e-03
GC_5_9 ref NI_5 NS_9 0 3.1580746247459571e-03
GC_5_10 ref NI_5 NS_10 0 3.8930405887443245e-02
GC_5_11 ref NI_5 NS_11 0 -4.5407483224431189e-03
GC_5_12 ref NI_5 NS_12 0 -2.6439336598689945e-04
GC_5_13 ref NI_5 NS_13 0 8.1641448432762539e-02
GC_5_14 ref NI_5 NS_14 0 -2.2866372599714443e-03
GC_5_15 ref NI_5 NS_15 0 -6.4796514711138826e-03
GC_5_16 ref NI_5 NS_16 0 -4.1112273210506877e-04
GC_5_17 ref NI_5 NS_17 0 -1.1441811548125891e-01
GC_5_18 ref NI_5 NS_18 0 -1.7896494158322518e-01
GC_5_19 ref NI_5 NS_19 0 1.9064174948673972e-03
GC_5_20 ref NI_5 NS_20 0 -2.6967976292543009e-03
GC_5_21 ref NI_5 NS_21 0 3.4523551317640247e-02
GC_5_22 ref NI_5 NS_22 0 2.9715916366568274e-02
GC_5_23 ref NI_5 NS_23 0 -8.4245421652096551e-03
GC_5_24 ref NI_5 NS_24 0 -4.7332118471083226e-04
GC_5_25 ref NI_5 NS_25 0 -2.3671055302724137e-02
GC_5_26 ref NI_5 NS_26 0 1.8592684095746406e-02
GC_5_27 ref NI_5 NS_27 0 9.9794025430832139e-03
GC_5_28 ref NI_5 NS_28 0 3.3528695917465562e-04
GC_5_29 ref NI_5 NS_29 0 1.8444050902355921e-03
GC_5_30 ref NI_5 NS_30 0 3.0659698669239236e-02
GC_5_31 ref NI_5 NS_31 0 -1.1845242042988018e-03
GC_5_32 ref NI_5 NS_32 0 -1.3473455664656946e-05
GC_5_33 ref NI_5 NS_33 0 -2.1496734455146476e-02
GC_5_34 ref NI_5 NS_34 0 3.0531108876682464e-02
GC_5_35 ref NI_5 NS_35 0 4.5084351807435927e-03
GC_5_36 ref NI_5 NS_36 0 1.4371084609238484e-04
GC_5_37 ref NI_5 NS_37 0 2.9184209714007266e-02
GC_5_38 ref NI_5 NS_38 0 4.2322241926866525e-02
GC_5_39 ref NI_5 NS_39 0 -1.2105052023793420e-02
GC_5_40 ref NI_5 NS_40 0 -6.6419487886964590e-04
GD_5_1 ref NI_5 NA_1 0 5.6355133684796561e-02
GD_5_2 ref NI_5 NA_2 0 5.3600824967539630e-03
GD_5_3 ref NI_5 NA_3 0 9.9904469068208841e-03
GD_5_4 ref NI_5 NA_4 0 -3.5418385477685894e-02
GD_5_5 ref NI_5 NA_5 0 6.1340543963608614e+00
GD_5_6 ref NI_5 NA_6 0 3.6608733567016307e-03
GD_5_7 ref NI_5 NA_7 0 5.4652042124195277e-02
GD_5_8 ref NI_5 NA_8 0 1.6313881038061067e-02
GD_5_9 ref NI_5 NA_9 0 4.7031797054476292e-02
GD_5_10 ref NI_5 NA_10 0 -5.1102931466946054e-03
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 1.6038843534533595e-02
GC_6_2 ref NI_6 NS_2 0 1.0242054811535912e-03
GC_6_3 ref NI_6 NS_3 0 5.6957884264274439e-03
GC_6_4 ref NI_6 NS_4 0 8.1652925848059335e-04
GC_6_5 ref NI_6 NS_5 0 4.2497259074504301e-03
GC_6_6 ref NI_6 NS_6 0 -1.5741510167784592e-02
GC_6_7 ref NI_6 NS_7 0 1.0208696270172493e-02
GC_6_8 ref NI_6 NS_8 0 3.3861162419889473e-03
GC_6_9 ref NI_6 NS_9 0 8.7622699374895974e-02
GC_6_10 ref NI_6 NS_10 0 -5.7987010788282112e-03
GC_6_11 ref NI_6 NS_11 0 -6.4668086169735938e-03
GC_6_12 ref NI_6 NS_12 0 -4.5564489713371145e-04
GC_6_13 ref NI_6 NS_13 0 -1.2296107328806542e-02
GC_6_14 ref NI_6 NS_14 0 4.0559559022967262e-02
GC_6_15 ref NI_6 NS_15 0 -1.0421700133799365e-03
GC_6_16 ref NI_6 NS_16 0 -3.0671471620194116e-04
GC_6_17 ref NI_6 NS_17 0 3.4523551317640268e-02
GC_6_18 ref NI_6 NS_18 0 2.9715916366568233e-02
GC_6_19 ref NI_6 NS_19 0 -8.4245421652096239e-03
GC_6_20 ref NI_6 NS_20 0 -4.7332118471084245e-04
GC_6_21 ref NI_6 NS_21 0 -1.5991582212654512e-01
GC_6_22 ref NI_6 NS_22 0 -1.4560539272814521e-01
GC_6_23 ref NI_6 NS_23 0 -1.4081648170373834e-03
GC_6_24 ref NI_6 NS_24 0 -2.6945039155950520e-03
GC_6_25 ref NI_6 NS_25 0 -1.9510460000270236e-02
GC_6_26 ref NI_6 NS_26 0 1.5443294979047908e-02
GC_6_27 ref NI_6 NS_27 0 1.0262645278439226e-02
GC_6_28 ref NI_6 NS_28 0 4.1904732283747699e-04
GC_6_29 ref NI_6 NS_29 0 -1.7227987729805470e-02
GC_6_30 ref NI_6 NS_30 0 3.2600610567924654e-02
GC_6_31 ref NI_6 NS_31 0 3.1517572092761483e-03
GC_6_32 ref NI_6 NS_32 0 -7.3642009457495331e-05
GC_6_33 ref NI_6 NS_33 0 -1.9881638604123675e-02
GC_6_34 ref NI_6 NS_34 0 2.4978122363527675e-02
GC_6_35 ref NI_6 NS_35 0 6.6815809067697577e-03
GC_6_36 ref NI_6 NS_36 0 1.4827646531546048e-04
GC_6_37 ref NI_6 NS_37 0 8.9543867096906815e-02
GC_6_38 ref NI_6 NS_38 0 2.1636653769743632e-02
GC_6_39 ref NI_6 NS_39 0 -1.8756134483546273e-02
GC_6_40 ref NI_6 NS_40 0 -7.0057795438619830e-04
GD_6_1 ref NI_6 NA_1 0 5.0471637227204741e-02
GD_6_2 ref NI_6 NA_2 0 1.9555793346000445e-03
GD_6_3 ref NI_6 NA_3 0 -3.8120430899299444e-02
GD_6_4 ref NI_6 NA_4 0 3.4257919791530804e-02
GD_6_5 ref NI_6 NA_5 0 3.6608733567016307e-03
GD_6_6 ref NI_6 NA_6 0 6.1545309353170232e+00
GD_6_7 ref NI_6 NA_7 0 4.0738925603292994e-02
GD_6_8 ref NI_6 NA_8 0 4.2301488907484239e-02
GD_6_9 ref NI_6 NA_9 0 4.4484535813205439e-02
GD_6_10 ref NI_6 NA_10 0 -4.8199734849176869e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 1.5673628918650323e-01
GC_7_2 ref NI_7 NS_2 0 -5.4422240748697850e-02
GC_7_3 ref NI_7 NS_3 0 -4.5558330472525487e-03
GC_7_4 ref NI_7 NS_4 0 -4.8255496919648598e-04
GC_7_5 ref NI_7 NS_5 0 -5.4757353472088370e-02
GC_7_6 ref NI_7 NS_6 0 4.8432721002467469e-02
GC_7_7 ref NI_7 NS_7 0 6.3193530027690729e-03
GC_7_8 ref NI_7 NS_8 0 1.0980268473048671e-04
GC_7_9 ref NI_7 NS_9 0 -2.2960144719277584e-02
GC_7_10 ref NI_7 NS_10 0 3.3759717648248373e-02
GC_7_11 ref NI_7 NS_11 0 3.3743486241537201e-03
GC_7_12 ref NI_7 NS_12 0 3.1254140906205029e-04
GC_7_13 ref NI_7 NS_13 0 -3.5087144044085528e-02
GC_7_14 ref NI_7 NS_14 0 3.6481814077924737e-02
GC_7_15 ref NI_7 NS_15 0 5.3140391880611062e-03
GC_7_16 ref NI_7 NS_16 0 2.1260212166353577e-04
GC_7_17 ref NI_7 NS_17 0 -2.3671055302724116e-02
GC_7_18 ref NI_7 NS_18 0 1.8592684095746371e-02
GC_7_19 ref NI_7 NS_19 0 9.9794025430832330e-03
GC_7_20 ref NI_7 NS_20 0 3.3528695917464879e-04
GC_7_21 ref NI_7 NS_21 0 -1.9510460000270239e-02
GC_7_22 ref NI_7 NS_22 0 1.5443294979047915e-02
GC_7_23 ref NI_7 NS_23 0 1.0262645278439220e-02
GC_7_24 ref NI_7 NS_24 0 4.1904732283747862e-04
GC_7_25 ref NI_7 NS_25 0 -2.8275010107658765e-03
GC_7_26 ref NI_7 NS_26 0 -1.9345282672334146e-01
GC_7_27 ref NI_7 NS_27 0 -2.5069133391581934e-02
GC_7_28 ref NI_7 NS_28 0 -1.5502043904109695e-03
GC_7_29 ref NI_7 NS_29 0 -2.7634087303229173e-02
GC_7_30 ref NI_7 NS_30 0 5.6980693194731334e-02
GC_7_31 ref NI_7 NS_31 0 -5.4224302179976249e-03
GC_7_32 ref NI_7 NS_32 0 1.7165421489291315e-04
GC_7_33 ref NI_7 NS_33 0 4.5471592867665833e-02
GC_7_34 ref NI_7 NS_34 0 4.0491680258682529e-02
GC_7_35 ref NI_7 NS_35 0 -1.6754501910372685e-02
GC_7_36 ref NI_7 NS_36 0 2.4053260422244975e-05
GC_7_37 ref NI_7 NS_37 0 -1.1283187046283128e-02
GC_7_38 ref NI_7 NS_38 0 -3.7150003654563232e-03
GC_7_39 ref NI_7 NS_39 0 1.6424276300686193e-02
GC_7_40 ref NI_7 NS_40 0 5.1077249455670965e-04
GD_7_1 ref NI_7 NA_1 0 6.5163080021274966e-02
GD_7_2 ref NI_7 NA_2 0 3.8224227635124522e-02
GD_7_3 ref NI_7 NA_3 0 2.0806132777250325e-02
GD_7_4 ref NI_7 NA_4 0 6.0083579010503652e-02
GD_7_5 ref NI_7 NA_5 0 5.4652042124195277e-02
GD_7_6 ref NI_7 NA_6 0 4.0738925603292994e-02
GD_7_7 ref NI_7 NA_7 0 6.0163293904908057e+00
GD_7_8 ref NI_7 NA_8 0 7.6536782607352334e-03
GD_7_9 ref NI_7 NA_9 0 -8.4157188359470184e-02
GD_7_10 ref NI_7 NA_10 0 4.4880225888124507e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 4.2388831347213315e-02
GC_8_2 ref NI_8 NS_2 0 -5.7072665363381509e-05
GC_8_3 ref NI_8 NS_3 0 -1.8712654210431768e-04
GC_8_4 ref NI_8 NS_4 0 4.2660241190153615e-04
GC_8_5 ref NI_8 NS_5 0 -1.5822475902383847e-02
GC_8_6 ref NI_8 NS_6 0 3.1653286958344446e-03
GC_8_7 ref NI_8 NS_7 0 1.0574769492320363e-02
GC_8_8 ref NI_8 NS_8 0 2.0708252231318612e-03
GC_8_9 ref NI_8 NS_9 0 4.3275404060015869e-03
GC_8_10 ref NI_8 NS_10 0 3.0033589221368964e-02
GC_8_11 ref NI_8 NS_11 0 -1.6360144432542058e-03
GC_8_12 ref NI_8 NS_12 0 1.7537452515320498e-05
GC_8_13 ref NI_8 NS_13 0 9.8237636307620640e-02
GC_8_14 ref NI_8 NS_14 0 -1.3500073932005224e-02
GC_8_15 ref NI_8 NS_15 0 -6.9919212594823305e-03
GC_8_16 ref NI_8 NS_16 0 -1.3208538042503622e-04
GC_8_17 ref NI_8 NS_17 0 1.8444050902355694e-03
GC_8_18 ref NI_8 NS_18 0 3.0659698669239271e-02
GC_8_19 ref NI_8 NS_19 0 -1.1845242042988265e-03
GC_8_20 ref NI_8 NS_20 0 -1.3473455664648623e-05
GC_8_21 ref NI_8 NS_21 0 -1.7227987729805452e-02
GC_8_22 ref NI_8 NS_22 0 3.2600610567924633e-02
GC_8_23 ref NI_8 NS_23 0 3.1517572092761648e-03
GC_8_24 ref NI_8 NS_24 0 -7.3642009457500413e-05
GC_8_25 ref NI_8 NS_25 0 -2.7634087303229124e-02
GC_8_26 ref NI_8 NS_26 0 5.6980693194731244e-02
GC_8_27 ref NI_8 NS_27 0 -5.4224302179975746e-03
GC_8_28 ref NI_8 NS_28 0 1.7165421489289634e-04
GC_8_29 ref NI_8 NS_29 0 -1.6714043298534953e-01
GC_8_30 ref NI_8 NS_30 0 -1.4843136168703042e-01
GC_8_31 ref NI_8 NS_31 0 7.1453383174706548e-04
GC_8_32 ref NI_8 NS_32 0 -2.0497056456054790e-03
GC_8_33 ref NI_8 NS_33 0 1.1682391365174778e-01
GC_8_34 ref NI_8 NS_34 0 -2.1842860358987116e-02
GC_8_35 ref NI_8 NS_35 0 -8.1768814785156459e-03
GC_8_36 ref NI_8 NS_36 0 -1.3173028978030111e-04
GC_8_37 ref NI_8 NS_37 0 -3.2245996028563317e-02
GC_8_38 ref NI_8 NS_38 0 2.9135475689950226e-02
GC_8_39 ref NI_8 NS_39 0 9.0515888487955123e-03
GC_8_40 ref NI_8 NS_40 0 -2.2077362152019309e-04
GD_8_1 ref NI_8 NA_1 0 5.9289726184005034e-02
GD_8_2 ref NI_8 NA_2 0 2.8448913567763662e-02
GD_8_3 ref NI_8 NA_3 0 1.5283203179337724e-02
GD_8_4 ref NI_8 NA_4 0 -2.6594784861370145e-02
GD_8_5 ref NI_8 NA_5 0 1.6313881038061067e-02
GD_8_6 ref NI_8 NA_6 0 4.2301488907484239e-02
GD_8_7 ref NI_8 NA_7 0 7.6536782607352334e-03
GD_8_8 ref NI_8 NA_8 0 6.1140739243370339e+00
GD_8_9 ref NI_8 NA_9 0 -4.5858489602525351e-02
GD_8_10 ref NI_8 NA_10 0 6.8502342178267714e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 9.4766406843071152e-02
GC_9_2 ref NI_9 NS_2 0 -2.6301358439356947e-02
GC_9_3 ref NI_9 NS_3 0 -1.6996999742963611e-03
GC_9_4 ref NI_9 NS_4 0 -5.7163478466707526e-06
GC_9_5 ref NI_9 NS_5 0 -3.2596088039927827e-02
GC_9_6 ref NI_9 NS_6 0 2.3126113919842439e-02
GC_9_7 ref NI_9 NS_7 0 8.5900926470023568e-03
GC_9_8 ref NI_9 NS_8 0 1.2042834365308627e-03
GC_9_9 ref NI_9 NS_9 0 -9.0289894699766889e-03
GC_9_10 ref NI_9 NS_10 0 3.2900124511295932e-02
GC_9_11 ref NI_9 NS_11 0 3.1795988702955184e-04
GC_9_12 ref NI_9 NS_12 0 1.6393562014070930e-04
GC_9_13 ref NI_9 NS_13 0 -1.6118534311936630e-02
GC_9_14 ref NI_9 NS_14 0 4.4102749175031319e-02
GC_9_15 ref NI_9 NS_15 0 -2.9298356793683133e-03
GC_9_16 ref NI_9 NS_16 0 2.0640564552851665e-04
GC_9_17 ref NI_9 NS_17 0 -2.1496734455146414e-02
GC_9_18 ref NI_9 NS_18 0 3.0531108876682353e-02
GC_9_19 ref NI_9 NS_19 0 4.5084351807436543e-03
GC_9_20 ref NI_9 NS_20 0 1.4371084609236454e-04
GC_9_21 ref NI_9 NS_21 0 -1.9881638604123664e-02
GC_9_22 ref NI_9 NS_22 0 2.4978122363527658e-02
GC_9_23 ref NI_9 NS_23 0 6.6815809067697698e-03
GC_9_24 ref NI_9 NS_24 0 1.4827646531545707e-04
GC_9_25 ref NI_9 NS_25 0 4.5471592867665854e-02
GC_9_26 ref NI_9 NS_26 0 4.0491680258682508e-02
GC_9_27 ref NI_9 NS_27 0 -1.6754501910372671e-02
GC_9_28 ref NI_9 NS_28 0 2.4053260422239889e-05
GC_9_29 ref NI_9 NS_29 0 1.1682391365174782e-01
GC_9_30 ref NI_9 NS_30 0 -2.1842860358987155e-02
GC_9_31 ref NI_9 NS_31 0 -8.1768814785156182e-03
GC_9_32 ref NI_9 NS_32 0 -1.3173028978030954e-04
GC_9_33 ref NI_9 NS_33 0 -1.3120046161647117e-01
GC_9_34 ref NI_9 NS_34 0 -1.6195029718248308e-01
GC_9_35 ref NI_9 NS_35 0 -3.6833226554192165e-03
GC_9_36 ref NI_9 NS_36 0 -1.7992776082480552e-03
GC_9_37 ref NI_9 NS_37 0 -2.2265118350514240e-02
GC_9_38 ref NI_9 NS_38 0 1.2276177993670498e-02
GC_9_39 ref NI_9 NS_39 0 1.3099620814989331e-02
GC_9_40 ref NI_9 NS_40 0 1.0325428526243959e-04
GD_9_1 ref NI_9 NA_1 0 7.6065124805223122e-02
GD_9_2 ref NI_9 NA_2 0 3.1506159389301520e-02
GD_9_3 ref NI_9 NA_3 0 1.5316715881942491e-02
GD_9_4 ref NI_9 NA_4 0 1.0921862159842498e-02
GD_9_5 ref NI_9 NA_5 0 4.7031797054476292e-02
GD_9_6 ref NI_9 NA_6 0 4.4484535813205439e-02
GD_9_7 ref NI_9 NA_7 0 -8.4157188359470184e-02
GD_9_8 ref NI_9 NA_8 0 -4.5858489602525351e-02
GD_9_9 ref NI_9 NA_9 0 6.1139946111589163e+00
GD_9_10 ref NI_9 NA_10 0 6.1060862726095518e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -3.0816328969552440e-03
GC_10_2 ref NI_10 NS_2 0 5.7046937816704101e-03
GC_10_3 ref NI_10 NS_3 0 8.4189203549593101e-03
GC_10_4 ref NI_10 NS_4 0 1.0026149523033711e-03
GC_10_5 ref NI_10 NS_5 0 1.5493410662131392e-02
GC_10_6 ref NI_10 NS_6 0 -2.7105334790442321e-02
GC_10_7 ref NI_10 NS_7 0 1.0614652217690809e-02
GC_10_8 ref NI_10 NS_8 0 4.0100582230260303e-03
GC_10_9 ref NI_10 NS_9 0 -3.3805215504509933e-02
GC_10_10 ref NI_10 NS_10 0 6.1598141976597708e-02
GC_10_11 ref NI_10 NS_11 0 -4.0336686224232074e-03
GC_10_12 ref NI_10 NS_12 0 -4.8571089692193948e-04
GC_10_13 ref NI_10 NS_13 0 -4.1121727907133102e-02
GC_10_14 ref NI_10 NS_14 0 5.0062412625052469e-02
GC_10_15 ref NI_10 NS_15 0 2.9903280190847971e-03
GC_10_16 ref NI_10 NS_16 0 -5.3750832522690088e-04
GC_10_17 ref NI_10 NS_17 0 2.9184209714007259e-02
GC_10_18 ref NI_10 NS_18 0 4.2322241926866525e-02
GC_10_19 ref NI_10 NS_19 0 -1.2105052023793427e-02
GC_10_20 ref NI_10 NS_20 0 -6.6419487886964438e-04
GC_10_21 ref NI_10 NS_21 0 8.9543867096906787e-02
GC_10_22 ref NI_10 NS_22 0 2.1636653769743632e-02
GC_10_23 ref NI_10 NS_23 0 -1.8756134483546273e-02
GC_10_24 ref NI_10 NS_24 0 -7.0057795438619830e-04
GC_10_25 ref NI_10 NS_25 0 -1.1283187046283154e-02
GC_10_26 ref NI_10 NS_26 0 -3.7150003654562841e-03
GC_10_27 ref NI_10 NS_27 0 1.6424276300686168e-02
GC_10_28 ref NI_10 NS_28 0 5.1077249455671822e-04
GC_10_29 ref NI_10 NS_29 0 -3.2245996028563380e-02
GC_10_30 ref NI_10 NS_30 0 2.9135475689950337e-02
GC_10_31 ref NI_10 NS_31 0 9.0515888487954464e-03
GC_10_32 ref NI_10 NS_32 0 -2.2077362152017114e-04
GC_10_33 ref NI_10 NS_33 0 -2.2265118350514264e-02
GC_10_34 ref NI_10 NS_34 0 1.2276177993670550e-02
GC_10_35 ref NI_10 NS_35 0 1.3099620814989301e-02
GC_10_36 ref NI_10 NS_36 0 1.0325428526244970e-04
GC_10_37 ref NI_10 NS_37 0 1.1498976520940668e-02
GC_10_38 ref NI_10 NS_38 0 -1.9234907910873791e-01
GC_10_39 ref NI_10 NS_39 0 -2.5940782904631952e-02
GC_10_40 ref NI_10 NS_40 0 -2.9353397689011449e-03
GD_10_1 ref NI_10 NA_1 0 4.3436854442796276e-02
GD_10_2 ref NI_10 NA_2 0 -1.0361725855051292e-02
GD_10_3 ref NI_10 NA_3 0 2.4761776691655059e-02
GD_10_4 ref NI_10 NA_4 0 6.2703557515954786e-02
GD_10_5 ref NI_10 NA_5 0 -5.1102931466946054e-03
GD_10_6 ref NI_10 NA_6 0 -4.8199734849176869e-02
GD_10_7 ref NI_10 NA_7 0 4.4880225888124507e-02
GD_10_8 ref NI_10 NA_8 0 6.8502342178267714e-02
GD_10_9 ref NI_10 NA_9 0 6.1060862726095518e-02
GD_10_10 ref NI_10 NA_10 0 6.0527734403182194e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.7763147160859353e+02
GS_1_1 0 NS_1 NA_1 0 1.4548200045778645e-01
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 2.8991282876789563e+02
GS_2_1 0 NS_2 NA_1 0 1.4548200045778645e-01
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 6.2118036436066882e+02
GS_3_1 0 NS_3 NA_1 0 1.4548200045778645e-01
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 1.6804456537393244e+03
GS_4_1 0 NS_4 NA_1 0 1.4548200045778645e-01
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.7763147160859353e+02
GS_5_2 0 NS_5 NA_2 0 1.4548200045778645e-01
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 2.8991282876789563e+02
GS_6_2 0 NS_6 NA_2 0 1.4548200045778645e-01
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 6.2118036436066882e+02
GS_7_2 0 NS_7 NA_2 0 1.4548200045778645e-01
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 1.6804456537393244e+03
GS_8_2 0 NS_8 NA_2 0 1.4548200045778645e-01
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.7763147160859353e+02
GS_9_3 0 NS_9 NA_3 0 1.4548200045778645e-01
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 2.8991282876789563e+02
GS_10_3 0 NS_10 NA_3 0 1.4548200045778645e-01
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 6.2118036436066882e+02
GS_11_3 0 NS_11 NA_3 0 1.4548200045778645e-01
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 1.6804456537393244e+03
GS_12_3 0 NS_12 NA_3 0 1.4548200045778645e-01
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.7763147160859353e+02
GS_13_4 0 NS_13 NA_4 0 1.4548200045778645e-01
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 2.8991282876789563e+02
GS_14_4 0 NS_14 NA_4 0 1.4548200045778645e-01
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 6.2118036436066882e+02
GS_15_4 0 NS_15 NA_4 0 1.4548200045778645e-01
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 1.6804456537393244e+03
GS_16_4 0 NS_16 NA_4 0 1.4548200045778645e-01
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.7763147160859353e+02
GS_17_5 0 NS_17 NA_5 0 1.4548200045778645e-01
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 2.8991282876789563e+02
GS_18_5 0 NS_18 NA_5 0 1.4548200045778645e-01
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 6.2118036436066882e+02
GS_19_5 0 NS_19 NA_5 0 1.4548200045778645e-01
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 1.6804456537393244e+03
GS_20_5 0 NS_20 NA_5 0 1.4548200045778645e-01
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.7763147160859353e+02
GS_21_6 0 NS_21 NA_6 0 1.4548200045778645e-01
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 2.8991282876789563e+02
GS_22_6 0 NS_22 NA_6 0 1.4548200045778645e-01
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 6.2118036436066882e+02
GS_23_6 0 NS_23 NA_6 0 1.4548200045778645e-01
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 1.6804456537393244e+03
GS_24_6 0 NS_24 NA_6 0 1.4548200045778645e-01
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.7763147160859353e+02
GS_25_7 0 NS_25 NA_7 0 1.4548200045778645e-01
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 2.8991282876789563e+02
GS_26_7 0 NS_26 NA_7 0 1.4548200045778645e-01
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 6.2118036436066882e+02
GS_27_7 0 NS_27 NA_7 0 1.4548200045778645e-01
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 1.6804456537393244e+03
GS_28_7 0 NS_28 NA_7 0 1.4548200045778645e-01
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.7763147160859353e+02
GS_29_8 0 NS_29 NA_8 0 1.4548200045778645e-01
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 2.8991282876789563e+02
GS_30_8 0 NS_30 NA_8 0 1.4548200045778645e-01
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 6.2118036436066882e+02
GS_31_8 0 NS_31 NA_8 0 1.4548200045778645e-01
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 1.6804456537393244e+03
GS_32_8 0 NS_32 NA_8 0 1.4548200045778645e-01
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 1.7763147160859353e+02
GS_33_9 0 NS_33 NA_9 0 1.4548200045778645e-01
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 2.8991282876789563e+02
GS_34_9 0 NS_34 NA_9 0 1.4548200045778645e-01
*
* Real pole n. 35
CS_35 NS_35 0 9.9999999999999998e-13
RS_35 NS_35 0 6.2118036436066882e+02
GS_35_9 0 NS_35 NA_9 0 1.4548200045778645e-01
*
* Real pole n. 36
CS_36 NS_36 0 9.9999999999999998e-13
RS_36 NS_36 0 1.6804456537393244e+03
GS_36_9 0 NS_36 NA_9 0 1.4548200045778645e-01
*
* Real pole n. 37
CS_37 NS_37 0 9.9999999999999998e-13
RS_37 NS_37 0 1.7763147160859353e+02
GS_37_10 0 NS_37 NA_10 0 1.4548200045778645e-01
*
* Real pole n. 38
CS_38 NS_38 0 9.9999999999999998e-13
RS_38 NS_38 0 2.8991282876789563e+02
GS_38_10 0 NS_38 NA_10 0 1.4548200045778645e-01
*
* Real pole n. 39
CS_39 NS_39 0 9.9999999999999998e-13
RS_39 NS_39 0 6.2118036436066882e+02
GS_39_10 0 NS_39 NA_10 0 1.4548200045778645e-01
*
* Real pole n. 40
CS_40 NS_40 0 9.9999999999999998e-13
RS_40 NS_40 0 1.6804456537393244e+03
GS_40_10 0 NS_40 NA_10 0 1.4548200045778645e-01
*
******************************

.ends
*******************
* End of subcircuit
*******************
