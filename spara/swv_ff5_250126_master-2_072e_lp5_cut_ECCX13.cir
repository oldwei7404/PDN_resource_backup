**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 18-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Fri Apr 18 11:30:09 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Fri Apr 18 11:30:09 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_VDDCR_ECCX13_Group_DIE1_GRP_1_0_VSS
**  Port[2] = PORT_2_BGA1_VDDCR_ECCX13_Group_BGA1_GRP_1_1_VSS
**  Port[3] = VDDCR_ECCX13_C18_2
**  Port[4] = VDDCR_ECCX13_C19_2
**  Port[5] = VDDCR_ECCX13_C21_2
**  Port[6] = VDDCR_ECCX13_C22_2
**  Port[7] = VDDCR_ECCX13_C100_2
**  Port[8] = VDDCR_ECCX13_C101_2
**  Port[9] = VDDCR_ECCX13_C104_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 4]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_ECCX13
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -3.7740285436736176e-01
GC_1_2 ref NI_1 NS_2 0 2.3587843334055190e-02
GC_1_3 ref NI_1 NS_3 0 -2.1510105315519841e-02
GC_1_4 ref NI_1 NS_4 0 -1.2540436944536118e-02
GC_1_5 ref NI_1 NS_5 0 3.8555519251005471e-01
GC_1_6 ref NI_1 NS_6 0 -4.8267592334555250e-02
GC_1_7 ref NI_1 NS_7 0 -1.7808857036215923e-02
GC_1_8 ref NI_1 NS_8 0 -1.4503056593718084e-02
GC_1_9 ref NI_1 NS_9 0 6.1904941254003120e-03
GC_1_10 ref NI_1 NS_10 0 -7.4279929987884135e-03
GC_1_11 ref NI_1 NS_11 0 7.8478427728648614e-03
GC_1_12 ref NI_1 NS_12 0 4.8166694266171626e-03
GC_1_13 ref NI_1 NS_13 0 9.3431725042777726e-03
GC_1_14 ref NI_1 NS_14 0 -7.2403625429797915e-03
GC_1_15 ref NI_1 NS_15 0 6.5524800586138042e-03
GC_1_16 ref NI_1 NS_16 0 4.8913814994077029e-03
GC_1_17 ref NI_1 NS_17 0 3.0182437846185063e-04
GC_1_18 ref NI_1 NS_18 0 -6.0852230854740105e-03
GC_1_19 ref NI_1 NS_19 0 6.1183547238878814e-03
GC_1_20 ref NI_1 NS_20 0 5.7565846368902501e-03
GC_1_21 ref NI_1 NS_21 0 4.4226148770910934e-03
GC_1_22 ref NI_1 NS_22 0 -1.0531588060421435e-02
GC_1_23 ref NI_1 NS_23 0 6.8546653871546940e-03
GC_1_24 ref NI_1 NS_24 0 5.9283574215023317e-03
GC_1_25 ref NI_1 NS_25 0 6.5831428833466625e-03
GC_1_26 ref NI_1 NS_26 0 -3.4373339860824040e-03
GC_1_27 ref NI_1 NS_27 0 8.8941806792440081e-03
GC_1_28 ref NI_1 NS_28 0 3.6775327151494360e-03
GC_1_29 ref NI_1 NS_29 0 1.2847735865966155e-02
GC_1_30 ref NI_1 NS_30 0 6.1735594343130997e-03
GC_1_31 ref NI_1 NS_31 0 7.4626315889610327e-03
GC_1_32 ref NI_1 NS_32 0 1.7368991637259940e-03
GC_1_33 ref NI_1 NS_33 0 2.9534597707753355e-02
GC_1_34 ref NI_1 NS_34 0 1.4058098844781786e-02
GC_1_35 ref NI_1 NS_35 0 4.9181700142816968e-03
GC_1_36 ref NI_1 NS_36 0 -4.1540411821879637e-04
GD_1_1 ref NI_1 NA_1 0 5.3943571908709584e+00
GD_1_2 ref NI_1 NA_2 0 9.1644540168341865e-02
GD_1_3 ref NI_1 NA_3 0 3.6462244798059318e-02
GD_1_4 ref NI_1 NA_4 0 4.9500095096079999e-02
GD_1_5 ref NI_1 NA_5 0 3.5613747542999508e-02
GD_1_6 ref NI_1 NA_6 0 3.0406716882992003e-02
GD_1_7 ref NI_1 NA_7 0 3.9419239930414816e-02
GD_1_8 ref NI_1 NA_8 0 5.3820885925750052e-02
GD_1_9 ref NI_1 NA_9 0 6.0951466667524441e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 3.8555519251005460e-01
GC_2_2 ref NI_2 NS_2 0 -4.8267592334555007e-02
GC_2_3 ref NI_2 NS_3 0 -1.7808857036216107e-02
GC_2_4 ref NI_2 NS_4 0 -1.4503056593718032e-02
GC_2_5 ref NI_2 NS_5 0 -2.1847891751390136e-01
GC_2_6 ref NI_2 NS_6 0 4.6213648411650553e-03
GC_2_7 ref NI_2 NS_7 0 -3.5787226662593492e-02
GC_2_8 ref NI_2 NS_8 0 -2.0087067691674721e-02
GC_2_9 ref NI_2 NS_9 0 -2.4121574682765094e-03
GC_2_10 ref NI_2 NS_10 0 -1.0628263442554537e-02
GC_2_11 ref NI_2 NS_11 0 8.5242070192126512e-03
GC_2_12 ref NI_2 NS_12 0 6.1407138532148780e-03
GC_2_13 ref NI_2 NS_13 0 -4.3869670467205739e-03
GC_2_14 ref NI_2 NS_14 0 -5.3878907865546992e-03
GC_2_15 ref NI_2 NS_15 0 6.0872945436141676e-03
GC_2_16 ref NI_2 NS_16 0 6.2312495331530169e-03
GC_2_17 ref NI_2 NS_17 0 -6.1992303070812721e-04
GC_2_18 ref NI_2 NS_18 0 -1.2842176053679769e-02
GC_2_19 ref NI_2 NS_19 0 6.1502353102883527e-03
GC_2_20 ref NI_2 NS_20 0 7.1887696560510046e-03
GC_2_21 ref NI_2 NS_21 0 4.1670369667327727e-03
GC_2_22 ref NI_2 NS_22 0 -1.5641571180592159e-02
GC_2_23 ref NI_2 NS_23 0 5.6673134164746458e-03
GC_2_24 ref NI_2 NS_24 0 7.4586099837155861e-03
GC_2_25 ref NI_2 NS_25 0 -9.2146571773811369e-03
GC_2_26 ref NI_2 NS_26 0 -6.3353107527670790e-03
GC_2_27 ref NI_2 NS_27 0 1.2038447793860874e-02
GC_2_28 ref NI_2 NS_28 0 4.7567438927445232e-03
GC_2_29 ref NI_2 NS_29 0 -2.8737297867419617e-02
GC_2_30 ref NI_2 NS_30 0 1.4648488905606789e-02
GC_2_31 ref NI_2 NS_31 0 1.2807641022172174e-02
GC_2_32 ref NI_2 NS_32 0 2.3895046836134187e-03
GC_2_33 ref NI_2 NS_33 0 -5.1867584257228164e-02
GC_2_34 ref NI_2 NS_34 0 4.5009315737496891e-02
GC_2_35 ref NI_2 NS_35 0 1.0370663943201418e-02
GC_2_36 ref NI_2 NS_36 0 -1.5734518682787726e-04
GD_2_1 ref NI_2 NA_1 0 9.1644540168341865e-02
GD_2_2 ref NI_2 NA_2 0 5.5006621538092677e+00
GD_2_3 ref NI_2 NA_3 0 1.9210772245844734e-02
GD_2_4 ref NI_2 NA_4 0 1.8385056955247239e-02
GD_2_5 ref NI_2 NA_5 0 2.8017054015308733e-02
GD_2_6 ref NI_2 NA_6 0 1.4189788594503039e-02
GD_2_7 ref NI_2 NA_7 0 2.4536434288287286e-02
GD_2_8 ref NI_2 NA_8 0 3.7404135658757512e-02
GD_2_9 ref NI_2 NA_9 0 3.6207173796965232e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 6.1904941254002704e-03
GC_3_2 ref NI_3 NS_2 0 -7.4279929987883285e-03
GC_3_3 ref NI_3 NS_3 0 7.8478427728647989e-03
GC_3_4 ref NI_3 NS_4 0 4.8166694266171808e-03
GC_3_5 ref NI_3 NS_5 0 -2.4121574682765489e-03
GC_3_6 ref NI_3 NS_6 0 -1.0628263442554450e-02
GC_3_7 ref NI_3 NS_7 0 8.5242070192125853e-03
GC_3_8 ref NI_3 NS_8 0 6.1407138532148979e-03
GC_3_9 ref NI_3 NS_9 0 -5.6521897845173689e-02
GC_3_10 ref NI_3 NS_10 0 -2.5983815765468654e-01
GC_3_11 ref NI_3 NS_11 0 7.6193696778007356e-03
GC_3_12 ref NI_3 NS_12 0 -4.7362042612411597e-03
GC_3_13 ref NI_3 NS_13 0 1.8814234991817148e-02
GC_3_14 ref NI_3 NS_14 0 4.2309357133438377e-02
GC_3_15 ref NI_3 NS_15 0 -3.4452762605813292e-03
GC_3_16 ref NI_3 NS_16 0 -1.5187829308147139e-03
GC_3_17 ref NI_3 NS_17 0 -2.3755578039141658e-02
GC_3_18 ref NI_3 NS_18 0 6.3769292435627456e-02
GC_3_19 ref NI_3 NS_19 0 -2.7852421216838200e-03
GC_3_20 ref NI_3 NS_20 0 -1.7724241910360926e-03
GC_3_21 ref NI_3 NS_21 0 3.9347769263330105e-02
GC_3_22 ref NI_3 NS_22 0 7.1897642044029042e-02
GC_3_23 ref NI_3 NS_23 0 -2.1401846823948165e-02
GC_3_24 ref NI_3 NS_24 0 -2.2538984364262504e-03
GC_3_25 ref NI_3 NS_25 0 4.2888142962186855e-02
GC_3_26 ref NI_3 NS_26 0 4.6630814054654419e-02
GC_3_27 ref NI_3 NS_27 0 -1.2539837224521110e-02
GC_3_28 ref NI_3 NS_28 0 -1.0129457255581439e-03
GC_3_29 ref NI_3 NS_29 0 -9.6508897131556710e-03
GC_3_30 ref NI_3 NS_30 0 3.4907008305556673e-02
GC_3_31 ref NI_3 NS_31 0 4.3906825955774605e-03
GC_3_32 ref NI_3 NS_32 0 -1.7980519043631727e-04
GC_3_33 ref NI_3 NS_33 0 -1.1780135457625195e-02
GC_3_34 ref NI_3 NS_34 0 1.7962150065188209e-02
GC_3_35 ref NI_3 NS_35 0 1.1331055282467252e-02
GC_3_36 ref NI_3 NS_36 0 6.7793181359541185e-04
GD_3_1 ref NI_3 NA_1 0 3.6462244798059318e-02
GD_3_2 ref NI_3 NA_2 0 1.9210772245844734e-02
GD_3_3 ref NI_3 NA_3 0 6.1733229389018112e+00
GD_3_4 ref NI_3 NA_4 0 3.2377802035306026e-02
GD_3_5 ref NI_3 NA_5 0 5.0748373876484967e-02
GD_3_6 ref NI_3 NA_6 0 -5.3967680247002048e-02
GD_3_7 ref NI_3 NA_7 0 -4.9992273511735408e-02
GD_3_8 ref NI_3 NA_8 0 3.1699732210333495e-02
GD_3_9 ref NI_3 NA_9 0 4.2554545892902904e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 9.3431725042777275e-03
GC_4_2 ref NI_4 NS_2 0 -7.2403625429796987e-03
GC_4_3 ref NI_4 NS_3 0 6.5524800586137348e-03
GC_4_4 ref NI_4 NS_4 0 4.8913814994077211e-03
GC_4_5 ref NI_4 NS_5 0 -4.3869670467205643e-03
GC_4_6 ref NI_4 NS_6 0 -5.3878907865547209e-03
GC_4_7 ref NI_4 NS_7 0 6.0872945436141841e-03
GC_4_8 ref NI_4 NS_8 0 6.2312495331530117e-03
GC_4_9 ref NI_4 NS_9 0 1.8814234991817121e-02
GC_4_10 ref NI_4 NS_10 0 4.2309357133438440e-02
GC_4_11 ref NI_4 NS_11 0 -3.4452762605813761e-03
GC_4_12 ref NI_4 NS_12 0 -1.5187829308147005e-03
GC_4_13 ref NI_4 NS_13 0 -2.5648025190580293e-01
GC_4_14 ref NI_4 NS_14 0 -1.3821532925127172e-01
GC_4_15 ref NI_4 NS_15 0 -4.8822449453828236e-06
GC_4_16 ref NI_4 NS_16 0 -5.1337122647755412e-03
GC_4_17 ref NI_4 NS_17 0 2.4050812966200569e-01
GC_4_18 ref NI_4 NS_18 0 -1.1749625642680840e-02
GC_4_19 ref NI_4 NS_19 0 -3.2380523510749187e-02
GC_4_20 ref NI_4 NS_20 0 -1.9990526468598321e-03
GC_4_21 ref NI_4 NS_21 0 -1.7560899458092520e-02
GC_4_22 ref NI_4 NS_22 0 5.3742726698018724e-02
GC_4_23 ref NI_4 NS_23 0 1.9046470438563816e-03
GC_4_24 ref NI_4 NS_24 0 -2.1922723861464060e-03
GC_4_25 ref NI_4 NS_25 0 6.0543045678031733e-03
GC_4_26 ref NI_4 NS_26 0 3.4071097396126522e-02
GC_4_27 ref NI_4 NS_27 0 2.7847477652455078e-03
GC_4_28 ref NI_4 NS_28 0 -9.9442561498635303e-04
GC_4_29 ref NI_4 NS_29 0 5.8907672113431737e-03
GC_4_30 ref NI_4 NS_30 0 2.0314551009082832e-02
GC_4_31 ref NI_4 NS_31 0 7.3544991552933628e-03
GC_4_32 ref NI_4 NS_32 0 -2.8064625851301435e-06
GC_4_33 ref NI_4 NS_33 0 1.7816733095751803e-03
GC_4_34 ref NI_4 NS_34 0 1.1291570086006250e-02
GC_4_35 ref NI_4 NS_35 0 1.0796879464376272e-02
GC_4_36 ref NI_4 NS_36 0 8.7044216576264821e-04
GD_4_1 ref NI_4 NA_1 0 4.9500095096079999e-02
GD_4_2 ref NI_4 NA_2 0 1.8385056955247239e-02
GD_4_3 ref NI_4 NA_3 0 3.2377802035306026e-02
GD_4_4 ref NI_4 NA_4 0 6.0568541270818717e+00
GD_4_5 ref NI_4 NA_5 0 -5.2905271955166339e-02
GD_4_6 ref NI_4 NA_6 0 5.9029419652473547e-02
GD_4_7 ref NI_4 NA_7 0 4.0373704899250434e-02
GD_4_8 ref NI_4 NA_8 0 3.7912693435664620e-02
GD_4_9 ref NI_4 NA_9 0 3.5664933548822102e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 3.0182437846184386e-04
GC_5_2 ref NI_5 NS_2 0 -6.0852230854739975e-03
GC_5_3 ref NI_5 NS_3 0 6.1183547238878718e-03
GC_5_4 ref NI_5 NS_4 0 5.7565846368902518e-03
GC_5_5 ref NI_5 NS_5 0 -6.1992303070811854e-04
GC_5_6 ref NI_5 NS_6 0 -1.2842176053679792e-02
GC_5_7 ref NI_5 NS_7 0 6.1502353102883649e-03
GC_5_8 ref NI_5 NS_8 0 7.1887696560510002e-03
GC_5_9 ref NI_5 NS_9 0 -2.3755578039141610e-02
GC_5_10 ref NI_5 NS_10 0 6.3769292435627359e-02
GC_5_11 ref NI_5 NS_11 0 -2.7852421216837423e-03
GC_5_12 ref NI_5 NS_12 0 -1.7724241910361135e-03
GC_5_13 ref NI_5 NS_13 0 2.4050812966200569e-01
GC_5_14 ref NI_5 NS_14 0 -1.1749625642680868e-02
GC_5_15 ref NI_5 NS_15 0 -3.2380523510749167e-02
GC_5_16 ref NI_5 NS_16 0 -1.9990526468598373e-03
GC_5_17 ref NI_5 NS_17 0 -9.9384827447963980e-02
GC_5_18 ref NI_5 NS_18 0 -1.6944857976201677e-01
GC_5_19 ref NI_5 NS_19 0 -2.1463561700772727e-02
GC_5_20 ref NI_5 NS_20 0 -6.3627325819360639e-03
GC_5_21 ref NI_5 NS_21 0 -3.1920857750615067e-02
GC_5_22 ref NI_5 NS_22 0 6.2309071147072376e-02
GC_5_23 ref NI_5 NS_23 0 2.5634978016722061e-03
GC_5_24 ref NI_5 NS_24 0 -2.6732662976422512e-03
GC_5_25 ref NI_5 NS_25 0 -3.8410817718658126e-02
GC_5_26 ref NI_5 NS_26 0 4.5468851502734560e-02
GC_5_27 ref NI_5 NS_27 0 8.6597287956524192e-03
GC_5_28 ref NI_5 NS_28 0 -1.1174416335537627e-03
GC_5_29 ref NI_5 NS_29 0 -2.7026740195314380e-02
GC_5_30 ref NI_5 NS_30 0 2.2747833524772821e-02
GC_5_31 ref NI_5 NS_31 0 1.4460263987103933e-02
GC_5_32 ref NI_5 NS_32 0 6.2611043818796953e-05
GC_5_33 ref NI_5 NS_33 0 -1.7812479036651552e-02
GC_5_34 ref NI_5 NS_34 0 6.0751103479597841e-03
GC_5_35 ref NI_5 NS_35 0 1.8025994866099748e-02
GC_5_36 ref NI_5 NS_36 0 1.0947859368997145e-03
GD_5_1 ref NI_5 NA_1 0 3.5613747542999508e-02
GD_5_2 ref NI_5 NA_2 0 2.8017054015308733e-02
GD_5_3 ref NI_5 NA_3 0 5.0748373876484967e-02
GD_5_4 ref NI_5 NA_4 0 -5.2905271955166339e-02
GD_5_5 ref NI_5 NA_5 0 5.9657822915117222e+00
GD_5_6 ref NI_5 NA_6 0 7.1428123330548737e-02
GD_5_7 ref NI_5 NA_7 0 7.6403786107134247e-02
GD_5_8 ref NI_5 NA_8 0 6.3827705026795606e-02
GD_5_9 ref NI_5 NA_9 0 5.2530231665866872e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 4.4226148770910908e-03
GC_6_2 ref NI_6 NS_2 0 -1.0531588060421437e-02
GC_6_3 ref NI_6 NS_3 0 6.8546653871546966e-03
GC_6_4 ref NI_6 NS_4 0 5.9283574215023291e-03
GC_6_5 ref NI_6 NS_5 0 4.1670369667328021e-03
GC_6_6 ref NI_6 NS_6 0 -1.5641571180592225e-02
GC_6_7 ref NI_6 NS_7 0 5.6673134164746978e-03
GC_6_8 ref NI_6 NS_8 0 7.4586099837155740e-03
GC_6_9 ref NI_6 NS_9 0 3.9347769263330119e-02
GC_6_10 ref NI_6 NS_10 0 7.1897642044029042e-02
GC_6_11 ref NI_6 NS_11 0 -2.1401846823948155e-02
GC_6_12 ref NI_6 NS_12 0 -2.2538984364262530e-03
GC_6_13 ref NI_6 NS_13 0 -1.7560899458092496e-02
GC_6_14 ref NI_6 NS_14 0 5.3742726698018661e-02
GC_6_15 ref NI_6 NS_15 0 1.9046470438564235e-03
GC_6_16 ref NI_6 NS_16 0 -2.1922723861464181e-03
GC_6_17 ref NI_6 NS_17 0 -3.1920857750615067e-02
GC_6_18 ref NI_6 NS_18 0 6.2309071147072362e-02
GC_6_19 ref NI_6 NS_19 0 2.5634978016722122e-03
GC_6_20 ref NI_6 NS_20 0 -2.6732662976422534e-03
GC_6_21 ref NI_6 NS_21 0 5.8450333101322451e-02
GC_6_22 ref NI_6 NS_22 0 -2.0876040208196164e-01
GC_6_23 ref NI_6 NS_23 0 -4.5892430153402802e-02
GC_6_24 ref NI_6 NS_24 0 -5.5947457730797009e-03
GC_6_25 ref NI_6 NS_25 0 -3.1203148562600563e-02
GC_6_26 ref NI_6 NS_26 0 4.3383152559366950e-02
GC_6_27 ref NI_6 NS_27 0 9.0947797602501344e-03
GC_6_28 ref NI_6 NS_28 0 -1.5261794378228883e-03
GC_6_29 ref NI_6 NS_29 0 -1.6837227716940861e-02
GC_6_30 ref NI_6 NS_30 0 1.0575269113190100e-02
GC_6_31 ref NI_6 NS_31 0 1.8504565121539425e-02
GC_6_32 ref NI_6 NS_32 0 -4.4932857644778414e-05
GC_6_33 ref NI_6 NS_33 0 -6.9245553375377692e-03
GC_6_34 ref NI_6 NS_34 0 -6.7941995447960962e-03
GC_6_35 ref NI_6 NS_35 0 2.2056094490391177e-02
GC_6_36 ref NI_6 NS_36 0 1.0775618241125700e-03
GD_6_1 ref NI_6 NA_1 0 3.0406716882992003e-02
GD_6_2 ref NI_6 NA_2 0 1.4189788594503039e-02
GD_6_3 ref NI_6 NA_3 0 -5.3967680247002048e-02
GD_6_4 ref NI_6 NA_4 0 5.9029419652473547e-02
GD_6_5 ref NI_6 NA_5 0 7.1428123330548737e-02
GD_6_6 ref NI_6 NA_6 0 6.0051586705680062e+00
GD_6_7 ref NI_6 NA_7 0 6.6655316221246125e-02
GD_6_8 ref NI_6 NA_8 0 5.8395297256833303e-02
GD_6_9 ref NI_6 NA_9 0 4.0905597051192649e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 6.5831428833466599e-03
GC_7_2 ref NI_7 NS_2 0 -3.4373339860823983e-03
GC_7_3 ref NI_7 NS_3 0 8.8941806792440046e-03
GC_7_4 ref NI_7 NS_4 0 3.6775327151494360e-03
GC_7_5 ref NI_7 NS_5 0 -9.2146571773811265e-03
GC_7_6 ref NI_7 NS_6 0 -6.3353107527671076e-03
GC_7_7 ref NI_7 NS_7 0 1.2038447793860894e-02
GC_7_8 ref NI_7 NS_8 0 4.7567438927445188e-03
GC_7_9 ref NI_7 NS_9 0 4.2888142962186904e-02
GC_7_10 ref NI_7 NS_10 0 4.6630814054654315e-02
GC_7_11 ref NI_7 NS_11 0 -1.2539837224521030e-02
GC_7_12 ref NI_7 NS_12 0 -1.0129457255581651e-03
GC_7_13 ref NI_7 NS_13 0 6.0543045678031785e-03
GC_7_14 ref NI_7 NS_14 0 3.4071097396126508e-02
GC_7_15 ref NI_7 NS_15 0 2.7847477652455190e-03
GC_7_16 ref NI_7 NS_16 0 -9.9442561498635541e-04
GC_7_17 ref NI_7 NS_17 0 -3.8410817718658057e-02
GC_7_18 ref NI_7 NS_18 0 4.5468851502734400e-02
GC_7_19 ref NI_7 NS_19 0 8.6597287956525371e-03
GC_7_20 ref NI_7 NS_20 0 -1.1174416335537969e-03
GC_7_21 ref NI_7 NS_21 0 -3.1203148562600577e-02
GC_7_22 ref NI_7 NS_22 0 4.3383152559366985e-02
GC_7_23 ref NI_7 NS_23 0 9.0947797602501101e-03
GC_7_24 ref NI_7 NS_24 0 -1.5261794378228818e-03
GC_7_25 ref NI_7 NS_25 0 2.3411223028006453e-02
GC_7_26 ref NI_7 NS_26 0 -2.6377652243829591e-01
GC_7_27 ref NI_7 NS_27 0 -1.5609188337994186e-02
GC_7_28 ref NI_7 NS_28 0 -3.1203879345936378e-03
GC_7_29 ref NI_7 NS_29 0 2.2131932628694780e-02
GC_7_30 ref NI_7 NS_30 0 5.7769122328569726e-02
GC_7_31 ref NI_7 NS_31 0 -1.4300828190407495e-02
GC_7_32 ref NI_7 NS_32 0 -5.1226346525143514e-04
GC_7_33 ref NI_7 NS_33 0 -1.9057123487283906e-02
GC_7_34 ref NI_7 NS_34 0 4.5838544034008985e-02
GC_7_35 ref NI_7 NS_35 0 5.6168437607382801e-04
GC_7_36 ref NI_7 NS_36 0 3.6177628062697672e-06
GD_7_1 ref NI_7 NA_1 0 3.9419239930414816e-02
GD_7_2 ref NI_7 NA_2 0 2.4536434288287286e-02
GD_7_3 ref NI_7 NA_3 0 -4.9992273511735408e-02
GD_7_4 ref NI_7 NA_4 0 4.0373704899250434e-02
GD_7_5 ref NI_7 NA_5 0 7.6403786107134247e-02
GD_7_6 ref NI_7 NA_6 0 6.6655316221246125e-02
GD_7_7 ref NI_7 NA_7 0 6.0965709720482684e+00
GD_7_8 ref NI_7 NA_8 0 -4.8786522675270769e-02
GD_7_9 ref NI_7 NA_9 0 3.3335078480951796e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 1.2847735865966190e-02
GC_8_2 ref NI_8 NS_2 0 6.1735594343130182e-03
GC_8_3 ref NI_8 NS_3 0 7.4626315889610934e-03
GC_8_4 ref NI_8 NS_4 0 1.7368991637259756e-03
GC_8_5 ref NI_8 NS_5 0 -2.8737297867419551e-02
GC_8_6 ref NI_8 NS_6 0 1.4648488905606636e-02
GC_8_7 ref NI_8 NS_7 0 1.2807641022172290e-02
GC_8_8 ref NI_8 NS_8 0 2.3895046836133861e-03
GC_8_9 ref NI_8 NS_9 0 -9.6508897131556224e-03
GC_8_10 ref NI_8 NS_10 0 3.4907008305556569e-02
GC_8_11 ref NI_8 NS_11 0 4.3906825955775369e-03
GC_8_12 ref NI_8 NS_12 0 -1.7980519043633847e-04
GC_8_13 ref NI_8 NS_13 0 5.8907672113432492e-03
GC_8_14 ref NI_8 NS_14 0 2.0314551009082672e-02
GC_8_15 ref NI_8 NS_15 0 7.3544991552934877e-03
GC_8_16 ref NI_8 NS_16 0 -2.8064625851648342e-06
GC_8_17 ref NI_8 NS_17 0 -2.7026740195314366e-02
GC_8_18 ref NI_8 NS_18 0 2.2747833524772779e-02
GC_8_19 ref NI_8 NS_19 0 1.4460263987103966e-02
GC_8_20 ref NI_8 NS_20 0 6.2611043818787778e-05
GC_8_21 ref NI_8 NS_21 0 -1.6837227716940805e-02
GC_8_22 ref NI_8 NS_22 0 1.0575269113189973e-02
GC_8_23 ref NI_8 NS_23 0 1.8504565121539526e-02
GC_8_24 ref NI_8 NS_24 0 -4.4932857644806108e-05
GC_8_25 ref NI_8 NS_25 0 2.2131932628694808e-02
GC_8_26 ref NI_8 NS_26 0 5.7769122328569657e-02
GC_8_27 ref NI_8 NS_27 0 -1.4300828190407445e-02
GC_8_28 ref NI_8 NS_28 0 -5.1226346525144891e-04
GC_8_29 ref NI_8 NS_29 0 2.2743244375453726e-02
GC_8_30 ref NI_8 NS_30 0 -2.5307508420718450e-01
GC_8_31 ref NI_8 NS_31 0 -2.1920478268254277e-02
GC_8_32 ref NI_8 NS_32 0 -2.8419911063204194e-03
GC_8_33 ref NI_8 NS_33 0 2.3268889716402501e-02
GC_8_34 ref NI_8 NS_34 0 8.4992028438093697e-02
GC_8_35 ref NI_8 NS_35 0 -2.8966249113427701e-02
GC_8_36 ref NI_8 NS_36 0 -4.7779117266522520e-04
GD_8_1 ref NI_8 NA_1 0 5.3820885925750052e-02
GD_8_2 ref NI_8 NA_2 0 3.7404135658757512e-02
GD_8_3 ref NI_8 NA_3 0 3.1699732210333495e-02
GD_8_4 ref NI_8 NA_4 0 3.7912693435664620e-02
GD_8_5 ref NI_8 NA_5 0 6.3827705026795606e-02
GD_8_6 ref NI_8 NA_6 0 5.8395297256833303e-02
GD_8_7 ref NI_8 NA_7 0 -4.8786522675270769e-02
GD_8_8 ref NI_8 NA_8 0 6.0961072069385578e+00
GD_8_9 ref NI_8 NA_9 0 -6.8151683276921893e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 2.9534597707753366e-02
GC_9_2 ref NI_9 NS_2 0 1.4058098844781769e-02
GC_9_3 ref NI_9 NS_3 0 4.9181700142817151e-03
GC_9_4 ref NI_9 NS_4 0 -4.1540411821880245e-04
GC_9_5 ref NI_9 NS_5 0 -5.1867584257228178e-02
GC_9_6 ref NI_9 NS_6 0 4.5009315737496933e-02
GC_9_7 ref NI_9 NS_7 0 1.0370663943201386e-02
GC_9_8 ref NI_9 NS_8 0 -1.5734518682786818e-04
GC_9_9 ref NI_9 NS_9 0 -1.1780135457625206e-02
GC_9_10 ref NI_9 NS_10 0 1.7962150065188240e-02
GC_9_11 ref NI_9 NS_11 0 1.1331055282467228e-02
GC_9_12 ref NI_9 NS_12 0 6.7793181359541857e-04
GC_9_13 ref NI_9 NS_13 0 1.7816733095751644e-03
GC_9_14 ref NI_9 NS_14 0 1.1291570086006284e-02
GC_9_15 ref NI_9 NS_15 0 1.0796879464376248e-02
GC_9_16 ref NI_9 NS_16 0 8.7044216576265547e-04
GC_9_17 ref NI_9 NS_17 0 -1.7812479036651552e-02
GC_9_18 ref NI_9 NS_18 0 6.0751103479597833e-03
GC_9_19 ref NI_9 NS_19 0 1.8025994866099748e-02
GC_9_20 ref NI_9 NS_20 0 1.0947859368997128e-03
GC_9_21 ref NI_9 NS_21 0 -6.9245553375377614e-03
GC_9_22 ref NI_9 NS_22 0 -6.7941995447961126e-03
GC_9_23 ref NI_9 NS_23 0 2.2056094490391191e-02
GC_9_24 ref NI_9 NS_24 0 1.0775618241125658e-03
GC_9_25 ref NI_9 NS_25 0 -1.9057123487283969e-02
GC_9_26 ref NI_9 NS_26 0 4.5838544034009124e-02
GC_9_27 ref NI_9 NS_27 0 5.6168437607372773e-04
GC_9_28 ref NI_9 NS_28 0 3.6177628062977480e-06
GC_9_29 ref NI_9 NS_29 0 2.3268889716402508e-02
GC_9_30 ref NI_9 NS_30 0 8.4992028438093656e-02
GC_9_31 ref NI_9 NS_31 0 -2.8966249113427683e-02
GC_9_32 ref NI_9 NS_32 0 -4.7779117266523143e-04
GC_9_33 ref NI_9 NS_33 0 5.8950341768140929e-02
GC_9_34 ref NI_9 NS_34 0 -2.1980795962127964e-01
GC_9_35 ref NI_9 NS_35 0 -4.9118251489792271e-02
GC_9_36 ref NI_9 NS_36 0 -2.5713486691147963e-03
GD_9_1 ref NI_9 NA_1 0 6.0951466667524441e-02
GD_9_2 ref NI_9 NA_2 0 3.6207173796965232e-02
GD_9_3 ref NI_9 NA_3 0 4.2554545892902904e-02
GD_9_4 ref NI_9 NA_4 0 3.5664933548822102e-02
GD_9_5 ref NI_9 NA_5 0 5.2530231665866872e-02
GD_9_6 ref NI_9 NA_6 0 4.0905597051192649e-02
GD_9_7 ref NI_9 NA_7 0 3.3335078480951796e-02
GD_9_8 ref NI_9 NA_8 0 -6.8151683276921893e-02
GD_9_9 ref NI_9 NA_9 0 6.0089749627241673e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.4286361812799026e+02
GS_1_1 0 NS_1 NA_1 0 1.3157946876420126e-01
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 2.7805727062833165e+02
GS_2_1 0 NS_2 NA_1 0 1.3157946876420126e-01
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 5.1457223582456368e+02
GS_3_1 0 NS_3 NA_1 0 1.3157946876420126e-01
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 1.4077357796737581e+03
GS_4_1 0 NS_4 NA_1 0 1.3157946876420126e-01
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.4286361812799026e+02
GS_5_2 0 NS_5 NA_2 0 1.3157946876420126e-01
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 2.7805727062833165e+02
GS_6_2 0 NS_6 NA_2 0 1.3157946876420126e-01
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 5.1457223582456368e+02
GS_7_2 0 NS_7 NA_2 0 1.3157946876420126e-01
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 1.4077357796737581e+03
GS_8_2 0 NS_8 NA_2 0 1.3157946876420126e-01
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.4286361812799026e+02
GS_9_3 0 NS_9 NA_3 0 1.3157946876420126e-01
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 2.7805727062833165e+02
GS_10_3 0 NS_10 NA_3 0 1.3157946876420126e-01
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 5.1457223582456368e+02
GS_11_3 0 NS_11 NA_3 0 1.3157946876420126e-01
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 1.4077357796737581e+03
GS_12_3 0 NS_12 NA_3 0 1.3157946876420126e-01
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.4286361812799026e+02
GS_13_4 0 NS_13 NA_4 0 1.3157946876420126e-01
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 2.7805727062833165e+02
GS_14_4 0 NS_14 NA_4 0 1.3157946876420126e-01
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 5.1457223582456368e+02
GS_15_4 0 NS_15 NA_4 0 1.3157946876420126e-01
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 1.4077357796737581e+03
GS_16_4 0 NS_16 NA_4 0 1.3157946876420126e-01
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.4286361812799026e+02
GS_17_5 0 NS_17 NA_5 0 1.3157946876420126e-01
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 2.7805727062833165e+02
GS_18_5 0 NS_18 NA_5 0 1.3157946876420126e-01
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 5.1457223582456368e+02
GS_19_5 0 NS_19 NA_5 0 1.3157946876420126e-01
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 1.4077357796737581e+03
GS_20_5 0 NS_20 NA_5 0 1.3157946876420126e-01
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.4286361812799026e+02
GS_21_6 0 NS_21 NA_6 0 1.3157946876420126e-01
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 2.7805727062833165e+02
GS_22_6 0 NS_22 NA_6 0 1.3157946876420126e-01
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 5.1457223582456368e+02
GS_23_6 0 NS_23 NA_6 0 1.3157946876420126e-01
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 1.4077357796737581e+03
GS_24_6 0 NS_24 NA_6 0 1.3157946876420126e-01
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.4286361812799026e+02
GS_25_7 0 NS_25 NA_7 0 1.3157946876420126e-01
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 2.7805727062833165e+02
GS_26_7 0 NS_26 NA_7 0 1.3157946876420126e-01
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 5.1457223582456368e+02
GS_27_7 0 NS_27 NA_7 0 1.3157946876420126e-01
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 1.4077357796737581e+03
GS_28_7 0 NS_28 NA_7 0 1.3157946876420126e-01
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.4286361812799026e+02
GS_29_8 0 NS_29 NA_8 0 1.3157946876420126e-01
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 2.7805727062833165e+02
GS_30_8 0 NS_30 NA_8 0 1.3157946876420126e-01
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 5.1457223582456368e+02
GS_31_8 0 NS_31 NA_8 0 1.3157946876420126e-01
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 1.4077357796737581e+03
GS_32_8 0 NS_32 NA_8 0 1.3157946876420126e-01
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 1.4286361812799026e+02
GS_33_9 0 NS_33 NA_9 0 1.3157946876420126e-01
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 2.7805727062833165e+02
GS_34_9 0 NS_34 NA_9 0 1.3157946876420126e-01
*
* Real pole n. 35
CS_35 NS_35 0 9.9999999999999998e-13
RS_35 NS_35 0 5.1457223582456368e+02
GS_35_9 0 NS_35 NA_9 0 1.3157946876420126e-01
*
* Real pole n. 36
CS_36 NS_36 0 9.9999999999999998e-13
RS_36 NS_36 0 1.4077357796737581e+03
GS_36_9 0 NS_36 NA_9 0 1.3157946876420126e-01
*
******************************

.ends
*******************
* End of subcircuit
*******************
