**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 18-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0001_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Thu Apr 17 16:39:10 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Thu Apr 17 16:39:10 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_VDDCR_GFX_Group_DIE1_VSS_Group
**  Port[2] = PORT_2_BGA1_VDDCR_GFX_Group_BGA1_VSS_Group
**  Port[3] = VDDCR_GFX_C8_2
**  Port[4] = VDDCR_GFX_C12_2
**  Port[5] = VDDCR_GFX_C42_2
**  Port[6] = VDDCR_GFX_C43_2
**  Port[7] = VDDCR_GFX_C44_1
**  Port[8] = VDDCR_GFX_C45_2
**  Port[9] = VDDCR_GFX_C46_1
**  Port[10] = VDDCR_GFX_C47_2
**  Port[11] = VDDCR_GFX_C92_1
**  Port[12] = VDDCR_GFX_C128_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 4]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Data based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_GFX
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -5.4024029392742856e-01
GC_1_2 ref NI_1 NS_2 0 -1.0317483723104736e-03
GC_1_3 ref NI_1 NS_3 0 -1.8243199509824189e-03
GC_1_4 ref NI_1 NS_4 0 -4.5562237191012133e-04
GC_1_5 ref NI_1 NS_5 0 1.8510723420902431e-01
GC_1_6 ref NI_1 NS_6 0 -2.3222409791344156e-02
GC_1_7 ref NI_1 NS_7 0 -3.2427561750426430e-03
GC_1_8 ref NI_1 NS_8 0 -3.8205557306860371e-04
GC_1_9 ref NI_1 NS_9 0 2.3579265671282729e-02
GC_1_10 ref NI_1 NS_10 0 1.2240752669374422e-03
GC_1_11 ref NI_1 NS_11 0 3.0479794894764413e-03
GC_1_12 ref NI_1 NS_12 0 1.2600725345530289e-04
GC_1_13 ref NI_1 NS_13 0 5.2833586358898836e-02
GC_1_14 ref NI_1 NS_14 0 1.6583165714079199e-03
GC_1_15 ref NI_1 NS_15 0 -3.6163376831841262e-04
GC_1_16 ref NI_1 NS_16 0 -5.4671561255632490e-05
GC_1_17 ref NI_1 NS_17 0 1.7811864995868246e-02
GC_1_18 ref NI_1 NS_18 0 -1.3556965337652056e-03
GC_1_19 ref NI_1 NS_19 0 5.0205020445589213e-03
GC_1_20 ref NI_1 NS_20 0 1.7110629367415750e-04
GC_1_21 ref NI_1 NS_21 0 6.3758617863162628e-02
GC_1_22 ref NI_1 NS_22 0 -1.0654747023312241e-03
GC_1_23 ref NI_1 NS_23 0 -8.3999200760171441e-04
GC_1_24 ref NI_1 NS_24 0 5.4540073917121044e-05
GC_1_25 ref NI_1 NS_25 0 3.6357684917648611e-02
GC_1_26 ref NI_1 NS_26 0 4.9674065940904250e-03
GC_1_27 ref NI_1 NS_27 0 -8.2023135944923593e-06
GC_1_28 ref NI_1 NS_28 0 -5.6473989629624193e-05
GC_1_29 ref NI_1 NS_29 0 4.7158701929021780e-02
GC_1_30 ref NI_1 NS_30 0 2.3366766963126397e-03
GC_1_31 ref NI_1 NS_31 0 -3.0740202709919298e-04
GC_1_32 ref NI_1 NS_32 0 -2.0313958588728780e-05
GC_1_33 ref NI_1 NS_33 0 5.6052423207993467e-02
GC_1_34 ref NI_1 NS_34 0 8.1267700654999670e-05
GC_1_35 ref NI_1 NS_35 0 6.7871614576412101e-06
GC_1_36 ref NI_1 NS_36 0 -1.1220493379973034e-04
GC_1_37 ref NI_1 NS_37 0 5.8779108765969916e-02
GC_1_38 ref NI_1 NS_38 0 7.3162036052739873e-04
GC_1_39 ref NI_1 NS_39 0 -7.0817970106467655e-04
GC_1_40 ref NI_1 NS_40 0 -9.2093389199308511e-05
GC_1_41 ref NI_1 NS_41 0 2.4337678161008632e-02
GC_1_42 ref NI_1 NS_42 0 1.0920179443954354e-03
GC_1_43 ref NI_1 NS_43 0 1.1421934914257212e-03
GC_1_44 ref NI_1 NS_44 0 6.1768672368550312e-04
GC_1_45 ref NI_1 NS_45 0 3.2015104158249007e-02
GC_1_46 ref NI_1 NS_46 0 3.6093407624422300e-03
GC_1_47 ref NI_1 NS_47 0 9.5204520351784428e-04
GC_1_48 ref NI_1 NS_48 0 -4.7514105609768663e-06
GD_1_1 ref NI_1 NA_1 0 5.2965610428346812e+00
GD_1_2 ref NI_1 NA_2 0 -1.1049370142590173e-01
GD_1_3 ref NI_1 NA_3 0 3.4417325083234314e-02
GD_1_4 ref NI_1 NA_4 0 4.2279014349945847e-02
GD_1_5 ref NI_1 NA_5 0 6.8478074950195159e-03
GD_1_6 ref NI_1 NA_6 0 4.7850360739640489e-02
GD_1_7 ref NI_1 NA_7 0 5.5081144924297082e-02
GD_1_8 ref NI_1 NA_8 0 6.9044973924009614e-02
GD_1_9 ref NI_1 NA_9 0 5.4981390350844199e-02
GD_1_10 ref NI_1 NA_10 0 5.5548360531877852e-02
GD_1_11 ref NI_1 NA_11 0 6.8998424774503020e-02
GD_1_12 ref NI_1 NA_12 0 7.1203443459177146e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 1.8510723420902447e-01
GC_2_2 ref NI_2 NS_2 0 -2.3222409791344208e-02
GC_2_3 ref NI_2 NS_3 0 -3.2427561750426204e-03
GC_2_4 ref NI_2 NS_4 0 -3.8205557306860479e-04
GC_2_5 ref NI_2 NS_5 0 8.0887364486360330e-02
GC_2_6 ref NI_2 NS_6 0 -1.2053623394178406e-01
GC_2_7 ref NI_2 NS_7 0 -1.8117197894261351e-02
GC_2_8 ref NI_2 NS_8 0 -1.8173582176498827e-03
GC_2_9 ref NI_2 NS_9 0 -1.0172927086223789e-02
GC_2_10 ref NI_2 NS_10 0 2.4540185323327201e-03
GC_2_11 ref NI_2 NS_11 0 6.4263472296917784e-03
GC_2_12 ref NI_2 NS_12 0 2.9968111819493522e-04
GC_2_13 ref NI_2 NS_13 0 -2.0829902946836756e-02
GC_2_14 ref NI_2 NS_14 0 1.8413943625512227e-02
GC_2_15 ref NI_2 NS_15 0 9.2245237401720971e-04
GC_2_16 ref NI_2 NS_16 0 3.3237325721909751e-05
GC_2_17 ref NI_2 NS_17 0 -3.5608984487191637e-03
GC_2_18 ref NI_2 NS_18 0 -3.6840757343827384e-03
GC_2_19 ref NI_2 NS_19 0 8.1693005337709103e-03
GC_2_20 ref NI_2 NS_20 0 4.6725372855372629e-04
GC_2_21 ref NI_2 NS_21 0 -1.9617769813411512e-02
GC_2_22 ref NI_2 NS_22 0 2.2675241793371118e-02
GC_2_23 ref NI_2 NS_23 0 -1.7684913129306918e-03
GC_2_24 ref NI_2 NS_24 0 2.5241949704554045e-04
GC_2_25 ref NI_2 NS_25 0 -2.1340853640095640e-02
GC_2_26 ref NI_2 NS_26 0 1.3512763699414307e-02
GC_2_27 ref NI_2 NS_27 0 3.4261765311906878e-03
GC_2_28 ref NI_2 NS_28 0 -1.0569716794794768e-04
GC_2_29 ref NI_2 NS_29 0 -2.0383356898430773e-02
GC_2_30 ref NI_2 NS_30 0 1.7720703129607187e-02
GC_2_31 ref NI_2 NS_31 0 1.0542684467508730e-03
GC_2_32 ref NI_2 NS_32 0 3.4604008659499065e-05
GC_2_33 ref NI_2 NS_33 0 -1.9399705457147663e-02
GC_2_34 ref NI_2 NS_34 0 1.9415015104224005e-02
GC_2_35 ref NI_2 NS_35 0 2.9505208064909501e-04
GC_2_36 ref NI_2 NS_36 0 2.9328762052002926e-05
GC_2_37 ref NI_2 NS_37 0 -2.1040221784931337e-02
GC_2_38 ref NI_2 NS_38 0 2.1837747972389580e-02
GC_2_39 ref NI_2 NS_39 0 -6.4999188960978400e-04
GC_2_40 ref NI_2 NS_40 0 2.1401084645459753e-05
GC_2_41 ref NI_2 NS_41 0 -1.1496067475267557e-02
GC_2_42 ref NI_2 NS_42 0 6.3571652752485719e-03
GC_2_43 ref NI_2 NS_43 0 2.7618980357932105e-03
GC_2_44 ref NI_2 NS_44 0 8.6773728532089933e-04
GC_2_45 ref NI_2 NS_45 0 -1.7946712517565803e-02
GC_2_46 ref NI_2 NS_46 0 1.0768965029734779e-02
GC_2_47 ref NI_2 NS_47 0 4.0433075828824943e-03
GC_2_48 ref NI_2 NS_48 0 9.7348232223137428e-06
GD_2_1 ref NI_2 NA_1 0 -1.1049370142590316e-01
GD_2_2 ref NI_2 NA_2 0 4.9923046789326051e+00
GD_2_3 ref NI_2 NA_3 0 1.7989340563152073e-02
GD_2_4 ref NI_2 NA_4 0 2.2296043174660045e-02
GD_2_5 ref NI_2 NA_5 0 -8.6367608827519950e-03
GD_2_6 ref NI_2 NA_6 0 -4.7618165819730421e-03
GD_2_7 ref NI_2 NA_7 0 5.6574455494252510e-02
GD_2_8 ref NI_2 NA_8 0 3.2871218329887791e-02
GD_2_9 ref NI_2 NA_9 0 1.0149389416682546e-02
GD_2_10 ref NI_2 NA_10 0 1.2696166119730930e-02
GD_2_11 ref NI_2 NA_11 0 3.0855131633762186e-02
GD_2_12 ref NI_2 NA_12 0 4.8787396589815193e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 2.3579265671282736e-02
GC_3_2 ref NI_3 NS_2 0 1.2240752669374208e-03
GC_3_3 ref NI_3 NS_3 0 3.0479794894764612e-03
GC_3_4 ref NI_3 NS_4 0 1.2600725345529598e-04
GC_3_5 ref NI_3 NS_5 0 -1.0172927086223749e-02
GC_3_6 ref NI_3 NS_6 0 2.4540185323326824e-03
GC_3_7 ref NI_3 NS_7 0 6.4263472296918114e-03
GC_3_8 ref NI_3 NS_8 0 2.9968111819492232e-04
GC_3_9 ref NI_3 NS_9 0 1.0524326196639983e-02
GC_3_10 ref NI_3 NS_10 0 -1.0067213317060496e-02
GC_3_11 ref NI_3 NS_11 0 -6.3751320963914990e-02
GC_3_12 ref NI_3 NS_12 0 -3.7742219970633901e-03
GC_3_13 ref NI_3 NS_13 0 -1.1353096581826204e-02
GC_3_14 ref NI_3 NS_14 0 2.0246533009897226e-02
GC_3_15 ref NI_3 NS_15 0 2.9256014312150341e-03
GC_3_16 ref NI_3 NS_16 0 -1.3613837674946823e-03
GC_3_17 ref NI_3 NS_17 0 1.7396753454671458e-03
GC_3_18 ref NI_3 NS_18 0 -4.1645205166468162e-03
GC_3_19 ref NI_3 NS_19 0 9.3902277654771028e-03
GC_3_20 ref NI_3 NS_20 0 -8.7841783508508427e-05
GC_3_21 ref NI_3 NS_21 0 -5.6347404456381046e-03
GC_3_22 ref NI_3 NS_22 0 1.0445804199490852e-02
GC_3_23 ref NI_3 NS_23 0 3.8157540095874009e-03
GC_3_24 ref NI_3 NS_24 0 -3.0696748716737356e-04
GC_3_25 ref NI_3 NS_25 0 -2.7747880199370275e-03
GC_3_26 ref NI_3 NS_26 0 -2.0582808777670791e-03
GC_3_27 ref NI_3 NS_27 0 7.2600327369700462e-03
GC_3_28 ref NI_3 NS_28 0 3.8682303136032011e-04
GC_3_29 ref NI_3 NS_29 0 -1.1428300084776557e-03
GC_3_30 ref NI_3 NS_30 0 -3.9500684320323770e-03
GC_3_31 ref NI_3 NS_31 0 7.1530889384758762e-03
GC_3_32 ref NI_3 NS_32 0 7.1118604053740171e-04
GC_3_33 ref NI_3 NS_33 0 -4.1349996860075410e-03
GC_3_34 ref NI_3 NS_34 0 6.1794963375037858e-04
GC_3_35 ref NI_3 NS_35 0 6.2014285771836231e-03
GC_3_36 ref NI_3 NS_36 0 3.7434131521640640e-04
GC_3_37 ref NI_3 NS_37 0 -2.1082245896604295e-03
GC_3_38 ref NI_3 NS_38 0 -3.3186716331648335e-03
GC_3_39 ref NI_3 NS_39 0 7.4003753857164352e-03
GC_3_40 ref NI_3 NS_40 0 5.6371415283833649e-04
GC_3_41 ref NI_3 NS_41 0 -3.1447823664535016e-04
GC_3_42 ref NI_3 NS_42 0 -2.7885775363377116e-03
GC_3_43 ref NI_3 NS_43 0 1.7116575295894082e-03
GC_3_44 ref NI_3 NS_44 0 2.2417264780638310e-03
GC_3_45 ref NI_3 NS_45 0 2.5351998154149197e-03
GC_3_46 ref NI_3 NS_46 0 -7.3728979495601820e-03
GC_3_47 ref NI_3 NS_47 0 7.5413616584136768e-03
GC_3_48 ref NI_3 NS_48 0 1.0199075629683881e-03
GD_3_1 ref NI_3 NA_1 0 3.4417325083234293e-02
GD_3_2 ref NI_3 NA_2 0 1.7989340563152004e-02
GD_3_3 ref NI_3 NA_3 0 6.1601316633644023e+00
GD_3_4 ref NI_3 NA_4 0 3.3406343909578341e-02
GD_3_5 ref NI_3 NA_5 0 -1.8804006694825851e-02
GD_3_6 ref NI_3 NA_6 0 1.0340676570497850e-02
GD_3_7 ref NI_3 NA_7 0 1.6805349451701347e-02
GD_3_8 ref NI_3 NA_8 0 3.5993423077489489e-03
GD_3_9 ref NI_3 NA_9 0 1.7201902524160814e-02
GD_3_10 ref NI_3 NA_10 0 4.8592592673977631e-03
GD_3_11 ref NI_3 NA_11 0 7.2084620726409927e-03
GD_3_12 ref NI_3 NA_12 0 -1.5186492656158266e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 5.2833586358898836e-02
GC_4_2 ref NI_4 NS_2 0 1.6583165714079084e-03
GC_4_3 ref NI_4 NS_3 0 -3.6163376831840378e-04
GC_4_4 ref NI_4 NS_4 0 -5.4671561255634110e-05
GC_4_5 ref NI_4 NS_5 0 -2.0829902946836693e-02
GC_4_6 ref NI_4 NS_6 0 1.8413943625512193e-02
GC_4_7 ref NI_4 NS_7 0 9.2245237401723573e-04
GC_4_8 ref NI_4 NS_8 0 3.3237325721900834e-05
GC_4_9 ref NI_4 NS_9 0 -1.1353096581826505e-02
GC_4_10 ref NI_4 NS_10 0 2.0246533009897334e-02
GC_4_11 ref NI_4 NS_11 0 2.9256014312149946e-03
GC_4_12 ref NI_4 NS_12 0 -1.3613837674946812e-03
GC_4_13 ref NI_4 NS_13 0 3.6830812378433685e-02
GC_4_14 ref NI_4 NS_14 0 -8.5320222617356556e-02
GC_4_15 ref NI_4 NS_15 0 -4.0677382803112089e-02
GC_4_16 ref NI_4 NS_16 0 -1.4497842734802638e-04
GC_4_17 ref NI_4 NS_17 0 -1.6122706117513248e-03
GC_4_18 ref NI_4 NS_18 0 -8.1367286430402308e-04
GC_4_19 ref NI_4 NS_19 0 8.5832682540734721e-03
GC_4_20 ref NI_4 NS_20 0 -2.2882324794387153e-04
GC_4_21 ref NI_4 NS_21 0 -3.3355256106730718e-03
GC_4_22 ref NI_4 NS_22 0 2.6653356986963719e-02
GC_4_23 ref NI_4 NS_23 0 -4.5618683360389555e-03
GC_4_24 ref NI_4 NS_24 0 -9.8173119127020717e-05
GC_4_25 ref NI_4 NS_25 0 -1.0613751601207311e-02
GC_4_26 ref NI_4 NS_26 0 5.1807859457617166e-03
GC_4_27 ref NI_4 NS_27 0 5.9337700602369878e-03
GC_4_28 ref NI_4 NS_28 0 -6.8077351627599331e-05
GC_4_29 ref NI_4 NS_29 0 -9.1022836001981820e-03
GC_4_30 ref NI_4 NS_30 0 3.0314687480195541e-03
GC_4_31 ref NI_4 NS_31 0 6.1906967314910057e-03
GC_4_32 ref NI_4 NS_32 0 1.7640054446455805e-04
GC_4_33 ref NI_4 NS_33 0 -1.0413820610042607e-02
GC_4_34 ref NI_4 NS_34 0 9.6541540579636615e-03
GC_4_35 ref NI_4 NS_35 0 3.7743266368246622e-03
GC_4_36 ref NI_4 NS_36 0 -3.0991298169987854e-05
GC_4_37 ref NI_4 NS_37 0 -1.0339014704954783e-02
GC_4_38 ref NI_4 NS_38 0 5.1074356588365006e-03
GC_4_39 ref NI_4 NS_39 0 5.6800726671522531e-03
GC_4_40 ref NI_4 NS_40 0 7.0309876821900616e-05
GC_4_41 ref NI_4 NS_41 0 -4.3408277681125772e-03
GC_4_42 ref NI_4 NS_42 0 1.4749436053567669e-04
GC_4_43 ref NI_4 NS_43 0 2.8570585224442155e-03
GC_4_44 ref NI_4 NS_44 0 1.5073065876132650e-03
GC_4_45 ref NI_4 NS_45 0 -4.8619502524211433e-03
GC_4_46 ref NI_4 NS_46 0 -2.6657939230947478e-03
GC_4_47 ref NI_4 NS_47 0 7.8962631547648977e-03
GC_4_48 ref NI_4 NS_48 0 3.7728027311014070e-04
GD_4_1 ref NI_4 NA_1 0 4.2279014349945881e-02
GD_4_2 ref NI_4 NA_2 0 2.2296043174659663e-02
GD_4_3 ref NI_4 NA_3 0 3.3406343909581783e-02
GD_4_4 ref NI_4 NA_4 0 5.9509932137523913e+00
GD_4_5 ref NI_4 NA_5 0 -5.3533085421626561e-03
GD_4_6 ref NI_4 NA_6 0 -2.3448782342621946e-02
GD_4_7 ref NI_4 NA_7 0 5.0857102433647737e-02
GD_4_8 ref NI_4 NA_8 0 3.7472403328571803e-02
GD_4_9 ref NI_4 NA_9 0 3.7002336629810298e-02
GD_4_10 ref NI_4 NA_10 0 3.5752373150207961e-02
GD_4_11 ref NI_4 NA_11 0 2.8515441575364703e-02
GD_4_12 ref NI_4 NA_12 0 2.1635770447143064e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 1.7811864995868284e-02
GC_5_2 ref NI_5 NS_2 0 -1.3556965337652364e-03
GC_5_3 ref NI_5 NS_3 0 5.0205020445589447e-03
GC_5_4 ref NI_5 NS_4 0 1.7110629367415091e-04
GC_5_5 ref NI_5 NS_5 0 -3.5608984487191537e-03
GC_5_6 ref NI_5 NS_6 0 -3.6840757343827211e-03
GC_5_7 ref NI_5 NS_7 0 8.1693005337708895e-03
GC_5_8 ref NI_5 NS_8 0 4.6725372855373361e-04
GC_5_9 ref NI_5 NS_9 0 1.7396753454669671e-03
GC_5_10 ref NI_5 NS_10 0 -4.1645205166467294e-03
GC_5_11 ref NI_5 NS_11 0 9.3902277654770525e-03
GC_5_12 ref NI_5 NS_12 0 -8.7841783508495091e-05
GC_5_13 ref NI_5 NS_13 0 -1.6122706117511962e-03
GC_5_14 ref NI_5 NS_14 0 -8.1367286430406342e-04
GC_5_15 ref NI_5 NS_15 0 8.5832682540734808e-03
GC_5_16 ref NI_5 NS_16 0 -2.2882324794386814e-04
GC_5_17 ref NI_5 NS_17 0 -1.0175789758894150e-02
GC_5_18 ref NI_5 NS_18 0 1.6059794066282829e-02
GC_5_19 ref NI_5 NS_19 0 -7.1709914103082015e-02
GC_5_20 ref NI_5 NS_20 0 -4.6498943694126505e-03
GC_5_21 ref NI_5 NS_21 0 -1.4913663172113917e-03
GC_5_22 ref NI_5 NS_22 0 1.1091861612758694e-02
GC_5_23 ref NI_5 NS_23 0 4.4720743825676090e-03
GC_5_24 ref NI_5 NS_24 0 -7.3807621923059597e-04
GC_5_25 ref NI_5 NS_25 0 -2.3538395493084559e-03
GC_5_26 ref NI_5 NS_26 0 2.8187392149859906e-03
GC_5_27 ref NI_5 NS_27 0 5.3554193797088045e-03
GC_5_28 ref NI_5 NS_28 0 2.1697650094724521e-04
GC_5_29 ref NI_5 NS_29 0 9.0245112823631748e-04
GC_5_30 ref NI_5 NS_30 0 -5.0956793506531225e-03
GC_5_31 ref NI_5 NS_31 0 7.6839931757599006e-03
GC_5_32 ref NI_5 NS_32 0 6.4876308360411962e-04
GC_5_33 ref NI_5 NS_33 0 -3.2560682423140030e-03
GC_5_34 ref NI_5 NS_34 0 1.5168574814550704e-03
GC_5_35 ref NI_5 NS_35 0 6.3163066466042084e-03
GC_5_36 ref NI_5 NS_36 0 1.5216446952184774e-04
GC_5_37 ref NI_5 NS_37 0 2.3788522951722742e-04
GC_5_38 ref NI_5 NS_38 0 -4.9888756021054309e-03
GC_5_39 ref NI_5 NS_39 0 7.9580860371466465e-03
GC_5_40 ref NI_5 NS_40 0 5.6692535269235061e-04
GC_5_41 ref NI_5 NS_41 0 1.0350909314177192e-03
GC_5_42 ref NI_5 NS_42 0 -3.0526424976171575e-03
GC_5_43 ref NI_5 NS_43 0 6.8848233616715772e-04
GC_5_44 ref NI_5 NS_44 0 2.5764405193008199e-03
GC_5_45 ref NI_5 NS_45 0 4.0033401227635712e-03
GC_5_46 ref NI_5 NS_46 0 -8.1198078198870382e-03
GC_5_47 ref NI_5 NS_47 0 7.5640745895759250e-03
GC_5_48 ref NI_5 NS_48 0 1.0784174543937187e-03
GD_5_1 ref NI_5 NA_1 0 6.8478074950194690e-03
GD_5_2 ref NI_5 NA_2 0 -8.6367608827519586e-03
GD_5_3 ref NI_5 NA_3 0 -1.8804006694824016e-02
GD_5_4 ref NI_5 NA_4 0 -5.3533085421641280e-03
GD_5_5 ref NI_5 NA_5 0 6.3097931121234625e+00
GD_5_6 ref NI_5 NA_6 0 -2.2125171228271723e-02
GD_5_7 ref NI_5 NA_7 0 1.9030873218578073e-02
GD_5_8 ref NI_5 NA_8 0 -8.0604765272791305e-03
GD_5_9 ref NI_5 NA_9 0 1.2171002392805696e-02
GD_5_10 ref NI_5 NA_10 0 -7.2973756202139636e-03
GD_5_11 ref NI_5 NA_11 0 -1.5084893316165350e-03
GD_5_12 ref NI_5 NA_12 0 -2.2664085088605849e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 6.3758617863162698e-02
GC_6_2 ref NI_6 NS_2 0 -1.0654747023312763e-03
GC_6_3 ref NI_6 NS_3 0 -8.3999200760167072e-04
GC_6_4 ref NI_6 NS_4 0 5.4540073917107579e-05
GC_6_5 ref NI_6 NS_5 0 -1.9617769813411561e-02
GC_6_6 ref NI_6 NS_6 0 2.2675241793371194e-02
GC_6_7 ref NI_6 NS_7 0 -1.7684913129307719e-03
GC_6_8 ref NI_6 NS_8 0 2.5241949704557043e-04
GC_6_9 ref NI_6 NS_9 0 -5.6347404456380855e-03
GC_6_10 ref NI_6 NS_10 0 1.0445804199490828e-02
GC_6_11 ref NI_6 NS_11 0 3.8157540095874187e-03
GC_6_12 ref NI_6 NS_12 0 -3.0696748716737838e-04
GC_6_13 ref NI_6 NS_13 0 -3.3355256106730401e-03
GC_6_14 ref NI_6 NS_14 0 2.6653356986963639e-02
GC_6_15 ref NI_6 NS_15 0 -4.5618683360388696e-03
GC_6_16 ref NI_6 NS_16 0 -9.8173119127053826e-05
GC_6_17 ref NI_6 NS_17 0 -1.4913663172114189e-03
GC_6_18 ref NI_6 NS_18 0 1.1091861612758677e-02
GC_6_19 ref NI_6 NS_19 0 4.4720743825676385e-03
GC_6_20 ref NI_6 NS_20 0 -7.3807621923060865e-04
GC_6_21 ref NI_6 NS_21 0 1.4231487292641835e-02
GC_6_22 ref NI_6 NS_22 0 -1.4115862515032965e-01
GC_6_23 ref NI_6 NS_23 0 -7.5671667385379922e-03
GC_6_24 ref NI_6 NS_24 0 -1.4723204234860386e-03
GC_6_25 ref NI_6 NS_25 0 -7.0405289308287516e-03
GC_6_26 ref NI_6 NS_26 0 1.8963695033450731e-02
GC_6_27 ref NI_6 NS_27 0 -1.3185894027471570e-03
GC_6_28 ref NI_6 NS_28 0 6.9606341433410744e-05
GC_6_29 ref NI_6 NS_29 0 -1.1455743776042459e-02
GC_6_30 ref NI_6 NS_30 0 1.1768910845420529e-02
GC_6_31 ref NI_6 NS_31 0 2.1985539281553579e-03
GC_6_32 ref NI_6 NS_32 0 1.8664241684276147e-04
GC_6_33 ref NI_6 NS_33 0 8.1202426581090514e-04
GC_6_34 ref NI_6 NS_34 0 2.3734477796097275e-02
GC_6_35 ref NI_6 NS_35 0 -4.8612713171589505e-03
GC_6_36 ref NI_6 NS_36 0 2.6744874389622776e-04
GC_6_37 ref NI_6 NS_37 0 -1.1617975884339833e-02
GC_6_38 ref NI_6 NS_38 0 1.3844045222421848e-02
GC_6_39 ref NI_6 NS_39 0 1.5155152252180344e-03
GC_6_40 ref NI_6 NS_40 0 1.1576699884408004e-04
GC_6_41 ref NI_6 NS_41 0 -4.9979573918665626e-03
GC_6_42 ref NI_6 NS_42 0 3.2859988955218978e-04
GC_6_43 ref NI_6 NS_43 0 2.6033715064612919e-03
GC_6_44 ref NI_6 NS_44 0 1.5876242841829842e-03
GC_6_45 ref NI_6 NS_45 0 -1.0010545493308284e-02
GC_6_46 ref NI_6 NS_46 0 4.1153474577783700e-03
GC_6_47 ref NI_6 NS_47 0 5.4071359480597535e-03
GC_6_48 ref NI_6 NS_48 0 2.6319212430543415e-04
GD_6_1 ref NI_6 NA_1 0 4.7850360739640309e-02
GD_6_2 ref NI_6 NA_2 0 -4.7618165819727611e-03
GD_6_3 ref NI_6 NA_3 0 1.0340676570497488e-02
GD_6_4 ref NI_6 NA_4 0 -2.3448782342621807e-02
GD_6_5 ref NI_6 NA_5 0 -2.2125171228271390e-02
GD_6_6 ref NI_6 NA_6 0 6.0561267152806399e+00
GD_6_7 ref NI_6 NA_7 0 1.7472272060356352e-02
GD_6_8 ref NI_6 NA_8 0 4.4565289452709433e-02
GD_6_9 ref NI_6 NA_9 0 -1.8129642542778705e-02
GD_6_10 ref NI_6 NA_10 0 3.3436726344444452e-02
GD_6_11 ref NI_6 NA_11 0 2.8076542912776510e-02
GD_6_12 ref NI_6 NA_12 0 4.9084763730171926e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 3.6357684917648646e-02
GC_7_2 ref NI_7 NS_2 0 4.9674065940903947e-03
GC_7_3 ref NI_7 NS_3 0 -8.2023135944669144e-06
GC_7_4 ref NI_7 NS_4 0 -5.6473989629632100e-05
GC_7_5 ref NI_7 NS_5 0 -2.1340853640095539e-02
GC_7_6 ref NI_7 NS_6 0 1.3512763699414275e-02
GC_7_7 ref NI_7 NS_7 0 3.4261765311906995e-03
GC_7_8 ref NI_7 NS_8 0 -1.0569716794794845e-04
GC_7_9 ref NI_7 NS_9 0 -2.7747880199369469e-03
GC_7_10 ref NI_7 NS_10 0 -2.0582808777671025e-03
GC_7_11 ref NI_7 NS_11 0 7.2600327369700488e-03
GC_7_12 ref NI_7 NS_12 0 3.8682303136032325e-04
GC_7_13 ref NI_7 NS_13 0 -1.0613751601207632e-02
GC_7_14 ref NI_7 NS_14 0 5.1807859457619091e-03
GC_7_15 ref NI_7 NS_15 0 5.9337700602368534e-03
GC_7_16 ref NI_7 NS_16 0 -6.8077351627558998e-05
GC_7_17 ref NI_7 NS_17 0 -2.3538395493081432e-03
GC_7_18 ref NI_7 NS_18 0 2.8187392149858878e-03
GC_7_19 ref NI_7 NS_19 0 5.3554193797088444e-03
GC_7_20 ref NI_7 NS_20 0 2.1697650094724125e-04
GC_7_21 ref NI_7 NS_21 0 -7.0405289308285565e-03
GC_7_22 ref NI_7 NS_22 0 1.8963695033450464e-02
GC_7_23 ref NI_7 NS_23 0 -1.3185894027469048e-03
GC_7_24 ref NI_7 NS_24 0 6.9606341433315578e-05
GC_7_25 ref NI_7 NS_25 0 -7.5881495083405482e-03
GC_7_26 ref NI_7 NS_26 0 -1.3726912457491508e-01
GC_7_27 ref NI_7 NS_27 0 -6.5851705240397712e-03
GC_7_28 ref NI_7 NS_28 0 -1.6108110632476716e-03
GC_7_29 ref NI_7 NS_29 0 -3.2129391351511005e-03
GC_7_30 ref NI_7 NS_30 0 2.1720561821589011e-02
GC_7_31 ref NI_7 NS_31 0 -1.8953080583995982e-03
GC_7_32 ref NI_7 NS_32 0 -2.2264742771906259e-04
GC_7_33 ref NI_7 NS_33 0 4.3908615799946954e-02
GC_7_34 ref NI_7 NS_34 0 4.7039640928574586e-02
GC_7_35 ref NI_7 NS_35 0 -2.1710320969203452e-02
GC_7_36 ref NI_7 NS_36 0 6.8005247211726857e-04
GC_7_37 ref NI_7 NS_37 0 -1.0030515894479512e-02
GC_7_38 ref NI_7 NS_38 0 1.9709722740402710e-02
GC_7_39 ref NI_7 NS_39 0 1.9661441710819607e-05
GC_7_40 ref NI_7 NS_40 0 -3.3440798253911891e-04
GC_7_41 ref NI_7 NS_41 0 -2.3808891229517158e-03
GC_7_42 ref NI_7 NS_42 0 -2.4645417738730848e-03
GC_7_43 ref NI_7 NS_43 0 3.7760854717617393e-03
GC_7_44 ref NI_7 NS_44 0 1.5554688015281604e-03
GC_7_45 ref NI_7 NS_45 0 -1.0666141870834280e-02
GC_7_46 ref NI_7 NS_46 0 9.1846886229533485e-03
GC_7_47 ref NI_7 NS_47 0 4.8888467665815297e-03
GC_7_48 ref NI_7 NS_48 0 -3.2857310236055349e-04
GD_7_1 ref NI_7 NA_1 0 5.5081144924296867e-02
GD_7_2 ref NI_7 NA_2 0 5.6574455494251379e-02
GD_7_3 ref NI_7 NA_3 0 1.6805349451700421e-02
GD_7_4 ref NI_7 NA_4 0 5.0857102433650526e-02
GD_7_5 ref NI_7 NA_5 0 1.9030873218575009e-02
GD_7_6 ref NI_7 NA_6 0 1.7472272060355402e-02
GD_7_7 ref NI_7 NA_7 0 6.0986112568656390e+00
GD_7_8 ref NI_7 NA_8 0 -7.0908471627533257e-04
GD_7_9 ref NI_7 NA_9 0 -1.6986156312950726e-01
GD_7_10 ref NI_7 NA_10 0 2.4949200069471354e-02
GD_7_11 ref NI_7 NA_11 0 1.9325568268209505e-02
GD_7_12 ref NI_7 NA_12 0 5.4464172091621833e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 4.7158701929021836e-02
GC_8_2 ref NI_8 NS_2 0 2.3366766963125768e-03
GC_8_3 ref NI_8 NS_3 0 -3.0740202709913871e-04
GC_8_4 ref NI_8 NS_4 0 -2.0313958588745887e-05
GC_8_5 ref NI_8 NS_5 0 -2.0383356898430807e-02
GC_8_6 ref NI_8 NS_6 0 1.7720703129607215e-02
GC_8_7 ref NI_8 NS_7 0 1.0542684467508474e-03
GC_8_8 ref NI_8 NS_8 0 3.4604008659508450e-05
GC_8_9 ref NI_8 NS_9 0 -1.1428300084776180e-03
GC_8_10 ref NI_8 NS_10 0 -3.9500684320324326e-03
GC_8_11 ref NI_8 NS_11 0 7.1530889384759282e-03
GC_8_12 ref NI_8 NS_12 0 7.1118604053738296e-04
GC_8_13 ref NI_8 NS_13 0 -9.1022836001981230e-03
GC_8_14 ref NI_8 NS_14 0 3.0314687480194995e-03
GC_8_15 ref NI_8 NS_15 0 6.1906967314910577e-03
GC_8_16 ref NI_8 NS_16 0 1.7640054446453892e-04
GC_8_17 ref NI_8 NS_17 0 9.0245112823639467e-04
GC_8_18 ref NI_8 NS_18 0 -5.0956793506532179e-03
GC_8_19 ref NI_8 NS_19 0 7.6839931757599865e-03
GC_8_20 ref NI_8 NS_20 0 6.4876308360408959e-04
GC_8_21 ref NI_8 NS_21 0 -1.1455743776042438e-02
GC_8_22 ref NI_8 NS_22 0 1.1768910845420606e-02
GC_8_23 ref NI_8 NS_23 0 2.1985539281552616e-03
GC_8_24 ref NI_8 NS_24 0 1.8664241684280243e-04
GC_8_25 ref NI_8 NS_25 0 -3.2129391351510272e-03
GC_8_26 ref NI_8 NS_26 0 2.1720561821588998e-02
GC_8_27 ref NI_8 NS_27 0 -1.8953080583996047e-03
GC_8_28 ref NI_8 NS_28 0 -2.2264742771905632e-04
GC_8_29 ref NI_8 NS_29 0 6.5915846096149229e-03
GC_8_30 ref NI_8 NS_30 0 -1.3746542508385817e-01
GC_8_31 ref NI_8 NS_31 0 -7.9521887785105310e-03
GC_8_32 ref NI_8 NS_32 0 -1.7601506048442641e-03
GC_8_33 ref NI_8 NS_33 0 -8.4392385684353838e-03
GC_8_34 ref NI_8 NS_34 0 1.9014708278961678e-02
GC_8_35 ref NI_8 NS_35 0 -1.2912811317938385e-05
GC_8_36 ref NI_8 NS_36 0 -2.4399990498997232e-04
GC_8_37 ref NI_8 NS_37 0 1.0676220787102337e-02
GC_8_38 ref NI_8 NS_38 0 3.6304349883006577e-02
GC_8_39 ref NI_8 NS_39 0 -1.0495214475390223e-02
GC_8_40 ref NI_8 NS_40 0 -8.8152461166138526e-05
GC_8_41 ref NI_8 NS_41 0 -4.6271918471300971e-03
GC_8_42 ref NI_8 NS_42 0 7.8608788607815300e-04
GC_8_43 ref NI_8 NS_43 0 3.0424481500607938e-03
GC_8_44 ref NI_8 NS_44 0 1.3291874408616290e-03
GC_8_45 ref NI_8 NS_45 0 -2.8536987736436843e-03
GC_8_46 ref NI_8 NS_46 0 3.4898158213677664e-02
GC_8_47 ref NI_8 NS_47 0 -7.4437612592478377e-03
GC_8_48 ref NI_8 NS_48 0 -5.7895564800106657e-04
GD_8_1 ref NI_8 NA_1 0 6.9044973924009281e-02
GD_8_2 ref NI_8 NA_2 0 3.2871218329888138e-02
GD_8_3 ref NI_8 NA_3 0 3.5993423077486280e-03
GD_8_4 ref NI_8 NA_4 0 3.7472403328571421e-02
GD_8_5 ref NI_8 NA_5 0 -8.0604765272795312e-03
GD_8_6 ref NI_8 NA_6 0 4.4565289452708691e-02
GD_8_7 ref NI_8 NA_7 0 -7.0908471627607352e-04
GD_8_8 ref NI_8 NA_8 0 6.0971787887310329e+00
GD_8_9 ref NI_8 NA_9 0 1.0393692195647470e-02
GD_8_10 ref NI_8 NA_10 0 -9.5717660475839003e-02
GD_8_11 ref NI_8 NA_11 0 3.3519305249915067e-02
GD_8_12 ref NI_8 NA_12 0 -6.1356206937761264e-03
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 5.6052423207993522e-02
GC_9_2 ref NI_9 NS_2 0 8.1267700654975329e-05
GC_9_3 ref NI_9 NS_3 0 6.7871614576569912e-06
GC_9_4 ref NI_9 NS_4 0 -1.1220493379973373e-04
GC_9_5 ref NI_9 NS_5 0 -1.9399705457147559e-02
GC_9_6 ref NI_9 NS_6 0 1.9415015104223915e-02
GC_9_7 ref NI_9 NS_7 0 2.9505208064916928e-04
GC_9_8 ref NI_9 NS_8 0 2.9328762051974923e-05
GC_9_9 ref NI_9 NS_9 0 -4.1349996860074959e-03
GC_9_10 ref NI_9 NS_10 0 6.1794963375032220e-04
GC_9_11 ref NI_9 NS_11 0 6.2014285771836725e-03
GC_9_12 ref NI_9 NS_12 0 3.7434131521638737e-04
GC_9_13 ref NI_9 NS_13 0 -1.0413820610042574e-02
GC_9_14 ref NI_9 NS_14 0 9.6541540579636650e-03
GC_9_15 ref NI_9 NS_15 0 3.7743266368246570e-03
GC_9_16 ref NI_9 NS_16 0 -3.0991298169985808e-05
GC_9_17 ref NI_9 NS_17 0 -3.2560682423138660e-03
GC_9_18 ref NI_9 NS_18 0 1.5168574814549934e-03
GC_9_19 ref NI_9 NS_19 0 6.3163066466042639e-03
GC_9_20 ref NI_9 NS_20 0 1.5216446952182882e-04
GC_9_21 ref NI_9 NS_21 0 8.1202426581090438e-04
GC_9_22 ref NI_9 NS_22 0 2.3734477796097473e-02
GC_9_23 ref NI_9 NS_23 0 -4.8612713171591803e-03
GC_9_24 ref NI_9 NS_24 0 2.6744874389632051e-04
GC_9_25 ref NI_9 NS_25 0 4.3908615799947308e-02
GC_9_26 ref NI_9 NS_26 0 4.7039640928574052e-02
GC_9_27 ref NI_9 NS_27 0 -2.1710320969202945e-02
GC_9_28 ref NI_9 NS_28 0 6.8005247211708262e-04
GC_9_29 ref NI_9 NS_29 0 -8.4392385684353057e-03
GC_9_30 ref NI_9 NS_30 0 1.9014708278961852e-02
GC_9_31 ref NI_9 NS_31 0 -1.2912811318148246e-05
GC_9_32 ref NI_9 NS_32 0 -2.4399990498988379e-04
GC_9_33 ref NI_9 NS_33 0 -2.8337026204643442e-02
GC_9_34 ref NI_9 NS_34 0 -1.4865335810757016e-01
GC_9_35 ref NI_9 NS_35 0 1.9350976317900313e-03
GC_9_36 ref NI_9 NS_36 0 -1.9766721225612815e-03
GC_9_37 ref NI_9 NS_37 0 -7.3675763421095671e-03
GC_9_38 ref NI_9 NS_38 0 2.1665772622576841e-02
GC_9_39 ref NI_9 NS_39 0 -1.4287758440623523e-03
GC_9_40 ref NI_9 NS_40 0 -2.2575937585605992e-04
GC_9_41 ref NI_9 NS_41 0 -3.4638900310431800e-03
GC_9_42 ref NI_9 NS_42 0 -1.3125161071307087e-03
GC_9_43 ref NI_9 NS_43 0 3.5187974948940682e-03
GC_9_44 ref NI_9 NS_44 0 1.5062605513476051e-03
GC_9_45 ref NI_9 NS_45 0 -1.1692852299749460e-02
GC_9_46 ref NI_9 NS_46 0 8.2534946561219676e-03
GC_9_47 ref NI_9 NS_47 0 5.2071223552132865e-03
GC_9_48 ref NI_9 NS_48 0 -2.4725677727375269e-04
GD_9_1 ref NI_9 NA_1 0 5.4981390350843880e-02
GD_9_2 ref NI_9 NA_2 0 1.0149389416681989e-02
GD_9_3 ref NI_9 NA_3 0 1.7201902524160737e-02
GD_9_4 ref NI_9 NA_4 0 3.7002336629810034e-02
GD_9_5 ref NI_9 NA_5 0 1.2171002392804503e-02
GD_9_6 ref NI_9 NA_6 0 -1.8129642542779503e-02
GD_9_7 ref NI_9 NA_7 0 -1.6986156312950909e-01
GD_9_8 ref NI_9 NA_8 0 1.0393692195645864e-02
GD_9_9 ref NI_9 NA_9 0 6.1801949971068018e+00
GD_9_10 ref NI_9 NA_10 0 6.5008713789818260e-03
GD_9_11 ref NI_9 NA_11 0 1.9664443866584998e-02
GD_9_12 ref NI_9 NA_12 0 5.4198560305247924e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 5.8779108765969930e-02
GC_10_2 ref NI_10 NS_2 0 7.3162036052736446e-04
GC_10_3 ref NI_10 NS_3 0 -7.0817970106464619e-04
GC_10_4 ref NI_10 NS_4 0 -9.2093389199317713e-05
GC_10_5 ref NI_10 NS_5 0 -2.1040221784931187e-02
GC_10_6 ref NI_10 NS_6 0 2.1837747972389545e-02
GC_10_7 ref NI_10 NS_7 0 -6.4999188960977543e-04
GC_10_8 ref NI_10 NS_8 0 2.1401084645462532e-05
GC_10_9 ref NI_10 NS_9 0 -2.1082245896604417e-03
GC_10_10 ref NI_10 NS_10 0 -3.3186716331647910e-03
GC_10_11 ref NI_10 NS_11 0 7.4003753857163970e-03
GC_10_12 ref NI_10 NS_12 0 5.6371415283835199e-04
GC_10_13 ref NI_10 NS_13 0 -1.0339014704954788e-02
GC_10_14 ref NI_10 NS_14 0 5.1074356588364433e-03
GC_10_15 ref NI_10 NS_15 0 5.6800726671523173e-03
GC_10_16 ref NI_10 NS_16 0 7.0309876821875584e-05
GC_10_17 ref NI_10 NS_17 0 2.3788522951712543e-04
GC_10_18 ref NI_10 NS_18 0 -4.9888756021054491e-03
GC_10_19 ref NI_10 NS_19 0 7.9580860371466899e-03
GC_10_20 ref NI_10 NS_20 0 5.6692535269233034e-04
GC_10_21 ref NI_10 NS_21 0 -1.1617975884339880e-02
GC_10_22 ref NI_10 NS_22 0 1.3844045222421834e-02
GC_10_23 ref NI_10 NS_23 0 1.5155152252180615e-03
GC_10_24 ref NI_10 NS_24 0 1.1576699884406712e-04
GC_10_25 ref NI_10 NS_25 0 -1.0030515894479600e-02
GC_10_26 ref NI_10 NS_26 0 1.9709722740402957e-02
GC_10_27 ref NI_10 NS_27 0 1.9661441710555983e-05
GC_10_28 ref NI_10 NS_28 0 -3.3440798253901358e-04
GC_10_29 ref NI_10 NS_29 0 1.0676220787102309e-02
GC_10_30 ref NI_10 NS_30 0 3.6304349883006522e-02
GC_10_31 ref NI_10 NS_31 0 -1.0495214475390161e-02
GC_10_32 ref NI_10 NS_32 0 -8.8152461166165808e-05
GC_10_33 ref NI_10 NS_33 0 -7.3675763421094664e-03
GC_10_34 ref NI_10 NS_34 0 2.1665772622576674e-02
GC_10_35 ref NI_10 NS_35 0 -1.4287758440621919e-03
GC_10_36 ref NI_10 NS_36 0 -2.2575937585612047e-04
GC_10_37 ref NI_10 NS_37 0 1.5145741061525140e-02
GC_10_38 ref NI_10 NS_38 0 -1.3045572837338695e-01
GC_10_39 ref NI_10 NS_39 0 -1.3646486380048881e-02
GC_10_40 ref NI_10 NS_40 0 -1.2709981281742325e-03
GC_10_41 ref NI_10 NS_41 0 -4.6843688101439523e-03
GC_10_42 ref NI_10 NS_42 0 -5.2104921794386911e-04
GC_10_43 ref NI_10 NS_43 0 3.6504817822966703e-03
GC_10_44 ref NI_10 NS_44 0 1.3637726834695265e-03
GC_10_45 ref NI_10 NS_45 0 -1.3720210992281746e-02
GC_10_46 ref NI_10 NS_46 0 2.1340551893591703e-02
GC_10_47 ref NI_10 NS_47 0 -1.3117380871464655e-04
GC_10_48 ref NI_10 NS_48 0 -5.1595312741025280e-04
GD_10_1 ref NI_10 NA_1 0 5.5548360531877831e-02
GD_10_2 ref NI_10 NA_2 0 1.2696166119729404e-02
GD_10_3 ref NI_10 NA_3 0 4.8592592673977891e-03
GD_10_4 ref NI_10 NA_4 0 3.5752373150208322e-02
GD_10_5 ref NI_10 NA_5 0 -7.2973756202127284e-03
GD_10_6 ref NI_10 NA_6 0 3.3436726344445007e-02
GD_10_7 ref NI_10 NA_7 0 2.4949200069471204e-02
GD_10_8 ref NI_10 NA_8 0 -9.5717660475838351e-02
GD_10_9 ref NI_10 NA_9 0 6.5008713789813525e-03
GD_10_10 ref NI_10 NA_10 0 6.0553017658953419e+00
GD_10_11 ref NI_10 NA_11 0 2.7786670411599029e-02
GD_10_12 ref NI_10 NA_12 0 6.1249328954740223e-02
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 2.4337678161008680e-02
GC_11_2 ref NI_11 NS_2 0 1.0920179443954007e-03
GC_11_3 ref NI_11 NS_3 0 1.1421934914257472e-03
GC_11_4 ref NI_11 NS_4 0 6.1768672368549596e-04
GC_11_5 ref NI_11 NS_5 0 -1.1496067475267506e-02
GC_11_6 ref NI_11 NS_6 0 6.3571652752485407e-03
GC_11_7 ref NI_11 NS_7 0 2.7618980357932261e-03
GC_11_8 ref NI_11 NS_8 0 8.6773728532089619e-04
GC_11_9 ref NI_11 NS_9 0 -3.1447823664530327e-04
GC_11_10 ref NI_11 NS_10 0 -2.7885775363377255e-03
GC_11_11 ref NI_11 NS_11 0 1.7116575295894126e-03
GC_11_12 ref NI_11 NS_12 0 2.2417264780638302e-03
GC_11_13 ref NI_11 NS_13 0 -4.3408277681124246e-03
GC_11_14 ref NI_11 NS_14 0 1.4749436053564270e-04
GC_11_15 ref NI_11 NS_15 0 2.8570585224442177e-03
GC_11_16 ref NI_11 NS_16 0 1.5073065876132705e-03
GC_11_17 ref NI_11 NS_17 0 1.0350909314178602e-03
GC_11_18 ref NI_11 NS_18 0 -3.0526424976172269e-03
GC_11_19 ref NI_11 NS_19 0 6.8848233616719773e-04
GC_11_20 ref NI_11 NS_20 0 2.5764405193008100e-03
GC_11_21 ref NI_11 NS_21 0 -4.9979573918665018e-03
GC_11_22 ref NI_11 NS_22 0 3.2859988955219151e-04
GC_11_23 ref NI_11 NS_23 0 2.6033715064612741e-03
GC_11_24 ref NI_11 NS_24 0 1.5876242841829948e-03
GC_11_25 ref NI_11 NS_25 0 -2.3808891229517844e-03
GC_11_26 ref NI_11 NS_26 0 -2.4645417738730570e-03
GC_11_27 ref NI_11 NS_27 0 3.7760854717617219e-03
GC_11_28 ref NI_11 NS_28 0 1.5554688015281656e-03
GC_11_29 ref NI_11 NS_29 0 -4.6271918471301066e-03
GC_11_30 ref NI_11 NS_30 0 7.8608788607817685e-04
GC_11_31 ref NI_11 NS_31 0 3.0424481500607686e-03
GC_11_32 ref NI_11 NS_32 0 1.3291874408616379e-03
GC_11_33 ref NI_11 NS_33 0 -3.4638900310431783e-03
GC_11_34 ref NI_11 NS_34 0 -1.3125161071306840e-03
GC_11_35 ref NI_11 NS_35 0 3.5187974948940391e-03
GC_11_36 ref NI_11 NS_36 0 1.5062605513476159e-03
GC_11_37 ref NI_11 NS_37 0 -4.6843688101439697e-03
GC_11_38 ref NI_11 NS_38 0 -5.2104921794384536e-04
GC_11_39 ref NI_11 NS_39 0 3.6504817822966503e-03
GC_11_40 ref NI_11 NS_40 0 1.3637726834695334e-03
GC_11_41 ref NI_11 NS_41 0 1.8867483495381691e-02
GC_11_42 ref NI_11 NS_42 0 2.1437675255782788e-03
GC_11_43 ref NI_11 NS_43 0 -3.0292149787544059e-02
GC_11_44 ref NI_11 NS_44 0 -1.6159319657080687e-02
GC_11_45 ref NI_11 NS_45 0 -3.4145815759198811e-03
GC_11_46 ref NI_11 NS_46 0 -5.8340674444730745e-06
GC_11_47 ref NI_11 NS_47 0 3.8289173026300467e-03
GC_11_48 ref NI_11 NS_48 0 1.1762893682650247e-03
GD_11_1 ref NI_11 NA_1 0 6.8998424774502687e-02
GD_11_2 ref NI_11 NA_2 0 3.0855131633761700e-02
GD_11_3 ref NI_11 NA_3 0 7.2084620726407325e-03
GD_11_4 ref NI_11 NA_4 0 2.8515441575362923e-02
GD_11_5 ref NI_11 NA_5 0 -1.5084893316178458e-03
GD_11_6 ref NI_11 NA_6 0 2.8076542912775726e-02
GD_11_7 ref NI_11 NA_7 0 1.9325568268210056e-02
GD_11_8 ref NI_11 NA_8 0 3.3519305249915178e-02
GD_11_9 ref NI_11 NA_9 0 1.9664443866584912e-02
GD_11_10 ref NI_11 NA_10 0 2.7786670411599140e-02
GD_11_11 ref NI_11 NA_11 0 5.9363417096575386e+00
GD_11_12 ref NI_11 NA_12 0 2.7163182673571488e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 3.2015104158249055e-02
GC_12_2 ref NI_12 NS_2 0 3.6093407624421870e-03
GC_12_3 ref NI_12 NS_3 0 9.5204520351787779e-04
GC_12_4 ref NI_12 NS_4 0 -4.7514105609865818e-06
GC_12_5 ref NI_12 NS_5 0 -1.7946712517565754e-02
GC_12_6 ref NI_12 NS_6 0 1.0768965029734739e-02
GC_12_7 ref NI_12 NS_7 0 4.0433075828825334e-03
GC_12_8 ref NI_12 NS_8 0 9.7348232222981777e-06
GC_12_9 ref NI_12 NS_9 0 2.5351998154150824e-03
GC_12_10 ref NI_12 NS_10 0 -7.3728979495602393e-03
GC_12_11 ref NI_12 NS_11 0 7.5413616584137011e-03
GC_12_12 ref NI_12 NS_12 0 1.0199075629683846e-03
GC_12_13 ref NI_12 NS_13 0 -4.8619502524210097e-03
GC_12_14 ref NI_12 NS_14 0 -2.6657939230948021e-03
GC_12_15 ref NI_12 NS_15 0 7.8962631547649220e-03
GC_12_16 ref NI_12 NS_16 0 3.7728027311013706e-04
GC_12_17 ref NI_12 NS_17 0 4.0033401227634723e-03
GC_12_18 ref NI_12 NS_18 0 -8.1198078198870677e-03
GC_12_19 ref NI_12 NS_19 0 7.5640745895759788e-03
GC_12_20 ref NI_12 NS_20 0 1.0784174543936932e-03
GC_12_21 ref NI_12 NS_21 0 -1.0010545493308360e-02
GC_12_22 ref NI_12 NS_22 0 4.1153474577783926e-03
GC_12_23 ref NI_12 NS_23 0 5.4071359480597483e-03
GC_12_24 ref NI_12 NS_24 0 2.6319212430543339e-04
GC_12_25 ref NI_12 NS_25 0 -1.0666141870834313e-02
GC_12_26 ref NI_12 NS_26 0 9.1846886229533589e-03
GC_12_27 ref NI_12 NS_27 0 4.8888467665815262e-03
GC_12_28 ref NI_12 NS_28 0 -3.2857310236055447e-04
GC_12_29 ref NI_12 NS_29 0 -2.8536987736435303e-03
GC_12_30 ref NI_12 NS_30 0 3.4898158213677623e-02
GC_12_31 ref NI_12 NS_31 0 -7.4437612592478334e-03
GC_12_32 ref NI_12 NS_32 0 -5.7895564800106158e-04
GC_12_33 ref NI_12 NS_33 0 -1.1692852299749370e-02
GC_12_34 ref NI_12 NS_34 0 8.2534946561219295e-03
GC_12_35 ref NI_12 NS_35 0 5.2071223552133065e-03
GC_12_36 ref NI_12 NS_36 0 -2.4725677727375817e-04
GC_12_37 ref NI_12 NS_37 0 -1.3720210992281823e-02
GC_12_38 ref NI_12 NS_38 0 2.1340551893591742e-02
GC_12_39 ref NI_12 NS_39 0 -1.3117380871466983e-04
GC_12_40 ref NI_12 NS_40 0 -5.1595312741024597e-04
GC_12_41 ref NI_12 NS_41 0 -3.4145815759203174e-03
GC_12_42 ref NI_12 NS_42 0 -5.8340674443485793e-06
GC_12_43 ref NI_12 NS_43 0 3.8289173026300198e-03
GC_12_44 ref NI_12 NS_44 0 1.1762893682650164e-03
GC_12_45 ref NI_12 NS_45 0 3.9713660034157078e-02
GC_12_46 ref NI_12 NS_46 0 -7.2963140850438132e-02
GC_12_47 ref NI_12 NS_47 0 -4.0524584759758848e-02
GC_12_48 ref NI_12 NS_48 0 -2.0750953049082504e-03
GD_12_1 ref NI_12 NA_1 0 7.1203443459176771e-02
GD_12_2 ref NI_12 NA_2 0 4.8787396589814916e-02
GD_12_3 ref NI_12 NA_3 0 -1.5186492656159734e-02
GD_12_4 ref NI_12 NA_4 0 2.1635770447141909e-02
GD_12_5 ref NI_12 NA_5 0 -2.2664085088604433e-02
GD_12_6 ref NI_12 NA_6 0 4.9084763730172516e-02
GD_12_7 ref NI_12 NA_7 0 5.4464172091622270e-02
GD_12_8 ref NI_12 NA_8 0 -6.1356206937778820e-03
GD_12_9 ref NI_12 NA_9 0 5.4198560305247105e-02
GD_12_10 ref NI_12 NA_10 0 6.1249328954740841e-02
GD_12_11 ref NI_12 NA_11 0 2.7163182673575727e-02
GD_12_12 ref NI_12 NA_12 0 5.8922835742883271e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.0276301101571967e+02
GS_1_1 0 NS_1 NA_1 0 1.7993858959636094e-01
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 3.8246865430039924e+02
GS_2_1 0 NS_2 NA_1 0 1.7993858959636094e-01
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 7.8124259337973263e+02
GS_3_1 0 NS_3 NA_1 0 1.7993858959636094e-01
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 2.1580431831481342e+03
GS_4_1 0 NS_4 NA_1 0 1.7993858959636094e-01
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.0276301101571967e+02
GS_5_2 0 NS_5 NA_2 0 1.7993858959636094e-01
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 3.8246865430039924e+02
GS_6_2 0 NS_6 NA_2 0 1.7993858959636094e-01
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 7.8124259337973263e+02
GS_7_2 0 NS_7 NA_2 0 1.7993858959636094e-01
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 2.1580431831481342e+03
GS_8_2 0 NS_8 NA_2 0 1.7993858959636094e-01
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.0276301101571967e+02
GS_9_3 0 NS_9 NA_3 0 1.7993858959636094e-01
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 3.8246865430039924e+02
GS_10_3 0 NS_10 NA_3 0 1.7993858959636094e-01
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 7.8124259337973263e+02
GS_11_3 0 NS_11 NA_3 0 1.7993858959636094e-01
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 2.1580431831481342e+03
GS_12_3 0 NS_12 NA_3 0 1.7993858959636094e-01
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.0276301101571967e+02
GS_13_4 0 NS_13 NA_4 0 1.7993858959636094e-01
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 3.8246865430039924e+02
GS_14_4 0 NS_14 NA_4 0 1.7993858959636094e-01
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 7.8124259337973263e+02
GS_15_4 0 NS_15 NA_4 0 1.7993858959636094e-01
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 2.1580431831481342e+03
GS_16_4 0 NS_16 NA_4 0 1.7993858959636094e-01
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.0276301101571967e+02
GS_17_5 0 NS_17 NA_5 0 1.7993858959636094e-01
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 3.8246865430039924e+02
GS_18_5 0 NS_18 NA_5 0 1.7993858959636094e-01
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 7.8124259337973263e+02
GS_19_5 0 NS_19 NA_5 0 1.7993858959636094e-01
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 2.1580431831481342e+03
GS_20_5 0 NS_20 NA_5 0 1.7993858959636094e-01
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.0276301101571967e+02
GS_21_6 0 NS_21 NA_6 0 1.7993858959636094e-01
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 3.8246865430039924e+02
GS_22_6 0 NS_22 NA_6 0 1.7993858959636094e-01
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 7.8124259337973263e+02
GS_23_6 0 NS_23 NA_6 0 1.7993858959636094e-01
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 2.1580431831481342e+03
GS_24_6 0 NS_24 NA_6 0 1.7993858959636094e-01
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.0276301101571967e+02
GS_25_7 0 NS_25 NA_7 0 1.7993858959636094e-01
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 3.8246865430039924e+02
GS_26_7 0 NS_26 NA_7 0 1.7993858959636094e-01
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 7.8124259337973263e+02
GS_27_7 0 NS_27 NA_7 0 1.7993858959636094e-01
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 2.1580431831481342e+03
GS_28_7 0 NS_28 NA_7 0 1.7993858959636094e-01
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.0276301101571967e+02
GS_29_8 0 NS_29 NA_8 0 1.7993858959636094e-01
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 3.8246865430039924e+02
GS_30_8 0 NS_30 NA_8 0 1.7993858959636094e-01
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 7.8124259337973263e+02
GS_31_8 0 NS_31 NA_8 0 1.7993858959636094e-01
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 2.1580431831481342e+03
GS_32_8 0 NS_32 NA_8 0 1.7993858959636094e-01
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 1.0276301101571967e+02
GS_33_9 0 NS_33 NA_9 0 1.7993858959636094e-01
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 3.8246865430039924e+02
GS_34_9 0 NS_34 NA_9 0 1.7993858959636094e-01
*
* Real pole n. 35
CS_35 NS_35 0 9.9999999999999998e-13
RS_35 NS_35 0 7.8124259337973263e+02
GS_35_9 0 NS_35 NA_9 0 1.7993858959636094e-01
*
* Real pole n. 36
CS_36 NS_36 0 9.9999999999999998e-13
RS_36 NS_36 0 2.1580431831481342e+03
GS_36_9 0 NS_36 NA_9 0 1.7993858959636094e-01
*
* Real pole n. 37
CS_37 NS_37 0 9.9999999999999998e-13
RS_37 NS_37 0 1.0276301101571967e+02
GS_37_10 0 NS_37 NA_10 0 1.7993858959636094e-01
*
* Real pole n. 38
CS_38 NS_38 0 9.9999999999999998e-13
RS_38 NS_38 0 3.8246865430039924e+02
GS_38_10 0 NS_38 NA_10 0 1.7993858959636094e-01
*
* Real pole n. 39
CS_39 NS_39 0 9.9999999999999998e-13
RS_39 NS_39 0 7.8124259337973263e+02
GS_39_10 0 NS_39 NA_10 0 1.7993858959636094e-01
*
* Real pole n. 40
CS_40 NS_40 0 9.9999999999999998e-13
RS_40 NS_40 0 2.1580431831481342e+03
GS_40_10 0 NS_40 NA_10 0 1.7993858959636094e-01
*
* Real pole n. 41
CS_41 NS_41 0 9.9999999999999998e-13
RS_41 NS_41 0 1.0276301101571967e+02
GS_41_11 0 NS_41 NA_11 0 1.7993858959636094e-01
*
* Real pole n. 42
CS_42 NS_42 0 9.9999999999999998e-13
RS_42 NS_42 0 3.8246865430039924e+02
GS_42_11 0 NS_42 NA_11 0 1.7993858959636094e-01
*
* Real pole n. 43
CS_43 NS_43 0 9.9999999999999998e-13
RS_43 NS_43 0 7.8124259337973263e+02
GS_43_11 0 NS_43 NA_11 0 1.7993858959636094e-01
*
* Real pole n. 44
CS_44 NS_44 0 9.9999999999999998e-13
RS_44 NS_44 0 2.1580431831481342e+03
GS_44_11 0 NS_44 NA_11 0 1.7993858959636094e-01
*
* Real pole n. 45
CS_45 NS_45 0 9.9999999999999998e-13
RS_45 NS_45 0 1.0276301101571967e+02
GS_45_12 0 NS_45 NA_12 0 1.7993858959636094e-01
*
* Real pole n. 46
CS_46 NS_46 0 9.9999999999999998e-13
RS_46 NS_46 0 3.8246865430039924e+02
GS_46_12 0 NS_46 NA_12 0 1.7993858959636094e-01
*
* Real pole n. 47
CS_47 NS_47 0 9.9999999999999998e-13
RS_47 NS_47 0 7.8124259337973263e+02
GS_47_12 0 NS_47 NA_12 0 1.7993858959636094e-01
*
* Real pole n. 48
CS_48 NS_48 0 9.9999999999999998e-13
RS_48 NS_48 0 2.1580431831481342e+03
GS_48_12 0 NS_48 NA_12 0 1.7993858959636094e-01
*
******************************

.ends
*******************
* End of subcircuit
*******************
