**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 18-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0002_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Thu Apr 17 16:10:48 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Thu Apr 17 16:10:48 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_GRP_1_0_VDDCR_PCCX_DIE1_GRP_1_0_VSS
**  Port[2] = PORT_2_BGA1_VDDCR_PCCX_Group_BGA1_VSS_Group
**  Port[3] = VDDCR_PCCX_B1_2
**  Port[4] = VDDCR_PCCX_B2_2
**  Port[5] = VDDCR_PCCX_B3_2
**  Port[6] = VDDCR_PCCX_B4_2
**  Port[7] = VDDCR_PCCX_C11_1
**  Port[8] = VDDCR_PCCX_C14_1
**  Port[9] = VDDCR_PCCX_C15_2
**  Port[10] = VDDCR_PCCX_C20_1
**  Port[11] = VDDCR_PCCX_C25_2
**  Port[12] = VDDCR_PCCX_C26_1
**  Port[13] = VDDCR_PCCX_C107_1
**  Port[14] = VDDCR_PCCX_C110_2
**  Port[15] = VDDCR_PCCX_C111_1
**  Port[16] = VDDCR_PCCX_C112_1
**  Port[17] = VDDCR_PCCX_C113_1
**  Port[18] = VDDCR_PCCX_C114_1
**  Port[19] = VDDCR_PCCX_C115_2
**  Port[20] = VDDCR_PCCX_C116_2
**  Port[21] = VDDCR_PCCX_C117_1
**  Port[22] = VDDCR_PCCX_C118_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 4]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Data based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_PCCX
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 a_16 a_17 a_18 a_19 a_20 a_21 a_22 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -4.0336395545036413e-01
GC_1_2 ref NI_1 NS_2 0 -3.8258046891244464e-02
GC_1_3 ref NI_1 NS_3 0 1.7059649372822320e-03
GC_1_4 ref NI_1 NS_4 0 -2.9541444473486752e-03
GC_1_5 ref NI_1 NS_5 0 1.5773577754677845e-01
GC_1_6 ref NI_1 NS_6 0 -1.3462128864439285e-01
GC_1_7 ref NI_1 NS_7 0 1.3802227472311230e-02
GC_1_8 ref NI_1 NS_8 0 -3.1378935165014246e-03
GC_1_9 ref NI_1 NS_9 0 7.2632169431744512e-02
GC_1_10 ref NI_1 NS_10 0 1.1247640308125487e-02
GC_1_11 ref NI_1 NS_11 0 -3.6137789368312209e-03
GC_1_12 ref NI_1 NS_12 0 -2.6168099064399061e-03
GC_1_13 ref NI_1 NS_13 0 3.6972902297101658e-02
GC_1_14 ref NI_1 NS_14 0 2.7480236222226704e-02
GC_1_15 ref NI_1 NS_15 0 -3.0705451873408811e-03
GC_1_16 ref NI_1 NS_16 0 -2.6992676067492402e-03
GC_1_17 ref NI_1 NS_17 0 2.9387359950394275e-02
GC_1_18 ref NI_1 NS_18 0 3.1448410132154082e-02
GC_1_19 ref NI_1 NS_19 0 -3.3486751585579725e-03
GC_1_20 ref NI_1 NS_20 0 -2.7011872993659082e-03
GC_1_21 ref NI_1 NS_21 0 7.8996626371419285e-02
GC_1_22 ref NI_1 NS_22 0 1.0134544927377155e-02
GC_1_23 ref NI_1 NS_23 0 -4.3143609202619809e-03
GC_1_24 ref NI_1 NS_24 0 -2.5226432271477791e-03
GC_1_25 ref NI_1 NS_25 0 3.6372786265592309e-02
GC_1_26 ref NI_1 NS_26 0 4.6637213302549979e-04
GC_1_27 ref NI_1 NS_27 0 -2.7948341919779361e-03
GC_1_28 ref NI_1 NS_28 0 4.8955428941250601e-04
GC_1_29 ref NI_1 NS_29 0 3.2292843751048572e-02
GC_1_30 ref NI_1 NS_30 0 6.3115060050122004e-03
GC_1_31 ref NI_1 NS_31 0 -2.6380185106119236e-03
GC_1_32 ref NI_1 NS_32 0 -4.0707310119709082e-05
GC_1_33 ref NI_1 NS_33 0 -1.0450294014886449e-03
GC_1_34 ref NI_1 NS_34 0 -2.3134886506268435e-03
GC_1_35 ref NI_1 NS_35 0 2.8641232251576869e-03
GC_1_36 ref NI_1 NS_36 0 1.5226275839014534e-03
GC_1_37 ref NI_1 NS_37 0 5.4738207764572083e-03
GC_1_38 ref NI_1 NS_38 0 8.9405219354817822e-03
GC_1_39 ref NI_1 NS_39 0 -9.9937391299419675e-04
GC_1_40 ref NI_1 NS_40 0 8.0755900993592471e-04
GC_1_41 ref NI_1 NS_41 0 1.1978983646532725e-02
GC_1_42 ref NI_1 NS_42 0 5.2979245047338414e-03
GC_1_43 ref NI_1 NS_43 0 1.2962679954213430e-04
GC_1_44 ref NI_1 NS_44 0 5.6611401188876021e-04
GC_1_45 ref NI_1 NS_45 0 1.2888015492268937e-02
GC_1_46 ref NI_1 NS_46 0 7.5564675871784455e-03
GC_1_47 ref NI_1 NS_47 0 -8.0519864895391776e-04
GC_1_48 ref NI_1 NS_48 0 4.7923443160023666e-04
GC_1_49 ref NI_1 NS_49 0 2.0532494190558876e-02
GC_1_50 ref NI_1 NS_50 0 4.2334238811923665e-03
GC_1_51 ref NI_1 NS_51 0 -1.6068696755167998e-03
GC_1_52 ref NI_1 NS_52 0 5.8884738391563787e-04
GC_1_53 ref NI_1 NS_53 0 1.7558881729784981e-02
GC_1_54 ref NI_1 NS_54 0 9.9341191196039569e-03
GC_1_55 ref NI_1 NS_55 0 -1.1487822857991115e-03
GC_1_56 ref NI_1 NS_56 0 -3.4923606055336339e-05
GC_1_57 ref NI_1 NS_57 0 -3.4941132273052296e-04
GC_1_58 ref NI_1 NS_58 0 -1.5193092378732156e-03
GC_1_59 ref NI_1 NS_59 0 2.2249152614269253e-03
GC_1_60 ref NI_1 NS_60 0 1.5510902952697752e-03
GC_1_61 ref NI_1 NS_61 0 8.3585972649220764e-04
GC_1_62 ref NI_1 NS_62 0 -2.9820600403508931e-03
GC_1_63 ref NI_1 NS_63 0 1.9854791581288486e-03
GC_1_64 ref NI_1 NS_64 0 1.7600901658147341e-03
GC_1_65 ref NI_1 NS_65 0 -3.2260297229064227e-03
GC_1_66 ref NI_1 NS_66 0 2.1957691018327343e-03
GC_1_67 ref NI_1 NS_67 0 1.0327326559857386e-03
GC_1_68 ref NI_1 NS_68 0 1.5767742116457285e-03
GC_1_69 ref NI_1 NS_69 0 -2.6944274288191704e-03
GC_1_70 ref NI_1 NS_70 0 6.9664338587891077e-03
GC_1_71 ref NI_1 NS_71 0 1.7649706780079741e-04
GC_1_72 ref NI_1 NS_72 0 1.1735922528498996e-03
GC_1_73 ref NI_1 NS_73 0 1.0543145254502911e-04
GC_1_74 ref NI_1 NS_74 0 -2.5005264695154199e-03
GC_1_75 ref NI_1 NS_75 0 1.3992732668733758e-03
GC_1_76 ref NI_1 NS_76 0 1.9075508001442959e-03
GC_1_77 ref NI_1 NS_77 0 -1.4367063847260102e-03
GC_1_78 ref NI_1 NS_78 0 2.3037633742007129e-03
GC_1_79 ref NI_1 NS_79 0 1.1826950900346825e-03
GC_1_80 ref NI_1 NS_80 0 1.4391422295396508e-03
GC_1_81 ref NI_1 NS_81 0 4.7693551199827705e-04
GC_1_82 ref NI_1 NS_82 0 1.3747307257892462e-03
GC_1_83 ref NI_1 NS_83 0 1.8420131708687143e-03
GC_1_84 ref NI_1 NS_84 0 1.2584690945433099e-03
GC_1_85 ref NI_1 NS_85 0 -4.4799559222594160e-04
GC_1_86 ref NI_1 NS_86 0 2.2897194244904501e-03
GC_1_87 ref NI_1 NS_87 0 1.9658236311908975e-03
GC_1_88 ref NI_1 NS_88 0 1.1677365954509439e-03
GD_1_1 ref NI_1 NA_1 0 4.3977486372574601e+00
GD_1_2 ref NI_1 NA_2 0 2.3020788182456324e+00
GD_1_3 ref NI_1 NA_3 0 -2.6009497927506753e-01
GD_1_4 ref NI_1 NA_4 0 -2.0492169432750443e-01
GD_1_5 ref NI_1 NA_5 0 -1.8265394821971304e-01
GD_1_6 ref NI_1 NA_6 0 -3.0866747587269072e-01
GD_1_7 ref NI_1 NA_7 0 -4.9566673267090001e-02
GD_1_8 ref NI_1 NA_8 0 -6.1168562716012585e-02
GD_1_9 ref NI_1 NA_9 0 1.1308504218378724e-02
GD_1_10 ref NI_1 NA_10 0 -1.3116111819848361e-02
GD_1_11 ref NI_1 NA_11 0 -2.5389628498844477e-02
GD_1_12 ref NI_1 NA_12 0 -2.9348325708986451e-02
GD_1_13 ref NI_1 NA_13 0 -1.7917977476735014e-02
GD_1_14 ref NI_1 NA_14 0 -3.6513082885175914e-02
GD_1_15 ref NI_1 NA_15 0 1.0341537333451349e-02
GD_1_16 ref NI_1 NA_16 0 6.0085971391491116e-03
GD_1_17 ref NI_1 NA_17 0 1.9489074561877168e-02
GD_1_18 ref NI_1 NA_18 0 1.5490529324692057e-02
GD_1_19 ref NI_1 NA_19 0 1.0597484620794791e-02
GD_1_20 ref NI_1 NA_20 0 8.9824662860813007e-03
GD_1_21 ref NI_1 NA_21 0 2.3785865559241095e-03
GD_1_22 ref NI_1 NA_22 0 1.8644275564419278e-03
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 1.5773577754677862e-01
GC_2_2 ref NI_2 NS_2 0 -1.3462128864439302e-01
GC_2_3 ref NI_2 NS_3 0 1.3802227472311324e-02
GC_2_4 ref NI_2 NS_4 0 -3.1378935165014593e-03
GC_2_5 ref NI_2 NS_5 0 -4.6322140502906350e-01
GC_2_6 ref NI_2 NS_6 0 7.8849340244991975e-02
GC_2_7 ref NI_2 NS_7 0 -1.2203928141731050e-02
GC_2_8 ref NI_2 NS_8 0 -2.1162399942930925e-03
GC_2_9 ref NI_2 NS_9 0 8.0247487739651416e-02
GC_2_10 ref NI_2 NS_10 0 -6.1550001036461983e-03
GC_2_11 ref NI_2 NS_11 0 -3.0532801098401997e-03
GC_2_12 ref NI_2 NS_12 0 -2.9195125666820042e-03
GC_2_13 ref NI_2 NS_13 0 5.2740299793268733e-02
GC_2_14 ref NI_2 NS_14 0 9.5464093965853293e-03
GC_2_15 ref NI_2 NS_15 0 -3.2387166061211728e-03
GC_2_16 ref NI_2 NS_16 0 -2.9835743678846764e-03
GC_2_17 ref NI_2 NS_17 0 4.6227308273795717e-02
GC_2_18 ref NI_2 NS_18 0 1.5665959771236075e-02
GC_2_19 ref NI_2 NS_19 0 -3.8957840009396171e-03
GC_2_20 ref NI_2 NS_20 0 -2.9688333656038464e-03
GC_2_21 ref NI_2 NS_21 0 9.3035328170378920e-02
GC_2_22 ref NI_2 NS_22 0 -1.3164654547332136e-02
GC_2_23 ref NI_2 NS_23 0 -3.1957337150796861e-03
GC_2_24 ref NI_2 NS_24 0 -2.8667047673833876e-03
GC_2_25 ref NI_2 NS_25 0 2.8915056896065234e-02
GC_2_26 ref NI_2 NS_26 0 -9.0876870722833298e-04
GC_2_27 ref NI_2 NS_27 0 -7.0081135431961539e-04
GC_2_28 ref NI_2 NS_28 0 3.3586719839491112e-04
GC_2_29 ref NI_2 NS_29 0 2.8439944698958892e-02
GC_2_30 ref NI_2 NS_30 0 1.7918592551503809e-03
GC_2_31 ref NI_2 NS_31 0 -3.1052412059699041e-04
GC_2_32 ref NI_2 NS_32 0 -1.4145148628637462e-04
GC_2_33 ref NI_2 NS_33 0 1.4967125050167022e-03
GC_2_34 ref NI_2 NS_34 0 -3.3826298664315088e-03
GC_2_35 ref NI_2 NS_35 0 2.5588397993367368e-03
GC_2_36 ref NI_2 NS_36 0 1.6161115239206117e-03
GC_2_37 ref NI_2 NS_37 0 8.0926457200590201e-03
GC_2_38 ref NI_2 NS_38 0 3.5780566508636894e-03
GC_2_39 ref NI_2 NS_39 0 5.6203119021123039e-04
GC_2_40 ref NI_2 NS_40 0 7.7638281513281785e-04
GC_2_41 ref NI_2 NS_41 0 1.4435851780650429e-02
GC_2_42 ref NI_2 NS_42 0 1.8343069127208132e-04
GC_2_43 ref NI_2 NS_43 0 1.3392803706875399e-03
GC_2_44 ref NI_2 NS_44 0 5.4214893109104346e-04
GC_2_45 ref NI_2 NS_45 0 1.5200431622384719e-02
GC_2_46 ref NI_2 NS_46 0 1.7825329315993312e-03
GC_2_47 ref NI_2 NS_47 0 7.3460937871826953e-04
GC_2_48 ref NI_2 NS_48 0 4.3796665309751934e-04
GC_2_49 ref NI_2 NS_49 0 1.4714465573394597e-02
GC_2_50 ref NI_2 NS_50 0 2.5858220190886514e-03
GC_2_51 ref NI_2 NS_51 0 3.3445113850422067e-04
GC_2_52 ref NI_2 NS_52 0 5.8214954826946858e-04
GC_2_53 ref NI_2 NS_53 0 1.8275212848668284e-02
GC_2_54 ref NI_2 NS_54 0 4.0239735639925013e-03
GC_2_55 ref NI_2 NS_55 0 8.5907879761739985e-04
GC_2_56 ref NI_2 NS_56 0 -1.0548779971768574e-04
GC_2_57 ref NI_2 NS_57 0 2.0704458462419777e-03
GC_2_58 ref NI_2 NS_58 0 -2.8422776740220489e-03
GC_2_59 ref NI_2 NS_59 0 2.0260922023197865e-03
GC_2_60 ref NI_2 NS_60 0 1.6430160688276005e-03
GC_2_61 ref NI_2 NS_61 0 3.0458349567153032e-03
GC_2_62 ref NI_2 NS_62 0 -4.0705479072415491e-03
GC_2_63 ref NI_2 NS_63 0 1.6915584443507048e-03
GC_2_64 ref NI_2 NS_64 0 1.8783288561936579e-03
GC_2_65 ref NI_2 NS_65 0 -1.8278648472925938e-04
GC_2_66 ref NI_2 NS_66 0 -5.0500752828717466e-04
GC_2_67 ref NI_2 NS_67 0 1.3042576475560722e-03
GC_2_68 ref NI_2 NS_68 0 1.6934175408519999e-03
GC_2_69 ref NI_2 NS_69 0 -2.8990479159065482e-05
GC_2_70 ref NI_2 NS_70 0 2.8571499589052766e-03
GC_2_71 ref NI_2 NS_71 0 1.2673515757478937e-03
GC_2_72 ref NI_2 NS_72 0 1.2416429608223087e-03
GC_2_73 ref NI_2 NS_73 0 2.1392471640371198e-03
GC_2_74 ref NI_2 NS_74 0 -3.5503428937819267e-03
GC_2_75 ref NI_2 NS_75 0 1.0667630797550121e-03
GC_2_76 ref NI_2 NS_76 0 2.0537647890451344e-03
GC_2_77 ref NI_2 NS_77 0 2.0216996801941038e-03
GC_2_78 ref NI_2 NS_78 0 -6.4294856129531726e-04
GC_2_79 ref NI_2 NS_79 0 1.5014241453254462e-03
GC_2_80 ref NI_2 NS_80 0 1.5133803056345491e-03
GC_2_81 ref NI_2 NS_81 0 3.7871694546960334e-03
GC_2_82 ref NI_2 NS_82 0 -1.3708211072161127e-03
GC_2_83 ref NI_2 NS_83 0 2.0686047366301327e-03
GC_2_84 ref NI_2 NS_84 0 1.3191542356397745e-03
GC_2_85 ref NI_2 NS_85 0 3.2265647235403729e-03
GC_2_86 ref NI_2 NS_86 0 -6.3030768678238333e-04
GC_2_87 ref NI_2 NS_87 0 2.2004075053359560e-03
GC_2_88 ref NI_2 NS_88 0 1.2224888420963899e-03
GD_2_1 ref NI_2 NA_1 0 2.3020788182456311e+00
GD_2_2 ref NI_2 NA_2 0 2.0506095344212376e+00
GD_2_3 ref NI_2 NA_3 0 2.8590725762004682e-01
GD_2_4 ref NI_2 NA_4 0 2.5798410670596539e-01
GD_2_5 ref NI_2 NA_5 0 2.0498985960794563e-01
GD_2_6 ref NI_2 NA_6 0 3.0030813793049255e-01
GD_2_7 ref NI_2 NA_7 0 1.1955713518886905e-02
GD_2_8 ref NI_2 NA_8 0 1.6008220254537363e-02
GD_2_9 ref NI_2 NA_9 0 5.5100772909195753e-03
GD_2_10 ref NI_2 NA_10 0 1.5985603439480828e-02
GD_2_11 ref NI_2 NA_11 0 2.6106781308481718e-02
GD_2_12 ref NI_2 NA_12 0 2.6298260827187534e-02
GD_2_13 ref NI_2 NA_13 0 -3.9261076803747087e-03
GD_2_14 ref NI_2 NA_14 0 2.3368737795557114e-02
GD_2_15 ref NI_2 NA_15 0 7.8574403657145648e-03
GD_2_16 ref NI_2 NA_16 0 -1.6599215924740655e-04
GD_2_17 ref NI_2 NA_17 0 1.0249783089220711e-02
GD_2_18 ref NI_2 NA_18 0 9.8748388425400849e-03
GD_2_19 ref NI_2 NA_19 0 2.2987164826771002e-03
GD_2_20 ref NI_2 NA_20 0 8.1778987577350408e-03
GD_2_21 ref NI_2 NA_21 0 8.4324464071352731e-03
GD_2_22 ref NI_2 NA_22 0 8.3569322270458934e-03
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 7.2632169431744567e-02
GC_3_2 ref NI_3 NS_2 0 1.1247640308125709e-02
GC_3_3 ref NI_3 NS_3 0 -3.6137789368314217e-03
GC_3_4 ref NI_3 NS_4 0 -2.6168099064398415e-03
GC_3_5 ref NI_3 NS_5 0 8.0247487739650916e-02
GC_3_6 ref NI_3 NS_6 0 -6.1550001036457498e-03
GC_3_7 ref NI_3 NS_7 0 -3.0532801098404000e-03
GC_3_8 ref NI_3 NS_8 0 -2.9195125666819479e-03
GC_3_9 ref NI_3 NS_9 0 2.3936415909513752e-02
GC_3_10 ref NI_3 NS_10 0 -2.3571382193183571e-01
GC_3_11 ref NI_3 NS_11 0 -7.7180125538156320e-03
GC_3_12 ref NI_3 NS_12 0 -7.4868348747692349e-03
GC_3_13 ref NI_3 NS_13 0 3.7782715736628558e-02
GC_3_14 ref NI_3 NS_14 0 5.9737156178742604e-02
GC_3_15 ref NI_3 NS_15 0 -1.2289159363835378e-02
GC_3_16 ref NI_3 NS_16 0 -4.7168261300377387e-03
GC_3_17 ref NI_3 NS_17 0 -5.3525271315907362e-02
GC_3_18 ref NI_3 NS_18 0 7.8352224376975144e-02
GC_3_19 ref NI_3 NS_19 0 -2.2232325172360213e-03
GC_3_20 ref NI_3 NS_20 0 -4.6829309585146323e-03
GC_3_21 ref NI_3 NS_21 0 -6.0688489239071185e-02
GC_3_22 ref NI_3 NS_22 0 7.6156544597489856e-02
GC_3_23 ref NI_3 NS_23 0 -1.1109487484885687e-03
GC_3_24 ref NI_3 NS_24 0 -4.1893917597863812e-03
GC_3_25 ref NI_3 NS_25 0 -1.8519037447215204e-02
GC_3_26 ref NI_3 NS_26 0 1.2708226352004321e-02
GC_3_27 ref NI_3 NS_27 0 2.7456588434438441e-03
GC_3_28 ref NI_3 NS_28 0 6.4745823275109645e-04
GC_3_29 ref NI_3 NS_29 0 -1.8899551303638736e-02
GC_3_30 ref NI_3 NS_30 0 1.0790651062540044e-02
GC_3_31 ref NI_3 NS_31 0 5.5542207589056661e-03
GC_3_32 ref NI_3 NS_32 0 5.2984001563513567e-05
GC_3_33 ref NI_3 NS_33 0 4.1980600425920384e-03
GC_3_34 ref NI_3 NS_34 0 -5.7192531980524795e-03
GC_3_35 ref NI_3 NS_35 0 1.4252252492899623e-04
GC_3_36 ref NI_3 NS_36 0 2.5176041097514355e-03
GC_3_37 ref NI_3 NS_37 0 -8.5870477948399426e-03
GC_3_38 ref NI_3 NS_38 0 2.2704410227927635e-03
GC_3_39 ref NI_3 NS_39 0 3.1329849838689946e-03
GC_3_40 ref NI_3 NS_40 0 1.2809754737587472e-03
GC_3_41 ref NI_3 NS_41 0 -7.0594548286546082e-03
GC_3_42 ref NI_3 NS_42 0 1.4335243161745620e-03
GC_3_43 ref NI_3 NS_43 0 4.1003016921095457e-03
GC_3_44 ref NI_3 NS_44 0 1.0489256714162930e-03
GC_3_45 ref NI_3 NS_45 0 -1.0163663903024258e-02
GC_3_46 ref NI_3 NS_46 0 3.6491560248560649e-03
GC_3_47 ref NI_3 NS_47 0 4.2574490773180521e-03
GC_3_48 ref NI_3 NS_48 0 8.6625583998030473e-04
GC_3_49 ref NI_3 NS_49 0 -1.1556178608519662e-02
GC_3_50 ref NI_3 NS_50 0 5.0123277721501412e-03
GC_3_51 ref NI_3 NS_51 0 3.4519818563243381e-03
GC_3_52 ref NI_3 NS_52 0 1.0069623396001572e-03
GC_3_53 ref NI_3 NS_53 0 -1.2219142052185892e-02
GC_3_54 ref NI_3 NS_54 0 3.5466898919314059e-03
GC_3_55 ref NI_3 NS_55 0 7.0118920147277004e-03
GC_3_56 ref NI_3 NS_56 0 1.7242685793003259e-04
GC_3_57 ref NI_3 NS_57 0 2.0866092509275610e-03
GC_3_58 ref NI_3 NS_58 0 -3.7121939040962149e-03
GC_3_59 ref NI_3 NS_59 0 -3.5798372832140192e-04
GC_3_60 ref NI_3 NS_60 0 2.5101108748111691e-03
GC_3_61 ref NI_3 NS_61 0 1.4152139446999648e-03
GC_3_62 ref NI_3 NS_62 0 -2.1023225141135310e-03
GC_3_63 ref NI_3 NS_63 0 -1.8202154810709396e-03
GC_3_64 ref NI_3 NS_64 0 2.7918095888088707e-03
GC_3_65 ref NI_3 NS_65 0 -5.3926922964822827e-04
GC_3_66 ref NI_3 NS_66 0 -1.8531211137333117e-03
GC_3_67 ref NI_3 NS_67 0 -7.0845158686544873e-04
GC_3_68 ref NI_3 NS_68 0 2.5095317454058240e-03
GC_3_69 ref NI_3 NS_69 0 -2.6642590563883697e-03
GC_3_70 ref NI_3 NS_70 0 -2.1192371748030704e-03
GC_3_71 ref NI_3 NS_71 0 1.7593395577463361e-03
GC_3_72 ref NI_3 NS_72 0 1.9177601913356460e-03
GC_3_73 ref NI_3 NS_73 0 -4.0619215867622205e-04
GC_3_74 ref NI_3 NS_74 0 -7.0067149660982560e-05
GC_3_75 ref NI_3 NS_75 0 -2.9533458706915965e-03
GC_3_76 ref NI_3 NS_76 0 2.9662568989076176e-03
GC_3_77 ref NI_3 NS_77 0 -6.6902811594280842e-04
GC_3_78 ref NI_3 NS_78 0 -2.1334511251989885e-03
GC_3_79 ref NI_3 NS_79 0 1.7609549464698426e-04
GC_3_80 ref NI_3 NS_80 0 2.3015333734643893e-03
GC_3_81 ref NI_3 NS_81 0 6.8684113419638186e-04
GC_3_82 ref NI_3 NS_82 0 -3.7066498272151195e-03
GC_3_83 ref NI_3 NS_83 0 1.3100528766410693e-03
GC_3_84 ref NI_3 NS_84 0 2.0978344536776179e-03
GC_3_85 ref NI_3 NS_85 0 8.8270739190534210e-04
GC_3_86 ref NI_3 NS_86 0 -4.4559970965609656e-03
GC_3_87 ref NI_3 NS_87 0 1.9892542740597200e-03
GC_3_88 ref NI_3 NS_88 0 1.9811635287880591e-03
GD_3_1 ref NI_3 NA_1 0 -2.6009497927506969e-01
GD_3_2 ref NI_3 NA_2 0 2.8590725762004870e-01
GD_3_3 ref NI_3 NA_3 0 5.6889800466517393e+00
GD_3_4 ref NI_3 NA_4 0 -8.6399326864232670e-02
GD_3_5 ref NI_3 NA_5 0 9.9145824097450666e-02
GD_3_6 ref NI_3 NA_6 0 8.7011227304551922e-02
GD_3_7 ref NI_3 NA_7 0 3.3385670891754052e-02
GD_3_8 ref NI_3 NA_8 0 3.5053637747666420e-02
GD_3_9 ref NI_3 NA_9 0 -1.9034418098429517e-03
GD_3_10 ref NI_3 NA_10 0 2.6691526450837673e-02
GD_3_11 ref NI_3 NA_11 0 1.6701316255450471e-02
GD_3_12 ref NI_3 NA_12 0 2.4824977541701671e-02
GD_3_13 ref NI_3 NA_13 0 2.7124309813207789e-02
GD_3_14 ref NI_3 NA_14 0 2.6003631586462378e-02
GD_3_15 ref NI_3 NA_15 0 3.6465130113329833e-03
GD_3_16 ref NI_3 NA_16 0 4.3490204399095197e-03
GD_3_17 ref NI_3 NA_17 0 1.3221349842107231e-02
GD_3_18 ref NI_3 NA_18 0 1.7918826173858260e-02
GD_3_19 ref NI_3 NA_19 0 1.1012035651683912e-02
GD_3_20 ref NI_3 NA_20 0 1.0750794552155742e-02
GD_3_21 ref NI_3 NA_21 0 5.0755145705317266e-03
GD_3_22 ref NI_3 NA_22 0 5.2105197710585341e-03
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 3.6972902297100763e-02
GC_4_2 ref NI_4 NS_2 0 2.7480236222227599e-02
GC_4_3 ref NI_4 NS_3 0 -3.0705451873412988e-03
GC_4_4 ref NI_4 NS_4 0 -2.6992676067491305e-03
GC_4_5 ref NI_4 NS_5 0 5.2740299793268178e-02
GC_4_6 ref NI_4 NS_6 0 9.5464093965859226e-03
GC_4_7 ref NI_4 NS_7 0 -3.2387166061214829e-03
GC_4_8 ref NI_4 NS_8 0 -2.9835743678845827e-03
GC_4_9 ref NI_4 NS_9 0 3.7782715736629120e-02
GC_4_10 ref NI_4 NS_10 0 5.9737156178742166e-02
GC_4_11 ref NI_4 NS_11 0 -1.2289159363835237e-02
GC_4_12 ref NI_4 NS_12 0 -4.7168261300377691e-03
GC_4_13 ref NI_4 NS_13 0 -2.0444003924085782e-02
GC_4_14 ref NI_4 NS_14 0 -2.2588080291551890e-01
GC_4_15 ref NI_4 NS_15 0 -3.1802824254614720e-03
GC_4_16 ref NI_4 NS_16 0 -7.6541001359537956e-03
GC_4_17 ref NI_4 NS_17 0 1.9858123155073192e-02
GC_4_18 ref NI_4 NS_18 0 6.0247735188509025e-02
GC_4_19 ref NI_4 NS_19 0 -8.7266789132915742e-03
GC_4_20 ref NI_4 NS_20 0 -4.8993744938111202e-03
GC_4_21 ref NI_4 NS_21 0 -5.3671042564059065e-02
GC_4_22 ref NI_4 NS_22 0 7.9609885265932892e-02
GC_4_23 ref NI_4 NS_23 0 -3.1095454564593118e-03
GC_4_24 ref NI_4 NS_24 0 -4.4769651875202860e-03
GC_4_25 ref NI_4 NS_25 0 -1.7111557610375389e-02
GC_4_26 ref NI_4 NS_26 0 9.5230293844821047e-03
GC_4_27 ref NI_4 NS_27 0 3.7566117147394109e-03
GC_4_28 ref NI_4 NS_28 0 6.4394731027710692e-04
GC_4_29 ref NI_4 NS_29 0 -1.6605384007643092e-02
GC_4_30 ref NI_4 NS_30 0 6.7556085947766131e-03
GC_4_31 ref NI_4 NS_31 0 6.7317187962093895e-03
GC_4_32 ref NI_4 NS_32 0 5.7353007255217550e-05
GC_4_33 ref NI_4 NS_33 0 4.7419314425996648e-03
GC_4_34 ref NI_4 NS_34 0 -5.7364540844644357e-03
GC_4_35 ref NI_4 NS_35 0 -2.2846404933190114e-04
GC_4_36 ref NI_4 NS_36 0 2.6027833508011564e-03
GC_4_37 ref NI_4 NS_37 0 -6.4697543618311652e-03
GC_4_38 ref NI_4 NS_38 0 -1.4399089324188916e-04
GC_4_39 ref NI_4 NS_39 0 3.5999712637375218e-03
GC_4_40 ref NI_4 NS_40 0 1.3201565987635848e-03
GC_4_41 ref NI_4 NS_41 0 -5.1411099621006436e-03
GC_4_42 ref NI_4 NS_42 0 -1.0576152634798309e-03
GC_4_43 ref NI_4 NS_43 0 4.6415863447373702e-03
GC_4_44 ref NI_4 NS_44 0 1.0846066454551968e-03
GC_4_45 ref NI_4 NS_45 0 -8.0361314898297290e-03
GC_4_46 ref NI_4 NS_46 0 7.9527197963016026e-04
GC_4_47 ref NI_4 NS_47 0 4.9329924806237654e-03
GC_4_48 ref NI_4 NS_48 0 8.9371649263305698e-04
GC_4_49 ref NI_4 NS_49 0 -9.4309312839225869e-03
GC_4_50 ref NI_4 NS_50 0 2.1110567902907469e-03
GC_4_51 ref NI_4 NS_51 0 4.1510115771335090e-03
GC_4_52 ref NI_4 NS_52 0 1.0320096339608684e-03
GC_4_53 ref NI_4 NS_53 0 -9.2292486478534920e-03
GC_4_54 ref NI_4 NS_54 0 -4.3662193869240711e-04
GC_4_55 ref NI_4 NS_55 0 8.0283869098596358e-03
GC_4_56 ref NI_4 NS_56 0 1.8911269914530072e-04
GC_4_57 ref NI_4 NS_57 0 2.5443488674250932e-03
GC_4_58 ref NI_4 NS_58 0 -3.7605423919016335e-03
GC_4_59 ref NI_4 NS_59 0 -6.8899326538385112e-04
GC_4_60 ref NI_4 NS_60 0 2.5905027649882513e-03
GC_4_61 ref NI_4 NS_61 0 1.4183919969969539e-03
GC_4_62 ref NI_4 NS_62 0 -1.7252929209164484e-03
GC_4_63 ref NI_4 NS_63 0 -2.2592189491933258e-03
GC_4_64 ref NI_4 NS_64 0 2.8753109193769564e-03
GC_4_65 ref NI_4 NS_65 0 1.4724666855782671e-04
GC_4_66 ref NI_4 NS_66 0 -2.1160465728142881e-03
GC_4_67 ref NI_4 NS_67 0 -9.8128378635474662e-04
GC_4_68 ref NI_4 NS_68 0 2.5867877210057522e-03
GC_4_69 ref NI_4 NS_69 0 -9.2638707019041412e-04
GC_4_70 ref NI_4 NS_70 0 -3.5358746660868069e-03
GC_4_71 ref NI_4 NS_71 0 1.8169334709829711e-03
GC_4_72 ref NI_4 NS_72 0 1.9819499881053135e-03
GC_4_73 ref NI_4 NS_73 0 -6.3562448718494939e-04
GC_4_74 ref NI_4 NS_74 0 5.1348503200922160e-04
GC_4_75 ref NI_4 NS_75 0 -3.4371315173368465e-03
GC_4_76 ref NI_4 NS_76 0 3.0495258764298202e-03
GC_4_77 ref NI_4 NS_77 0 2.1840606807530037e-04
GC_4_78 ref NI_4 NS_78 0 -2.6988369848646040e-03
GC_4_79 ref NI_4 NS_79 0 4.6131572021525935e-06
GC_4_80 ref NI_4 NS_80 0 2.3741951306711761e-03
GC_4_81 ref NI_4 NS_81 0 1.7643028425598259e-03
GC_4_82 ref NI_4 NS_82 0 -4.5009915153162447e-03
GC_4_83 ref NI_4 NS_83 0 1.2041269299508254e-03
GC_4_84 ref NI_4 NS_84 0 2.1690756703159762e-03
GC_4_85 ref NI_4 NS_85 0 2.1903343124066842e-03
GC_4_86 ref NI_4 NS_86 0 -5.4520379463792292e-03
GC_4_87 ref NI_4 NS_87 0 1.9288794960918569e-03
GC_4_88 ref NI_4 NS_88 0 2.0516171622542373e-03
GD_4_1 ref NI_4 NA_1 0 -2.0492169432750146e-01
GD_4_2 ref NI_4 NA_2 0 2.5798410670596694e-01
GD_4_3 ref NI_4 NA_3 0 -8.6399326864235487e-02
GD_4_4 ref NI_4 NA_4 0 5.8403807875130722e+00
GD_4_5 ref NI_4 NA_5 0 -1.4479978903430338e-02
GD_4_6 ref NI_4 NA_6 0 7.3860735767347169e-02
GD_4_7 ref NI_4 NA_7 0 3.9649100994339291e-02
GD_4_8 ref NI_4 NA_8 0 3.9985479058713282e-02
GD_4_9 ref NI_4 NA_9 0 -4.2286078973802653e-03
GD_4_10 ref NI_4 NA_10 0 2.5040930048806982e-02
GD_4_11 ref NI_4 NA_11 0 1.6435253143331129e-02
GD_4_12 ref NI_4 NA_12 0 2.4926295043796776e-02
GD_4_13 ref NI_4 NA_13 0 2.7703977257703148e-02
GD_4_14 ref NI_4 NA_14 0 2.5835599487867907e-02
GD_4_15 ref NI_4 NA_15 0 2.0381639636608199e-03
GD_4_16 ref NI_4 NA_16 0 3.8994997726657129e-03
GD_4_17 ref NI_4 NA_17 0 1.1126215607861575e-02
GD_4_18 ref NI_4 NA_18 0 1.4228558983616552e-02
GD_4_19 ref NI_4 NA_19 0 1.1162600468302347e-02
GD_4_20 ref NI_4 NA_20 0 8.7465744593693551e-03
GD_4_21 ref NI_4 NA_21 0 2.8137188618949874e-03
GD_4_22 ref NI_4 NA_22 0 2.4180133411303342e-03
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 2.9387359950393575e-02
GC_5_2 ref NI_5 NS_2 0 3.1448410132154839e-02
GC_5_3 ref NI_5 NS_3 0 -3.3486751585583428e-03
GC_5_4 ref NI_5 NS_4 0 -2.7011872993658098e-03
GC_5_5 ref NI_5 NS_5 0 4.6227308273795266e-02
GC_5_6 ref NI_5 NS_6 0 1.5665959771236616e-02
GC_5_7 ref NI_5 NS_7 0 -3.8957840009399181e-03
GC_5_8 ref NI_5 NS_8 0 -2.9688333656037536e-03
GC_5_9 ref NI_5 NS_9 0 -5.3525271315907418e-02
GC_5_10 ref NI_5 NS_10 0 7.8352224376975241e-02
GC_5_11 ref NI_5 NS_11 0 -2.2232325172360911e-03
GC_5_12 ref NI_5 NS_12 0 -4.6829309585146080e-03
GC_5_13 ref NI_5 NS_13 0 1.9858123155073199e-02
GC_5_14 ref NI_5 NS_14 0 6.0247735188508983e-02
GC_5_15 ref NI_5 NS_15 0 -8.7266789132915534e-03
GC_5_16 ref NI_5 NS_16 0 -4.8993744938111271e-03
GC_5_17 ref NI_5 NS_17 0 -1.3026939997805983e-02
GC_5_18 ref NI_5 NS_18 0 -2.2903039584775495e-01
GC_5_19 ref NI_5 NS_19 0 -4.0556667151379301e-03
GC_5_20 ref NI_5 NS_20 0 -7.5581336811609990e-03
GC_5_21 ref NI_5 NS_21 0 4.0547061903630680e-02
GC_5_22 ref NI_5 NS_22 0 5.9023617212714416e-02
GC_5_23 ref NI_5 NS_23 0 -1.3536701013260849e-02
GC_5_24 ref NI_5 NS_24 0 -4.4105523986491344e-03
GC_5_25 ref NI_5 NS_25 0 -1.7561816379733829e-02
GC_5_26 ref NI_5 NS_26 0 9.5291718824534310e-03
GC_5_27 ref NI_5 NS_27 0 3.8746716104373375e-03
GC_5_28 ref NI_5 NS_28 0 6.2775050978025886e-04
GC_5_29 ref NI_5 NS_29 0 -1.6925838815619917e-02
GC_5_30 ref NI_5 NS_30 0 6.6063009381934212e-03
GC_5_31 ref NI_5 NS_31 0 6.9444534310733894e-03
GC_5_32 ref NI_5 NS_32 0 2.5321832649620805e-05
GC_5_33 ref NI_5 NS_33 0 5.2147411055498529e-03
GC_5_34 ref NI_5 NS_34 0 -6.1380336901713482e-03
GC_5_35 ref NI_5 NS_35 0 -1.1111361966202339e-04
GC_5_36 ref NI_5 NS_36 0 2.5956412372264074e-03
GC_5_37 ref NI_5 NS_37 0 -6.4524079036506841e-03
GC_5_38 ref NI_5 NS_38 0 -3.5326525598088201e-04
GC_5_39 ref NI_5 NS_39 0 3.7155761132046505e-03
GC_5_40 ref NI_5 NS_40 0 1.3098589184646263e-03
GC_5_41 ref NI_5 NS_41 0 -5.1460947314343657e-03
GC_5_42 ref NI_5 NS_42 0 -1.2917992445470176e-03
GC_5_43 ref NI_5 NS_43 0 4.7982436729908408e-03
GC_5_44 ref NI_5 NS_44 0 1.0663422222895783e-03
GC_5_45 ref NI_5 NS_45 0 -8.1716692107781271e-03
GC_5_46 ref NI_5 NS_46 0 6.4181166164933281e-04
GC_5_47 ref NI_5 NS_47 0 5.0652250159181058e-03
GC_5_48 ref NI_5 NS_48 0 8.7874056036043235e-04
GC_5_49 ref NI_5 NS_49 0 -9.3840607336598773e-03
GC_5_50 ref NI_5 NS_50 0 1.8233819086806878e-03
GC_5_51 ref NI_5 NS_51 0 4.3181932596733233e-03
GC_5_52 ref NI_5 NS_52 0 1.0136214153209397e-03
GC_5_53 ref NI_5 NS_53 0 -9.2986603075929843e-03
GC_5_54 ref NI_5 NS_54 0 -7.2721043520838403e-04
GC_5_55 ref NI_5 NS_55 0 8.2556625706712797e-03
GC_5_56 ref NI_5 NS_56 0 1.5844997297013704e-04
GC_5_57 ref NI_5 NS_57 0 2.9567451602948314e-03
GC_5_58 ref NI_5 NS_58 0 -4.1223603931367465e-03
GC_5_59 ref NI_5 NS_59 0 -5.7959846058841860e-04
GC_5_60 ref NI_5 NS_60 0 2.5836751898499302e-03
GC_5_61 ref NI_5 NS_61 0 1.8201905203192551e-03
GC_5_62 ref NI_5 NS_62 0 -2.0544440704645664e-03
GC_5_63 ref NI_5 NS_63 0 -2.1696531209650705e-03
GC_5_64 ref NI_5 NS_64 0 2.8712001271950656e-03
GC_5_65 ref NI_5 NS_65 0 5.5171038430505410e-04
GC_5_66 ref NI_5 NS_66 0 -2.4698220776791335e-03
GC_5_67 ref NI_5 NS_67 0 -8.7721163475298566e-04
GC_5_68 ref NI_5 NS_68 0 2.5807617603583410e-03
GC_5_69 ref NI_5 NS_69 0 -5.5422088817582088e-04
GC_5_70 ref NI_5 NS_70 0 -3.9268880094982519e-03
GC_5_71 ref NI_5 NS_71 0 1.9543736427435217e-03
GC_5_72 ref NI_5 NS_72 0 1.9711283487425955e-03
GC_5_73 ref NI_5 NS_73 0 -2.4360620629232247e-04
GC_5_74 ref NI_5 NS_74 0 2.0527022198261487e-04
GC_5_75 ref NI_5 NS_75 0 -3.3586630975739724e-03
GC_5_76 ref NI_5 NS_76 0 3.0467880201691892e-03
GC_5_77 ref NI_5 NS_77 0 5.6796023585393507e-04
GC_5_78 ref NI_5 NS_78 0 -3.0381380091228463e-03
GC_5_79 ref NI_5 NS_79 0 1.1720106492272753e-04
GC_5_80 ref NI_5 NS_80 0 2.3662876283550233e-03
GC_5_81 ref NI_5 NS_81 0 2.1126615307388362e-03
GC_5_82 ref NI_5 NS_82 0 -4.8607792207435128e-03
GC_5_83 ref NI_5 NS_83 0 1.3328690019192664e-03
GC_5_84 ref NI_5 NS_84 0 2.1587751704843969e-03
GC_5_85 ref NI_5 NS_85 0 2.5468164234552755e-03
GC_5_86 ref NI_5 NS_86 0 -5.8310282170691199e-03
GC_5_87 ref NI_5 NS_87 0 2.0681629177803453e-03
GC_5_88 ref NI_5 NS_88 0 2.0399720644930070e-03
GD_5_1 ref NI_5 NA_1 0 -1.8265394821971109e-01
GD_5_2 ref NI_5 NA_2 0 2.0498985960794661e-01
GD_5_3 ref NI_5 NA_3 0 9.9145824097450819e-02
GD_5_4 ref NI_5 NA_4 0 -1.4479978903429969e-02
GD_5_5 ref NI_5 NA_5 0 5.8586534029051558e+00
GD_5_6 ref NI_5 NA_6 0 -9.1676941819857485e-02
GD_5_7 ref NI_5 NA_7 0 4.2946399941218606e-02
GD_5_8 ref NI_5 NA_8 0 4.2692984877132877e-02
GD_5_9 ref NI_5 NA_9 0 -5.8559494104742952e-03
GD_5_10 ref NI_5 NA_10 0 2.6011930282702527e-02
GD_5_11 ref NI_5 NA_11 0 1.7399691593131206e-02
GD_5_12 ref NI_5 NA_12 0 2.6594827415758776e-02
GD_5_13 ref NI_5 NA_13 0 2.8760619770199582e-02
GD_5_14 ref NI_5 NA_14 0 2.7425784554088398e-02
GD_5_15 ref NI_5 NA_15 0 6.6607471029696806e-04
GD_5_16 ref NI_5 NA_16 0 2.4669398076721818e-03
GD_5_17 ref NI_5 NA_17 0 9.8293232253942112e-03
GD_5_18 ref NI_5 NA_18 0 1.3387181720848641e-02
GD_5_19 ref NI_5 NA_19 0 9.7059800606605802e-03
GD_5_20 ref NI_5 NA_20 0 7.7539587922662969e-03
GD_5_21 ref NI_5 NA_21 0 1.8817615603255366e-03
GD_5_22 ref NI_5 NA_22 0 1.5265641757536714e-03
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 7.8996626371419063e-02
GC_6_2 ref NI_6 NS_2 0 1.0134544927377580e-02
GC_6_3 ref NI_6 NS_3 0 -4.3143609202622672e-03
GC_6_4 ref NI_6 NS_4 0 -2.5226432271476902e-03
GC_6_5 ref NI_6 NS_5 0 9.3035328170378850e-02
GC_6_6 ref NI_6 NS_6 0 -1.3164654547331824e-02
GC_6_7 ref NI_6 NS_7 0 -3.1957337150799298e-03
GC_6_8 ref NI_6 NS_8 0 -2.8667047673833013e-03
GC_6_9 ref NI_6 NS_9 0 -6.0688489239071351e-02
GC_6_10 ref NI_6 NS_10 0 7.6156544597490078e-02
GC_6_11 ref NI_6 NS_11 0 -1.1109487484886921e-03
GC_6_12 ref NI_6 NS_12 0 -4.1893917597863413e-03
GC_6_13 ref NI_6 NS_13 0 -5.3671042564059669e-02
GC_6_14 ref NI_6 NS_14 0 7.9609885265933295e-02
GC_6_15 ref NI_6 NS_15 0 -3.1095454564594276e-03
GC_6_16 ref NI_6 NS_16 0 -4.4769651875202670e-03
GC_6_17 ref NI_6 NS_17 0 4.0547061903630249e-02
GC_6_18 ref NI_6 NS_18 0 5.9023617212714666e-02
GC_6_19 ref NI_6 NS_19 0 -1.3536701013260922e-02
GC_6_20 ref NI_6 NS_20 0 -4.4105523986491249e-03
GC_6_21 ref NI_6 NS_21 0 3.0641949965890883e-03
GC_6_22 ref NI_6 NS_22 0 -2.3595850826894058e-01
GC_6_23 ref NI_6 NS_23 0 -6.5419423645968660e-03
GC_6_24 ref NI_6 NS_24 0 -6.6842556445087615e-03
GC_6_25 ref NI_6 NS_25 0 -1.8601313789914645e-02
GC_6_26 ref NI_6 NS_26 0 1.4479307248215232e-02
GC_6_27 ref NI_6 NS_27 0 2.2306797084778660e-03
GC_6_28 ref NI_6 NS_28 0 5.8864887318958400e-04
GC_6_29 ref NI_6 NS_29 0 -1.9727932319764798e-02
GC_6_30 ref NI_6 NS_30 0 1.3458635853329804e-02
GC_6_31 ref NI_6 NS_31 0 4.7758466419250568e-03
GC_6_32 ref NI_6 NS_32 0 1.0698002217283462e-06
GC_6_33 ref NI_6 NS_33 0 4.7206797535060034e-03
GC_6_34 ref NI_6 NS_34 0 -6.4723184234648798e-03
GC_6_35 ref NI_6 NS_35 0 7.5077589587908583e-04
GC_6_36 ref NI_6 NS_36 0 2.4015992668518101e-03
GC_6_37 ref NI_6 NS_37 0 -9.2091133127353182e-03
GC_6_38 ref NI_6 NS_38 0 3.4803855227186513e-03
GC_6_39 ref NI_6 NS_39 0 3.0124757467251927e-03
GC_6_40 ref NI_6 NS_40 0 1.2007877401970107e-03
GC_6_41 ref NI_6 NS_41 0 -7.4612766125908420e-03
GC_6_42 ref NI_6 NS_42 0 2.7367388401119430e-03
GC_6_43 ref NI_6 NS_43 0 3.9257299136545637e-03
GC_6_44 ref NI_6 NS_44 0 9.6113505712528541e-04
GC_6_45 ref NI_6 NS_45 0 -1.0798384861218025e-02
GC_6_46 ref NI_6 NS_46 0 5.3149523583091640e-03
GC_6_47 ref NI_6 NS_47 0 3.9303290017780514e-03
GC_6_48 ref NI_6 NS_48 0 7.9164424628332358e-04
GC_6_49 ref NI_6 NS_49 0 -1.2129338227652253e-02
GC_6_50 ref NI_6 NS_50 0 6.3522086909275060e-03
GC_6_51 ref NI_6 NS_51 0 3.2480683841773334e-03
GC_6_52 ref NI_6 NS_52 0 9.3430261951872888e-04
GC_6_53 ref NI_6 NS_53 0 -1.3510368989049004e-02
GC_6_54 ref NI_6 NS_54 0 6.1095670069169659e-03
GC_6_55 ref NI_6 NS_55 0 6.4342764701427781e-03
GC_6_56 ref NI_6 NS_56 0 9.6497141868665762e-05
GC_6_57 ref NI_6 NS_57 0 2.7004508632175739e-03
GC_6_58 ref NI_6 NS_58 0 -4.4422662064293773e-03
GC_6_59 ref NI_6 NS_59 0 2.0738495957546373e-04
GC_6_60 ref NI_6 NS_60 0 2.3997630508300134e-03
GC_6_61 ref NI_6 NS_61 0 2.4356137147525572e-03
GC_6_62 ref NI_6 NS_62 0 -3.2111635990982250e-03
GC_6_63 ref NI_6 NS_63 0 -1.1750261230025318e-03
GC_6_64 ref NI_6 NS_64 0 2.6841954973726308e-03
GC_6_65 ref NI_6 NS_65 0 3.3978973080168277e-06
GC_6_66 ref NI_6 NS_66 0 -2.5034107453785325e-03
GC_6_67 ref NI_6 NS_67 0 -1.8948305391044301e-04
GC_6_68 ref NI_6 NS_68 0 2.4074209589086413e-03
GC_6_69 ref NI_6 NS_69 0 -2.8869984302134720e-03
GC_6_70 ref NI_6 NS_70 0 -1.9137757262335663e-03
GC_6_71 ref NI_6 NS_71 0 2.0425944250039353e-03
GC_6_72 ref NI_6 NS_72 0 1.8200633212698948e-03
GC_6_73 ref NI_6 NS_73 0 8.2873284806584530e-04
GC_6_74 ref NI_6 NS_74 0 -1.3677405343527434e-03
GC_6_75 ref NI_6 NS_75 0 -2.2807135975834044e-03
GC_6_76 ref NI_6 NS_76 0 2.8631722875659777e-03
GC_6_77 ref NI_6 NS_77 0 -3.2603389341423451e-04
GC_6_78 ref NI_6 NS_78 0 -2.4757017898526835e-03
GC_6_79 ref NI_6 NS_79 0 6.0817874618036307e-04
GC_6_80 ref NI_6 NS_80 0 2.1977307402693928e-03
GC_6_81 ref NI_6 NS_81 0 8.3930013454423672e-04
GC_6_82 ref NI_6 NS_82 0 -3.8186364838154185e-03
GC_6_83 ref NI_6 NS_83 0 1.6901650648490857e-03
GC_6_84 ref NI_6 NS_84 0 1.9904500289118512e-03
GC_6_85 ref NI_6 NS_85 0 8.2926379214360094e-04
GC_6_86 ref NI_6 NS_86 0 -4.3791577464887630e-03
GC_6_87 ref NI_6 NS_87 0 2.3326242015059341e-03
GC_6_88 ref NI_6 NS_88 0 1.8723268807764107e-03
GD_6_1 ref NI_6 NA_1 0 -3.0866747587269161e-01
GD_6_2 ref NI_6 NA_2 0 3.0030813793049160e-01
GD_6_3 ref NI_6 NA_3 0 8.7011227304552033e-02
GD_6_4 ref NI_6 NA_4 0 7.3860735767350097e-02
GD_6_5 ref NI_6 NA_5 0 -9.1676941819855307e-02
GD_6_6 ref NI_6 NA_6 0 5.7917021603946290e+00
GD_6_7 ref NI_6 NA_7 0 2.7823141677943256e-02
GD_6_8 ref NI_6 NA_8 0 3.0797347156370537e-02
GD_6_9 ref NI_6 NA_9 0 -4.2695744700364992e-03
GD_6_10 ref NI_6 NA_10 0 2.4963151018252517e-02
GD_6_11 ref NI_6 NA_11 0 1.3815214274564539e-02
GD_6_12 ref NI_6 NA_12 0 2.2245703991897851e-02
GD_6_13 ref NI_6 NA_13 0 2.4606550706451600e-02
GD_6_14 ref NI_6 NA_14 0 2.4044199133912456e-02
GD_6_15 ref NI_6 NA_15 0 7.5992989354388776e-04
GD_6_16 ref NI_6 NA_16 0 3.2773976861855732e-04
GD_6_17 ref NI_6 NA_17 0 1.0452195044491672e-02
GD_6_18 ref NI_6 NA_18 0 1.6598344958885687e-02
GD_6_19 ref NI_6 NA_19 0 6.4154965838467580e-03
GD_6_20 ref NI_6 NA_20 0 8.0739010201958880e-03
GD_6_21 ref NI_6 NA_21 0 2.7878617194367177e-03
GD_6_22 ref NI_6 NA_22 0 3.3511568213449626e-03
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 3.6372786265592122e-02
GC_7_2 ref NI_7 NS_2 0 4.6637213302616956e-04
GC_7_3 ref NI_7 NS_3 0 -2.7948341919784418e-03
GC_7_4 ref NI_7 NS_4 0 4.8955428941267537e-04
GC_7_5 ref NI_7 NS_5 0 2.8915056896065029e-02
GC_7_6 ref NI_7 NS_6 0 -9.0876870722781289e-04
GC_7_7 ref NI_7 NS_7 0 -7.0081135431999866e-04
GC_7_8 ref NI_7 NS_8 0 3.3586719839504519e-04
GC_7_9 ref NI_7 NS_9 0 -1.8519037447215697e-02
GC_7_10 ref NI_7 NS_10 0 1.2708226352004528e-02
GC_7_11 ref NI_7 NS_11 0 2.7456588434438618e-03
GC_7_12 ref NI_7 NS_12 0 6.4745823275107173e-04
GC_7_13 ref NI_7 NS_13 0 -1.7111557610374643e-02
GC_7_14 ref NI_7 NS_14 0 9.5230293844815895e-03
GC_7_15 ref NI_7 NS_15 0 3.7566117147395648e-03
GC_7_16 ref NI_7 NS_16 0 6.4394731027707884e-04
GC_7_17 ref NI_7 NS_17 0 -1.7561816379733787e-02
GC_7_18 ref NI_7 NS_18 0 9.5291718824533616e-03
GC_7_19 ref NI_7 NS_19 0 3.8746716104373800e-03
GC_7_20 ref NI_7 NS_20 0 6.2775050978024509e-04
GC_7_21 ref NI_7 NS_21 0 -1.8601313789914767e-02
GC_7_22 ref NI_7 NS_22 0 1.4479307248215124e-02
GC_7_23 ref NI_7 NS_23 0 2.2306797084780052e-03
GC_7_24 ref NI_7 NS_24 0 5.8864887318952838e-04
GC_7_25 ref NI_7 NS_25 0 1.7718793607326224e-02
GC_7_26 ref NI_7 NS_26 0 -2.6733893468339082e-01
GC_7_27 ref NI_7 NS_27 0 -1.2244779507694762e-02
GC_7_28 ref NI_7 NS_28 0 -2.4049583458570552e-03
GC_7_29 ref NI_7 NS_29 0 2.1263607905937930e-03
GC_7_30 ref NI_7 NS_30 0 3.7470219529568104e-02
GC_7_31 ref NI_7 NS_31 0 -9.8797097739648874e-03
GC_7_32 ref NI_7 NS_32 0 -1.0920082351399102e-04
GC_7_33 ref NI_7 NS_33 0 5.3726095157828752e-03
GC_7_34 ref NI_7 NS_34 0 -1.2134151435715062e-02
GC_7_35 ref NI_7 NS_35 0 9.3378988948454832e-03
GC_7_36 ref NI_7 NS_36 0 4.1678499168723831e-04
GC_7_37 ref NI_7 NS_37 0 6.4459788962468900e-02
GC_7_38 ref NI_7 NS_38 0 2.2963404101958809e-02
GC_7_39 ref NI_7 NS_39 0 -1.5768554814323151e-02
GC_7_40 ref NI_7 NS_40 0 -1.8906887756148393e-04
GC_7_41 ref NI_7 NS_41 0 -7.6634282453016626e-03
GC_7_42 ref NI_7 NS_42 0 1.4612592115801721e-02
GC_7_43 ref NI_7 NS_43 0 1.4018638744512342e-03
GC_7_44 ref NI_7 NS_44 0 8.2571656184791338e-05
GC_7_45 ref NI_7 NS_45 0 1.2989847955203177e-04
GC_7_46 ref NI_7 NS_46 0 2.6842489339382627e-02
GC_7_47 ref NI_7 NS_47 0 -5.2248729084119691e-03
GC_7_48 ref NI_7 NS_48 0 -1.3924844673725779e-05
GC_7_49 ref NI_7 NS_49 0 1.2115343076102037e-02
GC_7_50 ref NI_7 NS_50 0 4.3070123109689960e-02
GC_7_51 ref NI_7 NS_51 0 -1.3955180329031300e-02
GC_7_52 ref NI_7 NS_52 0 -3.4329430860012501e-04
GC_7_53 ref NI_7 NS_53 0 -1.8154309774133130e-02
GC_7_54 ref NI_7 NS_54 0 2.7095866319767209e-02
GC_7_55 ref NI_7 NS_55 0 -1.2036860112356071e-03
GC_7_56 ref NI_7 NS_56 0 -1.6181197663989245e-04
GC_7_57 ref NI_7 NS_57 0 1.0834657035369028e-03
GC_7_58 ref NI_7 NS_58 0 -5.6081077013308660e-03
GC_7_59 ref NI_7 NS_59 0 7.6395423105625592e-03
GC_7_60 ref NI_7 NS_60 0 3.0007887211618809e-04
GC_7_61 ref NI_7 NS_61 0 -2.1927267699306877e-03
GC_7_62 ref NI_7 NS_62 0 -3.6263187632670541e-03
GC_7_63 ref NI_7 NS_63 0 8.4737587096818511e-03
GC_7_64 ref NI_7 NS_64 0 -2.0535224014555850e-05
GC_7_65 ref NI_7 NS_65 0 -1.8197707450438971e-02
GC_7_66 ref NI_7 NS_66 0 1.6644883609349161e-02
GC_7_67 ref NI_7 NS_67 0 3.7240319307467354e-03
GC_7_68 ref NI_7 NS_68 0 -3.8345479333963984e-04
GC_7_69 ref NI_7 NS_69 0 -1.9786804135074960e-02
GC_7_70 ref NI_7 NS_70 0 3.6373363751617871e-02
GC_7_71 ref NI_7 NS_71 0 -4.2043570796651683e-03
GC_7_72 ref NI_7 NS_72 0 -4.8922547265918613e-04
GC_7_73 ref NI_7 NS_73 0 -3.7627329807956738e-03
GC_7_74 ref NI_7 NS_74 0 -4.3047773373867636e-03
GC_7_75 ref NI_7 NS_75 0 9.5339939829459253e-03
GC_7_76 ref NI_7 NS_76 0 -2.0796155107192225e-04
GC_7_77 ref NI_7 NS_77 0 -1.1420716250890160e-02
GC_7_78 ref NI_7 NS_78 0 1.7804794633930140e-02
GC_7_79 ref NI_7 NS_79 0 1.4878669880391555e-03
GC_7_80 ref NI_7 NS_80 0 -1.4772689176329411e-04
GC_7_81 ref NI_7 NS_81 0 -4.3580878952263532e-03
GC_7_82 ref NI_7 NS_82 0 4.8391950387020391e-03
GC_7_83 ref NI_7 NS_83 0 4.6563953715838113e-03
GC_7_84 ref NI_7 NS_84 0 1.7098565453939232e-04
GC_7_85 ref NI_7 NS_85 0 -1.8772107076101567e-03
GC_7_86 ref NI_7 NS_86 0 -1.5134316783981354e-03
GC_7_87 ref NI_7 NS_87 0 6.6235678097898770e-03
GC_7_88 ref NI_7 NS_88 0 2.7731463823912628e-04
GD_7_1 ref NI_7 NA_1 0 -4.9566673267091930e-02
GD_7_2 ref NI_7 NA_2 0 1.1955713518886133e-02
GD_7_3 ref NI_7 NA_3 0 3.3385670891757341e-02
GD_7_4 ref NI_7 NA_4 0 3.9649100994335267e-02
GD_7_5 ref NI_7 NA_5 0 4.2946399941218585e-02
GD_7_6 ref NI_7 NA_6 0 2.7823141677944890e-02
GD_7_7 ref NI_7 NA_7 0 5.9914651374726793e+00
GD_7_8 ref NI_7 NA_8 0 -1.6025793561775133e-02
GD_7_9 ref NI_7 NA_9 0 -3.2760020416988719e-03
GD_7_10 ref NI_7 NA_10 0 -1.4883812969054042e-01
GD_7_11 ref NI_7 NA_11 0 1.9377839137623216e-02
GD_7_12 ref NI_7 NA_12 0 -2.0411720057915148e-03
GD_7_13 ref NI_7 NA_13 0 -1.5814844505743837e-02
GD_7_14 ref NI_7 NA_14 0 4.2143570700742768e-02
GD_7_15 ref NI_7 NA_15 0 8.0844968506332462e-03
GD_7_16 ref NI_7 NA_16 0 1.6153008314845244e-02
GD_7_17 ref NI_7 NA_17 0 6.3335933660782301e-02
GD_7_18 ref NI_7 NA_18 0 5.9348038498263901e-02
GD_7_19 ref NI_7 NA_19 0 2.8662601367383977e-02
GD_7_20 ref NI_7 NA_20 0 2.3688332280182044e-02
GD_7_21 ref NI_7 NA_21 0 1.5205542917998478e-02
GD_7_22 ref NI_7 NA_22 0 9.4786653583733456e-03
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 3.2292843751048954e-02
GC_8_2 ref NI_8 NS_2 0 6.3115060050123965e-03
GC_8_3 ref NI_8 NS_3 0 -2.6380185106122393e-03
GC_8_4 ref NI_8 NS_4 0 -4.0707310119588756e-05
GC_8_5 ref NI_8 NS_5 0 2.8439944698959021e-02
GC_8_6 ref NI_8 NS_6 0 1.7918592551506105e-03
GC_8_7 ref NI_8 NS_7 0 -3.1052412059724742e-04
GC_8_8 ref NI_8 NS_8 0 -1.4145148628627577e-04
GC_8_9 ref NI_8 NS_9 0 -1.8899551303639482e-02
GC_8_10 ref NI_8 NS_10 0 1.0790651062540469e-02
GC_8_11 ref NI_8 NS_11 0 5.5542207589055950e-03
GC_8_12 ref NI_8 NS_12 0 5.2984001563511588e-05
GC_8_13 ref NI_8 NS_13 0 -1.6605384007641243e-02
GC_8_14 ref NI_8 NS_14 0 6.7556085947754127e-03
GC_8_15 ref NI_8 NS_15 0 6.7317187962097026e-03
GC_8_16 ref NI_8 NS_16 0 5.7353007255169316e-05
GC_8_17 ref NI_8 NS_17 0 -1.6925838815619616e-02
GC_8_18 ref NI_8 NS_18 0 6.6063009381931246e-03
GC_8_19 ref NI_8 NS_19 0 6.9444534310735325e-03
GC_8_20 ref NI_8 NS_20 0 2.5321832649579856e-05
GC_8_21 ref NI_8 NS_21 0 -1.9727932319765485e-02
GC_8_22 ref NI_8 NS_22 0 1.3458635853330179e-02
GC_8_23 ref NI_8 NS_23 0 4.7758466419250091e-03
GC_8_24 ref NI_8 NS_24 0 1.0698002217210732e-06
GC_8_25 ref NI_8 NS_25 0 2.1263607905935762e-03
GC_8_26 ref NI_8 NS_26 0 3.7470219529568416e-02
GC_8_27 ref NI_8 NS_27 0 -9.8797097739650713e-03
GC_8_28 ref NI_8 NS_28 0 -1.0920082351393274e-04
GC_8_29 ref NI_8 NS_29 0 1.0557864628377507e-01
GC_8_30 ref NI_8 NS_30 0 -2.6363284465772646e-01
GC_8_31 ref NI_8 NS_31 0 -3.6275742241392100e-02
GC_8_32 ref NI_8 NS_32 0 -1.1932201915076451e-03
GC_8_33 ref NI_8 NS_33 0 -5.2897683663012353e-03
GC_8_34 ref NI_8 NS_34 0 -4.6045399522456898e-03
GC_8_35 ref NI_8 NS_35 0 9.4100784709017712e-03
GC_8_36 ref NI_8 NS_36 0 -1.2761199802142161e-05
GC_8_37 ref NI_8 NS_37 0 -1.5805276319770443e-02
GC_8_38 ref NI_8 NS_38 0 3.0922295254689706e-02
GC_8_39 ref NI_8 NS_39 0 -3.7682475013701058e-03
GC_8_40 ref NI_8 NS_40 0 -2.4641026569276019e-05
GC_8_41 ref NI_8 NS_41 0 -1.6311199695859979e-02
GC_8_42 ref NI_8 NS_42 0 3.6806652649704785e-02
GC_8_43 ref NI_8 NS_43 0 -4.9618868880449279e-03
GC_8_44 ref NI_8 NS_44 0 -4.2456732978172123e-04
GC_8_45 ref NI_8 NS_45 0 1.8418664601218011e-02
GC_8_46 ref NI_8 NS_46 0 4.4261115403325828e-02
GC_8_47 ref NI_8 NS_47 0 -1.5899884731647211e-02
GC_8_48 ref NI_8 NS_48 0 -1.6103125781704455e-04
GC_8_49 ref NI_8 NS_49 0 -1.7806833651663304e-02
GC_8_50 ref NI_8 NS_50 0 2.2764449589525643e-02
GC_8_51 ref NI_8 NS_51 0 -2.2434240980157748e-04
GC_8_52 ref NI_8 NS_52 0 7.2894770622206019e-05
GC_8_53 ref NI_8 NS_53 0 -2.9555335846923391e-02
GC_8_54 ref NI_8 NS_54 0 5.8891767483448487e-02
GC_8_55 ref NI_8 NS_55 0 -1.0870430149291925e-02
GC_8_56 ref NI_8 NS_56 0 -7.5553035587730096e-04
GC_8_57 ref NI_8 NS_57 0 -3.1465108686470344e-03
GC_8_58 ref NI_8 NS_58 0 -3.1036991206245053e-03
GC_8_59 ref NI_8 NS_59 0 7.7856043490308726e-03
GC_8_60 ref NI_8 NS_60 0 1.7050437216683959e-04
GC_8_61 ref NI_8 NS_61 0 7.7101874004994455e-03
GC_8_62 ref NI_8 NS_62 0 -1.2847087905458344e-02
GC_8_63 ref NI_8 NS_63 0 8.7483125896515093e-03
GC_8_64 ref NI_8 NS_64 0 5.7038136741551773e-04
GC_8_65 ref NI_8 NS_65 0 2.9401570895663301e-03
GC_8_66 ref NI_8 NS_66 0 -8.3440236808432731e-03
GC_8_67 ref NI_8 NS_67 0 7.3485862725087437e-03
GC_8_68 ref NI_8 NS_68 0 6.6218420808140173e-04
GC_8_69 ref NI_8 NS_69 0 -9.4469232378781732e-03
GC_8_70 ref NI_8 NS_70 0 4.5272325508934801e-03
GC_8_71 ref NI_8 NS_71 0 5.1255153498378165e-03
GC_8_72 ref NI_8 NS_72 0 3.5494275703579925e-04
GC_8_73 ref NI_8 NS_73 0 1.4146190649132945e-02
GC_8_74 ref NI_8 NS_74 0 -1.8166737130352811e-02
GC_8_75 ref NI_8 NS_75 0 8.6757412529573710e-03
GC_8_76 ref NI_8 NS_76 0 9.3233643446531352e-04
GC_8_77 ref NI_8 NS_77 0 -4.9686580458782360e-03
GC_8_78 ref NI_8 NS_78 0 2.8643183658617006e-03
GC_8_79 ref NI_8 NS_79 0 5.1489663288851887e-03
GC_8_80 ref NI_8 NS_80 0 3.2834816433782526e-04
GC_8_81 ref NI_8 NS_81 0 -1.2249153189915377e-02
GC_8_82 ref NI_8 NS_82 0 1.2198963359485870e-02
GC_8_83 ref NI_8 NS_83 0 3.7248745414673015e-03
GC_8_84 ref NI_8 NS_84 0 -4.4810203410638979e-05
GC_8_85 ref NI_8 NS_85 0 -1.5809995092933949e-02
GC_8_86 ref NI_8 NS_86 0 1.3417432163011458e-02
GC_8_87 ref NI_8 NS_87 0 4.3991546371278598e-03
GC_8_88 ref NI_8 NS_88 0 -2.1991518394452744e-04
GD_8_1 ref NI_8 NA_1 0 -6.1168562716017075e-02
GD_8_2 ref NI_8 NA_2 0 1.6008220254535181e-02
GD_8_3 ref NI_8 NA_3 0 3.5053637747670896e-02
GD_8_4 ref NI_8 NA_4 0 3.9985479058703435e-02
GD_8_5 ref NI_8 NA_5 0 4.2692984877131704e-02
GD_8_6 ref NI_8 NA_6 0 3.0797347156374822e-02
GD_8_7 ref NI_8 NA_7 0 -1.6025793561774585e-02
GD_8_8 ref NI_8 NA_8 0 5.8530491255954891e+00
GD_8_9 ref NI_8 NA_9 0 3.2387207428245156e-02
GD_8_10 ref NI_8 NA_10 0 3.0926854367127072e-02
GD_8_11 ref NI_8 NA_11 0 3.5816421270765356e-02
GD_8_12 ref NI_8 NA_12 0 -5.6804758400323944e-02
GD_8_13 ref NI_8 NA_13 0 4.5075052324307294e-02
GD_8_14 ref NI_8 NA_14 0 5.7938492267302050e-02
GD_8_15 ref NI_8 NA_15 0 2.1386629970869212e-02
GD_8_16 ref NI_8 NA_16 0 -1.3315226623149469e-02
GD_8_17 ref NI_8 NA_17 0 2.0456082307131729e-03
GD_8_18 ref NI_8 NA_18 0 3.3450827990170739e-02
GD_8_19 ref NI_8 NA_19 0 -3.1928821486261943e-02
GD_8_20 ref NI_8 NA_20 0 1.6053901588556935e-02
GD_8_21 ref NI_8 NA_21 0 3.2586336272780132e-02
GD_8_22 ref NI_8 NA_22 0 4.4420975422582630e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -1.0450294014880486e-03
GC_9_2 ref NI_9 NS_2 0 -2.3134886506268357e-03
GC_9_3 ref NI_9 NS_3 0 2.8641232251574522e-03
GC_9_4 ref NI_9 NS_4 0 1.5226275839015518e-03
GC_9_5 ref NI_9 NS_5 0 1.4967125050170712e-03
GC_9_6 ref NI_9 NS_6 0 -3.3826298664314672e-03
GC_9_7 ref NI_9 NS_7 0 2.5588397993365451e-03
GC_9_8 ref NI_9 NS_8 0 1.6161115239206967e-03
GC_9_9 ref NI_9 NS_9 0 4.1980600425914547e-03
GC_9_10 ref NI_9 NS_10 0 -5.7192531980521481e-03
GC_9_11 ref NI_9 NS_11 0 1.4252252492894432e-04
GC_9_12 ref NI_9 NS_12 0 2.5176041097514342e-03
GC_9_13 ref NI_9 NS_13 0 4.7419314426007057e-03
GC_9_14 ref NI_9 NS_14 0 -5.7364540844650706e-03
GC_9_15 ref NI_9 NS_15 0 -2.2846404933176022e-04
GC_9_16 ref NI_9 NS_16 0 2.6027833508011420e-03
GC_9_17 ref NI_9 NS_17 0 5.2147411055498806e-03
GC_9_18 ref NI_9 NS_18 0 -6.1380336901714775e-03
GC_9_19 ref NI_9 NS_19 0 -1.1111361966191949e-04
GC_9_20 ref NI_9 NS_20 0 2.5956412372263723e-03
GC_9_21 ref NI_9 NS_21 0 4.7206797535046642e-03
GC_9_22 ref NI_9 NS_22 0 -6.4723184234641859e-03
GC_9_23 ref NI_9 NS_23 0 7.5077589587901471e-04
GC_9_24 ref NI_9 NS_24 0 2.4015992668517893e-03
GC_9_25 ref NI_9 NS_25 0 5.3726095157829151e-03
GC_9_26 ref NI_9 NS_26 0 -1.2134151435715170e-02
GC_9_27 ref NI_9 NS_27 0 9.3378988948455612e-03
GC_9_28 ref NI_9 NS_28 0 4.1678499168721088e-04
GC_9_29 ref NI_9 NS_29 0 -5.2897683663002222e-03
GC_9_30 ref NI_9 NS_30 0 -4.6045399522463880e-03
GC_9_31 ref NI_9 NS_31 0 9.4100784709019829e-03
GC_9_32 ref NI_9 NS_32 0 -1.2761199802183696e-05
GC_9_33 ref NI_9 NS_33 0 -2.3508470492439579e-02
GC_9_34 ref NI_9 NS_34 0 -1.8020823756945550e-01
GC_9_35 ref NI_9 NS_35 0 -3.6008521301503428e-02
GC_9_36 ref NI_9 NS_36 0 -4.3392767230290554e-03
GC_9_37 ref NI_9 NS_37 0 -6.6803086334900038e-04
GC_9_38 ref NI_9 NS_38 0 -6.7830993362728593e-03
GC_9_39 ref NI_9 NS_39 0 9.2319670964472276e-03
GC_9_40 ref NI_9 NS_40 0 7.2857014217516362e-05
GC_9_41 ref NI_9 NS_41 0 -5.8541353144836883e-02
GC_9_42 ref NI_9 NS_42 0 6.5262488692248502e-02
GC_9_43 ref NI_9 NS_43 0 -5.5003834574777026e-03
GC_9_44 ref NI_9 NS_44 0 -1.5360310483760555e-03
GC_9_45 ref NI_9 NS_45 0 -2.7691691550607914e-02
GC_9_46 ref NI_9 NS_46 0 2.2554199670769125e-02
GC_9_47 ref NI_9 NS_47 0 4.6589819679670489e-03
GC_9_48 ref NI_9 NS_48 0 -8.7279636542829592e-04
GC_9_49 ref NI_9 NS_49 0 2.0547577217433548e-02
GC_9_50 ref NI_9 NS_50 0 -2.3640597796919668e-02
GC_9_51 ref NI_9 NS_51 0 9.8026739941671753e-03
GC_9_52 ref NI_9 NS_52 0 9.5922384931845968e-04
GC_9_53 ref NI_9 NS_53 0 -1.5644750684440635e-02
GC_9_54 ref NI_9 NS_54 0 1.7483845609083835e-03
GC_9_55 ref NI_9 NS_55 0 1.0062255782936954e-02
GC_9_56 ref NI_9 NS_56 0 -4.9747613309077707e-04
GC_9_57 ref NI_9 NS_57 0 4.5590309081428637e-02
GC_9_58 ref NI_9 NS_58 0 6.5938248706595606e-02
GC_9_59 ref NI_9 NS_59 0 -2.3715261416449526e-02
GC_9_60 ref NI_9 NS_60 0 -2.5330638357510212e-03
GC_9_61 ref NI_9 NS_61 0 -2.5447774923850853e-02
GC_9_62 ref NI_9 NS_62 0 2.1848762022101245e-02
GC_9_63 ref NI_9 NS_63 0 5.4202872510856264e-03
GC_9_64 ref NI_9 NS_64 0 -1.1338580385313671e-03
GC_9_65 ref NI_9 NS_65 0 2.0208510811952358e-02
GC_9_66 ref NI_9 NS_66 0 -2.3788066072981586e-02
GC_9_67 ref NI_9 NS_67 0 1.1145689408355640e-02
GC_9_68 ref NI_9 NS_68 0 5.6660955763755282e-04
GC_9_69 ref NI_9 NS_69 0 2.3680167923592135e-02
GC_9_70 ref NI_9 NS_70 0 -2.6272815814544749e-02
GC_9_71 ref NI_9 NS_71 0 1.0707596210169753e-02
GC_9_72 ref NI_9 NS_72 0 8.4735285789465679e-04
GC_9_73 ref NI_9 NS_73 0 1.4758410610765847e-02
GC_9_74 ref NI_9 NS_74 0 -1.9333311002029219e-02
GC_9_75 ref NI_9 NS_75 0 1.1177569430818872e-02
GC_9_76 ref NI_9 NS_76 0 2.6171518829130495e-04
GC_9_77 ref NI_9 NS_77 0 -1.2972869402867711e-02
GC_9_78 ref NI_9 NS_78 0 5.4161039334780399e-03
GC_9_79 ref NI_9 NS_79 0 8.8015787894467571e-03
GC_9_80 ref NI_9 NS_80 0 -7.0968983572516388e-04
GC_9_81 ref NI_9 NS_81 0 -5.3539044959593884e-02
GC_9_82 ref NI_9 NS_82 0 7.3869748717051389e-02
GC_9_83 ref NI_9 NS_83 0 -8.0717003773021680e-03
GC_9_84 ref NI_9 NS_84 0 -2.2166220048596840e-03
GC_9_85 ref NI_9 NS_85 0 7.3272924423261138e-02
GC_9_86 ref NI_9 NS_86 0 7.1473285169085340e-02
GC_9_87 ref NI_9 NS_87 0 -3.3237228906631409e-02
GC_9_88 ref NI_9 NS_88 0 -2.3736067021385243e-03
GD_9_1 ref NI_9 NA_1 0 1.1308504218373263e-02
GD_9_2 ref NI_9 NA_2 0 5.5100772909163253e-03
GD_9_3 ref NI_9 NA_3 0 -1.9034418098396576e-03
GD_9_4 ref NI_9 NA_4 0 -4.2286078973859925e-03
GD_9_5 ref NI_9 NA_5 0 -5.8559494104738754e-03
GD_9_6 ref NI_9 NA_6 0 -4.2695744700284605e-03
GD_9_7 ref NI_9 NA_7 0 -3.2760020416986902e-03
GD_9_8 ref NI_9 NA_8 0 3.2387207428239972e-02
GD_9_9 ref NI_9 NA_9 0 6.0919327366233516e+00
GD_9_10 ref NI_9 NA_10 0 1.4969784423833744e-02
GD_9_11 ref NI_9 NA_11 0 1.1092883366478289e-01
GD_9_12 ref NI_9 NA_12 0 8.3590727035345078e-02
GD_9_13 ref NI_9 NA_13 0 -5.2648826340816905e-02
GD_9_14 ref NI_9 NA_14 0 6.8610090469426996e-02
GD_9_15 ref NI_9 NA_15 0 -6.5296704223143154e-02
GD_9_16 ref NI_9 NA_16 0 7.3153322171731525e-02
GD_9_17 ref NI_9 NA_17 0 -5.2136484549955189e-02
GD_9_18 ref NI_9 NA_18 0 -6.3410861940488464e-02
GD_9_19 ref NI_9 NA_19 0 -3.4146085510720868e-02
GD_9_20 ref NI_9 NA_20 0 4.3196045499964419e-02
GD_9_21 ref NI_9 NA_21 0 1.2074403650099688e-01
GD_9_22 ref NI_9 NA_22 0 -6.6354501912318495e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 5.4738207764569316e-03
GC_10_2 ref NI_10 NS_2 0 8.9405219354824674e-03
GC_10_3 ref NI_10 NS_3 0 -9.9937391299468074e-04
GC_10_4 ref NI_10 NS_4 0 8.0755900993608452e-04
GC_10_5 ref NI_10 NS_5 0 8.0926457200588692e-03
GC_10_6 ref NI_10 NS_6 0 3.5780566508641603e-03
GC_10_7 ref NI_10 NS_7 0 5.6203119021086859e-04
GC_10_8 ref NI_10 NS_8 0 7.7638281513294763e-04
GC_10_9 ref NI_10 NS_9 0 -8.5870477948403485e-03
GC_10_10 ref NI_10 NS_10 0 2.2704410227929440e-03
GC_10_11 ref NI_10 NS_11 0 3.1329849838689964e-03
GC_10_12 ref NI_10 NS_12 0 1.2809754737587347e-03
GC_10_13 ref NI_10 NS_13 0 -6.4697543618309969e-03
GC_10_14 ref NI_10 NS_14 0 -1.4399089324209656e-04
GC_10_15 ref NI_10 NS_15 0 3.5999712637376341e-03
GC_10_16 ref NI_10 NS_16 0 1.3201565987635512e-03
GC_10_17 ref NI_10 NS_17 0 -6.4524079036505462e-03
GC_10_18 ref NI_10 NS_18 0 -3.5326525598101445e-04
GC_10_19 ref NI_10 NS_19 0 3.7155761132047125e-03
GC_10_20 ref NI_10 NS_20 0 1.3098589184646105e-03
GC_10_21 ref NI_10 NS_21 0 -9.2091133127351222e-03
GC_10_22 ref NI_10 NS_22 0 3.4803855227183789e-03
GC_10_23 ref NI_10 NS_23 0 3.0124757467253523e-03
GC_10_24 ref NI_10 NS_24 0 1.2007877401969611e-03
GC_10_25 ref NI_10 NS_25 0 6.4459788962469761e-02
GC_10_26 ref NI_10 NS_26 0 2.2963404101958258e-02
GC_10_27 ref NI_10 NS_27 0 -1.5768554814323002e-02
GC_10_28 ref NI_10 NS_28 0 -1.8906887756150537e-04
GC_10_29 ref NI_10 NS_29 0 -1.5805276319770994e-02
GC_10_30 ref NI_10 NS_30 0 3.0922295254690039e-02
GC_10_31 ref NI_10 NS_31 0 -3.7682475013701825e-03
GC_10_32 ref NI_10 NS_32 0 -2.4641026569266955e-05
GC_10_33 ref NI_10 NS_33 0 -6.6803086334899268e-04
GC_10_34 ref NI_10 NS_34 0 -6.7830993362729399e-03
GC_10_35 ref NI_10 NS_35 0 9.2319670964473004e-03
GC_10_36 ref NI_10 NS_36 0 7.2857014217489853e-05
GC_10_37 ref NI_10 NS_37 0 5.0182579341441207e-02
GC_10_38 ref NI_10 NS_38 0 -2.8108685734979294e-01
GC_10_39 ref NI_10 NS_39 0 -1.5588365479632448e-02
GC_10_40 ref NI_10 NS_40 0 -1.6465022170460515e-03
GC_10_41 ref NI_10 NS_41 0 -6.7205360466300905e-03
GC_10_42 ref NI_10 NS_42 0 9.1465941169252361e-03
GC_10_43 ref NI_10 NS_43 0 3.6495479296909622e-03
GC_10_44 ref NI_10 NS_44 0 5.0284196302518066e-05
GC_10_45 ref NI_10 NS_45 0 2.3748901840525312e-03
GC_10_46 ref NI_10 NS_46 0 2.3694914206440557e-02
GC_10_47 ref NI_10 NS_47 0 -4.2321763872776872e-03
GC_10_48 ref NI_10 NS_48 0 -4.0739236903517966e-05
GC_10_49 ref NI_10 NS_49 0 -2.2527091830160533e-02
GC_10_50 ref NI_10 NS_50 0 4.1530811792767269e-02
GC_10_51 ref NI_10 NS_51 0 -5.6255209999440704e-03
GC_10_52 ref NI_10 NS_52 0 -5.6655392883205849e-04
GC_10_53 ref NI_10 NS_53 0 -1.5122797463410862e-02
GC_10_54 ref NI_10 NS_54 0 1.5318059806424738e-02
GC_10_55 ref NI_10 NS_55 0 2.6798057880983665e-03
GC_10_56 ref NI_10 NS_56 0 2.6366834678436029e-05
GC_10_57 ref NI_10 NS_57 0 -3.6929278624257410e-03
GC_10_58 ref NI_10 NS_58 0 4.6510657015159211e-03
GC_10_59 ref NI_10 NS_59 0 5.4383156158407595e-03
GC_10_60 ref NI_10 NS_60 0 -1.3681796894241858e-04
GC_10_61 ref NI_10 NS_61 0 -1.3938147889309893e-02
GC_10_62 ref NI_10 NS_62 0 1.8254772490505604e-02
GC_10_63 ref NI_10 NS_63 0 3.6191387371137377e-03
GC_10_64 ref NI_10 NS_64 0 -7.3281729431369589e-04
GC_10_65 ref NI_10 NS_65 0 -1.6795307842605935e-02
GC_10_66 ref NI_10 NS_66 0 2.4393293919278438e-02
GC_10_67 ref NI_10 NS_67 0 1.7037768291516989e-03
GC_10_68 ref NI_10 NS_68 0 -9.1147469405768384e-04
GC_10_69 ref NI_10 NS_69 0 -1.5939472572513522e-02
GC_10_70 ref NI_10 NS_70 0 3.4088679421537170e-02
GC_10_71 ref NI_10 NS_71 0 -2.9543907542740355e-03
GC_10_72 ref NI_10 NS_72 0 -8.3268951660939844e-04
GC_10_73 ref NI_10 NS_73 0 -1.6624357895255737e-02
GC_10_74 ref NI_10 NS_74 0 1.0772259657201189e-02
GC_10_75 ref NI_10 NS_75 0 7.8856939703309120e-03
GC_10_76 ref NI_10 NS_76 0 -9.8667942876269187e-04
GC_10_77 ref NI_10 NS_77 0 3.6703330282935959e-02
GC_10_78 ref NI_10 NS_78 0 2.3832446806450729e-02
GC_10_79 ref NI_10 NS_79 0 -9.1412471616347784e-03
GC_10_80 ref NI_10 NS_80 0 -5.7042158199806659e-04
GC_10_81 ref NI_10 NS_81 0 -1.7356937184211127e-03
GC_10_82 ref NI_10 NS_82 0 1.2140847497007345e-02
GC_10_83 ref NI_10 NS_83 0 1.7798134758082260e-03
GC_10_84 ref NI_10 NS_84 0 -1.1246822880014027e-04
GC_10_85 ref NI_10 NS_85 0 -3.5459991192776049e-03
GC_10_86 ref NI_10 NS_86 0 -9.2250224586780242e-04
GC_10_87 ref NI_10 NS_87 0 7.4082548687223852e-03
GC_10_88 ref NI_10 NS_88 0 3.6107725871858326e-05
GD_10_1 ref NI_10 NA_1 0 -1.3116111819849736e-02
GD_10_2 ref NI_10 NA_2 0 1.5985603439479901e-02
GD_10_3 ref NI_10 NA_3 0 2.6691526450840223e-02
GD_10_4 ref NI_10 NA_4 0 2.5040930048806566e-02
GD_10_5 ref NI_10 NA_5 0 2.6011930282701920e-02
GD_10_6 ref NI_10 NA_6 0 2.4963151018252132e-02
GD_10_7 ref NI_10 NA_7 0 -1.4883812969054494e-01
GD_10_8 ref NI_10 NA_8 0 3.0926854367130205e-02
GD_10_9 ref NI_10 NA_9 0 1.4969784423834122e-02
GD_10_10 ref NI_10 NA_10 0 5.9648671966652564e+00
GD_10_11 ref NI_10 NA_11 0 2.1609795987844571e-02
GD_10_12 ref NI_10 NA_12 0 -6.0799478959961276e-03
GD_10_13 ref NI_10 NA_13 0 6.1300677618680910e-02
GD_10_14 ref NI_10 NA_14 0 4.2184635408276931e-02
GD_10_15 ref NI_10 NA_15 0 2.1347688789108293e-02
GD_10_16 ref NI_10 NA_16 0 3.4070444584747860e-02
GD_10_17 ref NI_10 NA_17 0 6.2299521473906258e-02
GD_10_18 ref NI_10 NA_18 0 5.7363943445639567e-02
GD_10_19 ref NI_10 NA_19 0 6.4037410640630260e-02
GD_10_20 ref NI_10 NA_20 0 -1.0289593706058649e-01
GD_10_21 ref NI_10 NA_21 0 1.2298351843054738e-02
GD_10_22 ref NI_10 NA_22 0 1.7411975784911844e-02
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 1.1978983646530141e-02
GC_11_2 ref NI_11 NS_2 0 5.2979245047359378e-03
GC_11_3 ref NI_11 NS_3 0 1.2962679954133221e-04
GC_11_4 ref NI_11 NS_4 0 5.6611401188895309e-04
GC_11_5 ref NI_11 NS_5 0 1.4435851780648896e-02
GC_11_6 ref NI_11 NS_6 0 1.8343069127341513e-04
GC_11_7 ref NI_11 NS_7 0 1.3392803706869709e-03
GC_11_8 ref NI_11 NS_8 0 5.4214893109119861e-04
GC_11_9 ref NI_11 NS_9 0 -7.0594548286524589e-03
GC_11_10 ref NI_11 NS_10 0 1.4335243161733668e-03
GC_11_11 ref NI_11 NS_11 0 4.1003016921097330e-03
GC_11_12 ref NI_11 NS_12 0 1.0489256714163039e-03
GC_11_13 ref NI_11 NS_13 0 -5.1411099621028172e-03
GC_11_14 ref NI_11 NS_14 0 -1.0576152634788176e-03
GC_11_15 ref NI_11 NS_15 0 4.6415863447373511e-03
GC_11_16 ref NI_11 NS_16 0 1.0846066454551263e-03
GC_11_17 ref NI_11 NS_17 0 -5.1460947314342052e-03
GC_11_18 ref NI_11 NS_18 0 -1.2917992445473680e-03
GC_11_19 ref NI_11 NS_19 0 4.7982436729910932e-03
GC_11_20 ref NI_11 NS_20 0 1.0663422222894909e-03
GC_11_21 ref NI_11 NS_21 0 -7.4612766125886631e-03
GC_11_22 ref NI_11 NS_22 0 2.7367388401106562e-03
GC_11_23 ref NI_11 NS_23 0 3.9257299136548178e-03
GC_11_24 ref NI_11 NS_24 0 9.6113505712527262e-04
GC_11_25 ref NI_11 NS_25 0 -7.6634282453026323e-03
GC_11_26 ref NI_11 NS_26 0 1.4612592115802289e-02
GC_11_27 ref NI_11 NS_27 0 1.4018638744511236e-03
GC_11_28 ref NI_11 NS_28 0 8.2571656184798127e-05
GC_11_29 ref NI_11 NS_29 0 -1.6311199695861051e-02
GC_11_30 ref NI_11 NS_30 0 3.6806652649705431e-02
GC_11_31 ref NI_11 NS_31 0 -4.9618868880450702e-03
GC_11_32 ref NI_11 NS_32 0 -4.2456732978170757e-04
GC_11_33 ref NI_11 NS_33 0 -5.8541353144836578e-02
GC_11_34 ref NI_11 NS_34 0 6.5262488692248294e-02
GC_11_35 ref NI_11 NS_35 0 -5.5003834574776532e-03
GC_11_36 ref NI_11 NS_36 0 -1.5360310483760640e-03
GC_11_37 ref NI_11 NS_37 0 -6.7205360466314080e-03
GC_11_38 ref NI_11 NS_38 0 9.1465941169260948e-03
GC_11_39 ref NI_11 NS_39 0 3.6495479296907341e-03
GC_11_40 ref NI_11 NS_40 0 5.0284196302554068e-05
GC_11_41 ref NI_11 NS_41 0 5.7249730953136289e-03
GC_11_42 ref NI_11 NS_42 0 -2.5069959835032213e-01
GC_11_43 ref NI_11 NS_43 0 -1.7998400570711254e-02
GC_11_44 ref NI_11 NS_44 0 -2.2940998469739228e-03
GC_11_45 ref NI_11 NS_45 0 -2.2833227860455849e-03
GC_11_46 ref NI_11 NS_46 0 3.6219795983945570e-02
GC_11_47 ref NI_11 NS_47 0 -6.8366485093702637e-03
GC_11_48 ref NI_11 NS_48 0 -6.3349928942064363e-04
GC_11_49 ref NI_11 NS_49 0 2.1135878956327352e-04
GC_11_50 ref NI_11 NS_50 0 -2.3602363573419450e-03
GC_11_51 ref NI_11 NS_51 0 5.6932289204009879e-03
GC_11_52 ref NI_11 NS_52 0 5.8041871308270321e-04
GC_11_53 ref NI_11 NS_53 0 1.1107035460651192e-02
GC_11_54 ref NI_11 NS_54 0 6.1599298111474174e-02
GC_11_55 ref NI_11 NS_55 0 -2.0780929099751266e-02
GC_11_56 ref NI_11 NS_56 0 -6.6330044058468172e-04
GC_11_57 ref NI_11 NS_57 0 -3.6506786446995620e-02
GC_11_58 ref NI_11 NS_58 0 3.3874668356880654e-02
GC_11_59 ref NI_11 NS_59 0 1.9812790903235909e-03
GC_11_60 ref NI_11 NS_60 0 -1.0850086361639726e-03
GC_11_61 ref NI_11 NS_61 0 1.9788279158298614e-03
GC_11_62 ref NI_11 NS_62 0 -1.0006522866398516e-02
GC_11_63 ref NI_11 NS_63 0 1.0179121373014395e-02
GC_11_64 ref NI_11 NS_64 0 5.0476818407845382e-05
GC_11_65 ref NI_11 NS_65 0 1.6460529761323117e-02
GC_11_66 ref NI_11 NS_66 0 -1.9438398417116070e-02
GC_11_67 ref NI_11 NS_67 0 8.7885145933804965e-03
GC_11_68 ref NI_11 NS_68 0 9.4737880633708816e-04
GC_11_69 ref NI_11 NS_69 0 1.0296233474674409e-02
GC_11_70 ref NI_11 NS_70 0 -1.3803027862901378e-02
GC_11_71 ref NI_11 NS_71 0 7.9395653444486736e-03
GC_11_72 ref NI_11 NS_72 0 8.2252225026365302e-04
GC_11_73 ref NI_11 NS_73 0 2.0837425168966889e-02
GC_11_74 ref NI_11 NS_74 0 -2.3266427858849296e-02
GC_11_75 ref NI_11 NS_75 0 9.4023394711677151e-03
GC_11_76 ref NI_11 NS_76 0 1.0189617005911390e-03
GC_11_77 ref NI_11 NS_77 0 -1.5607116189300698e-04
GC_11_78 ref NI_11 NS_78 0 -4.3782964010801355e-03
GC_11_79 ref NI_11 NS_79 0 8.1325956926650341e-03
GC_11_80 ref NI_11 NS_80 0 7.5433007326597995e-05
GC_11_81 ref NI_11 NS_81 0 -2.0042264659539510e-02
GC_11_82 ref NI_11 NS_82 0 3.2039190468721807e-02
GC_11_83 ref NI_11 NS_83 0 -2.5619962265162175e-04
GC_11_84 ref NI_11 NS_84 0 -1.0643336551266862e-03
GC_11_85 ref NI_11 NS_85 0 8.4911202339451902e-02
GC_11_86 ref NI_11 NS_86 0 2.7236385524205080e-02
GC_11_87 ref NI_11 NS_87 0 -2.0346849017221950e-02
GC_11_88 ref NI_11 NS_88 0 -1.0740539092518391e-03
GD_11_1 ref NI_11 NA_1 0 -2.5389628498833007e-02
GD_11_2 ref NI_11 NA_2 0 2.6106781308488449e-02
GD_11_3 ref NI_11 NA_3 0 1.6701316255437859e-02
GD_11_4 ref NI_11 NA_4 0 1.6435253143344652e-02
GD_11_5 ref NI_11 NA_5 0 1.7399691593131494e-02
GD_11_6 ref NI_11 NA_6 0 1.3815214274552283e-02
GD_11_7 ref NI_11 NA_7 0 1.9377839137628666e-02
GD_11_8 ref NI_11 NA_8 0 3.5816421270771427e-02
GD_11_9 ref NI_11 NA_9 0 1.1092883366478141e-01
GD_11_10 ref NI_11 NA_10 0 2.1609795987851680e-02
GD_11_11 ref NI_11 NA_11 0 6.0386624721447841e+00
GD_11_12 ref NI_11 NA_12 0 4.7193538633937522e-03
GD_11_13 ref NI_11 NA_13 0 1.0014054197154296e-03
GD_11_14 ref NI_11 NA_14 0 -1.9320861058222644e-02
GD_11_15 ref NI_11 NA_15 0 1.0839324095407807e-01
GD_11_16 ref NI_11 NA_16 0 7.7112883929230302e-03
GD_11_17 ref NI_11 NA_17 0 -4.1988650713853486e-02
GD_11_18 ref NI_11 NA_18 0 -2.4815385353530135e-02
GD_11_19 ref NI_11 NA_19 0 -5.5416946250223663e-02
GD_11_20 ref NI_11 NA_20 0 8.3176822595553701e-03
GD_11_21 ref NI_11 NA_21 0 5.2020520625750827e-02
GD_11_22 ref NI_11 NA_22 0 -9.2457186604713526e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 1.2888015492268296e-02
GC_12_2 ref NI_12 NS_2 0 7.5564675871787742e-03
GC_12_3 ref NI_12 NS_3 0 -8.0519864895393163e-04
GC_12_4 ref NI_12 NS_4 0 4.7923443160020863e-04
GC_12_5 ref NI_12 NS_5 0 1.5200431622384296e-02
GC_12_6 ref NI_12 NS_6 0 1.7825329315995396e-03
GC_12_7 ref NI_12 NS_7 0 7.3460937871825597e-04
GC_12_8 ref NI_12 NS_8 0 4.3796665309750829e-04
GC_12_9 ref NI_12 NS_9 0 -1.0163663903023323e-02
GC_12_10 ref NI_12 NS_10 0 3.6491560248553736e-03
GC_12_11 ref NI_12 NS_11 0 4.2574490773182854e-03
GC_12_12 ref NI_12 NS_12 0 8.6625583998025302e-04
GC_12_13 ref NI_12 NS_13 0 -8.0361314898310717e-03
GC_12_14 ref NI_12 NS_14 0 7.9527197963107121e-04
GC_12_15 ref NI_12 NS_15 0 4.9329924806234948e-03
GC_12_16 ref NI_12 NS_16 0 8.9371649263310913e-04
GC_12_17 ref NI_12 NS_17 0 -8.1716692107786579e-03
GC_12_18 ref NI_12 NS_18 0 6.4181166164978894e-04
GC_12_19 ref NI_12 NS_19 0 5.0652250159179124e-03
GC_12_20 ref NI_12 NS_20 0 8.7874056036048472e-04
GC_12_21 ref NI_12 NS_21 0 -1.0798384861216931e-02
GC_12_22 ref NI_12 NS_22 0 5.3149523583085143e-03
GC_12_23 ref NI_12 NS_23 0 3.9303290017781867e-03
GC_12_24 ref NI_12 NS_24 0 7.9164424628331458e-04
GC_12_25 ref NI_12 NS_25 0 1.2989847955173953e-04
GC_12_26 ref NI_12 NS_26 0 2.6842489339382703e-02
GC_12_27 ref NI_12 NS_27 0 -5.2248729084119240e-03
GC_12_28 ref NI_12 NS_28 0 -1.3924844673753010e-05
GC_12_29 ref NI_12 NS_29 0 1.8418664601217504e-02
GC_12_30 ref NI_12 NS_30 0 4.4261115403326216e-02
GC_12_31 ref NI_12 NS_31 0 -1.5899884731647360e-02
GC_12_32 ref NI_12 NS_32 0 -1.6103125781700766e-04
GC_12_33 ref NI_12 NS_33 0 -2.7691691550607703e-02
GC_12_34 ref NI_12 NS_34 0 2.2554199670768844e-02
GC_12_35 ref NI_12 NS_35 0 4.6589819679672103e-03
GC_12_36 ref NI_12 NS_36 0 -8.7279636542834786e-04
GC_12_37 ref NI_12 NS_37 0 2.3748901840525099e-03
GC_12_38 ref NI_12 NS_38 0 2.3694914206440692e-02
GC_12_39 ref NI_12 NS_39 0 -4.2321763872778008e-03
GC_12_40 ref NI_12 NS_40 0 -4.0739236903476671e-05
GC_12_41 ref NI_12 NS_41 0 -2.2833227860452219e-03
GC_12_42 ref NI_12 NS_42 0 3.6219795983945563e-02
GC_12_43 ref NI_12 NS_43 0 -6.8366485093703964e-03
GC_12_44 ref NI_12 NS_44 0 -6.3349928942058097e-04
GC_12_45 ref NI_12 NS_45 0 6.5322562938811446e-02
GC_12_46 ref NI_12 NS_46 0 -2.8653854758421871e-01
GC_12_47 ref NI_12 NS_47 0 -1.7353384454967799e-02
GC_12_48 ref NI_12 NS_48 0 -1.4769455941765130e-03
GC_12_49 ref NI_12 NS_49 0 -1.2849273866223598e-02
GC_12_50 ref NI_12 NS_50 0 1.1326354933302788e-02
GC_12_51 ref NI_12 NS_51 0 3.3843767078734358e-03
GC_12_52 ref NI_12 NS_52 0 1.9123836520037733e-04
GC_12_53 ref NI_12 NS_53 0 -2.6938887755099609e-02
GC_12_54 ref NI_12 NS_54 0 4.4556221925270610e-02
GC_12_55 ref NI_12 NS_55 0 -5.6751797007858311e-03
GC_12_56 ref NI_12 NS_56 0 -6.2454151295418276e-04
GC_12_57 ref NI_12 NS_57 0 -1.3193859057632007e-02
GC_12_58 ref NI_12 NS_58 0 1.8886560872628296e-02
GC_12_59 ref NI_12 NS_59 0 2.1999389414428705e-03
GC_12_60 ref NI_12 NS_60 0 -4.7316927621942571e-04
GC_12_61 ref NI_12 NS_61 0 -4.0157875048256950e-03
GC_12_62 ref NI_12 NS_62 0 7.4045920442097392e-04
GC_12_63 ref NI_12 NS_63 0 6.9064900727587560e-03
GC_12_64 ref NI_12 NS_64 0 -1.7053261491742621e-05
GC_12_65 ref NI_12 NS_65 0 3.8721973749701070e-03
GC_12_66 ref NI_12 NS_66 0 -9.0764956676429882e-03
GC_12_67 ref NI_12 NS_67 0 8.1651652088726816e-03
GC_12_68 ref NI_12 NS_68 0 4.4119308486429261e-04
GC_12_69 ref NI_12 NS_69 0 -3.7594898962071831e-03
GC_12_70 ref NI_12 NS_70 0 -1.3877680379934987e-03
GC_12_71 ref NI_12 NS_71 0 6.6852253148197557e-03
GC_12_72 ref NI_12 NS_72 0 3.2263934491627940e-04
GC_12_73 ref NI_12 NS_73 0 1.0367658755919619e-02
GC_12_74 ref NI_12 NS_74 0 -1.5454954445368383e-02
GC_12_75 ref NI_12 NS_75 0 9.4268432627749518e-03
GC_12_76 ref NI_12 NS_76 0 5.3332830018363914e-04
GC_12_77 ref NI_12 NS_77 0 -1.6526482711445741e-03
GC_12_78 ref NI_12 NS_78 0 1.0312026052049330e-02
GC_12_79 ref NI_12 NS_79 0 2.3456244846094235e-03
GC_12_80 ref NI_12 NS_80 0 -2.5130452857064380e-05
GC_12_81 ref NI_12 NS_81 0 2.0783757786704726e-02
GC_12_82 ref NI_12 NS_82 0 2.4270864544171676e-02
GC_12_83 ref NI_12 NS_83 0 -6.4138583372375111e-03
GC_12_84 ref NI_12 NS_84 0 -5.4135121481921811e-04
GC_12_85 ref NI_12 NS_85 0 -1.4163581731101885e-02
GC_12_86 ref NI_12 NS_86 0 2.9036966058885880e-02
GC_12_87 ref NI_12 NS_87 0 -8.1510027742227040e-04
GC_12_88 ref NI_12 NS_88 0 -8.3619580215855971e-04
GD_12_1 ref NI_12 NA_1 0 -2.9348325708982950e-02
GD_12_2 ref NI_12 NA_2 0 2.6298260827190011e-02
GD_12_3 ref NI_12 NA_3 0 2.4824977541697161e-02
GD_12_4 ref NI_12 NA_4 0 2.4926295043803916e-02
GD_12_5 ref NI_12 NA_5 0 2.6594827415761097e-02
GD_12_6 ref NI_12 NA_6 0 2.2245703991891751e-02
GD_12_7 ref NI_12 NA_7 0 -2.0411720057894015e-03
GD_12_8 ref NI_12 NA_8 0 -5.6804758400321766e-02
GD_12_9 ref NI_12 NA_9 0 8.3590727035344439e-02
GD_12_10 ref NI_12 NA_10 0 -6.0799478959966125e-03
GD_12_11 ref NI_12 NA_11 0 4.7193538633907911e-03
GD_12_12 ref NI_12 NA_12 0 5.9629950851638078e+00
GD_12_13 ref NI_12 NA_13 0 3.8058883832171854e-02
GD_12_14 ref NI_12 NA_14 0 6.3902305706086890e-02
GD_12_15 ref NI_12 NA_15 0 4.2773227742404205e-02
GD_12_16 ref NI_12 NA_16 0 1.7687069929506131e-02
GD_12_17 ref NI_12 NA_17 0 -1.6170020663386602e-04
GD_12_18 ref NI_12 NA_18 0 1.9698428739863078e-02
GD_12_19 ref NI_12 NA_19 0 -1.8997410301597205e-02
GD_12_20 ref NI_12 NA_20 0 5.2424654476168628e-03
GD_12_21 ref NI_12 NA_21 0 -5.8514272167478183e-02
GD_12_22 ref NI_12 NA_22 0 3.9240002588679747e-02
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 2.0532494190558127e-02
GC_13_2 ref NI_13 NS_2 0 4.2334238811929494e-03
GC_13_3 ref NI_13 NS_3 0 -1.6068696755169925e-03
GC_13_4 ref NI_13 NS_4 0 5.8884738391567061e-04
GC_13_5 ref NI_13 NS_5 0 1.4714465573394170e-02
GC_13_6 ref NI_13 NS_6 0 2.5858220190890058e-03
GC_13_7 ref NI_13 NS_7 0 3.3445113850407809e-04
GC_13_8 ref NI_13 NS_8 0 5.8214954826950500e-04
GC_13_9 ref NI_13 NS_9 0 -1.1556178608518940e-02
GC_13_10 ref NI_13 NS_10 0 5.0123277721496762e-03
GC_13_11 ref NI_13 NS_11 0 3.4519818563244599e-03
GC_13_12 ref NI_13 NS_12 0 1.0069623396001385e-03
GC_13_13 ref NI_13 NS_13 0 -9.4309312839235999e-03
GC_13_14 ref NI_13 NS_14 0 2.1110567902913316e-03
GC_13_15 ref NI_13 NS_15 0 4.1510115771333988e-03
GC_13_16 ref NI_13 NS_16 0 1.0320096339608725e-03
GC_13_17 ref NI_13 NS_17 0 -9.3840607336596066e-03
GC_13_18 ref NI_13 NS_18 0 1.8233819086805457e-03
GC_13_19 ref NI_13 NS_19 0 4.3181932596733398e-03
GC_13_20 ref NI_13 NS_20 0 1.0136214153209431e-03
GC_13_21 ref NI_13 NS_21 0 -1.2129338227651757e-02
GC_13_22 ref NI_13 NS_22 0 6.3522086909271989e-03
GC_13_23 ref NI_13 NS_23 0 3.2480683841774002e-03
GC_13_24 ref NI_13 NS_24 0 9.3430261951872216e-04
GC_13_25 ref NI_13 NS_25 0 1.2115343076101506e-02
GC_13_26 ref NI_13 NS_26 0 4.3070123109690328e-02
GC_13_27 ref NI_13 NS_27 0 -1.3955180329031413e-02
GC_13_28 ref NI_13 NS_28 0 -3.4329430860010403e-04
GC_13_29 ref NI_13 NS_29 0 -1.7806833651663811e-02
GC_13_30 ref NI_13 NS_30 0 2.2764449589525938e-02
GC_13_31 ref NI_13 NS_31 0 -2.2434240980162586e-04
GC_13_32 ref NI_13 NS_32 0 7.2894770622204894e-05
GC_13_33 ref NI_13 NS_33 0 2.0547577217433572e-02
GC_13_34 ref NI_13 NS_34 0 -2.3640597796919582e-02
GC_13_35 ref NI_13 NS_35 0 9.8026739941670833e-03
GC_13_36 ref NI_13 NS_36 0 9.5922384931849383e-04
GC_13_37 ref NI_13 NS_37 0 -2.2527091830160269e-02
GC_13_38 ref NI_13 NS_38 0 4.1530811792767179e-02
GC_13_39 ref NI_13 NS_39 0 -5.6255209999440938e-03
GC_13_40 ref NI_13 NS_40 0 -5.6655392883204114e-04
GC_13_41 ref NI_13 NS_41 0 2.1135878956315848e-04
GC_13_42 ref NI_13 NS_42 0 -2.3602363573417520e-03
GC_13_43 ref NI_13 NS_43 0 5.6932289204008656e-03
GC_13_44 ref NI_13 NS_44 0 5.8041871308274311e-04
GC_13_45 ref NI_13 NS_45 0 -1.2849273866223537e-02
GC_13_46 ref NI_13 NS_46 0 1.1326354933302848e-02
GC_13_47 ref NI_13 NS_47 0 3.3843767078733603e-03
GC_13_48 ref NI_13 NS_48 0 1.9123836520040666e-04
GC_13_49 ref NI_13 NS_49 0 8.7127561770907025e-02
GC_13_50 ref NI_13 NS_50 0 -2.3974331005459795e-01
GC_13_51 ref NI_13 NS_51 0 -3.9394185413346654e-02
GC_13_52 ref NI_13 NS_52 0 -2.1378983300349495e-03
GC_13_53 ref NI_13 NS_53 0 -9.2562832810081652e-03
GC_13_54 ref NI_13 NS_54 0 7.1983990384208388e-03
GC_13_55 ref NI_13 NS_55 0 4.1042922620057156e-03
GC_13_56 ref NI_13 NS_56 0 3.3827788782616523e-04
GC_13_57 ref NI_13 NS_57 0 1.0743841507022196e-02
GC_13_58 ref NI_13 NS_58 0 -1.5876654407203039e-02
GC_13_59 ref NI_13 NS_59 0 9.5458829736405054e-03
GC_13_60 ref NI_13 NS_60 0 5.2051513317940624e-04
GC_13_61 ref NI_13 NS_61 0 -3.9278383112501146e-03
GC_13_62 ref NI_13 NS_62 0 -5.4048659133671111e-03
GC_13_63 ref NI_13 NS_63 0 1.1162308788364671e-02
GC_13_64 ref NI_13 NS_64 0 -5.4849385255992082e-04
GC_13_65 ref NI_13 NS_65 0 -4.0188897976331253e-02
GC_13_66 ref NI_13 NS_66 0 5.5256065127578240e-02
GC_13_67 ref NI_13 NS_67 0 -4.6574440036972016e-03
GC_13_68 ref NI_13 NS_68 0 -1.6359046059355533e-03
GC_13_69 ref NI_13 NS_69 0 1.4618425616830003e-02
GC_13_70 ref NI_13 NS_70 0 7.9544947578049890e-02
GC_13_71 ref NI_13 NS_71 0 -2.6002338628746468e-02
GC_13_72 ref NI_13 NS_72 0 -1.5334673298845539e-03
GC_13_73 ref NI_13 NS_73 0 -2.4409553862384102e-02
GC_13_74 ref NI_13 NS_74 0 1.4466294846053948e-02
GC_13_75 ref NI_13 NS_75 0 9.7988891026025409e-03
GC_13_76 ref NI_13 NS_76 0 -1.5877412973026815e-03
GC_13_77 ref NI_13 NS_77 0 -1.9720516338562807e-02
GC_13_78 ref NI_13 NS_78 0 1.6293700087312152e-02
GC_13_79 ref NI_13 NS_79 0 4.9358688993450311e-03
GC_13_80 ref NI_13 NS_80 0 -6.1777454216990345e-04
GC_13_81 ref NI_13 NS_81 0 4.5366984420470461e-03
GC_13_82 ref NI_13 NS_82 0 -9.7197279921481909e-03
GC_13_83 ref NI_13 NS_83 0 8.3517328783589036e-03
GC_13_84 ref NI_13 NS_84 0 4.4198809129314691e-04
GC_13_85 ref NI_13 NS_85 0 1.3045068999976907e-02
GC_13_86 ref NI_13 NS_86 0 -1.6541053810536412e-02
GC_13_87 ref NI_13 NS_87 0 8.5608549056475185e-03
GC_13_88 ref NI_13 NS_88 0 8.3328727474170610e-04
GD_13_1 ref NI_13 NA_1 0 -1.7917977476731784e-02
GD_13_2 ref NI_13 NA_2 0 -3.9261076803728890e-03
GD_13_3 ref NI_13 NA_3 0 2.7124309813203872e-02
GD_13_4 ref NI_13 NA_4 0 2.7703977257708953e-02
GD_13_5 ref NI_13 NA_5 0 2.8760619770197931e-02
GD_13_6 ref NI_13 NA_6 0 2.4606550706449057e-02
GD_13_7 ref NI_13 NA_7 0 -1.5814844505741013e-02
GD_13_8 ref NI_13 NA_8 0 4.5075052324310118e-02
GD_13_9 ref NI_13 NA_9 0 -5.2648826340817544e-02
GD_13_10 ref NI_13 NA_10 0 6.1300677618679009e-02
GD_13_11 ref NI_13 NA_11 0 1.0014054197154327e-03
GD_13_12 ref NI_13 NA_12 0 3.8058883832171098e-02
GD_13_13 ref NI_13 NA_13 0 5.8654912111243878e+00
GD_13_14 ref NI_13 NA_14 0 2.7104608128801850e-02
GD_13_15 ref NI_13 NA_15 0 -1.8546713840214529e-02
GD_13_16 ref NI_13 NA_16 0 3.0296695508132025e-02
GD_13_17 ref NI_13 NA_17 0 1.0831529715159778e-01
GD_13_18 ref NI_13 NA_18 0 -6.2015047342266386e-02
GD_13_19 ref NI_13 NA_19 0 8.7155262381316947e-02
GD_13_20 ref NI_13 NA_20 0 6.9637058623407161e-02
GD_13_21 ref NI_13 NA_21 0 -2.6525363807157649e-03
GD_13_22 ref NI_13 NA_22 0 -3.2409908942330722e-02
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 1.7558881729786289e-02
GC_14_2 ref NI_14 NS_2 0 9.9341191196031225e-03
GC_14_3 ref NI_14 NS_3 0 -1.1487822857988816e-03
GC_14_4 ref NI_14 NS_4 0 -3.4923606055384220e-05
GC_14_5 ref NI_14 NS_5 0 1.8275212848669065e-02
GC_14_6 ref NI_14 NS_6 0 4.0239735639919713e-03
GC_14_7 ref NI_14 NS_7 0 8.5907879761755684e-04
GC_14_8 ref NI_14 NS_8 0 -1.0548779971771894e-04
GC_14_9 ref NI_14 NS_9 0 -1.2219142052187281e-02
GC_14_10 ref NI_14 NS_10 0 3.5466898919321388e-03
GC_14_11 ref NI_14 NS_11 0 7.0118920147276102e-03
GC_14_12 ref NI_14 NS_12 0 1.7242685793001370e-04
GC_14_13 ref NI_14 NS_13 0 -9.2292486478519412e-03
GC_14_14 ref NI_14 NS_14 0 -4.3662193869312772e-04
GC_14_15 ref NI_14 NS_15 0 8.0283869098596444e-03
GC_14_16 ref NI_14 NS_16 0 1.8911269914535247e-04
GC_14_17 ref NI_14 NS_17 0 -9.2986603075928716e-03
GC_14_18 ref NI_14 NS_18 0 -7.2721043520826358e-04
GC_14_19 ref NI_14 NS_19 0 8.2556625706711254e-03
GC_14_20 ref NI_14 NS_20 0 1.5844997297019669e-04
GC_14_21 ref NI_14 NS_21 0 -1.3510368989050255e-02
GC_14_22 ref NI_14 NS_22 0 6.1095670069177275e-03
GC_14_23 ref NI_14 NS_23 0 6.4342764701426098e-03
GC_14_24 ref NI_14 NS_24 0 9.6497141868683869e-05
GC_14_25 ref NI_14 NS_25 0 -1.8154309774133126e-02
GC_14_26 ref NI_14 NS_26 0 2.7095866319767330e-02
GC_14_27 ref NI_14 NS_27 0 -1.2036860112357112e-03
GC_14_28 ref NI_14 NS_28 0 -1.6181197663985507e-04
GC_14_29 ref NI_14 NS_29 0 -2.9555335846922704e-02
GC_14_30 ref NI_14 NS_30 0 5.8891767483448092e-02
GC_14_31 ref NI_14 NS_31 0 -1.0870430149291866e-02
GC_14_32 ref NI_14 NS_32 0 -7.5553035587729923e-04
GC_14_33 ref NI_14 NS_33 0 -1.5644750684441395e-02
GC_14_34 ref NI_14 NS_34 0 1.7483845609089200e-03
GC_14_35 ref NI_14 NS_35 0 1.0062255782936786e-02
GC_14_36 ref NI_14 NS_36 0 -4.9747613309074617e-04
GC_14_37 ref NI_14 NS_37 0 -1.5122797463410784e-02
GC_14_38 ref NI_14 NS_38 0 1.5318059806424930e-02
GC_14_39 ref NI_14 NS_39 0 2.6798057880981626e-03
GC_14_40 ref NI_14 NS_40 0 2.6366834678512154e-05
GC_14_41 ref NI_14 NS_41 0 1.1107035460653071e-02
GC_14_42 ref NI_14 NS_42 0 6.1599298111473258e-02
GC_14_43 ref NI_14 NS_43 0 -2.0780929099751239e-02
GC_14_44 ref NI_14 NS_44 0 -6.6330044058462599e-04
GC_14_45 ref NI_14 NS_45 0 -2.6938887755099117e-02
GC_14_46 ref NI_14 NS_46 0 4.4556221925270437e-02
GC_14_47 ref NI_14 NS_47 0 -5.6751797007858814e-03
GC_14_48 ref NI_14 NS_48 0 -6.2454151295414731e-04
GC_14_49 ref NI_14 NS_49 0 -9.2562832810077333e-03
GC_14_50 ref NI_14 NS_50 0 7.1983990384206168e-03
GC_14_51 ref NI_14 NS_51 0 4.1042922620057355e-03
GC_14_52 ref NI_14 NS_52 0 3.3827788782617255e-04
GC_14_53 ref NI_14 NS_53 0 1.1320281447472240e-01
GC_14_54 ref NI_14 NS_54 0 -2.0372355899263866e-01
GC_14_55 ref NI_14 NS_55 0 -6.2871636779469955e-02
GC_14_56 ref NI_14 NS_56 0 -1.7062082600198458e-03
GC_14_57 ref NI_14 NS_57 0 -4.2429013001957505e-03
GC_14_58 ref NI_14 NS_58 0 -4.2751949702037129e-03
GC_14_59 ref NI_14 NS_59 0 9.0031532691300046e-03
GC_14_60 ref NI_14 NS_60 0 -2.0961315061768688e-06
GC_14_61 ref NI_14 NS_61 0 1.4685838123291859e-02
GC_14_62 ref NI_14 NS_62 0 -1.8886541950028202e-02
GC_14_63 ref NI_14 NS_63 0 9.3943758270630014e-03
GC_14_64 ref NI_14 NS_64 0 7.9060232935429671e-04
GC_14_65 ref NI_14 NS_65 0 1.3128534953647835e-02
GC_14_66 ref NI_14 NS_66 0 -1.6148406817198403e-02
GC_14_67 ref NI_14 NS_67 0 7.4139460550780717e-03
GC_14_68 ref NI_14 NS_68 0 1.1337284313426698e-03
GC_14_69 ref NI_14 NS_69 0 3.6016103656102776e-03
GC_14_70 ref NI_14 NS_70 0 -8.1634981836108365e-03
GC_14_71 ref NI_14 NS_71 0 6.8614694101071915e-03
GC_14_72 ref NI_14 NS_72 0 7.8726378345831511e-04
GC_14_73 ref NI_14 NS_73 0 2.0577701132211336e-02
GC_14_74 ref NI_14 NS_74 0 -2.1638015370494822e-02
GC_14_75 ref NI_14 NS_75 0 7.5515253394943319e-03
GC_14_76 ref NI_14 NS_76 0 1.4130129215060864e-03
GC_14_77 ref NI_14 NS_77 0 3.7128690366673130e-03
GC_14_78 ref NI_14 NS_78 0 -7.8308018928464011e-03
GC_14_79 ref NI_14 NS_79 0 7.5397414451729714e-03
GC_14_80 ref NI_14 NS_80 0 5.2236923801383169e-04
GC_14_81 ref NI_14 NS_81 0 -1.2997290776052280e-02
GC_14_82 ref NI_14 NS_82 0 8.6536610818343292e-03
GC_14_83 ref NI_14 NS_83 0 6.1609732137464660e-03
GC_14_84 ref NI_14 NS_84 0 -3.0912678465152632e-04
GC_14_85 ref NI_14 NS_85 0 -3.3126530084607211e-02
GC_14_86 ref NI_14 NS_86 0 3.3040392470395738e-02
GC_14_87 ref NI_14 NS_87 0 6.8045199953653437e-04
GC_14_88 ref NI_14 NS_88 0 -6.5887184661626505e-04
GD_14_1 ref NI_14 NA_1 0 -3.6513082885183373e-02
GD_14_2 ref NI_14 NA_2 0 2.3368737795552846e-02
GD_14_3 ref NI_14 NA_3 0 2.6003631586470715e-02
GD_14_4 ref NI_14 NA_4 0 2.5835599487858286e-02
GD_14_5 ref NI_14 NA_5 0 2.7425784554086858e-02
GD_14_6 ref NI_14 NA_6 0 2.4044199133919343e-02
GD_14_7 ref NI_14 NA_7 0 4.2143570700742219e-02
GD_14_8 ref NI_14 NA_8 0 5.7938492267298101e-02
GD_14_9 ref NI_14 NA_9 0 6.8610090469430923e-02
GD_14_10 ref NI_14 NA_10 0 4.2184635408275412e-02
GD_14_11 ref NI_14 NA_11 0 -1.9320861058234461e-02
GD_14_12 ref NI_14 NA_12 0 6.3902305706083379e-02
GD_14_13 ref NI_14 NA_13 0 2.7104608128799279e-02
GD_14_14 ref NI_14 NA_14 0 5.8262489797255963e+00
GD_14_15 ref NI_14 NA_15 0 2.9930902086089346e-02
GD_14_16 ref NI_14 NA_16 0 -3.4563323517993301e-02
GD_14_17 ref NI_14 NA_17 0 -3.2154216791406440e-02
GD_14_18 ref NI_14 NA_18 0 -3.9021575538839585e-03
GD_14_19 ref NI_14 NA_19 0 -5.7462717635436568e-02
GD_14_20 ref NI_14 NA_20 0 -4.8301476394355166e-03
GD_14_21 ref NI_14 NA_21 0 4.3329973240439322e-02
GD_14_22 ref NI_14 NA_22 0 7.5399942314805152e-02
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -3.4941132272987363e-04
GC_15_2 ref NI_15 NS_2 0 -1.5193092378733349e-03
GC_15_3 ref NI_15 NS_3 0 2.2249152614267844e-03
GC_15_4 ref NI_15 NS_4 0 1.5510902952698413e-03
GC_15_5 ref NI_15 NS_5 0 2.0704458462423034e-03
GC_15_6 ref NI_15 NS_6 0 -2.8422776740219969e-03
GC_15_7 ref NI_15 NS_7 0 2.0260922023196053e-03
GC_15_8 ref NI_15 NS_8 0 1.6430160688276796e-03
GC_15_9 ref NI_15 NS_9 0 2.0866092509266650e-03
GC_15_10 ref NI_15 NS_10 0 -3.7121939040958194e-03
GC_15_11 ref NI_15 NS_11 0 -3.5798372832139286e-04
GC_15_12 ref NI_15 NS_12 0 2.5101108748111348e-03
GC_15_13 ref NI_15 NS_13 0 2.5443488674265786e-03
GC_15_14 ref NI_15 NS_14 0 -3.7605423919025421e-03
GC_15_15 ref NI_15 NS_15 0 -6.8899326538365423e-04
GC_15_16 ref NI_15 NS_16 0 2.5905027649882353e-03
GC_15_17 ref NI_15 NS_17 0 2.9567451602951112e-03
GC_15_18 ref NI_15 NS_18 0 -4.1223603931368888e-03
GC_15_19 ref NI_15 NS_19 0 -5.7959846058840928e-04
GC_15_20 ref NI_15 NS_20 0 2.5836751898499380e-03
GC_15_21 ref NI_15 NS_21 0 2.7004508632163431e-03
GC_15_22 ref NI_15 NS_22 0 -4.4422662064287624e-03
GC_15_23 ref NI_15 NS_23 0 2.0738495957541204e-04
GC_15_24 ref NI_15 NS_24 0 2.3997630508299905e-03
GC_15_25 ref NI_15 NS_25 0 1.0834657035373903e-03
GC_15_26 ref NI_15 NS_26 0 -5.6081077013311236e-03
GC_15_27 ref NI_15 NS_27 0 7.6395423105625870e-03
GC_15_28 ref NI_15 NS_28 0 3.0007887211619665e-04
GC_15_29 ref NI_15 NS_29 0 -3.1465108686455105e-03
GC_15_30 ref NI_15 NS_30 0 -3.1036991206253440e-03
GC_15_31 ref NI_15 NS_31 0 7.7856043490309983e-03
GC_15_32 ref NI_15 NS_32 0 1.7050437216685035e-04
GC_15_33 ref NI_15 NS_33 0 4.5590309081428880e-02
GC_15_34 ref NI_15 NS_34 0 6.5938248706595412e-02
GC_15_35 ref NI_15 NS_35 0 -2.3715261416449449e-02
GC_15_36 ref NI_15 NS_36 0 -2.5330638357510416e-03
GC_15_37 ref NI_15 NS_37 0 -3.6929278624252644e-03
GC_15_38 ref NI_15 NS_38 0 4.6510657015155698e-03
GC_15_39 ref NI_15 NS_39 0 5.4383156158408774e-03
GC_15_40 ref NI_15 NS_40 0 -1.3681796894244626e-04
GC_15_41 ref NI_15 NS_41 0 -3.6506786446995933e-02
GC_15_42 ref NI_15 NS_42 0 3.3874668356880737e-02
GC_15_43 ref NI_15 NS_43 0 1.9812790903236464e-03
GC_15_44 ref NI_15 NS_44 0 -1.0850086361640034e-03
GC_15_45 ref NI_15 NS_45 0 -1.3193859057631719e-02
GC_15_46 ref NI_15 NS_46 0 1.8886560872628085e-02
GC_15_47 ref NI_15 NS_47 0 2.1999389414429390e-03
GC_15_48 ref NI_15 NS_48 0 -4.7316927621944007e-04
GC_15_49 ref NI_15 NS_49 0 1.0743841507022267e-02
GC_15_50 ref NI_15 NS_50 0 -1.5876654407203053e-02
GC_15_51 ref NI_15 NS_51 0 9.5458829736404915e-03
GC_15_52 ref NI_15 NS_52 0 5.2051513317941534e-04
GC_15_53 ref NI_15 NS_53 0 -4.2429013001946880e-03
GC_15_54 ref NI_15 NS_54 0 -4.2751949702043712e-03
GC_15_55 ref NI_15 NS_55 0 9.0031532691301555e-03
GC_15_56 ref NI_15 NS_56 0 -2.0961315061929421e-06
GC_15_57 ref NI_15 NS_57 0 -4.5138297467436424e-02
GC_15_58 ref NI_15 NS_58 0 -2.2823208736557515e-01
GC_15_59 ref NI_15 NS_59 0 -1.1499274375838300e-02
GC_15_60 ref NI_15 NS_60 0 -3.7598046466631751e-03
GC_15_61 ref NI_15 NS_61 0 1.7456155563466125e-02
GC_15_62 ref NI_15 NS_62 0 3.5040376012448853e-02
GC_15_63 ref NI_15 NS_63 0 -8.9383895918263810e-03
GC_15_64 ref NI_15 NS_64 0 -1.1877103829538815e-03
GC_15_65 ref NI_15 NS_65 0 2.3373589114477683e-03
GC_15_66 ref NI_15 NS_66 0 -5.6460846276229658e-03
GC_15_67 ref NI_15 NS_67 0 8.8229918593190227e-03
GC_15_68 ref NI_15 NS_68 0 -1.7292199983140312e-04
GC_15_69 ref NI_15 NS_69 0 8.7478767288403959e-03
GC_15_70 ref NI_15 NS_70 0 -1.3686793653161373e-02
GC_15_71 ref NI_15 NS_71 0 9.9454889823691883e-03
GC_15_72 ref NI_15 NS_72 0 2.0241913947836767e-04
GC_15_73 ref NI_15 NS_73 0 -4.0388971434439421e-03
GC_15_74 ref NI_15 NS_74 0 4.0979897128753696e-03
GC_15_75 ref NI_15 NS_75 0 6.7854414825546912e-03
GC_15_76 ref NI_15 NS_76 0 -5.0733567468458601e-04
GC_15_77 ref NI_15 NS_77 0 -2.1399211815701560e-03
GC_15_78 ref NI_15 NS_78 0 2.3488936829158091e-02
GC_15_79 ref NI_15 NS_79 0 -8.8640666889178979e-04
GC_15_80 ref NI_15 NS_80 0 -8.5246967500951585e-04
GC_15_81 ref NI_15 NS_81 0 4.3530221607693903e-02
GC_15_82 ref NI_15 NS_82 0 4.1660065930227953e-02
GC_15_83 ref NI_15 NS_83 0 -1.6029739677589385e-02
GC_15_84 ref NI_15 NS_84 0 -1.4980301682552077e-03
GC_15_85 ref NI_15 NS_85 0 -2.9174774887859085e-02
GC_15_86 ref NI_15 NS_86 0 7.0462163451444695e-02
GC_15_87 ref NI_15 NS_87 0 -1.1672531096699596e-02
GC_15_88 ref NI_15 NS_88 0 -2.1098993513624731e-03
GD_15_1 ref NI_15 NA_1 0 1.0341537333445967e-02
GD_15_2 ref NI_15 NA_2 0 7.8574403657116487e-03
GD_15_3 ref NI_15 NA_3 0 3.6465130113388948e-03
GD_15_4 ref NI_15 NA_4 0 2.0381639636528376e-03
GD_15_5 ref NI_15 NA_5 0 6.6607471029539217e-04
GD_15_6 ref NI_15 NA_6 0 7.5992989355148715e-04
GD_15_7 ref NI_15 NA_7 0 8.0844968506303804e-03
GD_15_8 ref NI_15 NA_8 0 2.1386629970860275e-02
GD_15_9 ref NI_15 NA_9 0 -6.5296704223144417e-02
GD_15_10 ref NI_15 NA_10 0 2.1347688789105968e-02
GD_15_11 ref NI_15 NA_11 0 1.0839324095408029e-01
GD_15_12 ref NI_15 NA_12 0 4.2773227742402845e-02
GD_15_13 ref NI_15 NA_13 0 -1.8546713840215081e-02
GD_15_14 ref NI_15 NA_14 0 2.9930902086083549e-02
GD_15_15 ref NI_15 NA_15 0 6.1063605047503389e+00
GD_15_16 ref NI_15 NA_16 0 -1.3555966263419462e-02
GD_15_17 ref NI_15 NA_17 0 5.9018819321990396e-03
GD_15_18 ref NI_15 NA_18 0 -1.2416961860170028e-02
GD_15_19 ref NI_15 NA_19 0 2.8074002618755707e-02
GD_15_20 ref NI_15 NA_20 0 1.8362514597971013e-02
GD_15_21 ref NI_15 NA_21 0 -5.8262480200957617e-02
GD_15_22 ref NI_15 NA_22 0 4.9066860762096105e-02
*
* Port 16
VI_16 a_16 NI_16 0
RI_16 NI_16 ref 1.0000000000000001e-01
GC_16_1 ref NI_16 NS_1 0 8.3585972649163952e-04
GC_16_2 ref NI_16 NS_2 0 -2.9820600403506004e-03
GC_16_3 ref NI_16 NS_3 0 1.9854791581288274e-03
GC_16_4 ref NI_16 NS_4 0 1.7600901658147117e-03
GC_16_5 ref NI_16 NS_5 0 3.0458349567150681e-03
GC_16_6 ref NI_16 NS_6 0 -4.0705479072414355e-03
GC_16_7 ref NI_16 NS_7 0 1.6915584443507013e-03
GC_16_8 ref NI_16 NS_8 0 1.8783288561936503e-03
GC_16_9 ref NI_16 NS_9 0 1.4152139447004303e-03
GC_16_10 ref NI_16 NS_10 0 -2.1023225141138320e-03
GC_16_11 ref NI_16 NS_11 0 -1.8202154810708605e-03
GC_16_12 ref NI_16 NS_12 0 2.7918095888088594e-03
GC_16_13 ref NI_16 NS_13 0 1.4183919969961288e-03
GC_16_14 ref NI_16 NS_14 0 -1.7252929209159509e-03
GC_16_15 ref NI_16 NS_15 0 -2.2592189491934343e-03
GC_16_16 ref NI_16 NS_16 0 2.8753109193769659e-03
GC_16_17 ref NI_16 NS_17 0 1.8201905203192074e-03
GC_16_18 ref NI_16 NS_18 0 -2.0544440704645043e-03
GC_16_19 ref NI_16 NS_19 0 -2.1696531209651061e-03
GC_16_20 ref NI_16 NS_20 0 2.8712001271950782e-03
GC_16_21 ref NI_16 NS_21 0 2.4356137147527714e-03
GC_16_22 ref NI_16 NS_22 0 -3.2111635990983195e-03
GC_16_23 ref NI_16 NS_23 0 -1.1750261230025459e-03
GC_16_24 ref NI_16 NS_24 0 2.6841954973726473e-03
GC_16_25 ref NI_16 NS_25 0 -2.1927267699304105e-03
GC_16_26 ref NI_16 NS_26 0 -3.6263187632672345e-03
GC_16_27 ref NI_16 NS_27 0 8.4737587096819032e-03
GC_16_28 ref NI_16 NS_28 0 -2.0535224014565455e-05
GC_16_29 ref NI_16 NS_29 0 7.7101874004994325e-03
GC_16_30 ref NI_16 NS_30 0 -1.2847087905458330e-02
GC_16_31 ref NI_16 NS_31 0 8.7483125896514972e-03
GC_16_32 ref NI_16 NS_32 0 5.7038136741552347e-04
GC_16_33 ref NI_16 NS_33 0 -2.5447774923850589e-02
GC_16_34 ref NI_16 NS_34 0 2.1848762022101086e-02
GC_16_35 ref NI_16 NS_35 0 5.4202872510856620e-03
GC_16_36 ref NI_16 NS_36 0 -1.1338580385313701e-03
GC_16_37 ref NI_16 NS_37 0 -1.3938147889309627e-02
GC_16_38 ref NI_16 NS_38 0 1.8254772490505521e-02
GC_16_39 ref NI_16 NS_39 0 3.6191387371137035e-03
GC_16_40 ref NI_16 NS_40 0 -7.3281729431367410e-04
GC_16_41 ref NI_16 NS_41 0 1.9788279158288987e-03
GC_16_42 ref NI_16 NS_42 0 -1.0006522866397890e-02
GC_16_43 ref NI_16 NS_43 0 1.0179121373014230e-02
GC_16_44 ref NI_16 NS_44 0 5.0476818407872060e-05
GC_16_45 ref NI_16 NS_45 0 -4.0157875048265476e-03
GC_16_46 ref NI_16 NS_46 0 7.4045920442144522e-04
GC_16_47 ref NI_16 NS_47 0 6.9064900727586849e-03
GC_16_48 ref NI_16 NS_48 0 -1.7053261491747032e-05
GC_16_49 ref NI_16 NS_49 0 -3.9278383112506610e-03
GC_16_50 ref NI_16 NS_50 0 -5.4048659133667312e-03
GC_16_51 ref NI_16 NS_51 0 1.1162308788364550e-02
GC_16_52 ref NI_16 NS_52 0 -5.4849385255989469e-04
GC_16_53 ref NI_16 NS_53 0 1.4685838123292046e-02
GC_16_54 ref NI_16 NS_54 0 -1.8886541950028365e-02
GC_16_55 ref NI_16 NS_55 0 9.3943758270630690e-03
GC_16_56 ref NI_16 NS_56 0 7.9060232935428045e-04
GC_16_57 ref NI_16 NS_57 0 1.7456155563467159e-02
GC_16_58 ref NI_16 NS_58 0 3.5040376012448270e-02
GC_16_59 ref NI_16 NS_59 0 -8.9383895918262839e-03
GC_16_60 ref NI_16 NS_60 0 -1.1877103829538807e-03
GC_16_61 ref NI_16 NS_61 0 1.0527626619577654e-01
GC_16_62 ref NI_16 NS_62 0 -2.3569144474131262e-01
GC_16_63 ref NI_16 NS_63 0 -4.2533543490108350e-02
GC_16_64 ref NI_16 NS_64 0 -2.8703282179335242e-03
GC_16_65 ref NI_16 NS_65 0 -3.1224262599629876e-02
GC_16_66 ref NI_16 NS_66 0 4.1168192399774761e-02
GC_16_67 ref NI_16 NS_67 0 1.3127831475437195e-03
GC_16_68 ref NI_16 NS_68 0 -2.1700626844971820e-03
GC_16_69 ref NI_16 NS_69 0 -2.0701078384801456e-02
GC_16_70 ref NI_16 NS_70 0 1.3881988644213967e-02
GC_16_71 ref NI_16 NS_71 0 8.8449562050085563e-03
GC_16_72 ref NI_16 NS_72 0 -1.4544167724950313e-03
GC_16_73 ref NI_16 NS_73 0 -3.4905848114417257e-02
GC_16_74 ref NI_16 NS_74 0 7.2298365631844247e-02
GC_16_75 ref NI_16 NS_75 0 -9.9758196178864871e-03
GC_16_76 ref NI_16 NS_76 0 -2.6814112127591830e-03
GC_16_77 ref NI_16 NS_77 0 1.4061686806702153e-02
GC_16_78 ref NI_16 NS_78 0 6.0858054910338258e-02
GC_16_79 ref NI_16 NS_79 0 -1.7010324581015507e-02
GC_16_80 ref NI_16 NS_80 0 -1.6842254432371747e-03
GC_16_81 ref NI_16 NS_81 0 -2.0091620444824487e-02
GC_16_82 ref NI_16 NS_82 0 3.3903680218869414e-02
GC_16_83 ref NI_16 NS_83 0 -1.7780085861619911e-03
GC_16_84 ref NI_16 NS_84 0 -8.8607795158801063e-04
GC_16_85 ref NI_16 NS_85 0 -1.6084538690829823e-02
GC_16_86 ref NI_16 NS_86 0 6.1250018904320238e-03
GC_16_87 ref NI_16 NS_87 0 9.1012397168720952e-03
GC_16_88 ref NI_16 NS_88 0 -7.2603688885569044e-04
GD_16_1 ref NI_16 NA_1 0 6.0085971391522983e-03
GD_16_2 ref NI_16 NA_2 0 -1.6599215924592686e-04
GD_16_3 ref NI_16 NA_3 0 4.3490204399069341e-03
GD_16_4 ref NI_16 NA_4 0 3.8994997726704938e-03
GD_16_5 ref NI_16 NA_5 0 2.4669398076722963e-03
GD_16_6 ref NI_16 NA_6 0 3.2773976861735072e-04
GD_16_7 ref NI_16 NA_7 0 1.6153008314843696e-02
GD_16_8 ref NI_16 NA_8 0 -1.3315226623149351e-02
GD_16_9 ref NI_16 NA_9 0 7.3153322171729956e-02
GD_16_10 ref NI_16 NA_10 0 3.4070444584746035e-02
GD_16_11 ref NI_16 NA_11 0 7.7112883929280245e-03
GD_16_12 ref NI_16 NA_12 0 1.7687069929511131e-02
GD_16_13 ref NI_16 NA_13 0 3.0296695508134935e-02
GD_16_14 ref NI_16 NA_14 0 -3.4563323517994217e-02
GD_16_15 ref NI_16 NA_15 0 -1.3555966263425295e-02
GD_16_16 ref NI_16 NA_16 0 5.8400619992169771e+00
GD_16_17 ref NI_16 NA_17 0 9.7737941948354154e-02
GD_16_18 ref NI_16 NA_18 0 7.6388072867438345e-02
GD_16_19 ref NI_16 NA_19 0 1.0699116477946112e-01
GD_16_20 ref NI_16 NA_20 0 -6.8471955576627594e-02
GD_16_21 ref NI_16 NA_21 0 6.0881143366980410e-02
GD_16_22 ref NI_16 NA_22 0 5.5220574657782143e-02
*
* Port 17
VI_17 a_17 NI_17 0
RI_17 NI_17 ref 1.0000000000000001e-01
GC_17_1 ref NI_17 NS_1 0 -3.2260297229064370e-03
GC_17_2 ref NI_17 NS_2 0 2.1957691018329932e-03
GC_17_3 ref NI_17 NS_3 0 1.0327326559855267e-03
GC_17_4 ref NI_17 NS_4 0 1.5767742116457968e-03
GC_17_5 ref NI_17 NS_5 0 -1.8278648472923992e-04
GC_17_6 ref NI_17 NS_6 0 -5.0500752828701323e-04
GC_17_7 ref NI_17 NS_7 0 1.3042576475559176e-03
GC_17_8 ref NI_17 NS_8 0 1.6934175408520585e-03
GC_17_9 ref NI_17 NS_9 0 -5.3926922964848414e-04
GC_17_10 ref NI_17 NS_10 0 -1.8531211137331985e-03
GC_17_11 ref NI_17 NS_11 0 -7.0845158686544429e-04
GC_17_12 ref NI_17 NS_12 0 2.5095317454058128e-03
GC_17_13 ref NI_17 NS_13 0 1.4724666855874265e-04
GC_17_14 ref NI_17 NS_14 0 -2.1160465728148840e-03
GC_17_15 ref NI_17 NS_15 0 -9.8128378635459050e-04
GC_17_16 ref NI_17 NS_16 0 2.5867877210057279e-03
GC_17_17 ref NI_17 NS_17 0 5.5171038430553581e-04
GC_17_18 ref NI_17 NS_18 0 -2.4698220776794635e-03
GC_17_19 ref NI_17 NS_19 0 -8.7721163475289014e-04
GC_17_20 ref NI_17 NS_20 0 2.5807617603583236e-03
GC_17_21 ref NI_17 NS_21 0 3.3978973078891934e-06
GC_17_22 ref NI_17 NS_22 0 -2.5034107453784883e-03
GC_17_23 ref NI_17 NS_23 0 -1.8948305391043669e-04
GC_17_24 ref NI_17 NS_24 0 2.4074209589086356e-03
GC_17_25 ref NI_17 NS_25 0 -1.8197707450438604e-02
GC_17_26 ref NI_17 NS_26 0 1.6644883609348935e-02
GC_17_27 ref NI_17 NS_27 0 3.7240319307467896e-03
GC_17_28 ref NI_17 NS_28 0 -3.8345479333964564e-04
GC_17_29 ref NI_17 NS_29 0 2.9401570895662768e-03
GC_17_30 ref NI_17 NS_30 0 -8.3440236808432766e-03
GC_17_31 ref NI_17 NS_31 0 7.3485862725087697e-03
GC_17_32 ref NI_17 NS_32 0 6.6218420808139067e-04
GC_17_33 ref NI_17 NS_33 0 2.0208510811951508e-02
GC_17_34 ref NI_17 NS_34 0 -2.3788066072981125e-02
GC_17_35 ref NI_17 NS_35 0 1.1145689408355584e-02
GC_17_36 ref NI_17 NS_36 0 5.6660955763754197e-04
GC_17_37 ref NI_17 NS_37 0 -1.6795307842605880e-02
GC_17_38 ref NI_17 NS_38 0 2.4393293919278417e-02
GC_17_39 ref NI_17 NS_39 0 1.7037768291516958e-03
GC_17_40 ref NI_17 NS_40 0 -9.1147469405768026e-04
GC_17_41 ref NI_17 NS_41 0 1.6460529761324037e-02
GC_17_42 ref NI_17 NS_42 0 -1.9438398417116649e-02
GC_17_43 ref NI_17 NS_43 0 8.7885145933806370e-03
GC_17_44 ref NI_17 NS_44 0 9.4737880633707081e-04
GC_17_45 ref NI_17 NS_45 0 3.8721973749701812e-03
GC_17_46 ref NI_17 NS_46 0 -9.0764956676431009e-03
GC_17_47 ref NI_17 NS_47 0 8.1651652088727510e-03
GC_17_48 ref NI_17 NS_48 0 4.4119308486426908e-04
GC_17_49 ref NI_17 NS_49 0 -4.0188897976330691e-02
GC_17_50 ref NI_17 NS_50 0 5.5256065127577789e-02
GC_17_51 ref NI_17 NS_51 0 -4.6574440036970316e-03
GC_17_52 ref NI_17 NS_52 0 -1.6359046059355941e-03
GC_17_53 ref NI_17 NS_53 0 1.3128534953647741e-02
GC_17_54 ref NI_17 NS_54 0 -1.6148406817198400e-02
GC_17_55 ref NI_17 NS_55 0 7.4139460550780977e-03
GC_17_56 ref NI_17 NS_56 0 1.1337284313426583e-03
GC_17_57 ref NI_17 NS_57 0 2.3373589114467201e-03
GC_17_58 ref NI_17 NS_58 0 -5.6460846276223924e-03
GC_17_59 ref NI_17 NS_59 0 8.8229918593189394e-03
GC_17_60 ref NI_17 NS_60 0 -1.7292199983141011e-04
GC_17_61 ref NI_17 NS_61 0 -3.1224262599629991e-02
GC_17_62 ref NI_17 NS_62 0 4.1168192399774782e-02
GC_17_63 ref NI_17 NS_63 0 1.3127831475437403e-03
GC_17_64 ref NI_17 NS_64 0 -2.1700626844971924e-03
GC_17_65 ref NI_17 NS_65 0 4.4483156215563424e-02
GC_17_66 ref NI_17 NS_66 0 -2.2933750069458841e-01
GC_17_67 ref NI_17 NS_67 0 -2.8309298519095527e-02
GC_17_68 ref NI_17 NS_68 0 -4.4566642411173153e-03
GC_17_69 ref NI_17 NS_69 0 1.7340146397265232e-02
GC_17_70 ref NI_17 NS_70 0 7.6831584134647288e-02
GC_17_71 ref NI_17 NS_71 0 -2.2622854404840711e-02
GC_17_72 ref NI_17 NS_72 0 -2.4735379276647302e-03
GC_17_73 ref NI_17 NS_73 0 -1.9193591603187510e-02
GC_17_74 ref NI_17 NS_74 0 1.0038699542796742e-01
GC_17_75 ref NI_17 NS_75 0 -2.0746423194267120e-02
GC_17_76 ref NI_17 NS_76 0 -3.8879141514931393e-03
GC_17_77 ref NI_17 NS_77 0 -1.6198578047291481e-02
GC_17_78 ref NI_17 NS_78 0 3.8593682746580378e-02
GC_17_79 ref NI_17 NS_79 0 -2.2635998578486817e-03
GC_17_80 ref NI_17 NS_80 0 -1.6766131513119816e-03
GC_17_81 ref NI_17 NS_81 0 3.3146156354442488e-03
GC_17_82 ref NI_17 NS_82 0 -8.5987171337706045e-03
GC_17_83 ref NI_17 NS_83 0 9.2220251563387909e-03
GC_17_84 ref NI_17 NS_84 0 5.6291748777752977e-05
GC_17_85 ref NI_17 NS_85 0 2.0795425196377906e-02
GC_17_86 ref NI_17 NS_86 0 -2.4139462871679274e-02
GC_17_87 ref NI_17 NS_87 0 1.0576252995150658e-02
GC_17_88 ref NI_17 NS_88 0 7.6061936679909839e-04
GD_17_1 ref NI_17 NA_1 0 1.9489074561875663e-02
GD_17_2 ref NI_17 NA_2 0 1.0249783089219774e-02
GD_17_3 ref NI_17 NA_3 0 1.3221349842108975e-02
GD_17_4 ref NI_17 NA_4 0 1.1126215607856670e-02
GD_17_5 ref NI_17 NA_5 0 9.8293232253917600e-03
GD_17_6 ref NI_17 NA_6 0 1.0452195044492723e-02
GD_17_7 ref NI_17 NA_7 0 6.3335933660780289e-02
GD_17_8 ref NI_17 NA_8 0 2.0456082307136855e-03
GD_17_9 ref NI_17 NA_9 0 -5.2136484549950186e-02
GD_17_10 ref NI_17 NA_10 0 6.2299521473905856e-02
GD_17_11 ref NI_17 NA_11 0 -4.1988650713858357e-02
GD_17_12 ref NI_17 NA_12 0 -1.6170020663401844e-04
GD_17_13 ref NI_17 NA_13 0 1.0831529715159505e-01
GD_17_14 ref NI_17 NA_14 0 -3.2154216791405628e-02
GD_17_15 ref NI_17 NA_15 0 5.9018819322049958e-03
GD_17_16 ref NI_17 NA_16 0 9.7737941948354959e-02
GD_17_17 ref NI_17 NA_17 0 6.0044449331775409e+00
GD_17_18 ref NI_17 NA_18 0 -3.6949327615033438e-02
GD_17_19 ref NI_17 NA_19 0 2.3530162074890434e-02
GD_17_20 ref NI_17 NA_20 0 6.9009752436167277e-02
GD_17_21 ref NI_17 NA_21 0 4.3145789042726588e-03
GD_17_22 ref NI_17 NA_22 0 -5.3655051077592934e-02
*
* Port 18
VI_18 a_18 NI_18 0
RI_18 NI_18 ref 1.0000000000000001e-01
GC_18_1 ref NI_18 NS_1 0 -2.6944274288190923e-03
GC_18_2 ref NI_18 NS_2 0 6.9664338587891927e-03
GC_18_3 ref NI_18 NS_3 0 1.7649706780070330e-04
GC_18_4 ref NI_18 NS_4 0 1.1735922528499274e-03
GC_18_5 ref NI_18 NS_5 0 -2.8990479159072000e-05
GC_18_6 ref NI_18 NS_6 0 2.8571499589053759e-03
GC_18_7 ref NI_18 NS_7 0 1.2673515757478098e-03
GC_18_8 ref NI_18 NS_8 0 1.2416429608223393e-03
GC_18_9 ref NI_18 NS_9 0 -2.6642590563884607e-03
GC_18_10 ref NI_18 NS_10 0 -2.1192371748030886e-03
GC_18_11 ref NI_18 NS_11 0 1.7593395577463866e-03
GC_18_12 ref NI_18 NS_12 0 1.9177601913356256e-03
GC_18_13 ref NI_18 NS_13 0 -9.2638707019047028e-04
GC_18_14 ref NI_18 NS_14 0 -3.5358746660867990e-03
GC_18_15 ref NI_18 NS_15 0 1.8169334709829893e-03
GC_18_16 ref NI_18 NS_16 0 1.9819499881053053e-03
GC_18_17 ref NI_18 NS_17 0 -5.5422088817564156e-04
GC_18_18 ref NI_18 NS_18 0 -3.9268880094983517e-03
GC_18_19 ref NI_18 NS_19 0 1.9543736427435308e-03
GC_18_20 ref NI_18 NS_20 0 1.9711283487425994e-03
GC_18_21 ref NI_18 NS_21 0 -2.8869984302134556e-03
GC_18_22 ref NI_18 NS_22 0 -1.9137757262335808e-03
GC_18_23 ref NI_18 NS_23 0 2.0425944250039387e-03
GC_18_24 ref NI_18 NS_24 0 1.8200633212698955e-03
GC_18_25 ref NI_18 NS_25 0 -1.9786804135075334e-02
GC_18_26 ref NI_18 NS_26 0 3.6373363751618037e-02
GC_18_27 ref NI_18 NS_27 0 -4.2043570796651648e-03
GC_18_28 ref NI_18 NS_28 0 -4.8922547265920033e-04
GC_18_29 ref NI_18 NS_29 0 -9.4469232378789764e-03
GC_18_30 ref NI_18 NS_30 0 4.5272325508940378e-03
GC_18_31 ref NI_18 NS_31 0 5.1255153498376465e-03
GC_18_32 ref NI_18 NS_32 0 3.5494275703583416e-04
GC_18_33 ref NI_18 NS_33 0 2.3680167923591459e-02
GC_18_34 ref NI_18 NS_34 0 -2.6272815814544426e-02
GC_18_35 ref NI_18 NS_35 0 1.0707596210169730e-02
GC_18_36 ref NI_18 NS_36 0 8.4735285789464107e-04
GC_18_37 ref NI_18 NS_37 0 -1.5939472572513793e-02
GC_18_38 ref NI_18 NS_38 0 3.4088679421537323e-02
GC_18_39 ref NI_18 NS_39 0 -2.9543907542740576e-03
GC_18_40 ref NI_18 NS_40 0 -8.3268951660939975e-04
GC_18_41 ref NI_18 NS_41 0 1.0296233474675951e-02
GC_18_42 ref NI_18 NS_42 0 -1.3803027862902247e-02
GC_18_43 ref NI_18 NS_43 0 7.9395653444488245e-03
GC_18_44 ref NI_18 NS_44 0 8.2252225026365302e-04
GC_18_45 ref NI_18 NS_45 0 -3.7594898962065855e-03
GC_18_46 ref NI_18 NS_46 0 -1.3877680379940044e-03
GC_18_47 ref NI_18 NS_47 0 6.6852253148199665e-03
GC_18_48 ref NI_18 NS_48 0 3.2263934491622340e-04
GC_18_49 ref NI_18 NS_49 0 1.4618425616830454e-02
GC_18_50 ref NI_18 NS_50 0 7.9544947578049627e-02
GC_18_51 ref NI_18 NS_51 0 -2.6002338628746423e-02
GC_18_52 ref NI_18 NS_52 0 -1.5334673298845530e-03
GC_18_53 ref NI_18 NS_53 0 3.6016103656095269e-03
GC_18_54 ref NI_18 NS_54 0 -8.1634981836104844e-03
GC_18_55 ref NI_18 NS_55 0 6.8614694101071837e-03
GC_18_56 ref NI_18 NS_56 0 7.8726378345829093e-04
GC_18_57 ref NI_18 NS_57 0 8.7478767288395511e-03
GC_18_58 ref NI_18 NS_58 0 -1.3686793653160927e-02
GC_18_59 ref NI_18 NS_59 0 9.9454889823691398e-03
GC_18_60 ref NI_18 NS_60 0 2.0241913947835485e-04
GC_18_61 ref NI_18 NS_61 0 -2.0701078384801456e-02
GC_18_62 ref NI_18 NS_62 0 1.3881988644213980e-02
GC_18_63 ref NI_18 NS_63 0 8.8449562050085372e-03
GC_18_64 ref NI_18 NS_64 0 -1.4544167724950237e-03
GC_18_65 ref NI_18 NS_65 0 1.7340146397265197e-02
GC_18_66 ref NI_18 NS_66 0 7.6831584134647246e-02
GC_18_67 ref NI_18 NS_67 0 -2.2622854404840666e-02
GC_18_68 ref NI_18 NS_68 0 -2.4735379276647467e-03
GC_18_69 ref NI_18 NS_69 0 4.7688358241450110e-02
GC_18_70 ref NI_18 NS_70 0 -2.2986266072106692e-01
GC_18_71 ref NI_18 NS_71 0 -3.2169670591293761e-02
GC_18_72 ref NI_18 NS_72 0 -3.4139243999377579e-03
GC_18_73 ref NI_18 NS_73 0 -5.1711682976735000e-02
GC_18_74 ref NI_18 NS_74 0 5.7405940612860626e-02
GC_18_75 ref NI_18 NS_75 0 1.0234505789045660e-03
GC_18_76 ref NI_18 NS_76 0 -2.9979681187966324e-03
GC_18_77 ref NI_18 NS_77 0 -2.0745968715698494e-02
GC_18_78 ref NI_18 NS_78 0 2.8445990916217707e-02
GC_18_79 ref NI_18 NS_79 0 1.7923314960101243e-03
GC_18_80 ref NI_18 NS_80 0 -1.2567906595113358e-03
GC_18_81 ref NI_18 NS_81 0 6.4323519873888896e-03
GC_18_82 ref NI_18 NS_82 0 -1.1769117508572130e-02
GC_18_83 ref NI_18 NS_83 0 9.3520995304336024e-03
GC_18_84 ref NI_18 NS_84 0 2.7717568759954593e-04
GC_18_85 ref NI_18 NS_85 0 1.9968009393786134e-02
GC_18_86 ref NI_18 NS_86 0 -2.2984982306802158e-02
GC_18_87 ref NI_18 NS_87 0 9.8902253361349678e-03
GC_18_88 ref NI_18 NS_88 0 8.7750092635428129e-04
GD_18_1 ref NI_18 NA_1 0 1.5490529324690720e-02
GD_18_2 ref NI_18 NA_2 0 9.8748388425396027e-03
GD_18_3 ref NI_18 NA_3 0 1.7918826173859061e-02
GD_18_4 ref NI_18 NA_4 0 1.4228558983616899e-02
GD_18_5 ref NI_18 NA_5 0 1.3387181720847716e-02
GD_18_6 ref NI_18 NA_6 0 1.6598344958885684e-02
GD_18_7 ref NI_18 NA_7 0 5.9348038498266302e-02
GD_18_8 ref NI_18 NA_8 0 3.3450827990174660e-02
GD_18_9 ref NI_18 NA_9 0 -6.3410861940484467e-02
GD_18_10 ref NI_18 NA_10 0 5.7363943445641108e-02
GD_18_11 ref NI_18 NA_11 0 -2.4815385353539037e-02
GD_18_12 ref NI_18 NA_12 0 1.9698428739860333e-02
GD_18_13 ref NI_18 NA_13 0 -6.2015047342268897e-02
GD_18_14 ref NI_18 NA_14 0 -3.9021575538791555e-03
GD_18_15 ref NI_18 NA_15 0 -1.2416961860165117e-02
GD_18_16 ref NI_18 NA_16 0 7.6388072867438178e-02
GD_18_17 ref NI_18 NA_17 0 -3.6949327615033084e-02
GD_18_18 ref NI_18 NA_18 0 5.9921332412105599e+00
GD_18_19 ref NI_18 NA_19 0 1.4483749206685595e-01
GD_18_20 ref NI_18 NA_20 0 7.5545677584015980e-02
GD_18_21 ref NI_18 NA_21 0 -5.8245826608403694e-03
GD_18_22 ref NI_18 NA_22 0 -5.2127670978384270e-02
*
* Port 19
VI_19 a_19 NI_19 0
RI_19 NI_19 ref 1.0000000000000001e-01
GC_19_1 ref NI_19 NS_1 0 1.0543145254459593e-04
GC_19_2 ref NI_19 NS_2 0 -2.5005264695148388e-03
GC_19_3 ref NI_19 NS_3 0 1.3992732668730481e-03
GC_19_4 ref NI_19 NS_4 0 1.9075508001443915e-03
GC_19_5 ref NI_19 NS_5 0 2.1392471640369389e-03
GC_19_6 ref NI_19 NS_6 0 -3.5503428937815832e-03
GC_19_7 ref NI_19 NS_7 0 1.0667630797547723e-03
GC_19_8 ref NI_19 NS_8 0 2.0537647890452181e-03
GC_19_9 ref NI_19 NS_9 0 -4.0619215867594824e-04
GC_19_10 ref NI_19 NS_10 0 -7.0067149661276582e-05
GC_19_11 ref NI_19 NS_11 0 -2.9533458706914491e-03
GC_19_12 ref NI_19 NS_12 0 2.9662568989075760e-03
GC_19_13 ref NI_19 NS_13 0 -6.3562448718499200e-04
GC_19_14 ref NI_19 NS_14 0 5.1348503200916631e-04
GC_19_15 ref NI_19 NS_15 0 -3.4371315173367806e-03
GC_19_16 ref NI_19 NS_16 0 3.0495258764297950e-03
GC_19_17 ref NI_19 NS_17 0 -2.4360620629264879e-04
GC_19_18 ref NI_19 NS_18 0 2.0527022198274560e-04
GC_19_19 ref NI_19 NS_19 0 -3.3586630975739507e-03
GC_19_20 ref NI_19 NS_20 0 3.0467880201691692e-03
GC_19_21 ref NI_19 NS_21 0 8.2873284806575498e-04
GC_19_22 ref NI_19 NS_22 0 -1.3677405343527839e-03
GC_19_23 ref NI_19 NS_23 0 -2.2807135975833268e-03
GC_19_24 ref NI_19 NS_24 0 2.8631722875659474e-03
GC_19_25 ref NI_19 NS_25 0 -3.7627329807952796e-03
GC_19_26 ref NI_19 NS_26 0 -4.3047773373870290e-03
GC_19_27 ref NI_19 NS_27 0 9.5339939829459965e-03
GC_19_28 ref NI_19 NS_28 0 -2.0796155107193502e-04
GC_19_29 ref NI_19 NS_29 0 1.4146190649133208e-02
GC_19_30 ref NI_19 NS_30 0 -1.8166737130353054e-02
GC_19_31 ref NI_19 NS_31 0 8.6757412529574716e-03
GC_19_32 ref NI_19 NS_32 0 9.3233643446528674e-04
GC_19_33 ref NI_19 NS_33 0 1.4758410610766881e-02
GC_19_34 ref NI_19 NS_34 0 -1.9333311002029775e-02
GC_19_35 ref NI_19 NS_35 0 1.1177569430818945e-02
GC_19_36 ref NI_19 NS_36 0 2.6171518829131536e-04
GC_19_37 ref NI_19 NS_37 0 -1.6624357895255567e-02
GC_19_38 ref NI_19 NS_38 0 1.0772259657201032e-02
GC_19_39 ref NI_19 NS_39 0 7.8856939703309797e-03
GC_19_40 ref NI_19 NS_40 0 -9.8667942876271074e-04
GC_19_41 ref NI_19 NS_41 0 2.0837425168965317e-02
GC_19_42 ref NI_19 NS_42 0 -2.3266427858848429e-02
GC_19_43 ref NI_19 NS_43 0 9.4023394711675850e-03
GC_19_44 ref NI_19 NS_44 0 1.0189617005911310e-03
GC_19_45 ref NI_19 NS_45 0 1.0367658755918626e-02
GC_19_46 ref NI_19 NS_46 0 -1.5454954445367779e-02
GC_19_47 ref NI_19 NS_47 0 9.4268432627748183e-03
GC_19_48 ref NI_19 NS_48 0 5.3332830018365366e-04
GC_19_49 ref NI_19 NS_49 0 -2.4409553862384966e-02
GC_19_50 ref NI_19 NS_50 0 1.4466294846054439e-02
GC_19_51 ref NI_19 NS_51 0 9.7988891026024542e-03
GC_19_52 ref NI_19 NS_52 0 -1.5877412973026796e-03
GC_19_53 ref NI_19 NS_53 0 2.0577701132212432e-02
GC_19_54 ref NI_19 NS_54 0 -2.1638015370495520e-02
GC_19_55 ref NI_19 NS_55 0 7.5515253394945088e-03
GC_19_56 ref NI_19 NS_56 0 1.4130129215060624e-03
GC_19_57 ref NI_19 NS_57 0 -4.0388971434428397e-03
GC_19_58 ref NI_19 NS_58 0 4.0979897128747157e-03
GC_19_59 ref NI_19 NS_59 0 6.7854414825548274e-03
GC_19_60 ref NI_19 NS_60 0 -5.0733567468459772e-04
GC_19_61 ref NI_19 NS_61 0 -3.4905848114417104e-02
GC_19_62 ref NI_19 NS_62 0 7.2298365631844150e-02
GC_19_63 ref NI_19 NS_63 0 -9.9758196178864507e-03
GC_19_64 ref NI_19 NS_64 0 -2.6814112127591929e-03
GC_19_65 ref NI_19 NS_65 0 -1.9193591603187145e-02
GC_19_66 ref NI_19 NS_66 0 1.0038699542796727e-01
GC_19_67 ref NI_19 NS_67 0 -2.0746423194267120e-02
GC_19_68 ref NI_19 NS_68 0 -3.8879141514931263e-03
GC_19_69 ref NI_19 NS_69 0 -5.1711682976734813e-02
GC_19_70 ref NI_19 NS_70 0 5.7405940612860411e-02
GC_19_71 ref NI_19 NS_71 0 1.0234505789046570e-03
GC_19_72 ref NI_19 NS_72 0 -2.9979681187966602e-03
GC_19_73 ref NI_19 NS_73 0 8.9826897793447588e-02
GC_19_74 ref NI_19 NS_74 0 -1.7033779727744941e-01
GC_19_75 ref NI_19 NS_75 0 -6.0254774153875285e-02
GC_19_76 ref NI_19 NS_76 0 -5.3318938950199044e-03
GC_19_77 ref NI_19 NS_77 0 -3.6364150957595071e-02
GC_19_78 ref NI_19 NS_78 0 4.9879666035693777e-02
GC_19_79 ref NI_19 NS_79 0 -1.8352313510645686e-03
GC_19_80 ref NI_19 NS_80 0 -2.1169414669380934e-03
GC_19_81 ref NI_19 NS_81 0 -1.2332716846608933e-03
GC_19_82 ref NI_19 NS_82 0 -4.9447840382465637e-03
GC_19_83 ref NI_19 NS_83 0 9.2153396298303072e-03
GC_19_84 ref NI_19 NS_84 0 -1.8098333129641265e-04
GC_19_85 ref NI_19 NS_85 0 1.9471149409904239e-02
GC_19_86 ref NI_19 NS_86 0 -2.3558889500579668e-02
GC_19_87 ref NI_19 NS_87 0 1.1061248098446207e-02
GC_19_88 ref NI_19 NS_88 0 6.0156321901419832e-04
GD_19_1 ref NI_19 NA_1 0 1.0597484620795225e-02
GD_19_2 ref NI_19 NA_2 0 2.2987164826770469e-03
GD_19_3 ref NI_19 NA_3 0 1.1012035651683114e-02
GD_19_4 ref NI_19 NA_4 0 1.1162600468303007e-02
GD_19_5 ref NI_19 NA_5 0 9.7059800606627538e-03
GD_19_6 ref NI_19 NA_6 0 6.4154965838475646e-03
GD_19_7 ref NI_19 NA_7 0 2.8662601367381923e-02
GD_19_8 ref NI_19 NA_8 0 -3.1928821486263005e-02
GD_19_9 ref NI_19 NA_9 0 -3.4146085510726995e-02
GD_19_10 ref NI_19 NA_10 0 6.4037410640629400e-02
GD_19_11 ref NI_19 NA_11 0 -5.5416946250214469e-02
GD_19_12 ref NI_19 NA_12 0 -1.8997410301591817e-02
GD_19_13 ref NI_19 NA_13 0 8.7155262381321805e-02
GD_19_14 ref NI_19 NA_14 0 -5.7462717635442521e-02
GD_19_15 ref NI_19 NA_15 0 2.8074002618749639e-02
GD_19_16 ref NI_19 NA_16 0 1.0699116477946043e-01
GD_19_17 ref NI_19 NA_17 0 2.3530162074888287e-02
GD_19_18 ref NI_19 NA_18 0 1.4483749206685542e-01
GD_19_19 ref NI_19 NA_19 0 5.8779978831280273e+00
GD_19_20 ref NI_19 NA_20 0 1.1957087888219096e-01
GD_19_21 ref NI_19 NA_21 0 1.9564056026962137e-02
GD_19_22 ref NI_19 NA_22 0 -4.8474592815763627e-02
*
* Port 20
VI_20 a_20 NI_20 0
RI_20 NI_20 ref 1.0000000000000001e-01
GC_20_1 ref NI_20 NS_1 0 -1.4367063847263958e-03
GC_20_2 ref NI_20 NS_2 0 2.3037633742011183e-03
GC_20_3 ref NI_20 NS_3 0 1.1826950900344915e-03
GC_20_4 ref NI_20 NS_4 0 1.4391422295396972e-03
GC_20_5 ref NI_20 NS_5 0 2.0216996801937972e-03
GC_20_6 ref NI_20 NS_6 0 -6.4294856129498332e-04
GC_20_7 ref NI_20 NS_7 0 1.5014241453252743e-03
GC_20_8 ref NI_20 NS_8 0 1.5133803056346002e-03
GC_20_9 ref NI_20 NS_9 0 -6.6902811594286209e-04
GC_20_10 ref NI_20 NS_10 0 -2.1334511251990297e-03
GC_20_11 ref NI_20 NS_11 0 1.7609549464704294e-04
GC_20_12 ref NI_20 NS_12 0 2.3015333734643672e-03
GC_20_13 ref NI_20 NS_13 0 2.1840606807550835e-04
GC_20_14 ref NI_20 NS_14 0 -2.6988369848647787e-03
GC_20_15 ref NI_20 NS_15 0 4.6131572022225762e-06
GC_20_16 ref NI_20 NS_16 0 2.3741951306711583e-03
GC_20_17 ref NI_20 NS_17 0 5.6796023585387934e-04
GC_20_18 ref NI_20 NS_18 0 -3.0381380091228142e-03
GC_20_19 ref NI_20 NS_19 0 1.1720106492272249e-04
GC_20_20 ref NI_20 NS_20 0 2.3662876283550233e-03
GC_20_21 ref NI_20 NS_21 0 -3.2603389341373290e-04
GC_20_22 ref NI_20 NS_22 0 -2.4757017898529832e-03
GC_20_23 ref NI_20 NS_23 0 6.0817874618043094e-04
GC_20_24 ref NI_20 NS_24 0 2.1977307402693850e-03
GC_20_25 ref NI_20 NS_25 0 -1.1420716250890186e-02
GC_20_26 ref NI_20 NS_26 0 1.7804794633930147e-02
GC_20_27 ref NI_20 NS_27 0 1.4878669880391577e-03
GC_20_28 ref NI_20 NS_28 0 -1.4772689176329566e-04
GC_20_29 ref NI_20 NS_29 0 -4.9686580458784711e-03
GC_20_30 ref NI_20 NS_30 0 2.8643183658617951e-03
GC_20_31 ref NI_20 NS_31 0 5.1489663288852069e-03
GC_20_32 ref NI_20 NS_32 0 3.2834816433781057e-04
GC_20_33 ref NI_20 NS_33 0 -1.2972869402867824e-02
GC_20_34 ref NI_20 NS_34 0 5.4161039334781093e-03
GC_20_35 ref NI_20 NS_35 0 8.8015787894467450e-03
GC_20_36 ref NI_20 NS_36 0 -7.0968983572516366e-04
GC_20_37 ref NI_20 NS_37 0 3.6703330282935508e-02
GC_20_38 ref NI_20 NS_38 0 2.3832446806451048e-02
GC_20_39 ref NI_20 NS_39 0 -9.1412471616348721e-03
GC_20_40 ref NI_20 NS_40 0 -5.7042158199805055e-04
GC_20_41 ref NI_20 NS_41 0 -1.5607116189310377e-04
GC_20_42 ref NI_20 NS_42 0 -4.3782964010800549e-03
GC_20_43 ref NI_20 NS_43 0 8.1325956926650012e-03
GC_20_44 ref NI_20 NS_44 0 7.5433007326605842e-05
GC_20_45 ref NI_20 NS_45 0 -1.6526482711447517e-03
GC_20_46 ref NI_20 NS_46 0 1.0312026052049436e-02
GC_20_47 ref NI_20 NS_47 0 2.3456244846093996e-03
GC_20_48 ref NI_20 NS_48 0 -2.5130452857062120e-05
GC_20_49 ref NI_20 NS_49 0 -1.9720516338563084e-02
GC_20_50 ref NI_20 NS_50 0 1.6293700087312280e-02
GC_20_51 ref NI_20 NS_51 0 4.9358688993450268e-03
GC_20_52 ref NI_20 NS_52 0 -6.1777454216991093e-04
GC_20_53 ref NI_20 NS_53 0 3.7128690366672970e-03
GC_20_54 ref NI_20 NS_54 0 -7.8308018928463629e-03
GC_20_55 ref NI_20 NS_55 0 7.5397414451729402e-03
GC_20_56 ref NI_20 NS_56 0 5.2236923801384362e-04
GC_20_57 ref NI_20 NS_57 0 -2.1399211815705259e-03
GC_20_58 ref NI_20 NS_58 0 2.3488936829158289e-02
GC_20_59 ref NI_20 NS_59 0 -8.8640666889181006e-04
GC_20_60 ref NI_20 NS_60 0 -8.5246967500952290e-04
GC_20_61 ref NI_20 NS_61 0 1.4061686806702672e-02
GC_20_62 ref NI_20 NS_62 0 6.0858054910338008e-02
GC_20_63 ref NI_20 NS_63 0 -1.7010324581015483e-02
GC_20_64 ref NI_20 NS_64 0 -1.6842254432371593e-03
GC_20_65 ref NI_20 NS_65 0 -1.6198578047291721e-02
GC_20_66 ref NI_20 NS_66 0 3.8593682746580628e-02
GC_20_67 ref NI_20 NS_67 0 -2.2635998578487866e-03
GC_20_68 ref NI_20 NS_68 0 -1.6766131513119525e-03
GC_20_69 ref NI_20 NS_69 0 -2.0745968715698417e-02
GC_20_70 ref NI_20 NS_70 0 2.8445990916217630e-02
GC_20_71 ref NI_20 NS_71 0 1.7923314960101655e-03
GC_20_72 ref NI_20 NS_72 0 -1.2567906595113479e-03
GC_20_73 ref NI_20 NS_73 0 -3.6364150957594765e-02
GC_20_74 ref NI_20 NS_74 0 4.9879666035693583e-02
GC_20_75 ref NI_20 NS_75 0 -1.8352313510645272e-03
GC_20_76 ref NI_20 NS_76 0 -2.1169414669380995e-03
GC_20_77 ref NI_20 NS_77 0 7.7879544562513364e-02
GC_20_78 ref NI_20 NS_78 0 -2.7757171138641967e-01
GC_20_79 ref NI_20 NS_79 0 -2.0636138226650787e-02
GC_20_80 ref NI_20 NS_80 0 -2.3551428624453783e-03
GC_20_81 ref NI_20 NS_81 0 8.6928022213594890e-04
GC_20_82 ref NI_20 NS_82 0 2.2605601207144478e-02
GC_20_83 ref NI_20 NS_83 0 -2.0709066872292505e-03
GC_20_84 ref NI_20 NS_84 0 -5.3653580956325550e-04
GC_20_85 ref NI_20 NS_85 0 -6.9431848278175869e-03
GC_20_86 ref NI_20 NS_86 0 -5.2344708834099372e-04
GC_20_87 ref NI_20 NS_87 0 9.2940021263083917e-03
GC_20_88 ref NI_20 NS_88 0 -4.1814097143551873e-04
GD_20_1 ref NI_20 NA_1 0 8.9824662860823468e-03
GD_20_2 ref NI_20 NA_2 0 8.1778987577360539e-03
GD_20_3 ref NI_20 NA_3 0 1.0750794552156381e-02
GD_20_4 ref NI_20 NA_4 0 8.7465744593684287e-03
GD_20_5 ref NI_20 NA_5 0 7.7539587922665094e-03
GD_20_6 ref NI_20 NA_6 0 8.0739010201930882e-03
GD_20_7 ref NI_20 NA_7 0 2.3688332280182266e-02
GD_20_8 ref NI_20 NA_8 0 1.6053901588558534e-02
GD_20_9 ref NI_20 NA_9 0 4.3196045499965016e-02
GD_20_10 ref NI_20 NA_10 0 -1.0289593706058411e-01
GD_20_11 ref NI_20 NA_11 0 8.3176822595558472e-03
GD_20_12 ref NI_20 NA_12 0 5.2424654476178117e-03
GD_20_13 ref NI_20 NA_13 0 6.9637058623408854e-02
GD_20_14 ref NI_20 NA_14 0 -4.8301476394355045e-03
GD_20_15 ref NI_20 NA_15 0 1.8362514597973188e-02
GD_20_16 ref NI_20 NA_16 0 -6.8471955576631049e-02
GD_20_17 ref NI_20 NA_17 0 6.9009752436168262e-02
GD_20_18 ref NI_20 NA_18 0 7.5545677584015661e-02
GD_20_19 ref NI_20 NA_19 0 1.1957087888218956e-01
GD_20_20 ref NI_20 NA_20 0 5.9276136750382422e+00
GD_20_21 ref NI_20 NA_21 0 1.0452109408195655e-02
GD_20_22 ref NI_20 NA_22 0 2.8693017440172552e-02
*
* Port 21
VI_21 a_21 NI_21 0
RI_21 NI_21 ref 1.0000000000000001e-01
GC_21_1 ref NI_21 NS_1 0 4.7693551199812342e-04
GC_21_2 ref NI_21 NS_2 0 1.3747307257896996e-03
GC_21_3 ref NI_21 NS_3 0 1.8420131708683850e-03
GC_21_4 ref NI_21 NS_4 0 1.2584690945434175e-03
GC_21_5 ref NI_21 NS_5 0 3.7871694546958382e-03
GC_21_6 ref NI_21 NS_6 0 -1.3708211072157226e-03
GC_21_7 ref NI_21 NS_7 0 2.0686047366298577e-03
GC_21_8 ref NI_21 NS_8 0 1.3191542356398706e-03
GC_21_9 ref NI_21 NS_9 0 6.8684113419622270e-04
GC_21_10 ref NI_21 NS_10 0 -3.7066498272150601e-03
GC_21_11 ref NI_21 NS_11 0 1.3100528766410834e-03
GC_21_12 ref NI_21 NS_12 0 2.0978344536776083e-03
GC_21_13 ref NI_21 NS_13 0 1.7643028425601221e-03
GC_21_14 ref NI_21 NS_14 0 -4.5009915153165214e-03
GC_21_15 ref NI_21 NS_15 0 1.2041269299509537e-03
GC_21_16 ref NI_21 NS_16 0 2.1690756703159385e-03
GC_21_17 ref NI_21 NS_17 0 2.1126615307391272e-03
GC_21_18 ref NI_21 NS_18 0 -4.8607792207438190e-03
GC_21_19 ref NI_21 NS_19 0 1.3328690019194162e-03
GC_21_20 ref NI_21 NS_20 0 2.1587751704843536e-03
GC_21_21 ref NI_21 NS_21 0 8.3930013454411821e-04
GC_21_22 ref NI_21 NS_22 0 -3.8186364838154155e-03
GC_21_23 ref NI_21 NS_23 0 1.6901650648491265e-03
GC_21_24 ref NI_21 NS_24 0 1.9904500289118351e-03
GC_21_25 ref NI_21 NS_25 0 -4.3580878952259898e-03
GC_21_26 ref NI_21 NS_26 0 4.8391950387017268e-03
GC_21_27 ref NI_21 NS_27 0 4.6563953715839379e-03
GC_21_28 ref NI_21 NS_28 0 1.7098565453935996e-04
GC_21_29 ref NI_21 NS_29 0 -1.2249153189914885e-02
GC_21_30 ref NI_21 NS_30 0 1.2198963359485525e-02
GC_21_31 ref NI_21 NS_31 0 3.7248745414674121e-03
GC_21_32 ref NI_21 NS_32 0 -4.4810203410660128e-05
GC_21_33 ref NI_21 NS_33 0 -5.3539044959593676e-02
GC_21_34 ref NI_21 NS_34 0 7.3869748717051223e-02
GC_21_35 ref NI_21 NS_35 0 -8.0717003773021385e-03
GC_21_36 ref NI_21 NS_36 0 -2.2166220048596840e-03
GC_21_37 ref NI_21 NS_37 0 -1.7356937184211565e-03
GC_21_38 ref NI_21 NS_38 0 1.2140847497007485e-02
GC_21_39 ref NI_21 NS_39 0 1.7798134758081200e-03
GC_21_40 ref NI_21 NS_40 0 -1.1246822880010150e-04
GC_21_41 ref NI_21 NS_41 0 -2.0042264659540107e-02
GC_21_42 ref NI_21 NS_42 0 3.2039190468722077e-02
GC_21_43 ref NI_21 NS_43 0 -2.5619962265163552e-04
GC_21_44 ref NI_21 NS_44 0 -1.0643336551267018e-03
GC_21_45 ref NI_21 NS_45 0 2.0783757786704906e-02
GC_21_46 ref NI_21 NS_46 0 2.4270864544171593e-02
GC_21_47 ref NI_21 NS_47 0 -6.4138583372375076e-03
GC_21_48 ref NI_21 NS_48 0 -5.4135121481921236e-04
GC_21_49 ref NI_21 NS_49 0 4.5366984420466012e-03
GC_21_50 ref NI_21 NS_50 0 -9.7197279921479758e-03
GC_21_51 ref NI_21 NS_51 0 8.3517328783588914e-03
GC_21_52 ref NI_21 NS_52 0 4.4198809129313482e-04
GC_21_53 ref NI_21 NS_53 0 -1.2997290776051388e-02
GC_21_54 ref NI_21 NS_54 0 8.6536610818337013e-03
GC_21_55 ref NI_21 NS_55 0 6.1609732137466594e-03
GC_21_56 ref NI_21 NS_56 0 -3.0912678465156324e-04
GC_21_57 ref NI_21 NS_57 0 4.3530221607694090e-02
GC_21_58 ref NI_21 NS_58 0 4.1660065930227801e-02
GC_21_59 ref NI_21 NS_59 0 -1.6029739677589340e-02
GC_21_60 ref NI_21 NS_60 0 -1.4980301682552164e-03
GC_21_61 ref NI_21 NS_61 0 -2.0091620444824671e-02
GC_21_62 ref NI_21 NS_62 0 3.3903680218869567e-02
GC_21_63 ref NI_21 NS_63 0 -1.7780085861620447e-03
GC_21_64 ref NI_21 NS_64 0 -8.8607795158799686e-04
GC_21_65 ref NI_21 NS_65 0 3.3146156354440280e-03
GC_21_66 ref NI_21 NS_66 0 -8.5987171337705177e-03
GC_21_67 ref NI_21 NS_67 0 9.2220251563388065e-03
GC_21_68 ref NI_21 NS_68 0 5.6291748777738306e-05
GC_21_69 ref NI_21 NS_69 0 6.4323519873887361e-03
GC_21_70 ref NI_21 NS_70 0 -1.1769117508571948e-02
GC_21_71 ref NI_21 NS_71 0 9.3520995304334949e-03
GC_21_72 ref NI_21 NS_72 0 2.7717568759957878e-04
GC_21_73 ref NI_21 NS_73 0 -1.2332716846613122e-03
GC_21_74 ref NI_21 NS_74 0 -4.9447840382462489e-03
GC_21_75 ref NI_21 NS_75 0 9.2153396298301909e-03
GC_21_76 ref NI_21 NS_76 0 -1.8098333129638368e-04
GC_21_77 ref NI_21 NS_77 0 8.6928022213541808e-04
GC_21_78 ref NI_21 NS_78 0 2.2605601207144638e-02
GC_21_79 ref NI_21 NS_79 0 -2.0709066872291720e-03
GC_21_80 ref NI_21 NS_80 0 -5.3653580956330332e-04
GC_21_81 ref NI_21 NS_81 0 6.2541588013240973e-02
GC_21_82 ref NI_21 NS_82 0 -2.6711053187032463e-01
GC_21_83 ref NI_21 NS_83 0 -2.1534573388820193e-02
GC_21_84 ref NI_21 NS_84 0 -2.5684734381467345e-03
GC_21_85 ref NI_21 NS_85 0 -2.4781968114782768e-02
GC_21_86 ref NI_21 NS_86 0 5.4156887466824052e-02
GC_21_87 ref NI_21 NS_87 0 -6.5073126578310070e-03
GC_21_88 ref NI_21 NS_88 0 -1.8331565181926685e-03
GD_21_1 ref NI_21 NA_1 0 2.3785865559228076e-03
GD_21_2 ref NI_21 NA_2 0 8.4324464071351881e-03
GD_21_3 ref NI_21 NA_3 0 5.0755145705327388e-03
GD_21_4 ref NI_21 NA_4 0 2.8137188618939744e-03
GD_21_5 ref NI_21 NA_5 0 1.8817615603245984e-03
GD_21_6 ref NI_21 NA_6 0 2.7878617194378283e-03
GD_21_7 ref NI_21 NA_7 0 1.5205542917996803e-02
GD_21_8 ref NI_21 NA_8 0 3.2586336272777655e-02
GD_21_9 ref NI_21 NA_9 0 1.2074403650099563e-01
GD_21_10 ref NI_21 NA_10 0 1.2298351843054417e-02
GD_21_11 ref NI_21 NA_11 0 5.2020520625754525e-02
GD_21_12 ref NI_21 NA_12 0 -5.8514272167479092e-02
GD_21_13 ref NI_21 NA_13 0 -2.6525363807129373e-03
GD_21_14 ref NI_21 NA_14 0 4.3329973240434846e-02
GD_21_15 ref NI_21 NA_15 0 -5.8262480200958117e-02
GD_21_16 ref NI_21 NA_16 0 6.0881143366981375e-02
GD_21_17 ref NI_21 NA_17 0 4.3145789042742912e-03
GD_21_18 ref NI_21 NA_18 0 -5.8245826608398603e-03
GD_21_19 ref NI_21 NA_19 0 1.9564056026964156e-02
GD_21_20 ref NI_21 NA_20 0 1.0452109408199430e-02
GD_21_21 ref NI_21 NA_21 0 5.9470399167173902e+00
GD_21_22 ref NI_21 NA_22 0 7.0829491120820834e-02
*
* Port 22
VI_22 a_22 NI_22 0
RI_22 NI_22 ref 1.0000000000000001e-01
GC_22_1 ref NI_22 NS_1 0 -4.4799559222677003e-04
GC_22_2 ref NI_22 NS_2 0 2.2897194244908990e-03
GC_22_3 ref NI_22 NS_3 0 1.9658236311908537e-03
GC_22_4 ref NI_22 NS_4 0 1.1677365954509203e-03
GC_22_5 ref NI_22 NS_5 0 3.2265647235400238e-03
GC_22_6 ref NI_22 NS_6 0 -6.3030768678222840e-04
GC_22_7 ref NI_22 NS_7 0 2.2004075053359646e-03
GC_22_8 ref NI_22 NS_8 0 1.2224888420963732e-03
GC_22_9 ref NI_22 NS_9 0 8.8270739190653624e-04
GC_22_10 ref NI_22 NS_10 0 -4.4559970965618268e-03
GC_22_11 ref NI_22 NS_11 0 1.9892542740599984e-03
GC_22_12 ref NI_22 NS_12 0 1.9811635287880019e-03
GC_22_13 ref NI_22 NS_13 0 2.1903343124055818e-03
GC_22_14 ref NI_22 NS_14 0 -5.4520379463784963e-03
GC_22_15 ref NI_22 NS_15 0 1.9288794960916490e-03
GC_22_16 ref NI_22 NS_16 0 2.0516171622542751e-03
GC_22_17 ref NI_22 NS_17 0 2.5468164234555952e-03
GC_22_18 ref NI_22 NS_18 0 -5.8310282170692075e-03
GC_22_19 ref NI_22 NS_19 0 2.0681629177802890e-03
GC_22_20 ref NI_22 NS_20 0 2.0399720644930426e-03
GC_22_21 ref NI_22 NS_21 0 8.2926379214439967e-04
GC_22_22 ref NI_22 NS_22 0 -4.3791577464892522e-03
GC_22_23 ref NI_22 NS_23 0 2.3326242015060468e-03
GC_22_24 ref NI_22 NS_24 0 1.8723268807764001e-03
GC_22_25 ref NI_22 NS_25 0 -1.8772107076100674e-03
GC_22_26 ref NI_22 NS_26 0 -1.5134316783980664e-03
GC_22_27 ref NI_22 NS_27 0 6.6235678097897755e-03
GC_22_28 ref NI_22 NS_28 0 2.7731463823916900e-04
GC_22_29 ref NI_22 NS_29 0 -1.5809995092934865e-02
GC_22_30 ref NI_22 NS_30 0 1.3417432163012005e-02
GC_22_31 ref NI_22 NS_31 0 4.3991546371277418e-03
GC_22_32 ref NI_22 NS_32 0 -2.1991518394451589e-04
GC_22_33 ref NI_22 NS_33 0 7.3272924423260680e-02
GC_22_34 ref NI_22 NS_34 0 7.1473285169085660e-02
GC_22_35 ref NI_22 NS_35 0 -3.3237228906631514e-02
GC_22_36 ref NI_22 NS_36 0 -2.3736067021385043e-03
GC_22_37 ref NI_22 NS_37 0 -3.5459991192777545e-03
GC_22_38 ref NI_22 NS_38 0 -9.2250224586785631e-04
GC_22_39 ref NI_22 NS_39 0 7.4082548687224963e-03
GC_22_40 ref NI_22 NS_40 0 3.6107725871811332e-05
GC_22_41 ref NI_22 NS_41 0 8.4911202339451694e-02
GC_22_42 ref NI_22 NS_42 0 2.7236385524205185e-02
GC_22_43 ref NI_22 NS_43 0 -2.0346849017221974e-02
GC_22_44 ref NI_22 NS_44 0 -1.0740539092518337e-03
GC_22_45 ref NI_22 NS_45 0 -1.4163581731101688e-02
GC_22_46 ref NI_22 NS_46 0 2.9036966058885623e-02
GC_22_47 ref NI_22 NS_47 0 -8.1510027742212837e-04
GC_22_48 ref NI_22 NS_48 0 -8.3619580215860438e-04
GC_22_49 ref NI_22 NS_49 0 1.3045068999976935e-02
GC_22_50 ref NI_22 NS_50 0 -1.6541053810536305e-02
GC_22_51 ref NI_22 NS_51 0 8.5608549056474092e-03
GC_22_52 ref NI_22 NS_52 0 8.3328727474174860e-04
GC_22_53 ref NI_22 NS_53 0 -3.3126530084607662e-02
GC_22_54 ref NI_22 NS_54 0 3.3040392470396029e-02
GC_22_55 ref NI_22 NS_55 0 6.8045199953644384e-04
GC_22_56 ref NI_22 NS_56 0 -6.5887184661624456e-04
GC_22_57 ref NI_22 NS_57 0 -2.9174774887858405e-02
GC_22_58 ref NI_22 NS_58 0 7.0462163451444251e-02
GC_22_59 ref NI_22 NS_59 0 -1.1672531096699463e-02
GC_22_60 ref NI_22 NS_60 0 -2.1098993513624965e-03
GC_22_61 ref NI_22 NS_61 0 -1.6084538690829309e-02
GC_22_62 ref NI_22 NS_62 0 6.1250018904317003e-03
GC_22_63 ref NI_22 NS_63 0 9.1012397168721681e-03
GC_22_64 ref NI_22 NS_64 0 -7.2603688885569998e-04
GC_22_65 ref NI_22 NS_65 0 2.0795425196377497e-02
GC_22_66 ref NI_22 NS_66 0 -2.4139462871679038e-02
GC_22_67 ref NI_22 NS_67 0 1.0576252995150607e-02
GC_22_68 ref NI_22 NS_68 0 7.6061936679910241e-04
GC_22_69 ref NI_22 NS_69 0 1.9968009393785673e-02
GC_22_70 ref NI_22 NS_70 0 -2.2984982306801991e-02
GC_22_71 ref NI_22 NS_71 0 9.8902253361350060e-03
GC_22_72 ref NI_22 NS_72 0 8.7750092635425017e-04
GC_22_73 ref NI_22 NS_73 0 1.9471149409904961e-02
GC_22_74 ref NI_22 NS_74 0 -2.3558889500580039e-02
GC_22_75 ref NI_22 NS_75 0 1.1061248098446242e-02
GC_22_76 ref NI_22 NS_76 0 6.0156321901421296e-04
GC_22_77 ref NI_22 NS_77 0 -6.9431848278175487e-03
GC_22_78 ref NI_22 NS_78 0 -5.2344708834091316e-04
GC_22_79 ref NI_22 NS_79 0 9.2940021263082963e-03
GC_22_80 ref NI_22 NS_80 0 -4.1814097143548111e-04
GC_22_81 ref NI_22 NS_81 0 -2.4781968114782432e-02
GC_22_82 ref NI_22 NS_82 0 5.4156887466823886e-02
GC_22_83 ref NI_22 NS_83 0 -6.5073126578310122e-03
GC_22_84 ref NI_22 NS_84 0 -1.8331565181926544e-03
GC_22_85 ref NI_22 NS_85 0 -9.4095745641595341e-02
GC_22_86 ref NI_22 NS_86 0 -1.9521788166613210e-01
GC_22_87 ref NI_22 NS_87 0 -1.8196388893824016e-02
GC_22_88 ref NI_22 NS_88 0 -3.3278047800809566e-03
GD_22_1 ref NI_22 NA_1 0 1.8644275564464441e-03
GD_22_2 ref NI_22 NA_2 0 8.3569322270481382e-03
GD_22_3 ref NI_22 NA_3 0 5.2105197710524860e-03
GD_22_4 ref NI_22 NA_4 0 2.4180133411363129e-03
GD_22_5 ref NI_22 NA_5 0 1.5265641757513289e-03
GD_22_6 ref NI_22 NA_6 0 3.3511568213405369e-03
GD_22_7 ref NI_22 NA_7 0 9.4786653583722631e-03
GD_22_8 ref NI_22 NA_8 0 4.4420975422587820e-02
GD_22_9 ref NI_22 NA_9 0 -6.6354501912316247e-02
GD_22_10 ref NI_22 NA_10 0 1.7411975784913408e-02
GD_22_11 ref NI_22 NA_11 0 -9.2457186604712763e-02
GD_22_12 ref NI_22 NA_12 0 3.9240002588679164e-02
GD_22_13 ref NI_22 NA_13 0 -3.2409908942331263e-02
GD_22_14 ref NI_22 NA_14 0 7.5399942314807414e-02
GD_22_15 ref NI_22 NA_15 0 4.9066860762092469e-02
GD_22_16 ref NI_22 NA_16 0 5.5220574657779520e-02
GD_22_17 ref NI_22 NA_17 0 -5.3655051077590672e-02
GD_22_18 ref NI_22 NA_18 0 -5.2127670978381023e-02
GD_22_19 ref NI_22 NA_19 0 -4.8474592815767915e-02
GD_22_20 ref NI_22 NA_20 0 2.8693017440171865e-02
GD_22_21 ref NI_22 NA_21 0 7.0829491120818738e-02
GD_22_22 ref NI_22 NA_22 0 6.2165357015619280e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
* Impinging wave, port 16
RA_16 NA_16 0 1.5811388300841897e-01
FA_16 0 NA_16 VI_16 1.0
GA_16 0 NA_16 a_16 ref 1.0000000000000000e+01
*
* Impinging wave, port 17
RA_17 NA_17 0 1.5811388300841897e-01
FA_17 0 NA_17 VI_17 1.0
GA_17 0 NA_17 a_17 ref 1.0000000000000000e+01
*
* Impinging wave, port 18
RA_18 NA_18 0 1.5811388300841897e-01
FA_18 0 NA_18 VI_18 1.0
GA_18 0 NA_18 a_18 ref 1.0000000000000000e+01
*
* Impinging wave, port 19
RA_19 NA_19 0 1.5811388300841897e-01
FA_19 0 NA_19 VI_19 1.0
GA_19 0 NA_19 a_19 ref 1.0000000000000000e+01
*
* Impinging wave, port 20
RA_20 NA_20 0 1.5811388300841897e-01
FA_20 0 NA_20 VI_20 1.0
GA_20 0 NA_20 a_20 ref 1.0000000000000000e+01
*
* Impinging wave, port 21
RA_21 NA_21 0 1.5811388300841897e-01
FA_21 0 NA_21 VI_21 1.0
GA_21 0 NA_21 a_21 ref 1.0000000000000000e+01
*
* Impinging wave, port 22
RA_22 NA_22 0 1.5811388300841897e-01
FA_22 0 NA_22 VI_22 1.0
GA_22 0 NA_22 a_22 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.2037931961600535e+02
GS_1_1 0 NS_1 NA_1 0 1.6432470179296438e-01
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 2.3335966643407150e+02
GS_2_1 0 NS_2 NA_1 0 1.6432470179296438e-01
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 5.2309713510215488e+02
GS_3_1 0 NS_3 NA_1 0 1.6432470179296438e-01
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 1.5848590426319693e+03
GS_4_1 0 NS_4 NA_1 0 1.6432470179296438e-01
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.2037931961600535e+02
GS_5_2 0 NS_5 NA_2 0 1.6432470179296438e-01
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 2.3335966643407150e+02
GS_6_2 0 NS_6 NA_2 0 1.6432470179296438e-01
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 5.2309713510215488e+02
GS_7_2 0 NS_7 NA_2 0 1.6432470179296438e-01
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 1.5848590426319693e+03
GS_8_2 0 NS_8 NA_2 0 1.6432470179296438e-01
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.2037931961600535e+02
GS_9_3 0 NS_9 NA_3 0 1.6432470179296438e-01
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 2.3335966643407150e+02
GS_10_3 0 NS_10 NA_3 0 1.6432470179296438e-01
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 5.2309713510215488e+02
GS_11_3 0 NS_11 NA_3 0 1.6432470179296438e-01
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 1.5848590426319693e+03
GS_12_3 0 NS_12 NA_3 0 1.6432470179296438e-01
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.2037931961600535e+02
GS_13_4 0 NS_13 NA_4 0 1.6432470179296438e-01
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 2.3335966643407150e+02
GS_14_4 0 NS_14 NA_4 0 1.6432470179296438e-01
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 5.2309713510215488e+02
GS_15_4 0 NS_15 NA_4 0 1.6432470179296438e-01
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 1.5848590426319693e+03
GS_16_4 0 NS_16 NA_4 0 1.6432470179296438e-01
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.2037931961600535e+02
GS_17_5 0 NS_17 NA_5 0 1.6432470179296438e-01
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 2.3335966643407150e+02
GS_18_5 0 NS_18 NA_5 0 1.6432470179296438e-01
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 5.2309713510215488e+02
GS_19_5 0 NS_19 NA_5 0 1.6432470179296438e-01
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 1.5848590426319693e+03
GS_20_5 0 NS_20 NA_5 0 1.6432470179296438e-01
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.2037931961600535e+02
GS_21_6 0 NS_21 NA_6 0 1.6432470179296438e-01
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 2.3335966643407150e+02
GS_22_6 0 NS_22 NA_6 0 1.6432470179296438e-01
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 5.2309713510215488e+02
GS_23_6 0 NS_23 NA_6 0 1.6432470179296438e-01
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 1.5848590426319693e+03
GS_24_6 0 NS_24 NA_6 0 1.6432470179296438e-01
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.2037931961600535e+02
GS_25_7 0 NS_25 NA_7 0 1.6432470179296438e-01
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 2.3335966643407150e+02
GS_26_7 0 NS_26 NA_7 0 1.6432470179296438e-01
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 5.2309713510215488e+02
GS_27_7 0 NS_27 NA_7 0 1.6432470179296438e-01
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 1.5848590426319693e+03
GS_28_7 0 NS_28 NA_7 0 1.6432470179296438e-01
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.2037931961600535e+02
GS_29_8 0 NS_29 NA_8 0 1.6432470179296438e-01
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 2.3335966643407150e+02
GS_30_8 0 NS_30 NA_8 0 1.6432470179296438e-01
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 5.2309713510215488e+02
GS_31_8 0 NS_31 NA_8 0 1.6432470179296438e-01
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 1.5848590426319693e+03
GS_32_8 0 NS_32 NA_8 0 1.6432470179296438e-01
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 1.2037931961600535e+02
GS_33_9 0 NS_33 NA_9 0 1.6432470179296438e-01
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 2.3335966643407150e+02
GS_34_9 0 NS_34 NA_9 0 1.6432470179296438e-01
*
* Real pole n. 35
CS_35 NS_35 0 9.9999999999999998e-13
RS_35 NS_35 0 5.2309713510215488e+02
GS_35_9 0 NS_35 NA_9 0 1.6432470179296438e-01
*
* Real pole n. 36
CS_36 NS_36 0 9.9999999999999998e-13
RS_36 NS_36 0 1.5848590426319693e+03
GS_36_9 0 NS_36 NA_9 0 1.6432470179296438e-01
*
* Real pole n. 37
CS_37 NS_37 0 9.9999999999999998e-13
RS_37 NS_37 0 1.2037931961600535e+02
GS_37_10 0 NS_37 NA_10 0 1.6432470179296438e-01
*
* Real pole n. 38
CS_38 NS_38 0 9.9999999999999998e-13
RS_38 NS_38 0 2.3335966643407150e+02
GS_38_10 0 NS_38 NA_10 0 1.6432470179296438e-01
*
* Real pole n. 39
CS_39 NS_39 0 9.9999999999999998e-13
RS_39 NS_39 0 5.2309713510215488e+02
GS_39_10 0 NS_39 NA_10 0 1.6432470179296438e-01
*
* Real pole n. 40
CS_40 NS_40 0 9.9999999999999998e-13
RS_40 NS_40 0 1.5848590426319693e+03
GS_40_10 0 NS_40 NA_10 0 1.6432470179296438e-01
*
* Real pole n. 41
CS_41 NS_41 0 9.9999999999999998e-13
RS_41 NS_41 0 1.2037931961600535e+02
GS_41_11 0 NS_41 NA_11 0 1.6432470179296438e-01
*
* Real pole n. 42
CS_42 NS_42 0 9.9999999999999998e-13
RS_42 NS_42 0 2.3335966643407150e+02
GS_42_11 0 NS_42 NA_11 0 1.6432470179296438e-01
*
* Real pole n. 43
CS_43 NS_43 0 9.9999999999999998e-13
RS_43 NS_43 0 5.2309713510215488e+02
GS_43_11 0 NS_43 NA_11 0 1.6432470179296438e-01
*
* Real pole n. 44
CS_44 NS_44 0 9.9999999999999998e-13
RS_44 NS_44 0 1.5848590426319693e+03
GS_44_11 0 NS_44 NA_11 0 1.6432470179296438e-01
*
* Real pole n. 45
CS_45 NS_45 0 9.9999999999999998e-13
RS_45 NS_45 0 1.2037931961600535e+02
GS_45_12 0 NS_45 NA_12 0 1.6432470179296438e-01
*
* Real pole n. 46
CS_46 NS_46 0 9.9999999999999998e-13
RS_46 NS_46 0 2.3335966643407150e+02
GS_46_12 0 NS_46 NA_12 0 1.6432470179296438e-01
*
* Real pole n. 47
CS_47 NS_47 0 9.9999999999999998e-13
RS_47 NS_47 0 5.2309713510215488e+02
GS_47_12 0 NS_47 NA_12 0 1.6432470179296438e-01
*
* Real pole n. 48
CS_48 NS_48 0 9.9999999999999998e-13
RS_48 NS_48 0 1.5848590426319693e+03
GS_48_12 0 NS_48 NA_12 0 1.6432470179296438e-01
*
* Real pole n. 49
CS_49 NS_49 0 9.9999999999999998e-13
RS_49 NS_49 0 1.2037931961600535e+02
GS_49_13 0 NS_49 NA_13 0 1.6432470179296438e-01
*
* Real pole n. 50
CS_50 NS_50 0 9.9999999999999998e-13
RS_50 NS_50 0 2.3335966643407150e+02
GS_50_13 0 NS_50 NA_13 0 1.6432470179296438e-01
*
* Real pole n. 51
CS_51 NS_51 0 9.9999999999999998e-13
RS_51 NS_51 0 5.2309713510215488e+02
GS_51_13 0 NS_51 NA_13 0 1.6432470179296438e-01
*
* Real pole n. 52
CS_52 NS_52 0 9.9999999999999998e-13
RS_52 NS_52 0 1.5848590426319693e+03
GS_52_13 0 NS_52 NA_13 0 1.6432470179296438e-01
*
* Real pole n. 53
CS_53 NS_53 0 9.9999999999999998e-13
RS_53 NS_53 0 1.2037931961600535e+02
GS_53_14 0 NS_53 NA_14 0 1.6432470179296438e-01
*
* Real pole n. 54
CS_54 NS_54 0 9.9999999999999998e-13
RS_54 NS_54 0 2.3335966643407150e+02
GS_54_14 0 NS_54 NA_14 0 1.6432470179296438e-01
*
* Real pole n. 55
CS_55 NS_55 0 9.9999999999999998e-13
RS_55 NS_55 0 5.2309713510215488e+02
GS_55_14 0 NS_55 NA_14 0 1.6432470179296438e-01
*
* Real pole n. 56
CS_56 NS_56 0 9.9999999999999998e-13
RS_56 NS_56 0 1.5848590426319693e+03
GS_56_14 0 NS_56 NA_14 0 1.6432470179296438e-01
*
* Real pole n. 57
CS_57 NS_57 0 9.9999999999999998e-13
RS_57 NS_57 0 1.2037931961600535e+02
GS_57_15 0 NS_57 NA_15 0 1.6432470179296438e-01
*
* Real pole n. 58
CS_58 NS_58 0 9.9999999999999998e-13
RS_58 NS_58 0 2.3335966643407150e+02
GS_58_15 0 NS_58 NA_15 0 1.6432470179296438e-01
*
* Real pole n. 59
CS_59 NS_59 0 9.9999999999999998e-13
RS_59 NS_59 0 5.2309713510215488e+02
GS_59_15 0 NS_59 NA_15 0 1.6432470179296438e-01
*
* Real pole n. 60
CS_60 NS_60 0 9.9999999999999998e-13
RS_60 NS_60 0 1.5848590426319693e+03
GS_60_15 0 NS_60 NA_15 0 1.6432470179296438e-01
*
* Real pole n. 61
CS_61 NS_61 0 9.9999999999999998e-13
RS_61 NS_61 0 1.2037931961600535e+02
GS_61_16 0 NS_61 NA_16 0 1.6432470179296438e-01
*
* Real pole n. 62
CS_62 NS_62 0 9.9999999999999998e-13
RS_62 NS_62 0 2.3335966643407150e+02
GS_62_16 0 NS_62 NA_16 0 1.6432470179296438e-01
*
* Real pole n. 63
CS_63 NS_63 0 9.9999999999999998e-13
RS_63 NS_63 0 5.2309713510215488e+02
GS_63_16 0 NS_63 NA_16 0 1.6432470179296438e-01
*
* Real pole n. 64
CS_64 NS_64 0 9.9999999999999998e-13
RS_64 NS_64 0 1.5848590426319693e+03
GS_64_16 0 NS_64 NA_16 0 1.6432470179296438e-01
*
* Real pole n. 65
CS_65 NS_65 0 9.9999999999999998e-13
RS_65 NS_65 0 1.2037931961600535e+02
GS_65_17 0 NS_65 NA_17 0 1.6432470179296438e-01
*
* Real pole n. 66
CS_66 NS_66 0 9.9999999999999998e-13
RS_66 NS_66 0 2.3335966643407150e+02
GS_66_17 0 NS_66 NA_17 0 1.6432470179296438e-01
*
* Real pole n. 67
CS_67 NS_67 0 9.9999999999999998e-13
RS_67 NS_67 0 5.2309713510215488e+02
GS_67_17 0 NS_67 NA_17 0 1.6432470179296438e-01
*
* Real pole n. 68
CS_68 NS_68 0 9.9999999999999998e-13
RS_68 NS_68 0 1.5848590426319693e+03
GS_68_17 0 NS_68 NA_17 0 1.6432470179296438e-01
*
* Real pole n. 69
CS_69 NS_69 0 9.9999999999999998e-13
RS_69 NS_69 0 1.2037931961600535e+02
GS_69_18 0 NS_69 NA_18 0 1.6432470179296438e-01
*
* Real pole n. 70
CS_70 NS_70 0 9.9999999999999998e-13
RS_70 NS_70 0 2.3335966643407150e+02
GS_70_18 0 NS_70 NA_18 0 1.6432470179296438e-01
*
* Real pole n. 71
CS_71 NS_71 0 9.9999999999999998e-13
RS_71 NS_71 0 5.2309713510215488e+02
GS_71_18 0 NS_71 NA_18 0 1.6432470179296438e-01
*
* Real pole n. 72
CS_72 NS_72 0 9.9999999999999998e-13
RS_72 NS_72 0 1.5848590426319693e+03
GS_72_18 0 NS_72 NA_18 0 1.6432470179296438e-01
*
* Real pole n. 73
CS_73 NS_73 0 9.9999999999999998e-13
RS_73 NS_73 0 1.2037931961600535e+02
GS_73_19 0 NS_73 NA_19 0 1.6432470179296438e-01
*
* Real pole n. 74
CS_74 NS_74 0 9.9999999999999998e-13
RS_74 NS_74 0 2.3335966643407150e+02
GS_74_19 0 NS_74 NA_19 0 1.6432470179296438e-01
*
* Real pole n. 75
CS_75 NS_75 0 9.9999999999999998e-13
RS_75 NS_75 0 5.2309713510215488e+02
GS_75_19 0 NS_75 NA_19 0 1.6432470179296438e-01
*
* Real pole n. 76
CS_76 NS_76 0 9.9999999999999998e-13
RS_76 NS_76 0 1.5848590426319693e+03
GS_76_19 0 NS_76 NA_19 0 1.6432470179296438e-01
*
* Real pole n. 77
CS_77 NS_77 0 9.9999999999999998e-13
RS_77 NS_77 0 1.2037931961600535e+02
GS_77_20 0 NS_77 NA_20 0 1.6432470179296438e-01
*
* Real pole n. 78
CS_78 NS_78 0 9.9999999999999998e-13
RS_78 NS_78 0 2.3335966643407150e+02
GS_78_20 0 NS_78 NA_20 0 1.6432470179296438e-01
*
* Real pole n. 79
CS_79 NS_79 0 9.9999999999999998e-13
RS_79 NS_79 0 5.2309713510215488e+02
GS_79_20 0 NS_79 NA_20 0 1.6432470179296438e-01
*
* Real pole n. 80
CS_80 NS_80 0 9.9999999999999998e-13
RS_80 NS_80 0 1.5848590426319693e+03
GS_80_20 0 NS_80 NA_20 0 1.6432470179296438e-01
*
* Real pole n. 81
CS_81 NS_81 0 9.9999999999999998e-13
RS_81 NS_81 0 1.2037931961600535e+02
GS_81_21 0 NS_81 NA_21 0 1.6432470179296438e-01
*
* Real pole n. 82
CS_82 NS_82 0 9.9999999999999998e-13
RS_82 NS_82 0 2.3335966643407150e+02
GS_82_21 0 NS_82 NA_21 0 1.6432470179296438e-01
*
* Real pole n. 83
CS_83 NS_83 0 9.9999999999999998e-13
RS_83 NS_83 0 5.2309713510215488e+02
GS_83_21 0 NS_83 NA_21 0 1.6432470179296438e-01
*
* Real pole n. 84
CS_84 NS_84 0 9.9999999999999998e-13
RS_84 NS_84 0 1.5848590426319693e+03
GS_84_21 0 NS_84 NA_21 0 1.6432470179296438e-01
*
* Real pole n. 85
CS_85 NS_85 0 9.9999999999999998e-13
RS_85 NS_85 0 1.2037931961600535e+02
GS_85_22 0 NS_85 NA_22 0 1.6432470179296438e-01
*
* Real pole n. 86
CS_86 NS_86 0 9.9999999999999998e-13
RS_86 NS_86 0 2.3335966643407150e+02
GS_86_22 0 NS_86 NA_22 0 1.6432470179296438e-01
*
* Real pole n. 87
CS_87 NS_87 0 9.9999999999999998e-13
RS_87 NS_87 0 5.2309713510215488e+02
GS_87_22 0 NS_87 NA_22 0 1.6432470179296438e-01
*
* Real pole n. 88
CS_88 NS_88 0 9.9999999999999998e-13
RS_88 NS_88 0 1.5848590426319693e+03
GS_88_22 0 NS_88 NA_22 0 1.6432470179296438e-01
*
******************************

.ends
*******************
* End of subcircuit
*******************
