**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 07-May-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0000_PSI_S-parameter_Sweep_w_IPD_exp_L4_break
**   Design: unknown
**  Creation time: Wed May 07 21:10:49 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Wed May  7 21:10:49 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_GRP_1_0_VDDCR_PCCX_DIE1_GRP_1_0_VSS
**  Port[2] = PORT_1_IPD1_VDDCR_PCCX_Group_IPD1_VSS_Group
**  Port[3] = PORT_2_BGA1_VDDCR_PCCX_Group_BGA1_VSS_Group
**  Port[4] = VDDCR_PCCX_B1_2
**  Port[5] = VDDCR_PCCX_B2_2
**  Port[6] = VDDCR_PCCX_B3_2
**  Port[7] = VDDCR_PCCX_B4_2
**  Port[8] = VDDCR_PCCX_C11_1
**  Port[9] = VDDCR_PCCX_C14_1
**  Port[10] = VDDCR_PCCX_C15_2
**  Port[11] = VDDCR_PCCX_C20_1
**  Port[12] = VDDCR_PCCX_C25_2
**  Port[13] = VDDCR_PCCX_C26_1
**  Port[14] = VDDCR_PCCX_C107_1
**  Port[15] = VDDCR_PCCX_C110_2
**  Port[16] = VDDCR_PCCX_C111_1
**  Port[17] = VDDCR_PCCX_C112_1
**  Port[18] = VDDCR_PCCX_C113_1
**  Port[19] = VDDCR_PCCX_C114_1
**  Port[20] = VDDCR_PCCX_C115_2
**  Port[21] = VDDCR_PCCX_C116_2
**  Port[22] = VDDCR_PCCX_C117_1
**  Port[23] = VDDCR_PCCX_C118_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_PCCX_exp_L4_break
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 a_16 a_17 a_18 a_19 a_20 a_21 a_22 a_23 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -1.1713110626900702e+01
GC_1_2 ref NI_1 NS_2 0 -4.1481946841270174e+00
GC_1_3 ref NI_1 NS_3 0 6.4498142165920092e-01
GC_1_4 ref NI_1 NS_4 0 -1.8635082665493985e-01
GC_1_5 ref NI_1 NS_5 0 -9.0386435916089633e-04
GC_1_6 ref NI_1 NS_6 0 -3.5733699452006031e-02
GC_1_7 ref NI_1 NS_7 0 1.0581158341225350e+01
GC_1_8 ref NI_1 NS_8 0 -3.2226065145486378e+00
GC_1_9 ref NI_1 NS_9 0 5.0873659223939716e-01
GC_1_10 ref NI_1 NS_10 0 -1.2841569840516304e-01
GC_1_11 ref NI_1 NS_11 0 -2.9274541978607457e-04
GC_1_12 ref NI_1 NS_12 0 -1.9046085238722317e-02
GC_1_13 ref NI_1 NS_13 0 9.6268810950018455e+00
GC_1_14 ref NI_1 NS_14 0 -3.3921577209917171e+00
GC_1_15 ref NI_1 NS_15 0 8.7102441007674969e-01
GC_1_16 ref NI_1 NS_16 0 -2.1913724522093184e-01
GC_1_17 ref NI_1 NS_17 0 -5.3773587670122595e-04
GC_1_18 ref NI_1 NS_18 0 -3.0082202189608487e-02
GC_1_19 ref NI_1 NS_19 0 5.0466714703966298e-01
GC_1_20 ref NI_1 NS_20 0 1.2737996516001622e+00
GC_1_21 ref NI_1 NS_21 0 -1.9816075231505437e-01
GC_1_22 ref NI_1 NS_22 0 -2.5558085641255529e-02
GC_1_23 ref NI_1 NS_23 0 -1.8527255705571216e-04
GC_1_24 ref NI_1 NS_24 0 -5.7739251776375899e-02
GC_1_25 ref NI_1 NS_25 0 -6.3131499693435567e-02
GC_1_26 ref NI_1 NS_26 0 9.9074385006535903e-01
GC_1_27 ref NI_1 NS_27 0 9.5720467957243732e-02
GC_1_28 ref NI_1 NS_28 0 -5.6057327432475559e-02
GC_1_29 ref NI_1 NS_29 0 -1.9054871407621690e-04
GC_1_30 ref NI_1 NS_30 0 -5.7549556234309900e-02
GC_1_31 ref NI_1 NS_31 0 -1.8647473234360831e-01
GC_1_32 ref NI_1 NS_32 0 9.3215904419544549e-01
GC_1_33 ref NI_1 NS_33 0 1.6630337386430460e-01
GC_1_34 ref NI_1 NS_34 0 -7.1242953894873354e-02
GC_1_35 ref NI_1 NS_35 0 -2.0876894320911998e-04
GC_1_36 ref NI_1 NS_36 0 -5.6633020365232399e-02
GC_1_37 ref NI_1 NS_37 0 4.4239006129643144e-01
GC_1_38 ref NI_1 NS_38 0 1.4167652248832010e+00
GC_1_39 ref NI_1 NS_39 0 -2.5957397817931865e-01
GC_1_40 ref NI_1 NS_40 0 -2.9149526642358425e-02
GC_1_41 ref NI_1 NS_41 0 -1.9232028586714715e-04
GC_1_42 ref NI_1 NS_42 0 -5.5468133404510116e-02
GC_1_43 ref NI_1 NS_43 0 -2.8047908043275865e-01
GC_1_44 ref NI_1 NS_44 0 8.7818695319878515e-01
GC_1_45 ref NI_1 NS_45 0 -2.6843352286748440e-01
GC_1_46 ref NI_1 NS_46 0 2.4750335795487743e-02
GC_1_47 ref NI_1 NS_47 0 1.0480941346568494e-04
GC_1_48 ref NI_1 NS_48 0 1.4666800077395969e-03
GC_1_49 ref NI_1 NS_49 0 -4.1457218092944936e-01
GC_1_50 ref NI_1 NS_50 0 9.0309654797715000e-01
GC_1_51 ref NI_1 NS_51 0 -1.9779450633054874e-01
GC_1_52 ref NI_1 NS_52 0 6.0768499251703896e-03
GC_1_53 ref NI_1 NS_53 0 1.3540559708066888e-04
GC_1_54 ref NI_1 NS_54 0 -4.8861194647634772e-03
GC_1_55 ref NI_1 NS_55 0 -2.4631614644050331e-01
GC_1_56 ref NI_1 NS_56 0 8.1735171312409594e-02
GC_1_57 ref NI_1 NS_57 0 -1.1247637307315234e-01
GC_1_58 ref NI_1 NS_58 0 8.4880149313912273e-02
GC_1_59 ref NI_1 NS_59 0 1.8343122464636855e-04
GC_1_60 ref NI_1 NS_60 0 3.1415994312251845e-02
GC_1_61 ref NI_1 NS_61 0 -4.2177298614164549e-01
GC_1_62 ref NI_1 NS_62 0 3.6858918916096234e-01
GC_1_63 ref NI_1 NS_63 0 -2.7374108281507544e-02
GC_1_64 ref NI_1 NS_64 0 1.7812798790059686e-02
GC_1_65 ref NI_1 NS_65 0 1.3127513587145862e-04
GC_1_66 ref NI_1 NS_66 0 1.4244648422013504e-02
GC_1_67 ref NI_1 NS_67 0 -3.0781322290695856e-01
GC_1_68 ref NI_1 NS_68 0 4.2018354043215850e-01
GC_1_69 ref NI_1 NS_69 0 -7.9427154615393680e-02
GC_1_70 ref NI_1 NS_70 0 3.8849796168909351e-02
GC_1_71 ref NI_1 NS_71 0 2.3072388375172168e-04
GC_1_72 ref NI_1 NS_72 0 8.5373770849702085e-03
GC_1_73 ref NI_1 NS_73 0 -3.8702097558609805e-01
GC_1_74 ref NI_1 NS_74 0 4.9546184474753985e-01
GC_1_75 ref NI_1 NS_75 0 -7.4925020060313874e-02
GC_1_76 ref NI_1 NS_76 0 2.2538054364362885e-02
GC_1_77 ref NI_1 NS_77 0 1.9397277757273051e-04
GC_1_78 ref NI_1 NS_78 0 7.1802317747654120e-03
GC_1_79 ref NI_1 NS_79 0 -4.0432832632723958e-01
GC_1_80 ref NI_1 NS_80 0 6.2945472176712924e-01
GC_1_81 ref NI_1 NS_81 0 -1.5009394070302137e-01
GC_1_82 ref NI_1 NS_82 0 1.7676513504457578e-02
GC_1_83 ref NI_1 NS_83 0 1.4739524728237340e-04
GC_1_84 ref NI_1 NS_84 0 9.6532236922229672e-03
GC_1_85 ref NI_1 NS_85 0 -3.8479582149003516e-01
GC_1_86 ref NI_1 NS_86 0 5.9418583007210402e-01
GC_1_87 ref NI_1 NS_87 0 -3.8230752932826330e-02
GC_1_88 ref NI_1 NS_88 0 7.5423262341931139e-03
GC_1_89 ref NI_1 NS_89 0 1.9011592827668835e-04
GC_1_90 ref NI_1 NS_90 0 -3.8472481034820460e-03
GC_1_91 ref NI_1 NS_91 0 -2.5535249513390085e-01
GC_1_92 ref NI_1 NS_92 0 1.1007199068679209e-01
GC_1_93 ref NI_1 NS_93 0 -1.1242365235454960e-01
GC_1_94 ref NI_1 NS_94 0 7.3855394376871372e-02
GC_1_95 ref NI_1 NS_95 0 1.5433867083535451e-04
GC_1_96 ref NI_1 NS_96 0 3.2448921333429664e-02
GC_1_97 ref NI_1 NS_97 0 -2.4190104547637509e-01
GC_1_98 ref NI_1 NS_98 0 1.1842638415934967e-01
GC_1_99 ref NI_1 NS_99 0 -1.3839045499947250e-01
GC_1_100 ref NI_1 NS_100 0 6.9274418068891466e-02
GC_1_101 ref NI_1 NS_101 0 1.2067531001633592e-04
GC_1_102 ref NI_1 NS_102 0 3.8292931086164550e-02
GC_1_103 ref NI_1 NS_103 0 -2.7025694441665338e-01
GC_1_104 ref NI_1 NS_104 0 8.2571790816241011e-02
GC_1_105 ref NI_1 NS_105 0 -4.4770343833530415e-02
GC_1_106 ref NI_1 NS_106 0 4.2858054316382739e-02
GC_1_107 ref NI_1 NS_107 0 1.3709523597160318e-04
GC_1_108 ref NI_1 NS_108 0 3.4261863440170494e-02
GC_1_109 ref NI_1 NS_109 0 -3.5594706045532865e-01
GC_1_110 ref NI_1 NS_110 0 1.5172246835881079e-01
GC_1_111 ref NI_1 NS_111 0 1.5777917358995461e-02
GC_1_112 ref NI_1 NS_112 0 2.4086665602124174e-02
GC_1_113 ref NI_1 NS_113 0 1.3504919675394307e-04
GC_1_114 ref NI_1 NS_114 0 2.4697256272081598e-02
GC_1_115 ref NI_1 NS_115 0 -2.4100864812124434e-01
GC_1_116 ref NI_1 NS_116 0 1.1658549013891151e-01
GC_1_117 ref NI_1 NS_117 0 -1.3818434594350082e-01
GC_1_118 ref NI_1 NS_118 0 5.9471642872028406e-02
GC_1_119 ref NI_1 NS_119 0 1.3711391774101381e-04
GC_1_120 ref NI_1 NS_120 0 4.1708122990769349e-02
GC_1_121 ref NI_1 NS_121 0 -2.7130070015540592e-01
GC_1_122 ref NI_1 NS_122 0 1.1766696109763169e-01
GC_1_123 ref NI_1 NS_123 0 -5.2255745903259446e-02
GC_1_124 ref NI_1 NS_124 0 4.8731961432122363e-02
GC_1_125 ref NI_1 NS_125 0 1.2973968409611285e-04
GC_1_126 ref NI_1 NS_126 0 3.0437395145976459e-02
GC_1_127 ref NI_1 NS_127 0 -2.7788959523966794e-01
GC_1_128 ref NI_1 NS_128 0 1.4598328769697003e-01
GC_1_129 ref NI_1 NS_129 0 -6.8049162264507579e-02
GC_1_130 ref NI_1 NS_130 0 6.1116702917712533e-02
GC_1_131 ref NI_1 NS_131 0 1.5441795604818870e-04
GC_1_132 ref NI_1 NS_132 0 2.6092998627833534e-02
GC_1_133 ref NI_1 NS_133 0 -3.1736557929819686e-01
GC_1_134 ref NI_1 NS_134 0 1.5224606068889474e-01
GC_1_135 ref NI_1 NS_135 0 -5.9341238623398671e-02
GC_1_136 ref NI_1 NS_136 0 6.3703565407335405e-02
GC_1_137 ref NI_1 NS_137 0 1.7687275088867240e-04
GC_1_138 ref NI_1 NS_138 0 2.3626366286836710e-02
GD_1_1 ref NI_1 NA_1 0 4.8997414466338816e+00
GD_1_2 ref NI_1 NA_2 0 8.1655038089756188e-02
GD_1_3 ref NI_1 NA_3 0 4.2435644688675239e-01
GD_1_4 ref NI_1 NA_4 0 -1.7961083525412996e-01
GD_1_5 ref NI_1 NA_5 0 -9.9990563787522330e-02
GD_1_6 ref NI_1 NA_6 0 -7.3327264203192952e-02
GD_1_7 ref NI_1 NA_7 0 -2.1769754306249581e-01
GD_1_8 ref NI_1 NA_8 0 -5.3667705264675361e-02
GD_1_9 ref NI_1 NA_9 0 -4.0672665800542032e-02
GD_1_10 ref NI_1 NA_10 0 4.9172876199815439e-02
GD_1_11 ref NI_1 NA_11 0 2.7063371201476942e-02
GD_1_12 ref NI_1 NA_12 0 1.8826814727583698e-03
GD_1_13 ref NI_1 NA_13 0 7.1498621951984215e-03
GD_1_14 ref NI_1 NA_14 0 -2.6905444672572099e-03
GD_1_15 ref NI_1 NA_15 0 -1.8133545397743610e-02
GD_1_16 ref NI_1 NA_16 0 4.8095124058079586e-02
GD_1_17 ref NI_1 NA_17 0 4.6722942171464416e-02
GD_1_18 ref NI_1 NA_18 0 4.8981565717157290e-02
GD_1_19 ref NI_1 NA_19 0 4.5174813533013794e-02
GD_1_20 ref NI_1 NA_20 0 4.8723166017612431e-02
GD_1_21 ref NI_1 NA_21 0 4.1125165840779479e-02
GD_1_22 ref NI_1 NA_22 0 3.8784598235643279e-02
GD_1_23 ref NI_1 NA_23 0 4.4076164541179977e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 1.0581158341225350e+01
GC_2_2 ref NI_2 NS_2 0 -3.2226065145486364e+00
GC_2_3 ref NI_2 NS_3 0 5.0873659223939582e-01
GC_2_4 ref NI_2 NS_4 0 -1.2841569840516226e-01
GC_2_5 ref NI_2 NS_5 0 -2.9274541978602692e-04
GC_2_6 ref NI_2 NS_6 0 -1.9046085238722525e-02
GC_2_7 ref NI_2 NS_7 0 -1.7192822932278109e+01
GC_2_8 ref NI_2 NS_8 0 -2.5885824945031719e+00
GC_2_9 ref NI_2 NS_9 0 4.4667651279078463e-01
GC_2_10 ref NI_2 NS_10 0 -1.4133464198801088e-01
GC_2_11 ref NI_2 NS_11 0 -6.6482761268852068e-04
GC_2_12 ref NI_2 NS_12 0 -1.5392568239358804e-02
GC_2_13 ref NI_2 NS_13 0 7.5701830237956891e+00
GC_2_14 ref NI_2 NS_14 0 -2.2604453011815111e+00
GC_2_15 ref NI_2 NS_15 0 5.3040282933679017e-01
GC_2_16 ref NI_2 NS_16 0 -1.3363167919500610e-01
GC_2_17 ref NI_2 NS_17 0 -2.8587836120642929e-04
GC_2_18 ref NI_2 NS_18 0 -1.9607005434418998e-02
GC_2_19 ref NI_2 NS_19 0 -3.0007238467011660e-01
GC_2_20 ref NI_2 NS_20 0 1.0454181015817545e+00
GC_2_21 ref NI_2 NS_21 0 -1.4362761015501424e-01
GC_2_22 ref NI_2 NS_22 0 1.4809639645853851e-02
GC_2_23 ref NI_2 NS_23 0 3.5049507924635432e-05
GC_2_24 ref NI_2 NS_24 0 -3.5877078128152752e-02
GC_2_25 ref NI_2 NS_25 0 -4.6376913388286051e-01
GC_2_26 ref NI_2 NS_26 0 7.5056374713139362e-01
GC_2_27 ref NI_2 NS_27 0 7.5885264056867102e-02
GC_2_28 ref NI_2 NS_28 0 -6.2525493931546803e-03
GC_2_29 ref NI_2 NS_29 0 1.5826720976657645e-05
GC_2_30 ref NI_2 NS_30 0 -3.5511794326227877e-02
GC_2_31 ref NI_2 NS_31 0 -4.8960597525755917e-01
GC_2_32 ref NI_2 NS_32 0 7.0482082217119313e-01
GC_2_33 ref NI_2 NS_33 0 1.2422770847312650e-01
GC_2_34 ref NI_2 NS_34 0 -1.8071437358501388e-02
GC_2_35 ref NI_2 NS_35 0 -6.1916089781413896e-06
GC_2_36 ref NI_2 NS_36 0 -3.5128326063912946e-02
GC_2_37 ref NI_2 NS_37 0 1.8710315447127826e-02
GC_2_38 ref NI_2 NS_38 0 1.0818294968736311e+00
GC_2_39 ref NI_2 NS_39 0 -1.8899327563549423e-01
GC_2_40 ref NI_2 NS_40 0 4.5160205477008534e-03
GC_2_41 ref NI_2 NS_41 0 -1.8414311526891862e-05
GC_2_42 ref NI_2 NS_42 0 -3.4882099921957108e-02
GC_2_43 ref NI_2 NS_43 0 1.3118747945125102e+00
GC_2_44 ref NI_2 NS_44 0 5.1276538772976876e-01
GC_2_45 ref NI_2 NS_45 0 -2.5716960187540699e-01
GC_2_46 ref NI_2 NS_46 0 -2.1103159890354682e-02
GC_2_47 ref NI_2 NS_47 0 -2.1332082236921433e-06
GC_2_48 ref NI_2 NS_48 0 -2.6239004284109979e-04
GC_2_49 ref NI_2 NS_49 0 1.0990388615087021e+00
GC_2_50 ref NI_2 NS_50 0 6.3598491429094262e-01
GC_2_51 ref NI_2 NS_51 0 -2.3539949025764353e-01
GC_2_52 ref NI_2 NS_52 0 -4.3969210374623910e-02
GC_2_53 ref NI_2 NS_53 0 3.1287227576952584e-05
GC_2_54 ref NI_2 NS_54 0 -4.2903670579072526e-03
GC_2_55 ref NI_2 NS_55 0 -1.7457248658094418e-01
GC_2_56 ref NI_2 NS_56 0 3.0212847608036907e-02
GC_2_57 ref NI_2 NS_57 0 -4.5335503602083285e-02
GC_2_58 ref NI_2 NS_58 0 8.8659002895503394e-02
GC_2_59 ref NI_2 NS_59 0 1.2541063087357672e-04
GC_2_60 ref NI_2 NS_60 0 2.0225540002400375e-02
GC_2_61 ref NI_2 NS_61 0 1.2848174483766867e-01
GC_2_62 ref NI_2 NS_62 0 3.5234370585886282e-01
GC_2_63 ref NI_2 NS_63 0 -3.7245479059274285e-02
GC_2_64 ref NI_2 NS_64 0 -1.1597862736900484e-02
GC_2_65 ref NI_2 NS_65 0 4.8545626740698135e-05
GC_2_66 ref NI_2 NS_66 0 8.6324321656576202e-03
GC_2_67 ref NI_2 NS_67 0 3.0114683481360172e-01
GC_2_68 ref NI_2 NS_68 0 3.1338872577606763e-01
GC_2_69 ref NI_2 NS_69 0 -5.0497807750310715e-02
GC_2_70 ref NI_2 NS_70 0 4.2870565511225053e-03
GC_2_71 ref NI_2 NS_71 0 1.5605853991684286e-04
GC_2_72 ref NI_2 NS_72 0 4.7780171908117109e-03
GC_2_73 ref NI_2 NS_73 0 2.9458397142923548e-01
GC_2_74 ref NI_2 NS_74 0 4.1236438694447070e-01
GC_2_75 ref NI_2 NS_75 0 -7.7329774100820037e-02
GC_2_76 ref NI_2 NS_76 0 -1.2067559817462317e-02
GC_2_77 ref NI_2 NS_77 0 1.1775929099477401e-04
GC_2_78 ref NI_2 NS_78 0 3.9611596252881994e-03
GC_2_79 ref NI_2 NS_79 0 8.8577780951543583e-01
GC_2_80 ref NI_2 NS_80 0 4.2079382628863987e-01
GC_2_81 ref NI_2 NS_81 0 -1.5648784849359115e-01
GC_2_82 ref NI_2 NS_82 0 -2.6339969253522121e-02
GC_2_83 ref NI_2 NS_83 0 3.7483704943342375e-05
GC_2_84 ref NI_2 NS_84 0 5.1430015188595928e-03
GC_2_85 ref NI_2 NS_85 0 6.8888637831491895e-01
GC_2_86 ref NI_2 NS_86 0 4.4481844870665271e-01
GC_2_87 ref NI_2 NS_87 0 -4.3808815810288407e-02
GC_2_88 ref NI_2 NS_88 0 -5.1923759474371223e-02
GC_2_89 ref NI_2 NS_89 0 9.2249614641371603e-05
GC_2_90 ref NI_2 NS_90 0 -3.4626224335739461e-03
GC_2_91 ref NI_2 NS_91 0 -1.5871170719539546e-01
GC_2_92 ref NI_2 NS_92 0 6.0289637315428947e-02
GC_2_93 ref NI_2 NS_93 0 -5.5610849465048295e-02
GC_2_94 ref NI_2 NS_94 0 7.9952225105205735e-02
GC_2_95 ref NI_2 NS_95 0 9.6728574548783807e-05
GC_2_96 ref NI_2 NS_96 0 2.1142142590921131e-02
GC_2_97 ref NI_2 NS_97 0 -1.5348258309074586e-01
GC_2_98 ref NI_2 NS_98 0 6.2004572866819346e-02
GC_2_99 ref NI_2 NS_99 0 -8.5179269368225285e-02
GC_2_100 ref NI_2 NS_100 0 8.6672856418892996e-02
GC_2_101 ref NI_2 NS_101 0 5.6258109288118163e-05
GC_2_102 ref NI_2 NS_102 0 2.4975776595230873e-02
GC_2_103 ref NI_2 NS_103 0 -1.3587899632288106e-01
GC_2_104 ref NI_2 NS_104 0 5.9278404488636569e-02
GC_2_105 ref NI_2 NS_105 0 1.0086531812562440e-02
GC_2_106 ref NI_2 NS_106 0 3.9817514758437041e-02
GC_2_107 ref NI_2 NS_107 0 5.2037233622392038e-05
GC_2_108 ref NI_2 NS_108 0 2.2503193053595386e-02
GC_2_109 ref NI_2 NS_109 0 -1.4435216589523396e-02
GC_2_110 ref NI_2 NS_110 0 1.5982686661130882e-01
GC_2_111 ref NI_2 NS_111 0 4.4026304177366048e-02
GC_2_112 ref NI_2 NS_112 0 -1.8333766233659533e-03
GC_2_113 ref NI_2 NS_113 0 4.1118748290335486e-05
GC_2_114 ref NI_2 NS_114 0 1.5777953058230595e-02
GC_2_115 ref NI_2 NS_115 0 -1.5567517452819851e-01
GC_2_116 ref NI_2 NS_116 0 5.8454275541659009e-02
GC_2_117 ref NI_2 NS_117 0 -8.5140652899250088e-02
GC_2_118 ref NI_2 NS_118 0 8.0843242785318500e-02
GC_2_119 ref NI_2 NS_119 0 5.5978043963530521e-05
GC_2_120 ref NI_2 NS_120 0 2.7464712060927130e-02
GC_2_121 ref NI_2 NS_121 0 -1.0924691784930883e-01
GC_2_122 ref NI_2 NS_122 0 9.1131772870259531e-02
GC_2_123 ref NI_2 NS_123 0 -6.3650908843636477e-03
GC_2_124 ref NI_2 NS_124 0 4.5370379331732887e-02
GC_2_125 ref NI_2 NS_125 0 6.0928152917991316e-05
GC_2_126 ref NI_2 NS_126 0 1.9789479605078191e-02
GC_2_127 ref NI_2 NS_127 0 -9.0097765333877186e-02
GC_2_128 ref NI_2 NS_128 0 1.0647374900338233e-01
GC_2_129 ref NI_2 NS_129 0 -1.9730478324305502e-02
GC_2_130 ref NI_2 NS_130 0 5.4081999794319519e-02
GC_2_131 ref NI_2 NS_131 0 9.3914290273084820e-05
GC_2_132 ref NI_2 NS_132 0 1.6728503145072387e-02
GC_2_133 ref NI_2 NS_133 0 -1.2744926517793076e-01
GC_2_134 ref NI_2 NS_134 0 1.2374366550819896e-01
GC_2_135 ref NI_2 NS_135 0 -1.4435214061498216e-02
GC_2_136 ref NI_2 NS_136 0 5.3317596122806697e-02
GC_2_137 ref NI_2 NS_137 0 1.1481253392704796e-04
GC_2_138 ref NI_2 NS_138 0 1.4997235712712963e-02
GD_2_1 ref NI_2 NA_1 0 8.1655038089756188e-02
GD_2_2 ref NI_2 NA_2 0 5.1245579300646940e+00
GD_2_3 ref NI_2 NA_3 0 2.4434739068012346e-02
GD_2_4 ref NI_2 NA_4 0 -8.7814037238242326e-02
GD_2_5 ref NI_2 NA_5 0 -3.4096564361726082e-02
GD_2_6 ref NI_2 NA_6 0 -2.3175799104941223e-02
GD_2_7 ref NI_2 NA_7 0 -1.3128652999842433e-01
GD_2_8 ref NI_2 NA_8 0 -3.0894781079569351e-02
GD_2_9 ref NI_2 NA_9 0 -1.4430548915370522e-02
GD_2_10 ref NI_2 NA_10 0 4.7415529532657263e-02
GD_2_11 ref NI_2 NA_11 0 3.4354148756994794e-02
GD_2_12 ref NI_2 NA_12 0 1.8758992449274193e-02
GD_2_13 ref NI_2 NA_13 0 2.7884558551177208e-02
GD_2_14 ref NI_2 NA_14 0 -1.5902630717779160e-03
GD_2_15 ref NI_2 NA_15 0 1.7565446769250391e-03
GD_2_16 ref NI_2 NA_16 0 4.8854670325561164e-02
GD_2_17 ref NI_2 NA_17 0 4.3194806671855011e-02
GD_2_18 ref NI_2 NA_18 0 4.9283336592269487e-02
GD_2_19 ref NI_2 NA_19 0 4.3132014646401463e-02
GD_2_20 ref NI_2 NA_20 0 4.4216380779000246e-02
GD_2_21 ref NI_2 NA_21 0 4.2025253040731764e-02
GD_2_22 ref NI_2 NA_22 0 4.1296069638525459e-02
GD_2_23 ref NI_2 NA_23 0 4.4441747881328805e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 9.6268810950018455e+00
GC_3_2 ref NI_3 NS_2 0 -3.3921577209917171e+00
GC_3_3 ref NI_3 NS_3 0 8.7102441007674969e-01
GC_3_4 ref NI_3 NS_4 0 -2.1913724522093189e-01
GC_3_5 ref NI_3 NS_5 0 -5.3773587670122888e-04
GC_3_6 ref NI_3 NS_6 0 -3.0082202189608477e-02
GC_3_7 ref NI_3 NS_7 0 7.5701830237956891e+00
GC_3_8 ref NI_3 NS_8 0 -2.2604453011815133e+00
GC_3_9 ref NI_3 NS_9 0 5.3040282933679250e-01
GC_3_10 ref NI_3 NS_10 0 -1.3363167919500740e-01
GC_3_11 ref NI_3 NS_11 0 -2.8587836120650968e-04
GC_3_12 ref NI_3 NS_12 0 -1.9607005434418644e-02
GC_3_13 ref NI_3 NS_13 0 -1.7552269562974402e+01
GC_3_14 ref NI_3 NS_14 0 -7.9799023940837921e-01
GC_3_15 ref NI_3 NS_15 0 9.8580422623674821e-02
GC_3_16 ref NI_3 NS_16 0 -9.8841914614708690e-02
GC_3_17 ref NI_3 NS_17 0 -6.2800669682564999e-04
GC_3_18 ref NI_3 NS_18 0 -4.4272326942926189e-02
GC_3_19 ref NI_3 NS_19 0 2.1066218124043554e+00
GC_3_20 ref NI_3 NS_20 0 4.4032397250668215e-01
GC_3_21 ref NI_3 NS_21 0 -1.7332217448709088e-02
GC_3_22 ref NI_3 NS_22 0 -7.5440494582632467e-02
GC_3_23 ref NI_3 NS_23 0 -1.4567466505266329e-04
GC_3_24 ref NI_3 NS_24 0 -6.0656922428753840e-02
GC_3_25 ref NI_3 NS_25 0 1.4461820559344565e+00
GC_3_26 ref NI_3 NS_26 0 4.1402755200027797e-01
GC_3_27 ref NI_3 NS_27 0 1.4468228285614224e-01
GC_3_28 ref NI_3 NS_28 0 -9.3251446031111102e-02
GC_3_29 ref NI_3 NS_29 0 -1.4991022395467567e-04
GC_3_30 ref NI_3 NS_30 0 -6.1444371031534176e-02
GC_3_31 ref NI_3 NS_31 0 1.1920255838045106e+00
GC_3_32 ref NI_3 NS_32 0 4.9856247155031608e-01
GC_3_33 ref NI_3 NS_33 0 1.6673609967905478e-01
GC_3_34 ref NI_3 NS_34 0 -1.0215266480194252e-01
GC_3_35 ref NI_3 NS_35 0 -1.7430835694349689e-04
GC_3_36 ref NI_3 NS_36 0 -6.0946082950038630e-02
GC_3_37 ref NI_3 NS_37 0 2.5112305371652188e+00
GC_3_38 ref NI_3 NS_38 0 3.9158019793580884e-01
GC_3_39 ref NI_3 NS_39 0 -4.1491205364675467e-02
GC_3_40 ref NI_3 NS_40 0 -8.5936393758039520e-02
GC_3_41 ref NI_3 NS_41 0 -1.8876319040506866e-04
GC_3_42 ref NI_3 NS_42 0 -5.7762355924834689e-02
GC_3_43 ref NI_3 NS_43 0 2.4478296457623536e-01
GC_3_44 ref NI_3 NS_44 0 4.2120983869687567e-01
GC_3_45 ref NI_3 NS_45 0 -9.2065900161605360e-02
GC_3_46 ref NI_3 NS_46 0 2.0294882619342106e-02
GC_3_47 ref NI_3 NS_47 0 6.1058167943340316e-05
GC_3_48 ref NI_3 NS_48 0 2.7814772816358770e-03
GC_3_49 ref NI_3 NS_49 0 2.6396330370701510e-01
GC_3_50 ref NI_3 NS_50 0 4.1148984126674248e-01
GC_3_51 ref NI_3 NS_51 0 -2.9263593839232879e-02
GC_3_52 ref NI_3 NS_52 0 5.9996061730746269e-03
GC_3_53 ref NI_3 NS_53 0 8.9678483133321738e-05
GC_3_54 ref NI_3 NS_54 0 -4.4351881851193240e-03
GC_3_55 ref NI_3 NS_55 0 -2.0902376238791703e-01
GC_3_56 ref NI_3 NS_56 0 1.0906037491579111e-01
GC_3_57 ref NI_3 NS_57 0 -1.2832249294188597e-01
GC_3_58 ref NI_3 NS_58 0 7.6832145642583879e-02
GC_3_59 ref NI_3 NS_59 0 1.5201037508517261e-04
GC_3_60 ref NI_3 NS_60 0 3.3781511170553641e-02
GC_3_61 ref NI_3 NS_61 0 -3.1123683943519855e-02
GC_3_62 ref NI_3 NS_62 0 1.7788480717455543e-01
GC_3_63 ref NI_3 NS_63 0 -5.4682228133808865e-04
GC_3_64 ref NI_3 NS_64 0 2.6711092128941964e-02
GC_3_65 ref NI_3 NS_65 0 9.9108565644856204e-05
GC_3_66 ref NI_3 NS_66 0 1.5448663689130887e-02
GC_3_67 ref NI_3 NS_67 0 1.4417816930437155e-01
GC_3_68 ref NI_3 NS_68 0 1.8855404567052961e-01
GC_3_69 ref NI_3 NS_69 0 -2.8827246224850132e-02
GC_3_70 ref NI_3 NS_70 0 3.9707521950647071e-02
GC_3_71 ref NI_3 NS_71 0 1.8890392163309396e-04
GC_3_72 ref NI_3 NS_72 0 9.5053623762553167e-03
GC_3_73 ref NI_3 NS_73 0 1.2630963384612659e-01
GC_3_74 ref NI_3 NS_74 0 2.2273567479798898e-01
GC_3_75 ref NI_3 NS_75 0 -1.3748593273190262e-02
GC_3_76 ref NI_3 NS_76 0 2.6020492774443942e-02
GC_3_77 ref NI_3 NS_77 0 1.5307730587713563e-04
GC_3_78 ref NI_3 NS_78 0 8.0045118432013895e-03
GC_3_79 ref NI_3 NS_79 0 -9.5385706714877366e-02
GC_3_80 ref NI_3 NS_80 0 3.3422527635407928e-01
GC_3_81 ref NI_3 NS_81 0 -4.8004688223017226e-02
GC_3_82 ref NI_3 NS_82 0 2.6363492590246406e-02
GC_3_83 ref NI_3 NS_83 0 1.2797494030626787e-04
GC_3_84 ref NI_3 NS_84 0 1.1011087649907525e-02
GC_3_85 ref NI_3 NS_85 0 2.0317975878924155e-01
GC_3_86 ref NI_3 NS_86 0 2.4934436156093495e-01
GC_3_87 ref NI_3 NS_87 0 4.6591683306146624e-02
GC_3_88 ref NI_3 NS_88 0 1.6469463068910496e-02
GC_3_89 ref NI_3 NS_89 0 1.4952681502569573e-04
GC_3_90 ref NI_3 NS_90 0 -3.7734503266905906e-03
GC_3_91 ref NI_3 NS_91 0 -1.9450875053111993e-01
GC_3_92 ref NI_3 NS_92 0 1.1828101275784909e-01
GC_3_93 ref NI_3 NS_93 0 -1.2249430668249446e-01
GC_3_94 ref NI_3 NS_94 0 6.6158590153734584e-02
GC_3_95 ref NI_3 NS_95 0 1.2286314962137043e-04
GC_3_96 ref NI_3 NS_96 0 3.4911529360836274e-02
GC_3_97 ref NI_3 NS_97 0 -2.0950838253639675e-01
GC_3_98 ref NI_3 NS_98 0 1.3469028238048772e-01
GC_3_99 ref NI_3 NS_99 0 -1.4818897519246735e-01
GC_3_100 ref NI_3 NS_100 0 5.9823317089859551e-02
GC_3_101 ref NI_3 NS_101 0 9.1840195664814309e-05
GC_3_102 ref NI_3 NS_102 0 4.1406910506057742e-02
GC_3_103 ref NI_3 NS_103 0 -2.0698293650130156e-01
GC_3_104 ref NI_3 NS_104 0 9.0597519389836512e-02
GC_3_105 ref NI_3 NS_105 0 -7.4860768576248224e-02
GC_3_106 ref NI_3 NS_106 0 4.5605520155114397e-02
GC_3_107 ref NI_3 NS_107 0 1.1709268685895321e-04
GC_3_108 ref NI_3 NS_108 0 3.7034238871495102e-02
GC_3_109 ref NI_3 NS_109 0 -1.9710099990668878e-01
GC_3_110 ref NI_3 NS_110 0 9.6536882585411918e-02
GC_3_111 ref NI_3 NS_111 0 -7.3685608819747204e-03
GC_3_112 ref NI_3 NS_112 0 3.7732924961804949e-02
GC_3_113 ref NI_3 NS_113 0 1.2023354825079018e-04
GC_3_114 ref NI_3 NS_114 0 2.6587954700034222e-02
GC_3_115 ref NI_3 NS_115 0 -2.2806636118337020e-01
GC_3_116 ref NI_3 NS_116 0 1.3881785925506795e-01
GC_3_117 ref NI_3 NS_117 0 -1.5206753930719455e-01
GC_3_118 ref NI_3 NS_118 0 5.0967120888922850e-02
GC_3_119 ref NI_3 NS_119 0 1.1333874876745679e-04
GC_3_120 ref NI_3 NS_120 0 4.5201899545863115e-02
GC_3_121 ref NI_3 NS_121 0 -1.4819480619266526e-01
GC_3_122 ref NI_3 NS_122 0 1.0143799480907283e-01
GC_3_123 ref NI_3 NS_123 0 -7.1420593164368967e-02
GC_3_124 ref NI_3 NS_124 0 4.8704480436738404e-02
GC_3_125 ref NI_3 NS_125 0 9.9166828288135053e-05
GC_3_126 ref NI_3 NS_126 0 3.2825427348997738e-02
GC_3_127 ref NI_3 NS_127 0 -1.2307195692529187e-01
GC_3_128 ref NI_3 NS_128 0 1.1407349886045882e-01
GC_3_129 ref NI_3 NS_129 0 -7.7631243920407461e-02
GC_3_130 ref NI_3 NS_130 0 5.8658801644169124e-02
GC_3_131 ref NI_3 NS_131 0 1.1939921300200691e-04
GC_3_132 ref NI_3 NS_132 0 2.8073958875494805e-02
GC_3_133 ref NI_3 NS_133 0 -1.4350508299895176e-01
GC_3_134 ref NI_3 NS_134 0 1.2050154062343002e-01
GC_3_135 ref NI_3 NS_135 0 -7.2014058085038232e-02
GC_3_136 ref NI_3 NS_136 0 6.2263440680614075e-02
GC_3_137 ref NI_3 NS_137 0 1.4395539855350300e-04
GC_3_138 ref NI_3 NS_138 0 2.5320474964846545e-02
GD_3_1 ref NI_3 NA_1 0 4.2435644688675239e-01
GD_3_2 ref NI_3 NA_2 0 2.4434739068012346e-02
GD_3_3 ref NI_3 NA_3 0 3.7291462431496476e+00
GD_3_4 ref NI_3 NA_4 0 1.0526396649056888e-01
GD_3_5 ref NI_3 NA_5 0 1.3244297463538371e-01
GD_3_6 ref NI_3 NA_6 0 1.0857071752132437e-01
GD_3_7 ref NI_3 NA_7 0 7.1158121738415597e-02
GD_3_8 ref NI_3 NA_8 0 -4.9326954370873609e-02
GD_3_9 ref NI_3 NA_9 0 -4.5273173803263130e-02
GD_3_10 ref NI_3 NA_10 0 4.4859712326336065e-02
GD_3_11 ref NI_3 NA_11 0 1.2255736642646701e-02
GD_3_12 ref NI_3 NA_12 0 2.4105130401248659e-04
GD_3_13 ref NI_3 NA_13 0 1.3423859551646080e-03
GD_3_14 ref NI_3 NA_14 0 -1.5247028604070966e-02
GD_3_15 ref NI_3 NA_15 0 -2.6631376097196065e-02
GD_3_16 ref NI_3 NA_16 0 4.3963531100699053e-02
GD_3_17 ref NI_3 NA_17 0 4.3093360989765794e-02
GD_3_18 ref NI_3 NA_18 0 4.1019278948526111e-02
GD_3_19 ref NI_3 NA_19 0 2.9529317680593865e-02
GD_3_20 ref NI_3 NA_20 0 4.5935572097557678e-02
GD_3_21 ref NI_3 NA_21 0 3.2702930541577947e-02
GD_3_22 ref NI_3 NA_22 0 3.1542663324270553e-02
GD_3_23 ref NI_3 NA_23 0 3.4280824703889427e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 5.0466714703966264e-01
GC_4_2 ref NI_4 NS_2 0 1.2737996516001626e+00
GC_4_3 ref NI_4 NS_3 0 -1.9816075231505495e-01
GC_4_4 ref NI_4 NS_4 0 -2.5558085641255220e-02
GC_4_5 ref NI_4 NS_5 0 -1.8527255705569343e-04
GC_4_6 ref NI_4 NS_6 0 -5.7739251776375983e-02
GC_4_7 ref NI_4 NS_7 0 -3.0007238467011660e-01
GC_4_8 ref NI_4 NS_8 0 1.0454181015817545e+00
GC_4_9 ref NI_4 NS_9 0 -1.4362761015501410e-01
GC_4_10 ref NI_4 NS_10 0 1.4809639645853757e-02
GC_4_11 ref NI_4 NS_11 0 3.5049507924630879e-05
GC_4_12 ref NI_4 NS_12 0 -3.5877078128152724e-02
GC_4_13 ref NI_4 NS_13 0 2.1066218124043550e+00
GC_4_14 ref NI_4 NS_14 0 4.4032397250668287e-01
GC_4_15 ref NI_4 NS_15 0 -1.7332217448710066e-02
GC_4_16 ref NI_4 NS_16 0 -7.5440494582631940e-02
GC_4_17 ref NI_4 NS_17 0 -1.4567466505263025e-04
GC_4_18 ref NI_4 NS_18 0 -6.0656922428753986e-02
GC_4_19 ref NI_4 NS_19 0 4.4497940010160129e+00
GC_4_20 ref NI_4 NS_20 0 -6.0775889923220916e+00
GC_4_21 ref NI_4 NS_21 0 -4.5006173261334476e-01
GC_4_22 ref NI_4 NS_22 0 -3.5380641409660407e-01
GC_4_23 ref NI_4 NS_23 0 -2.4163792775989436e-03
GC_4_24 ref NI_4 NS_24 0 -1.1842580500862353e-01
GC_4_25 ref NI_4 NS_25 0 1.4799421254859835e-01
GC_4_26 ref NI_4 NS_26 0 1.9991371713534967e+00
GC_4_27 ref NI_4 NS_27 0 -1.3175850321449742e-01
GC_4_28 ref NI_4 NS_28 0 -1.6383759796298272e-01
GC_4_29 ref NI_4 NS_29 0 -4.8546231451513110e-04
GC_4_30 ref NI_4 NS_30 0 -1.0166014684833924e-01
GC_4_31 ref NI_4 NS_31 0 -7.7704168057214074e-01
GC_4_32 ref NI_4 NS_32 0 3.4366175518867448e-01
GC_4_33 ref NI_4 NS_33 0 9.6241281019798774e-01
GC_4_34 ref NI_4 NS_34 0 -2.0214942429117377e-01
GC_4_35 ref NI_4 NS_35 0 -2.5351210630396239e-04
GC_4_36 ref NI_4 NS_36 0 -9.1458113998990606e-02
GC_4_37 ref NI_4 NS_37 0 -9.2966430760240260e-01
GC_4_38 ref NI_4 NS_38 0 1.6535747564789255e-01
GC_4_39 ref NI_4 NS_39 0 9.9491413805055884e-01
GC_4_40 ref NI_4 NS_40 0 -1.7366832479541194e-01
GC_4_41 ref NI_4 NS_41 0 -1.6990789816448073e-04
GC_4_42 ref NI_4 NS_42 0 -8.3429588707043839e-02
GC_4_43 ref NI_4 NS_43 0 -3.6021505178656316e-01
GC_4_44 ref NI_4 NS_44 0 -1.2347870125011366e-01
GC_4_45 ref NI_4 NS_45 0 1.7059575091530541e-01
GC_4_46 ref NI_4 NS_46 0 6.7956378877045490e-02
GC_4_47 ref NI_4 NS_47 0 1.7548247196814778e-04
GC_4_48 ref NI_4 NS_48 0 8.3100650927358643e-03
GC_4_49 ref NI_4 NS_49 0 -2.9512045129732567e-01
GC_4_50 ref NI_4 NS_50 0 -2.2040146101551894e-01
GC_4_51 ref NI_4 NS_51 0 2.3310066830162060e-01
GC_4_52 ref NI_4 NS_52 0 8.9265036344808049e-02
GC_4_53 ref NI_4 NS_53 0 2.2747429232689804e-04
GC_4_54 ref NI_4 NS_54 0 -2.7203172469825220e-03
GC_4_55 ref NI_4 NS_55 0 -3.4686567252386225e-01
GC_4_56 ref NI_4 NS_56 0 2.5955842671841872e-01
GC_4_57 ref NI_4 NS_57 0 -2.6650731261514105e-01
GC_4_58 ref NI_4 NS_58 0 5.7123613173081789e-02
GC_4_59 ref NI_4 NS_59 0 2.3218579824501340e-04
GC_4_60 ref NI_4 NS_60 0 5.3323475869833492e-02
GC_4_61 ref NI_4 NS_61 0 -2.0145817598435342e-01
GC_4_62 ref NI_4 NS_62 0 -5.4739811726022318e-02
GC_4_63 ref NI_4 NS_63 0 5.6224218100981134e-03
GC_4_64 ref NI_4 NS_64 0 7.7617216668401517e-02
GC_4_65 ref NI_4 NS_65 0 2.2222547319167331e-04
GC_4_66 ref NI_4 NS_66 0 2.4872444062169298e-02
GC_4_67 ref NI_4 NS_67 0 -2.9497389302899629e-01
GC_4_68 ref NI_4 NS_68 0 1.1770276269037407e-02
GC_4_69 ref NI_4 NS_69 0 -3.1677515027504564e-02
GC_4_70 ref NI_4 NS_70 0 1.0193253916291165e-01
GC_4_71 ref NI_4 NS_71 0 3.0572868876905222e-04
GC_4_72 ref NI_4 NS_72 0 1.7857807069020550e-02
GC_4_73 ref NI_4 NS_73 0 -2.6326319896885952e-01
GC_4_74 ref NI_4 NS_74 0 -6.0974196848952798e-02
GC_4_75 ref NI_4 NS_75 0 4.0622258130186786e-02
GC_4_76 ref NI_4 NS_76 0 9.1280848117977542e-02
GC_4_77 ref NI_4 NS_77 0 2.7954910593870462e-04
GC_4_78 ref NI_4 NS_78 0 1.4899682911590472e-02
GC_4_79 ref NI_4 NS_79 0 -2.6455386298652495e-01
GC_4_80 ref NI_4 NS_80 0 -1.0850935916005972e-01
GC_4_81 ref NI_4 NS_81 0 8.2230608269368025e-02
GC_4_82 ref NI_4 NS_82 0 7.2280062894554978e-02
GC_4_83 ref NI_4 NS_83 0 2.3421072967248852e-04
GC_4_84 ref NI_4 NS_84 0 1.9236826003264304e-02
GC_4_85 ref NI_4 NS_85 0 -2.2476575823454309e-01
GC_4_86 ref NI_4 NS_86 0 -1.7059014182641610e-01
GC_4_87 ref NI_4 NS_87 0 1.1152138453239584e-01
GC_4_88 ref NI_4 NS_88 0 1.3101412700059786e-01
GC_4_89 ref NI_4 NS_89 0 2.8450467199505187e-04
GC_4_90 ref NI_4 NS_90 0 -1.8283506628162484e-03
GC_4_91 ref NI_4 NS_91 0 -3.2609709607804627e-01
GC_4_92 ref NI_4 NS_92 0 2.2309462347182241e-01
GC_4_93 ref NI_4 NS_93 0 -2.2086004369618284e-01
GC_4_94 ref NI_4 NS_94 0 4.0178898299296703e-02
GC_4_95 ref NI_4 NS_95 0 2.0666424029501908e-04
GC_4_96 ref NI_4 NS_96 0 5.4146636660904385e-02
GC_4_97 ref NI_4 NS_97 0 -3.1055119075023752e-01
GC_4_98 ref NI_4 NS_98 0 2.1883655892576989e-01
GC_4_99 ref NI_4 NS_99 0 -1.9334990368099353e-01
GC_4_100 ref NI_4 NS_100 0 4.0118407082238190e-03
GC_4_101 ref NI_4 NS_101 0 1.7912527287186042e-04
GC_4_102 ref NI_4 NS_102 0 6.2697170102197511e-02
GC_4_103 ref NI_4 NS_103 0 -2.3814986372449889e-01
GC_4_104 ref NI_4 NS_104 0 1.3648362215711260e-01
GC_4_105 ref NI_4 NS_105 0 -1.5164601775794856e-01
GC_4_106 ref NI_4 NS_106 0 2.1262184388647826e-02
GC_4_107 ref NI_4 NS_107 0 2.1358322400195451e-04
GC_4_108 ref NI_4 NS_108 0 5.5289342027616858e-02
GC_4_109 ref NI_4 NS_109 0 -1.8118278932731866e-01
GC_4_110 ref NI_4 NS_110 0 3.2149642901432421e-02
GC_4_111 ref NI_4 NS_111 0 -9.8147397099792907e-02
GC_4_112 ref NI_4 NS_112 0 6.1832924465524908e-02
GC_4_113 ref NI_4 NS_113 0 2.2485939062524815e-04
GC_4_114 ref NI_4 NS_114 0 4.0402572388239397e-02
GC_4_115 ref NI_4 NS_115 0 -2.9241587956551746e-01
GC_4_116 ref NI_4 NS_116 0 2.0087801214132475e-01
GC_4_117 ref NI_4 NS_117 0 -1.6285911615381302e-01
GC_4_118 ref NI_4 NS_118 0 -2.0622579296482067e-02
GC_4_119 ref NI_4 NS_119 0 2.0296003080630867e-04
GC_4_120 ref NI_4 NS_120 0 6.7185166932875365e-02
GC_4_121 ref NI_4 NS_121 0 -2.4576937034615121e-01
GC_4_122 ref NI_4 NS_122 0 1.2923061555280602e-01
GC_4_123 ref NI_4 NS_123 0 -1.4915929736631081e-01
GC_4_124 ref NI_4 NS_124 0 3.8316288690573706e-02
GC_4_125 ref NI_4 NS_125 0 2.0099926936383310e-04
GC_4_126 ref NI_4 NS_126 0 4.9933756523238060e-02
GC_4_127 ref NI_4 NS_127 0 -2.8469487893214163e-01
GC_4_128 ref NI_4 NS_128 0 1.5305011823865350e-01
GC_4_129 ref NI_4 NS_129 0 -1.7684199986784455e-01
GC_4_130 ref NI_4 NS_130 0 6.3492224267551717e-02
GC_4_131 ref NI_4 NS_131 0 2.1556821577143931e-04
GC_4_132 ref NI_4 NS_132 0 4.4280697477141306e-02
GC_4_133 ref NI_4 NS_133 0 -2.9407138231517715e-01
GC_4_134 ref NI_4 NS_134 0 1.5264566235762875e-01
GC_4_135 ref NI_4 NS_135 0 -1.8716600422872959e-01
GC_4_136 ref NI_4 NS_136 0 7.8910873312284385e-02
GC_4_137 ref NI_4 NS_137 0 2.3932000609763190e-04
GC_4_138 ref NI_4 NS_138 0 4.0724442197004884e-02
GD_4_1 ref NI_4 NA_1 0 -1.7961083525412996e-01
GD_4_2 ref NI_4 NA_2 0 -8.7814037238242326e-02
GD_4_3 ref NI_4 NA_3 0 1.0526396649056888e-01
GD_4_4 ref NI_4 NA_4 0 5.0775981057375299e+00
GD_4_5 ref NI_4 NA_5 0 -3.1762693809320487e-02
GD_4_6 ref NI_4 NA_6 0 1.1232714708511123e-01
GD_4_7 ref NI_4 NA_7 0 1.1825767057697106e-01
GD_4_8 ref NI_4 NA_8 0 6.3202163259541894e-02
GD_4_9 ref NI_4 NA_9 0 5.5353403880296616e-02
GD_4_10 ref NI_4 NA_10 0 6.6639176124854732e-02
GD_4_11 ref NI_4 NA_11 0 4.5441463876781760e-02
GD_4_12 ref NI_4 NA_12 0 5.6432015358776393e-02
GD_4_13 ref NI_4 NA_13 0 5.3052040549810428e-02
GD_4_14 ref NI_4 NA_14 0 5.5363975522177727e-02
GD_4_15 ref NI_4 NA_15 0 4.6975843950712540e-02
GD_4_16 ref NI_4 NA_16 0 6.3685154385703366e-02
GD_4_17 ref NI_4 NA_17 0 5.9897635825922765e-02
GD_4_18 ref NI_4 NA_18 0 5.1466822636001275e-02
GD_4_19 ref NI_4 NA_19 0 4.4317602641461125e-02
GD_4_20 ref NI_4 NA_20 0 5.7584430204278766e-02
GD_4_21 ref NI_4 NA_21 0 5.1008575663296647e-02
GD_4_22 ref NI_4 NA_22 0 5.6741517320112698e-02
GD_4_23 ref NI_4 NA_23 0 5.9245283648228127e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -6.3131499693435553e-02
GC_5_2 ref NI_5 NS_2 0 9.9074385006535903e-01
GC_5_3 ref NI_5 NS_3 0 9.5720467957243885e-02
GC_5_4 ref NI_5 NS_4 0 -5.6057327432475650e-02
GC_5_5 ref NI_5 NS_5 0 -1.9054871407622395e-04
GC_5_6 ref NI_5 NS_6 0 -5.7549556234309879e-02
GC_5_7 ref NI_5 NS_7 0 -4.6376913388286045e-01
GC_5_8 ref NI_5 NS_8 0 7.5056374713139340e-01
GC_5_9 ref NI_5 NS_9 0 7.5885264056867310e-02
GC_5_10 ref NI_5 NS_10 0 -6.2525493931547748e-03
GC_5_11 ref NI_5 NS_11 0 1.5826720976653098e-05
GC_5_12 ref NI_5 NS_12 0 -3.5511794326227850e-02
GC_5_13 ref NI_5 NS_13 0 1.4461820559344563e+00
GC_5_14 ref NI_5 NS_14 0 4.1402755200027869e-01
GC_5_15 ref NI_5 NS_15 0 1.4468228285614132e-01
GC_5_16 ref NI_5 NS_16 0 -9.3251446031110602e-02
GC_5_17 ref NI_5 NS_17 0 -1.4991022395464550e-04
GC_5_18 ref NI_5 NS_18 0 -6.1444371031534308e-02
GC_5_19 ref NI_5 NS_19 0 1.4799421254859835e-01
GC_5_20 ref NI_5 NS_20 0 1.9991371713534967e+00
GC_5_21 ref NI_5 NS_21 0 -1.3175850321449750e-01
GC_5_22 ref NI_5 NS_22 0 -1.6383759796298267e-01
GC_5_23 ref NI_5 NS_23 0 -4.8546231451512698e-04
GC_5_24 ref NI_5 NS_24 0 -1.0166014684833925e-01
GC_5_25 ref NI_5 NS_25 0 4.0156597072270088e+00
GC_5_26 ref NI_5 NS_26 0 -6.8130418534982891e+00
GC_5_27 ref NI_5 NS_27 0 4.5027371462105781e-02
GC_5_28 ref NI_5 NS_28 0 -3.6831695983038942e-01
GC_5_29 ref NI_5 NS_29 0 -2.0772206723678210e-03
GC_5_30 ref NI_5 NS_30 0 -1.2127380330662178e-01
GC_5_31 ref NI_5 NS_31 0 2.4257839754531538e-01
GC_5_32 ref NI_5 NS_32 0 1.4709890850347267e+00
GC_5_33 ref NI_5 NS_33 0 1.7700988004951582e-01
GC_5_34 ref NI_5 NS_34 0 -1.7279268478921053e-01
GC_5_35 ref NI_5 NS_35 0 -4.0875244689029920e-04
GC_5_36 ref NI_5 NS_36 0 -1.0274696246440319e-01
GC_5_37 ref NI_5 NS_37 0 -8.7065834529508845e-01
GC_5_38 ref NI_5 NS_38 0 4.0291485503828950e-01
GC_5_39 ref NI_5 NS_39 0 9.3391296390625944e-01
GC_5_40 ref NI_5 NS_40 0 -2.0617284089539878e-01
GC_5_41 ref NI_5 NS_41 0 -2.4534254184343894e-04
GC_5_42 ref NI_5 NS_42 0 -8.7355140108980961e-02
GC_5_43 ref NI_5 NS_43 0 -2.3143053965142196e-01
GC_5_44 ref NI_5 NS_44 0 -1.8262467169523233e-01
GC_5_45 ref NI_5 NS_45 0 1.5723551020916485e-01
GC_5_46 ref NI_5 NS_46 0 8.4449208972582054e-02
GC_5_47 ref NI_5 NS_47 0 1.7583023677688624e-04
GC_5_48 ref NI_5 NS_48 0 8.2520005888690739e-03
GC_5_49 ref NI_5 NS_49 0 -1.5729790593810203e-01
GC_5_50 ref NI_5 NS_50 0 -2.7597464411631961e-01
GC_5_51 ref NI_5 NS_51 0 2.0734401276795900e-01
GC_5_52 ref NI_5 NS_52 0 1.1200011140216859e-01
GC_5_53 ref NI_5 NS_53 0 2.3419297100927194e-04
GC_5_54 ref NI_5 NS_54 0 -3.3191171296198798e-03
GC_5_55 ref NI_5 NS_55 0 -3.6700724298481657e-01
GC_5_56 ref NI_5 NS_56 0 2.8377729318165135e-01
GC_5_57 ref NI_5 NS_57 0 -2.7961677200541890e-01
GC_5_58 ref NI_5 NS_58 0 5.2227488098694666e-02
GC_5_59 ref NI_5 NS_59 0 2.2156315763783788e-04
GC_5_60 ref NI_5 NS_60 0 5.5457609567449460e-02
GC_5_61 ref NI_5 NS_61 0 -1.5649681334231585e-01
GC_5_62 ref NI_5 NS_62 0 -5.2701798606562746e-02
GC_5_63 ref NI_5 NS_63 0 -2.6471433502957525e-02
GC_5_64 ref NI_5 NS_64 0 8.9040141206201170e-02
GC_5_65 ref NI_5 NS_65 0 2.2136743381371421e-04
GC_5_66 ref NI_5 NS_66 0 2.5549851214043649e-02
GC_5_67 ref NI_5 NS_67 0 -2.4525996917133980e-01
GC_5_68 ref NI_5 NS_68 0 4.5166534560283460e-03
GC_5_69 ref NI_5 NS_69 0 -6.0121052820383721e-02
GC_5_70 ref NI_5 NS_70 0 1.1416783531000897e-01
GC_5_71 ref NI_5 NS_71 0 3.0296601740204758e-04
GC_5_72 ref NI_5 NS_72 0 1.8413566028969586e-02
GC_5_73 ref NI_5 NS_73 0 -1.9766999961927498e-01
GC_5_74 ref NI_5 NS_74 0 -7.5434922244810299e-02
GC_5_75 ref NI_5 NS_75 0 1.1536587897114153e-02
GC_5_76 ref NI_5 NS_76 0 1.0566519796646145e-01
GC_5_77 ref NI_5 NS_77 0 2.7997308611386711e-04
GC_5_78 ref NI_5 NS_78 0 1.5209383326348545e-02
GC_5_79 ref NI_5 NS_79 0 -1.7846707658956731e-01
GC_5_80 ref NI_5 NS_80 0 -1.2873130002843086e-01
GC_5_81 ref NI_5 NS_81 0 5.3990469547835235e-02
GC_5_82 ref NI_5 NS_82 0 8.6592732565934930e-02
GC_5_83 ref NI_5 NS_83 0 2.3313950918004263e-04
GC_5_84 ref NI_5 NS_84 0 1.9615466843238092e-02
GC_5_85 ref NI_5 NS_85 0 -1.3463575389011062e-01
GC_5_86 ref NI_5 NS_86 0 -1.8799968050965335e-01
GC_5_87 ref NI_5 NS_87 0 6.7651028549357325e-02
GC_5_88 ref NI_5 NS_88 0 1.5426093700931984e-01
GC_5_89 ref NI_5 NS_89 0 2.8602880412103134e-04
GC_5_90 ref NI_5 NS_90 0 -2.1803204162061411e-03
GC_5_91 ref NI_5 NS_91 0 -3.3814920238897905e-01
GC_5_92 ref NI_5 NS_92 0 2.4095852576278246e-01
GC_5_93 ref NI_5 NS_93 0 -2.3082960934178051e-01
GC_5_94 ref NI_5 NS_94 0 3.5208606113845263e-02
GC_5_95 ref NI_5 NS_95 0 1.9701205891043549e-04
GC_5_96 ref NI_5 NS_96 0 5.6214386724344798e-02
GC_5_97 ref NI_5 NS_97 0 -3.2005199313289984e-01
GC_5_98 ref NI_5 NS_98 0 2.2948954835493471e-01
GC_5_99 ref NI_5 NS_99 0 -1.9365096133740092e-01
GC_5_100 ref NI_5 NS_100 0 -4.6412701951807529e-03
GC_5_101 ref NI_5 NS_101 0 1.6994491166855269e-04
GC_5_102 ref NI_5 NS_102 0 6.4990834722253032e-02
GC_5_103 ref NI_5 NS_103 0 -2.4644619767112863e-01
GC_5_104 ref NI_5 NS_104 0 1.5593859421177533e-01
GC_5_105 ref NI_5 NS_105 0 -1.6499544496268836e-01
GC_5_106 ref NI_5 NS_106 0 1.7671696592384437e-02
GC_5_107 ref NI_5 NS_107 0 2.0529758446461861e-04
GC_5_108 ref NI_5 NS_108 0 5.7243809598036349e-02
GC_5_109 ref NI_5 NS_109 0 -1.7684146988403873e-01
GC_5_110 ref NI_5 NS_110 0 5.8170537914005269e-02
GC_5_111 ref NI_5 NS_111 0 -1.3059467326196900e-01
GC_5_112 ref NI_5 NS_112 0 6.7191649721820568e-02
GC_5_113 ref NI_5 NS_113 0 2.1964610742570515e-04
GC_5_114 ref NI_5 NS_114 0 4.1709604817048322e-02
GC_5_115 ref NI_5 NS_115 0 -2.9932336791596842e-01
GC_5_116 ref NI_5 NS_116 0 2.0719992450716593e-01
GC_5_117 ref NI_5 NS_117 0 -1.5797162762486930e-01
GC_5_118 ref NI_5 NS_118 0 -3.1081399976184719e-02
GC_5_119 ref NI_5 NS_119 0 1.9391236190809173e-04
GC_5_120 ref NI_5 NS_120 0 6.9566131493551356e-02
GC_5_121 ref NI_5 NS_121 0 -2.4763427856419376e-01
GC_5_122 ref NI_5 NS_122 0 1.4600241342622083e-01
GC_5_123 ref NI_5 NS_123 0 -1.6478374037408047e-01
GC_5_124 ref NI_5 NS_124 0 3.6676633981741161e-02
GC_5_125 ref NI_5 NS_125 0 1.9223035762851295e-04
GC_5_126 ref NI_5 NS_126 0 5.1752919400152045e-02
GC_5_127 ref NI_5 NS_127 0 -2.8533483410865335e-01
GC_5_128 ref NI_5 NS_128 0 1.7078782424939884e-01
GC_5_129 ref NI_5 NS_129 0 -1.9623670580495187e-01
GC_5_130 ref NI_5 NS_130 0 6.3819911634703630e-02
GC_5_131 ref NI_5 NS_131 0 2.0809179242911897e-04
GC_5_132 ref NI_5 NS_132 0 4.5950697008816342e-02
GC_5_133 ref NI_5 NS_133 0 -2.9526954540030825e-01
GC_5_134 ref NI_5 NS_134 0 1.7385562726744574e-01
GC_5_135 ref NI_5 NS_135 0 -2.1119305788785020e-01
GC_5_136 ref NI_5 NS_136 0 8.0946629292580161e-02
GC_5_137 ref NI_5 NS_137 0 2.3133482615049825e-04
GC_5_138 ref NI_5 NS_138 0 4.2293595516820222e-02
GD_5_1 ref NI_5 NA_1 0 -9.9990563787522330e-02
GD_5_2 ref NI_5 NA_2 0 -3.4096564361726082e-02
GD_5_3 ref NI_5 NA_3 0 1.3244297463538371e-01
GD_5_4 ref NI_5 NA_4 0 -3.1762693809320487e-02
GD_5_5 ref NI_5 NA_5 0 5.1937420446955294e+00
GD_5_6 ref NI_5 NA_6 0 -2.0830381522072648e-02
GD_5_7 ref NI_5 NA_7 0 1.0627884006866030e-01
GD_5_8 ref NI_5 NA_8 0 4.8299544925948061e-02
GD_5_9 ref NI_5 NA_9 0 3.9034386760945977e-02
GD_5_10 ref NI_5 NA_10 0 6.9048696043268798e-02
GD_5_11 ref NI_5 NA_11 0 3.9582387663658285e-02
GD_5_12 ref NI_5 NA_12 0 5.0853376241704426e-02
GD_5_13 ref NI_5 NA_13 0 4.5279125357003208e-02
GD_5_14 ref NI_5 NA_14 0 4.4422133307015263e-02
GD_5_15 ref NI_5 NA_15 0 3.6156794956869090e-02
GD_5_16 ref NI_5 NA_16 0 6.5057960760121283e-02
GD_5_17 ref NI_5 NA_17 0 6.0955740164240796e-02
GD_5_18 ref NI_5 NA_18 0 5.2082220977809103e-02
GD_5_19 ref NI_5 NA_19 0 4.3201313950942996e-02
GD_5_20 ref NI_5 NA_20 0 5.8235671453367333e-02
GD_5_21 ref NI_5 NA_21 0 5.0974310252795078e-02
GD_5_22 ref NI_5 NA_22 0 5.6681749443423031e-02
GD_5_23 ref NI_5 NA_23 0 5.9209707371902502e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -1.8647473234360837e-01
GC_6_2 ref NI_6 NS_2 0 9.3215904419544593e-01
GC_6_3 ref NI_6 NS_3 0 1.6630337386430430e-01
GC_6_4 ref NI_6 NS_4 0 -7.1242953894873215e-02
GC_6_5 ref NI_6 NS_5 0 -2.0876894320911136e-04
GC_6_6 ref NI_6 NS_6 0 -5.6633020365232434e-02
GC_6_7 ref NI_6 NS_7 0 -4.8960597525755895e-01
GC_6_8 ref NI_6 NS_8 0 7.0482082217119257e-01
GC_6_9 ref NI_6 NS_9 0 1.2422770847312722e-01
GC_6_10 ref NI_6 NS_10 0 -1.8071437358501776e-02
GC_6_11 ref NI_6 NS_11 0 -6.1916089781645526e-06
GC_6_12 ref NI_6 NS_12 0 -3.5128326063912849e-02
GC_6_13 ref NI_6 NS_13 0 1.1920255838045106e+00
GC_6_14 ref NI_6 NS_14 0 4.9856247155031758e-01
GC_6_15 ref NI_6 NS_15 0 1.6673609967905273e-01
GC_6_16 ref NI_6 NS_16 0 -1.0215266480194136e-01
GC_6_17 ref NI_6 NS_17 0 -1.7430835694342531e-04
GC_6_18 ref NI_6 NS_18 0 -6.0946082950038942e-02
GC_6_19 ref NI_6 NS_19 0 -7.7704168057214096e-01
GC_6_20 ref NI_6 NS_20 0 3.4366175518867459e-01
GC_6_21 ref NI_6 NS_21 0 9.6241281019798752e-01
GC_6_22 ref NI_6 NS_22 0 -2.0214942429117366e-01
GC_6_23 ref NI_6 NS_23 0 -2.5351210630395664e-04
GC_6_24 ref NI_6 NS_24 0 -9.1458113998990620e-02
GC_6_25 ref NI_6 NS_25 0 2.4257839754531538e-01
GC_6_26 ref NI_6 NS_26 0 1.4709890850347265e+00
GC_6_27 ref NI_6 NS_27 0 1.7700988004951593e-01
GC_6_28 ref NI_6 NS_28 0 -1.7279268478921062e-01
GC_6_29 ref NI_6 NS_29 0 -4.0875244689030505e-04
GC_6_30 ref NI_6 NS_30 0 -1.0274696246440317e-01
GC_6_31 ref NI_6 NS_31 0 4.1302133723688934e+00
GC_6_32 ref NI_6 NS_32 0 -6.7362007314127021e+00
GC_6_33 ref NI_6 NS_33 0 -3.0128605343105037e-02
GC_6_34 ref NI_6 NS_34 0 -3.7626096225765443e-01
GC_6_35 ref NI_6 NS_35 0 -2.1918896805563702e-03
GC_6_36 ref NI_6 NS_36 0 -1.1751875373947705e-01
GC_6_37 ref NI_6 NS_37 0 1.3915520906425746e-01
GC_6_38 ref NI_6 NS_38 0 2.0646809225189595e+00
GC_6_39 ref NI_6 NS_39 0 -1.9145101116816957e-01
GC_6_40 ref NI_6 NS_40 0 -1.7215851520228517e-01
GC_6_41 ref NI_6 NS_41 0 -4.8241517488836056e-04
GC_6_42 ref NI_6 NS_42 0 -9.4562553417231451e-02
GC_6_43 ref NI_6 NS_43 0 -1.9726432648711326e-01
GC_6_44 ref NI_6 NS_44 0 -2.0824556777867234e-01
GC_6_45 ref NI_6 NS_45 0 1.7005235812209238e-01
GC_6_46 ref NI_6 NS_46 0 8.4680514571188983e-02
GC_6_47 ref NI_6 NS_47 0 1.8061580580385611e-04
GC_6_48 ref NI_6 NS_48 0 7.7740146565864910e-03
GC_6_49 ref NI_6 NS_49 0 -1.2000789590630408e-01
GC_6_50 ref NI_6 NS_50 0 -3.0326745564320795e-01
GC_6_51 ref NI_6 NS_51 0 2.2040364270356758e-01
GC_6_52 ref NI_6 NS_52 0 1.1263627758671579e-01
GC_6_53 ref NI_6 NS_53 0 2.6457146014791837e-04
GC_6_54 ref NI_6 NS_54 0 -4.0687509924986652e-03
GC_6_55 ref NI_6 NS_55 0 -3.7375469472566814e-01
GC_6_56 ref NI_6 NS_56 0 2.9404356147378424e-01
GC_6_57 ref NI_6 NS_57 0 -2.9100484340545796e-01
GC_6_58 ref NI_6 NS_58 0 5.6919863420328398e-02
GC_6_59 ref NI_6 NS_59 0 2.3075664288869018e-04
GC_6_60 ref NI_6 NS_60 0 5.4928758672202892e-02
GC_6_61 ref NI_6 NS_61 0 -1.4002510956428157e-01
GC_6_62 ref NI_6 NS_62 0 -6.0764858653037060e-02
GC_6_63 ref NI_6 NS_63 0 -2.6329668689088481e-02
GC_6_64 ref NI_6 NS_64 0 9.1758026011892480e-02
GC_6_65 ref NI_6 NS_65 0 2.4214618412521030e-04
GC_6_66 ref NI_6 NS_66 0 2.4952737257138410e-02
GC_6_67 ref NI_6 NS_67 0 -2.2955236658065128e-01
GC_6_68 ref NI_6 NS_68 0 -5.3535109119758227e-03
GC_6_69 ref NI_6 NS_69 0 -5.8344295575146407e-02
GC_6_70 ref NI_6 NS_70 0 1.1694019019173303e-01
GC_6_71 ref NI_6 NS_71 0 3.2099042616527327e-04
GC_6_72 ref NI_6 NS_72 0 1.7704575318128597e-02
GC_6_73 ref NI_6 NS_73 0 -1.7725513284958730e-01
GC_6_74 ref NI_6 NS_74 0 -8.8615623870842528e-02
GC_6_75 ref NI_6 NS_75 0 1.5474520771875012e-02
GC_6_76 ref NI_6 NS_76 0 1.0778055422778744e-01
GC_6_77 ref NI_6 NS_77 0 3.0627598007771197e-04
GC_6_78 ref NI_6 NS_78 0 1.4528938981821908e-02
GC_6_79 ref NI_6 NS_79 0 -1.5133877372092241e-01
GC_6_80 ref NI_6 NS_80 0 -1.4453807766435431e-01
GC_6_81 ref NI_6 NS_81 0 5.8952571478019064e-02
GC_6_82 ref NI_6 NS_82 0 8.8502880760859409e-02
GC_6_83 ref NI_6 NS_83 0 2.3570091981316477e-04
GC_6_84 ref NI_6 NS_84 0 1.9140525500731444e-02
GC_6_85 ref NI_6 NS_85 0 -1.0319524727855579e-01
GC_6_86 ref NI_6 NS_86 0 -2.0935152863626391e-01
GC_6_87 ref NI_6 NS_87 0 7.6206155842735393e-02
GC_6_88 ref NI_6 NS_88 0 1.5618314633218400e-01
GC_6_89 ref NI_6 NS_89 0 3.0636035791827351e-04
GC_6_90 ref NI_6 NS_90 0 -2.9764388751478332e-03
GC_6_91 ref NI_6 NS_91 0 -3.4398972177040837e-01
GC_6_92 ref NI_6 NS_92 0 2.5003944823802193e-01
GC_6_93 ref NI_6 NS_93 0 -2.4114126098703673e-01
GC_6_94 ref NI_6 NS_94 0 3.9550816662162126e-02
GC_6_95 ref NI_6 NS_95 0 2.0551386879051270e-04
GC_6_96 ref NI_6 NS_96 0 5.5720379591632729e-02
GC_6_97 ref NI_6 NS_97 0 -3.2863483629745899e-01
GC_6_98 ref NI_6 NS_98 0 2.4030033805103473e-01
GC_6_99 ref NI_6 NS_99 0 -2.0461508488091920e-01
GC_6_100 ref NI_6 NS_100 0 -4.9848206645148490e-04
GC_6_101 ref NI_6 NS_101 0 1.7625767151145468e-04
GC_6_102 ref NI_6 NS_102 0 6.4580246127822205e-02
GC_6_103 ref NI_6 NS_103 0 -2.5036269052159021e-01
GC_6_104 ref NI_6 NS_104 0 1.6401165302010251e-01
GC_6_105 ref NI_6 NS_105 0 -1.7461111024313083e-01
GC_6_106 ref NI_6 NS_106 0 2.1699714102415897e-02
GC_6_107 ref NI_6 NS_107 0 2.0946182219881492e-04
GC_6_108 ref NI_6 NS_108 0 5.6835713015961957e-02
GC_6_109 ref NI_6 NS_109 0 -1.6926320631764324e-01
GC_6_110 ref NI_6 NS_110 0 5.8721951257503860e-02
GC_6_111 ref NI_6 NS_111 0 -1.3608123742507722e-01
GC_6_112 ref NI_6 NS_112 0 7.0766972298384676e-02
GC_6_113 ref NI_6 NS_113 0 2.2367328646013347e-04
GC_6_114 ref NI_6 NS_114 0 4.1262532743851499e-02
GC_6_115 ref NI_6 NS_115 0 -3.0893302151807495e-01
GC_6_116 ref NI_6 NS_116 0 2.1856863663777373e-01
GC_6_117 ref NI_6 NS_117 0 -1.6895018740799250e-01
GC_6_118 ref NI_6 NS_118 0 -2.7185763129056208e-02
GC_6_119 ref NI_6 NS_119 0 1.9763446431235202e-04
GC_6_120 ref NI_6 NS_120 0 6.9229392835895825e-02
GC_6_121 ref NI_6 NS_121 0 -2.4910639520860298e-01
GC_6_122 ref NI_6 NS_122 0 1.5182847527897600e-01
GC_6_123 ref NI_6 NS_123 0 -1.7305120757632167e-01
GC_6_124 ref NI_6 NS_124 0 4.0655788555882054e-02
GC_6_125 ref NI_6 NS_125 0 2.0074457113290615e-04
GC_6_126 ref NI_6 NS_126 0 5.1263532861280506e-02
GC_6_127 ref NI_6 NS_127 0 -2.8550128007575171e-01
GC_6_128 ref NI_6 NS_128 0 1.7535126367567469e-01
GC_6_129 ref NI_6 NS_129 0 -2.0388508411537737e-01
GC_6_130 ref NI_6 NS_130 0 6.7912333720942547e-02
GC_6_131 ref NI_6 NS_131 0 2.1803765235151501e-04
GC_6_132 ref NI_6 NS_132 0 4.5397334153378335e-02
GC_6_133 ref NI_6 NS_133 0 -2.9345597499872850e-01
GC_6_134 ref NI_6 NS_134 0 1.7727288775998964e-01
GC_6_135 ref NI_6 NS_135 0 -2.1835473690768745e-01
GC_6_136 ref NI_6 NS_136 0 8.5101201682317953e-02
GC_6_137 ref NI_6 NS_137 0 2.4244324952160708e-04
GC_6_138 ref NI_6 NS_138 0 4.1702338034090562e-02
GD_6_1 ref NI_6 NA_1 0 -7.3327264203192952e-02
GD_6_2 ref NI_6 NA_2 0 -2.3175799104941223e-02
GD_6_3 ref NI_6 NA_3 0 1.0857071752132437e-01
GD_6_4 ref NI_6 NA_4 0 1.1232714708511123e-01
GD_6_5 ref NI_6 NA_5 0 -2.0830381522072648e-02
GD_6_6 ref NI_6 NA_6 0 5.2092467866757142e+00
GD_6_7 ref NI_6 NA_7 0 -2.7300142596788261e-02
GD_6_8 ref NI_6 NA_8 0 4.3526633691743706e-02
GD_6_9 ref NI_6 NA_9 0 3.3866509747031211e-02
GD_6_10 ref NI_6 NA_10 0 6.9680569246331883e-02
GD_6_11 ref NI_6 NA_11 0 3.6995658028465307e-02
GD_6_12 ref NI_6 NA_12 0 4.8545086274332551e-02
GD_6_13 ref NI_6 NA_13 0 4.2309896929411936e-02
GD_6_14 ref NI_6 NA_14 0 4.0312410242453321e-02
GD_6_15 ref NI_6 NA_15 0 3.1603587089529303e-02
GD_6_16 ref NI_6 NA_16 0 6.5595682997974081e-02
GD_6_17 ref NI_6 NA_17 0 6.1912081676294424e-02
GD_6_18 ref NI_6 NA_18 0 5.2303825800489583e-02
GD_6_19 ref NI_6 NA_19 0 4.1640565374859342e-02
GD_6_20 ref NI_6 NA_20 0 5.9350113253808096e-02
GD_6_21 ref NI_6 NA_21 0 5.0872537367087259e-02
GD_6_22 ref NI_6 NA_22 0 5.6433853631729196e-02
GD_6_23 ref NI_6 NA_23 0 5.8631501066239121e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 4.4239006129643149e-01
GC_7_2 ref NI_7 NS_2 0 1.4167652248832010e+00
GC_7_3 ref NI_7 NS_3 0 -2.5957397817931827e-01
GC_7_4 ref NI_7 NS_4 0 -2.9149526642358640e-02
GC_7_5 ref NI_7 NS_5 0 -1.9232028586716135e-04
GC_7_6 ref NI_7 NS_6 0 -5.5468133404510060e-02
GC_7_7 ref NI_7 NS_7 0 1.8710315447128010e-02
GC_7_8 ref NI_7 NS_8 0 1.0818294968736302e+00
GC_7_9 ref NI_7 NS_9 0 -1.8899327563549340e-01
GC_7_10 ref NI_7 NS_10 0 4.5160205477004197e-03
GC_7_11 ref NI_7 NS_11 0 -1.8414311526917903e-05
GC_7_12 ref NI_7 NS_12 0 -3.4882099921956997e-02
GC_7_13 ref NI_7 NS_13 0 2.5112305371652188e+00
GC_7_14 ref NI_7 NS_14 0 3.9158019793580889e-01
GC_7_15 ref NI_7 NS_15 0 -4.1491205364675529e-02
GC_7_16 ref NI_7 NS_16 0 -8.5936393758039492e-02
GC_7_17 ref NI_7 NS_17 0 -1.8876319040506712e-04
GC_7_18 ref NI_7 NS_18 0 -5.7762355924834689e-02
GC_7_19 ref NI_7 NS_19 0 -9.2966430760240260e-01
GC_7_20 ref NI_7 NS_20 0 1.6535747564789252e-01
GC_7_21 ref NI_7 NS_21 0 9.9491413805055884e-01
GC_7_22 ref NI_7 NS_22 0 -1.7366832479541194e-01
GC_7_23 ref NI_7 NS_23 0 -1.6990789816448084e-04
GC_7_24 ref NI_7 NS_24 0 -8.3429588707043839e-02
GC_7_25 ref NI_7 NS_25 0 -8.7065834529508845e-01
GC_7_26 ref NI_7 NS_26 0 4.0291485503828939e-01
GC_7_27 ref NI_7 NS_27 0 9.3391296390625944e-01
GC_7_28 ref NI_7 NS_28 0 -2.0617284089539886e-01
GC_7_29 ref NI_7 NS_29 0 -2.4534254184344463e-04
GC_7_30 ref NI_7 NS_30 0 -8.7355140108980947e-02
GC_7_31 ref NI_7 NS_31 0 1.3915520906425710e-01
GC_7_32 ref NI_7 NS_32 0 2.0646809225189608e+00
GC_7_33 ref NI_7 NS_33 0 -1.9145101116817151e-01
GC_7_34 ref NI_7 NS_34 0 -1.7215851520228415e-01
GC_7_35 ref NI_7 NS_35 0 -4.8241517488829339e-04
GC_7_36 ref NI_7 NS_36 0 -9.4562553417231743e-02
GC_7_37 ref NI_7 NS_37 0 3.7393872048166434e+00
GC_7_38 ref NI_7 NS_38 0 -6.2382402516987714e+00
GC_7_39 ref NI_7 NS_39 0 -4.6465083449118821e-01
GC_7_40 ref NI_7 NS_40 0 -3.0633583415127258e-01
GC_7_41 ref NI_7 NS_41 0 -2.0580235396239670e-03
GC_7_42 ref NI_7 NS_42 0 -1.0602584846050855e-01
GC_7_43 ref NI_7 NS_43 0 -3.6592788505979584e-01
GC_7_44 ref NI_7 NS_44 0 -1.0968101952508368e-01
GC_7_45 ref NI_7 NS_45 0 1.9614645101938413e-01
GC_7_46 ref NI_7 NS_46 0 5.4283058010692706e-02
GC_7_47 ref NI_7 NS_47 0 1.4550998095404113e-04
GC_7_48 ref NI_7 NS_48 0 7.5835265958008099e-03
GC_7_49 ref NI_7 NS_49 0 -3.0660592644094964e-01
GC_7_50 ref NI_7 NS_50 0 -2.0537247360184405e-01
GC_7_51 ref NI_7 NS_51 0 2.6665007542491054e-01
GC_7_52 ref NI_7 NS_52 0 7.0772774755923529e-02
GC_7_53 ref NI_7 NS_53 0 2.3283060805940538e-04
GC_7_54 ref NI_7 NS_54 0 -3.4776644618733552e-03
GC_7_55 ref NI_7 NS_55 0 -3.2884406459741417e-01
GC_7_56 ref NI_7 NS_56 0 2.4757778575375616e-01
GC_7_57 ref NI_7 NS_57 0 -2.6625811026572482e-01
GC_7_58 ref NI_7 NS_58 0 6.7396069800428712e-02
GC_7_59 ref NI_7 NS_59 0 2.1665574016247708e-04
GC_7_60 ref NI_7 NS_60 0 5.0595472008993898e-02
GC_7_61 ref NI_7 NS_61 0 -1.9334748132458238e-01
GC_7_62 ref NI_7 NS_62 0 -6.3528098061120739e-02
GC_7_63 ref NI_7 NS_63 0 3.0346984957181983e-02
GC_7_64 ref NI_7 NS_64 0 7.1775248120288557e-02
GC_7_65 ref NI_7 NS_65 0 2.1558319523000633e-04
GC_7_66 ref NI_7 NS_66 0 2.3273972191935395e-02
GC_7_67 ref NI_7 NS_67 0 -2.8147612810799499e-01
GC_7_68 ref NI_7 NS_68 0 6.2542519143228290e-03
GC_7_69 ref NI_7 NS_69 0 -5.9422016911842472e-03
GC_7_70 ref NI_7 NS_70 0 9.4433616708264556e-02
GC_7_71 ref NI_7 NS_71 0 2.9432413628016852e-04
GC_7_72 ref NI_7 NS_72 0 1.6261201357987733e-02
GC_7_73 ref NI_7 NS_73 0 -2.5766120849426594e-01
GC_7_74 ref NI_7 NS_74 0 -6.1524891313335751e-02
GC_7_75 ref NI_7 NS_75 0 6.7121888026958676e-02
GC_7_76 ref NI_7 NS_76 0 8.1683888831594068e-02
GC_7_77 ref NI_7 NS_77 0 2.7913784444916619e-04
GC_7_78 ref NI_7 NS_78 0 1.3481079682959161e-02
GC_7_79 ref NI_7 NS_79 0 -2.6369435673121205e-01
GC_7_80 ref NI_7 NS_80 0 -1.1558514210351629e-01
GC_7_81 ref NI_7 NS_81 0 1.1167050416819900e-01
GC_7_82 ref NI_7 NS_82 0 6.3158983621600079e-02
GC_7_83 ref NI_7 NS_83 0 2.0414318056342779e-04
GC_7_84 ref NI_7 NS_84 0 1.8154706670957831e-02
GC_7_85 ref NI_7 NS_85 0 -2.1393146418643985e-01
GC_7_86 ref NI_7 NS_86 0 -1.8160157916730346e-01
GC_7_87 ref NI_7 NS_87 0 1.5876269641177210e-01
GC_7_88 ref NI_7 NS_88 0 1.1237014943283484e-01
GC_7_89 ref NI_7 NS_89 0 2.7287647789466305e-04
GC_7_90 ref NI_7 NS_90 0 -2.7147582886357254e-03
GC_7_91 ref NI_7 NS_91 0 -3.1299839762002346e-01
GC_7_92 ref NI_7 NS_92 0 2.1609704816928518e-01
GC_7_93 ref NI_7 NS_93 0 -2.2305519593276710e-01
GC_7_94 ref NI_7 NS_94 0 5.0252025992705909e-02
GC_7_95 ref NI_7 NS_95 0 1.8955899475263523e-04
GC_7_96 ref NI_7 NS_96 0 5.1534640215773524e-02
GC_7_97 ref NI_7 NS_97 0 -3.0554295869533260e-01
GC_7_98 ref NI_7 NS_98 0 2.2130580659210966e-01
GC_7_99 ref NI_7 NS_99 0 -2.0613508873511019e-01
GC_7_100 ref NI_7 NS_100 0 1.7491567978730783e-02
GC_7_101 ref NI_7 NS_101 0 1.5884859281363245e-04
GC_7_102 ref NI_7 NS_102 0 6.0023113637104747e-02
GC_7_103 ref NI_7 NS_103 0 -2.2809850872596463e-01
GC_7_104 ref NI_7 NS_104 0 1.2954442527036428e-01
GC_7_105 ref NI_7 NS_105 0 -1.5273091686398904e-01
GC_7_106 ref NI_7 NS_106 0 3.0287377233556800e-02
GC_7_107 ref NI_7 NS_107 0 1.8983965772377480e-04
GC_7_108 ref NI_7 NS_108 0 5.2960642648932861e-02
GC_7_109 ref NI_7 NS_109 0 -1.6543972371101912e-01
GC_7_110 ref NI_7 NS_110 0 1.3147196435490274e-02
GC_7_111 ref NI_7 NS_111 0 -8.0170756908374011e-02
GC_7_112 ref NI_7 NS_112 0 6.3174802369237115e-02
GC_7_113 ref NI_7 NS_113 0 2.0031296893149528e-04
GC_7_114 ref NI_7 NS_114 0 3.8481998366684776e-02
GC_7_115 ref NI_7 NS_115 0 -2.9247368774657084e-01
GC_7_116 ref NI_7 NS_116 0 2.0861985644027786e-01
GC_7_117 ref NI_7 NS_117 0 -1.8115579484713629e-01
GC_7_118 ref NI_7 NS_118 0 -5.6567601861059920e-03
GC_7_119 ref NI_7 NS_119 0 1.7909425833501381e-04
GC_7_120 ref NI_7 NS_120 0 6.4576251065483578e-02
GC_7_121 ref NI_7 NS_121 0 -2.3336021066638046e-01
GC_7_122 ref NI_7 NS_122 0 1.2062801039830277e-01
GC_7_123 ref NI_7 NS_123 0 -1.4504823026163921e-01
GC_7_124 ref NI_7 NS_124 0 4.4895572264396250e-02
GC_7_125 ref NI_7 NS_125 0 1.8120474754825487e-04
GC_7_126 ref NI_7 NS_126 0 4.7631186886656296e-02
GC_7_127 ref NI_7 NS_127 0 -2.6872145194029734e-01
GC_7_128 ref NI_7 NS_128 0 1.4127414120547407e-01
GC_7_129 ref NI_7 NS_129 0 -1.6778737139072081e-01
GC_7_130 ref NI_7 NS_130 0 6.8281022083036602e-02
GC_7_131 ref NI_7 NS_131 0 1.9898045416196573e-04
GC_7_132 ref NI_7 NS_132 0 4.1941011612659111e-02
GC_7_133 ref NI_7 NS_133 0 -2.7629436110116629e-01
GC_7_134 ref NI_7 NS_134 0 1.3719759456785091e-01
GC_7_135 ref NI_7 NS_135 0 -1.7345757011613147e-01
GC_7_136 ref NI_7 NS_136 0 8.2170689729553062e-02
GC_7_137 ref NI_7 NS_137 0 2.2367652577506099e-04
GC_7_138 ref NI_7 NS_138 0 3.8415153944451601e-02
GD_7_1 ref NI_7 NA_1 0 -2.1769754306249581e-01
GD_7_2 ref NI_7 NA_2 0 -1.3128652999842433e-01
GD_7_3 ref NI_7 NA_3 0 7.1158121738415597e-02
GD_7_4 ref NI_7 NA_4 0 1.1825767057697106e-01
GD_7_5 ref NI_7 NA_5 0 1.0627884006866030e-01
GD_7_6 ref NI_7 NA_6 0 -2.7300142596788261e-02
GD_7_7 ref NI_7 NA_7 0 5.2631198110232171e+00
GD_7_8 ref NI_7 NA_8 0 5.7261148958476615e-02
GD_7_9 ref NI_7 NA_9 0 4.9868016082553257e-02
GD_7_10 ref NI_7 NA_10 0 6.2896231713640491e-02
GD_7_11 ref NI_7 NA_11 0 4.0707766801397913e-02
GD_7_12 ref NI_7 NA_12 0 5.0095360429540894e-02
GD_7_13 ref NI_7 NA_13 0 4.7595286356873066e-02
GD_7_14 ref NI_7 NA_14 0 5.0700720270001748e-02
GD_7_15 ref NI_7 NA_15 0 3.9525233533437357e-02
GD_7_16 ref NI_7 NA_16 0 6.0537331262040438e-02
GD_7_17 ref NI_7 NA_17 0 5.8064095129001313e-02
GD_7_18 ref NI_7 NA_18 0 4.8848380197813832e-02
GD_7_19 ref NI_7 NA_19 0 4.0174910803080187e-02
GD_7_20 ref NI_7 NA_20 0 5.6639330375089107e-02
GD_7_21 ref NI_7 NA_21 0 4.7516813669487186e-02
GD_7_22 ref NI_7 NA_22 0 5.2473097745503836e-02
GD_7_23 ref NI_7 NA_23 0 5.4656534146055549e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -2.8047908043275860e-01
GC_8_2 ref NI_8 NS_2 0 8.7818695319878448e-01
GC_8_3 ref NI_8 NS_3 0 -2.6843352286748368e-01
GC_8_4 ref NI_8 NS_4 0 2.4750335795487396e-02
GC_8_5 ref NI_8 NS_5 0 1.0480941346566212e-04
GC_8_6 ref NI_8 NS_6 0 1.4666800077396947e-03
GC_8_7 ref NI_8 NS_7 0 1.3118747945125102e+00
GC_8_8 ref NI_8 NS_8 0 5.1276538772976876e-01
GC_8_9 ref NI_8 NS_9 0 -2.5716960187540705e-01
GC_8_10 ref NI_8 NS_10 0 -2.1103159890354672e-02
GC_8_11 ref NI_8 NS_11 0 -2.1332082236896115e-06
GC_8_12 ref NI_8 NS_12 0 -2.6239004284110554e-04
GC_8_13 ref NI_8 NS_13 0 2.4478296457623541e-01
GC_8_14 ref NI_8 NS_14 0 4.2120983869687550e-01
GC_8_15 ref NI_8 NS_15 0 -9.2065900161605180e-02
GC_8_16 ref NI_8 NS_16 0 2.0294882619341984e-02
GC_8_17 ref NI_8 NS_17 0 6.1058167943331859e-05
GC_8_18 ref NI_8 NS_18 0 2.7814772816359117e-03
GC_8_19 ref NI_8 NS_19 0 -3.6021505178656288e-01
GC_8_20 ref NI_8 NS_20 0 -1.2347870125011499e-01
GC_8_21 ref NI_8 NS_21 0 1.7059575091530715e-01
GC_8_22 ref NI_8 NS_22 0 6.7956378877044532e-02
GC_8_23 ref NI_8 NS_23 0 1.7548247196808630e-04
GC_8_24 ref NI_8 NS_24 0 8.3100650927361332e-03
GC_8_25 ref NI_8 NS_25 0 -2.3143053965142196e-01
GC_8_26 ref NI_8 NS_26 0 -1.8262467169523233e-01
GC_8_27 ref NI_8 NS_27 0 1.5723551020916476e-01
GC_8_28 ref NI_8 NS_28 0 8.4449208972582110e-02
GC_8_29 ref NI_8 NS_29 0 1.7583023677688900e-04
GC_8_30 ref NI_8 NS_30 0 8.2520005888690618e-03
GC_8_31 ref NI_8 NS_31 0 -1.9726432648711298e-01
GC_8_32 ref NI_8 NS_32 0 -2.0824556777867345e-01
GC_8_33 ref NI_8 NS_33 0 1.7005235812209385e-01
GC_8_34 ref NI_8 NS_34 0 8.4680514571188206e-02
GC_8_35 ref NI_8 NS_35 0 1.8061580580380608e-04
GC_8_36 ref NI_8 NS_36 0 7.7740146565867061e-03
GC_8_37 ref NI_8 NS_37 0 -3.6592788505979562e-01
GC_8_38 ref NI_8 NS_38 0 -1.0968101952508434e-01
GC_8_39 ref NI_8 NS_39 0 1.9614645101938505e-01
GC_8_40 ref NI_8 NS_40 0 5.4283058010692213e-02
GC_8_41 ref NI_8 NS_41 0 1.4550998095400972e-04
GC_8_42 ref NI_8 NS_42 0 7.5835265958009487e-03
GC_8_43 ref NI_8 NS_43 0 2.8406340836135304e+00
GC_8_44 ref NI_8 NS_44 0 -5.7245953478633762e+00
GC_8_45 ref NI_8 NS_45 0 -1.3977788454083822e+00
GC_8_46 ref NI_8 NS_46 0 -2.0792630905065970e-01
GC_8_47 ref NI_8 NS_47 0 -7.6891571401177593e-04
GC_8_48 ref NI_8 NS_48 0 -2.4816952796812373e-02
GC_8_49 ref NI_8 NS_49 0 -4.5303763781593653e-01
GC_8_50 ref NI_8 NS_50 0 8.6178442187190274e-01
GC_8_51 ref NI_8 NS_51 0 8.3278265305094759e-02
GC_8_52 ref NI_8 NS_52 0 -1.6189166724518483e-01
GC_8_53 ref NI_8 NS_53 0 -6.9216299353478403e-05
GC_8_54 ref NI_8 NS_54 0 1.6214041831048214e-03
GC_8_55 ref NI_8 NS_55 0 -7.3753501852136971e-02
GC_8_56 ref NI_8 NS_56 0 -5.7119869574308348e-02
GC_8_57 ref NI_8 NS_57 0 -8.9655940944503090e-02
GC_8_58 ref NI_8 NS_58 0 1.7951353939342324e-01
GC_8_59 ref NI_8 NS_59 0 3.7638342852684192e-05
GC_8_60 ref NI_8 NS_60 0 3.4742054402489065e-03
GC_8_61 ref NI_8 NS_61 0 8.4695222755400743e-02
GC_8_62 ref NI_8 NS_62 0 2.0968382762821673e+00
GC_8_63 ref NI_8 NS_63 0 -7.5105431224729491e-01
GC_8_64 ref NI_8 NS_64 0 -1.1984029310119443e-01
GC_8_65 ref NI_8 NS_65 0 -1.4044823633868760e-04
GC_8_66 ref NI_8 NS_66 0 -5.1341248994989644e-03
GC_8_67 ref NI_8 NS_67 0 -1.9010166797349032e-01
GC_8_68 ref NI_8 NS_68 0 8.8504326444244483e-02
GC_8_69 ref NI_8 NS_69 0 1.8978698282454715e-01
GC_8_70 ref NI_8 NS_70 0 8.6118199958474617e-04
GC_8_71 ref NI_8 NS_71 0 4.2124610234442024e-05
GC_8_72 ref NI_8 NS_72 0 2.0124606787444059e-03
GC_8_73 ref NI_8 NS_73 0 -3.8204756226733277e-01
GC_8_74 ref NI_8 NS_74 0 6.3613400046341650e-01
GC_8_75 ref NI_8 NS_75 0 5.0706399140367106e-02
GC_8_76 ref NI_8 NS_76 0 -8.2573554881966424e-02
GC_8_77 ref NI_8 NS_77 0 -1.7485392188084118e-05
GC_8_78 ref NI_8 NS_78 0 1.5493639460439934e-03
GC_8_79 ref NI_8 NS_79 0 -4.7923381191307418e-01
GC_8_80 ref NI_8 NS_80 0 1.2939762227250482e+00
GC_8_81 ref NI_8 NS_81 0 -7.4229036569051970e-02
GC_8_82 ref NI_8 NS_82 0 -2.0420404510882470e-01
GC_8_83 ref NI_8 NS_83 0 -2.6136477939008186e-05
GC_8_84 ref NI_8 NS_84 0 -4.1501193912463312e-03
GC_8_85 ref NI_8 NS_85 0 -1.6225946451111747e-01
GC_8_86 ref NI_8 NS_86 0 -2.7875674756956546e-02
GC_8_87 ref NI_8 NS_87 0 4.3171013798279928e-01
GC_8_88 ref NI_8 NS_88 0 -8.8765708472319418e-02
GC_8_89 ref NI_8 NS_89 0 8.9957171234689018e-06
GC_8_90 ref NI_8 NS_90 0 1.1688518877842990e-03
GC_8_91 ref NI_8 NS_91 0 -1.3176255366588438e-01
GC_8_92 ref NI_8 NS_92 0 -3.0380117436226324e-02
GC_8_93 ref NI_8 NS_93 0 -1.3802064249563416e-02
GC_8_94 ref NI_8 NS_94 0 1.3614458431006385e-01
GC_8_95 ref NI_8 NS_95 0 2.2601823138902514e-05
GC_8_96 ref NI_8 NS_96 0 2.5388425978246499e-03
GC_8_97 ref NI_8 NS_97 0 3.8577997337255802e-03
GC_8_98 ref NI_8 NS_98 0 -1.7728671142049973e-01
GC_8_99 ref NI_8 NS_99 0 1.2166837405297512e-01
GC_8_100 ref NI_8 NS_100 0 1.1646368845622036e-01
GC_8_101 ref NI_8 NS_101 0 1.3448432040799738e-05
GC_8_102 ref NI_8 NS_102 0 -2.4856982525697929e-03
GC_8_103 ref NI_8 NS_103 0 -9.3811380773523981e-02
GC_8_104 ref NI_8 NS_104 0 -1.9834944996978446e-01
GC_8_105 ref NI_8 NS_105 0 4.0485878369902550e-01
GC_8_106 ref NI_8 NS_106 0 -1.7123060327552540e-02
GC_8_107 ref NI_8 NS_107 0 1.6067248324718441e-05
GC_8_108 ref NI_8 NS_108 0 -5.2335437269728407e-03
GC_8_109 ref NI_8 NS_109 0 -3.2517095563571724e-01
GC_8_110 ref NI_8 NS_110 0 2.4761214562230435e-01
GC_8_111 ref NI_8 NS_111 0 4.1001898497120770e-01
GC_8_112 ref NI_8 NS_112 0 -1.4451840985235415e-01
GC_8_113 ref NI_8 NS_113 0 1.9006880128325743e-06
GC_8_114 ref NI_8 NS_114 0 -4.6133486758172708e-03
GC_8_115 ref NI_8 NS_115 0 1.2045776509857578e-01
GC_8_116 ref NI_8 NS_116 0 -3.0530042316980316e-01
GC_8_117 ref NI_8 NS_117 0 1.9512579444033371e-01
GC_8_118 ref NI_8 NS_118 0 1.1809311706596874e-01
GC_8_119 ref NI_8 NS_119 0 4.7152841338183629e-05
GC_8_120 ref NI_8 NS_120 0 -6.5713986606684904e-03
GC_8_121 ref NI_8 NS_121 0 -2.8605774526610134e-01
GC_8_122 ref NI_8 NS_122 0 1.2679488512372256e-01
GC_8_123 ref NI_8 NS_123 0 2.2608495131844772e-01
GC_8_124 ref NI_8 NS_124 0 -1.5433881858647414e-02
GC_8_125 ref NI_8 NS_125 0 -1.7141321520486153e-05
GC_8_126 ref NI_8 NS_126 0 -1.2338763770782415e-03
GC_8_127 ref NI_8 NS_127 0 -2.0269937110815064e-01
GC_8_128 ref NI_8 NS_128 0 4.3946949587381191e-02
GC_8_129 ref NI_8 NS_129 0 8.4041241057692576e-02
GC_8_130 ref NI_8 NS_130 0 6.8410470923666825e-02
GC_8_131 ref NI_8 NS_131 0 1.8391775111947114e-05
GC_8_132 ref NI_8 NS_132 0 2.3143995815751895e-03
GC_8_133 ref NI_8 NS_133 0 -1.2410619114289649e-01
GC_8_134 ref NI_8 NS_134 0 -4.7028074423936146e-02
GC_8_135 ref NI_8 NS_135 0 4.4877400922568811e-02
GC_8_136 ref NI_8 NS_136 0 1.1052247416105476e-01
GC_8_137 ref NI_8 NS_137 0 2.6501599605229016e-05
GC_8_138 ref NI_8 NS_138 0 3.1590132163575560e-03
GD_8_1 ref NI_8 NA_1 0 -5.3667705264675361e-02
GD_8_2 ref NI_8 NA_2 0 -3.0894781079569351e-02
GD_8_3 ref NI_8 NA_3 0 -4.9326954370873609e-02
GD_8_4 ref NI_8 NA_4 0 6.3202163259541894e-02
GD_8_5 ref NI_8 NA_5 0 4.8299544925948061e-02
GD_8_6 ref NI_8 NA_6 0 4.3526633691743706e-02
GD_8_7 ref NI_8 NA_7 0 5.7261148958476615e-02
GD_8_8 ref NI_8 NA_8 0 5.6130807666780864e+00
GD_8_9 ref NI_8 NA_9 0 4.9531110751055568e-02
GD_8_10 ref NI_8 NA_10 0 2.9428497197374757e-02
GD_8_11 ref NI_8 NA_11 0 -3.2160052728370206e-02
GD_8_12 ref NI_8 NA_12 0 3.0806308514322714e-02
GD_8_13 ref NI_8 NA_13 0 5.5266326634729357e-02
GD_8_14 ref NI_8 NA_14 0 7.2948042108773883e-02
GD_8_15 ref NI_8 NA_15 0 1.9300633595979437e-02
GD_8_16 ref NI_8 NA_16 0 3.9232921450762383e-02
GD_8_17 ref NI_8 NA_17 0 1.6222684500992776e-02
GD_8_18 ref NI_8 NA_18 0 3.7043377189249306e-02
GD_8_19 ref NI_8 NA_19 0 6.1218605747786814e-02
GD_8_20 ref NI_8 NA_20 0 4.7891796702107655e-03
GD_8_21 ref NI_8 NA_21 0 4.5937647981590578e-02
GD_8_22 ref NI_8 NA_22 0 4.2638161180709157e-02
GD_8_23 ref NI_8 NA_23 0 3.1327546366697059e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -4.1457218092944931e-01
GC_9_2 ref NI_9 NS_2 0 9.0309654797714933e-01
GC_9_3 ref NI_9 NS_3 0 -1.9779450633054782e-01
GC_9_4 ref NI_9 NS_4 0 6.0768499251699030e-03
GC_9_5 ref NI_9 NS_5 0 1.3540559708063752e-04
GC_9_6 ref NI_9 NS_6 0 -4.8861194647633428e-03
GC_9_7 ref NI_9 NS_7 0 1.0990388615087023e+00
GC_9_8 ref NI_9 NS_8 0 6.3598491429094162e-01
GC_9_9 ref NI_9 NS_9 0 -2.3539949025764248e-01
GC_9_10 ref NI_9 NS_10 0 -4.3969210374624465e-02
GC_9_11 ref NI_9 NS_11 0 3.1287227576919387e-05
GC_9_12 ref NI_9 NS_12 0 -4.2903670579071043e-03
GC_9_13 ref NI_9 NS_13 0 2.6396330370701521e-01
GC_9_14 ref NI_9 NS_14 0 4.1148984126674226e-01
GC_9_15 ref NI_9 NS_15 0 -2.9263593839232424e-02
GC_9_16 ref NI_9 NS_16 0 5.9996061730743719e-03
GC_9_17 ref NI_9 NS_17 0 8.9678483133304675e-05
GC_9_18 ref NI_9 NS_18 0 -4.4351881851192520e-03
GC_9_19 ref NI_9 NS_19 0 -2.9512045129732561e-01
GC_9_20 ref NI_9 NS_20 0 -2.2040146101551886e-01
GC_9_21 ref NI_9 NS_21 0 2.3310066830162046e-01
GC_9_22 ref NI_9 NS_22 0 8.9265036344808146e-02
GC_9_23 ref NI_9 NS_23 0 2.2747429232690370e-04
GC_9_24 ref NI_9 NS_24 0 -2.7203172469825450e-03
GC_9_25 ref NI_9 NS_25 0 -1.5729790593810197e-01
GC_9_26 ref NI_9 NS_26 0 -2.7597464411631978e-01
GC_9_27 ref NI_9 NS_27 0 2.0734401276795913e-01
GC_9_28 ref NI_9 NS_28 0 1.1200011140216855e-01
GC_9_29 ref NI_9 NS_29 0 2.3419297100926901e-04
GC_9_30 ref NI_9 NS_30 0 -3.3191171296198664e-03
GC_9_31 ref NI_9 NS_31 0 -1.2000789590630390e-01
GC_9_32 ref NI_9 NS_32 0 -3.0326745564320845e-01
GC_9_33 ref NI_9 NS_33 0 2.2040364270356835e-01
GC_9_34 ref NI_9 NS_34 0 1.1263627758671534e-01
GC_9_35 ref NI_9 NS_35 0 2.6457146014788975e-04
GC_9_36 ref NI_9 NS_36 0 -4.0687509924985411e-03
GC_9_37 ref NI_9 NS_37 0 -3.0660592644094964e-01
GC_9_38 ref NI_9 NS_38 0 -2.0537247360184407e-01
GC_9_39 ref NI_9 NS_39 0 2.6665007542491059e-01
GC_9_40 ref NI_9 NS_40 0 7.0772774755923473e-02
GC_9_41 ref NI_9 NS_41 0 2.3283060805940250e-04
GC_9_42 ref NI_9 NS_42 0 -3.4776644618733422e-03
GC_9_43 ref NI_9 NS_43 0 -4.5303763781593642e-01
GC_9_44 ref NI_9 NS_44 0 8.6178442187190196e-01
GC_9_45 ref NI_9 NS_45 0 8.3278265305095647e-02
GC_9_46 ref NI_9 NS_46 0 -1.6189166724518536e-01
GC_9_47 ref NI_9 NS_47 0 -6.9216299353509858e-05
GC_9_48 ref NI_9 NS_48 0 1.6214041831049577e-03
GC_9_49 ref NI_9 NS_49 0 2.4615076658765362e+00
GC_9_50 ref NI_9 NS_50 0 -2.9857476277822563e+00
GC_9_51 ref NI_9 NS_51 0 -2.9306473042576155e+00
GC_9_52 ref NI_9 NS_52 0 -2.5170926620892947e-01
GC_9_53 ref NI_9 NS_53 0 -8.4507071463099323e-04
GC_9_54 ref NI_9 NS_54 0 -2.3617886574505916e-02
GC_9_55 ref NI_9 NS_55 0 2.2458212431895544e-01
GC_9_56 ref NI_9 NS_56 0 -3.8341603096005883e-01
GC_9_57 ref NI_9 NS_57 0 2.1380128799501555e-01
GC_9_58 ref NI_9 NS_58 0 1.1576074013061199e-01
GC_9_59 ref NI_9 NS_59 0 4.6163427298480079e-05
GC_9_60 ref NI_9 NS_60 0 -1.8032172929892949e-03
GC_9_61 ref NI_9 NS_61 0 -3.5929797986326167e-01
GC_9_62 ref NI_9 NS_62 0 2.6788536625005593e-01
GC_9_63 ref NI_9 NS_63 0 2.9751070015278602e-01
GC_9_64 ref NI_9 NS_64 0 -1.0540385953968019e-01
GC_9_65 ref NI_9 NS_65 0 -5.1096748497163752e-05
GC_9_66 ref NI_9 NS_66 0 4.0691452176878501e-03
GC_9_67 ref NI_9 NS_67 0 -1.1928159122859991e-01
GC_9_68 ref NI_9 NS_68 0 2.1343867192022373e-01
GC_9_69 ref NI_9 NS_69 0 4.3457777992555141e-01
GC_9_70 ref NI_9 NS_70 0 -1.5547314878150414e-01
GC_9_71 ref NI_9 NS_71 0 -4.0769561199994138e-05
GC_9_72 ref NI_9 NS_72 0 -2.9235324264701066e-03
GC_9_73 ref NI_9 NS_73 0 -4.4359594892251253e-01
GC_9_74 ref NI_9 NS_74 0 1.5122078285890674e+00
GC_9_75 ref NI_9 NS_75 0 -2.0315523846917063e-01
GC_9_76 ref NI_9 NS_76 0 -2.0553118583614111e-01
GC_9_77 ref NI_9 NS_77 0 -1.2634421571014711e-04
GC_9_78 ref NI_9 NS_78 0 -9.8744104074224175e-04
GC_9_79 ref NI_9 NS_79 0 -3.0366721929492840e-01
GC_9_80 ref NI_9 NS_80 0 -1.3590364643881095e-02
GC_9_81 ref NI_9 NS_81 0 3.5191420064768925e-01
GC_9_82 ref NI_9 NS_82 0 -5.4248022463293744e-02
GC_9_83 ref NI_9 NS_83 0 2.5846170874388257e-05
GC_9_84 ref NI_9 NS_84 0 4.6242808339524025e-03
GC_9_85 ref NI_9 NS_85 0 -1.9687640332622872e-01
GC_9_86 ref NI_9 NS_86 0 2.5375427036011217e-01
GC_9_87 ref NI_9 NS_87 0 7.1688050215101273e-01
GC_9_88 ref NI_9 NS_88 0 -3.0843538170508766e-01
GC_9_89 ref NI_9 NS_89 0 -1.3708428197849228e-04
GC_9_90 ref NI_9 NS_90 0 -3.0076127805224199e-03
GC_9_91 ref NI_9 NS_91 0 6.8199207233322470e-02
GC_9_92 ref NI_9 NS_92 0 -2.1193256520726139e-01
GC_9_93 ref NI_9 NS_93 0 1.2798739687421390e-01
GC_9_94 ref NI_9 NS_94 0 1.0790292422774309e-01
GC_9_95 ref NI_9 NS_95 0 1.9729154158210201e-05
GC_9_96 ref NI_9 NS_96 0 1.9440482255598929e-03
GC_9_97 ref NI_9 NS_97 0 -8.3950137269648256e-02
GC_9_98 ref NI_9 NS_98 0 -5.5772776593674919e-04
GC_9_99 ref NI_9 NS_99 0 -1.2843906725573734e-01
GC_9_100 ref NI_9 NS_100 0 1.7244344801731440e-01
GC_9_101 ref NI_9 NS_101 0 -5.5699436804087348e-06
GC_9_102 ref NI_9 NS_102 0 8.1556261965438810e-03
GC_9_103 ref NI_9 NS_103 0 -1.3876085234025357e-01
GC_9_104 ref NI_9 NS_104 0 -1.6853367267075984e-02
GC_9_105 ref NI_9 NS_105 0 -7.4242088951719742e-02
GC_9_106 ref NI_9 NS_106 0 1.4228033656603223e-01
GC_9_107 ref NI_9 NS_107 0 1.5720358289625374e-05
GC_9_108 ref NI_9 NS_108 0 1.1149699738344556e-02
GC_9_109 ref NI_9 NS_109 0 -9.8339946074933682e-02
GC_9_110 ref NI_9 NS_110 0 -1.6547362487027711e-01
GC_9_111 ref NI_9 NS_111 0 1.8250133713882610e-01
GC_9_112 ref NI_9 NS_112 0 5.8939612183798028e-02
GC_9_113 ref NI_9 NS_113 0 2.8555714850414459e-05
GC_9_114 ref NI_9 NS_114 0 7.8686346172701181e-03
GC_9_115 ref NI_9 NS_115 0 -2.3540757739380061e-01
GC_9_116 ref NI_9 NS_116 0 1.7582226511222027e-01
GC_9_117 ref NI_9 NS_117 0 -3.1527272830733383e-01
GC_9_118 ref NI_9 NS_118 0 2.1010293419468443e-01
GC_9_119 ref NI_9 NS_119 0 -1.5477264627366151e-06
GC_9_120 ref NI_9 NS_120 0 1.3923885412287300e-02
GC_9_121 ref NI_9 NS_121 0 -1.1221762058592166e-01
GC_9_122 ref NI_9 NS_122 0 -5.3573732958414597e-02
GC_9_123 ref NI_9 NS_123 0 1.0710816900544803e-01
GC_9_124 ref NI_9 NS_124 0 7.0201422610352657e-02
GC_9_125 ref NI_9 NS_125 0 -1.6151314557709526e-05
GC_9_126 ref NI_9 NS_126 0 6.8191304402380765e-03
GC_9_127 ref NI_9 NS_127 0 -5.3413632689881474e-02
GC_9_128 ref NI_9 NS_128 0 -1.2315034114684151e-01
GC_9_129 ref NI_9 NS_129 0 2.8355994118448830e-01
GC_9_130 ref NI_9 NS_130 0 1.1643339537188602e-02
GC_9_131 ref NI_9 NS_131 0 -2.7010709903280672e-05
GC_9_132 ref NI_9 NS_132 0 1.0699440907244191e-03
GC_9_133 ref NI_9 NS_133 0 4.5401090516708861e-02
GC_9_134 ref NI_9 NS_134 0 -2.6185974510163029e-01
GC_9_135 ref NI_9 NS_135 0 3.8436221693710143e-01
GC_9_136 ref NI_9 NS_136 0 2.5416438750611673e-03
GC_9_137 ref NI_9 NS_137 0 -2.8728008517329659e-07
GC_9_138 ref NI_9 NS_138 0 -2.1554130968703942e-03
GD_9_1 ref NI_9 NA_1 0 -4.0672665800542032e-02
GD_9_2 ref NI_9 NA_2 0 -1.4430548915370522e-02
GD_9_3 ref NI_9 NA_3 0 -4.5273173803263130e-02
GD_9_4 ref NI_9 NA_4 0 5.5353403880296616e-02
GD_9_5 ref NI_9 NA_5 0 3.9034386760945977e-02
GD_9_6 ref NI_9 NA_6 0 3.3866509747031211e-02
GD_9_7 ref NI_9 NA_7 0 4.9868016082553257e-02
GD_9_8 ref NI_9 NA_8 0 4.9531110751055568e-02
GD_9_9 ref NI_9 NA_9 0 5.7293926619875526e+00
GD_9_10 ref NI_9 NA_10 0 -1.6023220519019561e-02
GD_9_11 ref NI_9 NA_11 0 5.0149639000035481e-02
GD_9_12 ref NI_9 NA_12 0 6.8053496614447952e-03
GD_9_13 ref NI_9 NA_13 0 4.4381355263388704e-02
GD_9_14 ref NI_9 NA_14 0 4.8381997146387086e-02
GD_9_15 ref NI_9 NA_15 0 5.5050897514363874e-03
GD_9_16 ref NI_9 NA_16 0 6.1818165654722651e-03
GD_9_17 ref NI_9 NA_17 0 2.6660567993463346e-02
GD_9_18 ref NI_9 NA_18 0 3.9017639029203889e-02
GD_9_19 ref NI_9 NA_19 0 3.0693503746006729e-02
GD_9_20 ref NI_9 NA_20 0 5.0699508953413769e-02
GD_9_21 ref NI_9 NA_21 0 2.6828135929833841e-02
GD_9_22 ref NI_9 NA_22 0 1.2889784466917013e-02
GD_9_23 ref NI_9 NA_23 0 4.6051172397072329e-05
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -2.4631614644050320e-01
GC_10_2 ref NI_10 NS_2 0 8.1735171312408622e-02
GC_10_3 ref NI_10 NS_3 0 -1.1247637307315102e-01
GC_10_4 ref NI_10 NS_4 0 8.4880149313911551e-02
GC_10_5 ref NI_10 NS_5 0 1.8343122464632141e-04
GC_10_6 ref NI_10 NS_6 0 3.1415994312252046e-02
GC_10_7 ref NI_10 NS_7 0 -1.7457248658094390e-01
GC_10_8 ref NI_10 NS_8 0 3.0212847608035914e-02
GC_10_9 ref NI_10 NS_9 0 -4.5335503602081981e-02
GC_10_10 ref NI_10 NS_10 0 8.8659002895502659e-02
GC_10_11 ref NI_10 NS_11 0 1.2541063087353346e-04
GC_10_12 ref NI_10 NS_12 0 2.0225540002400570e-02
GC_10_13 ref NI_10 NS_13 0 -2.0902376238791723e-01
GC_10_14 ref NI_10 NS_14 0 1.0906037491579156e-01
GC_10_15 ref NI_10 NS_15 0 -1.2832249294188655e-01
GC_10_16 ref NI_10 NS_16 0 7.6832145642584213e-02
GC_10_17 ref NI_10 NS_17 0 1.5201037508519408e-04
GC_10_18 ref NI_10 NS_18 0 3.3781511170553551e-02
GC_10_19 ref NI_10 NS_19 0 -3.4686567252386258e-01
GC_10_20 ref NI_10 NS_20 0 2.5955842671842022e-01
GC_10_21 ref NI_10 NS_21 0 -2.6650731261514299e-01
GC_10_22 ref NI_10 NS_22 0 5.7123613173082913e-02
GC_10_23 ref NI_10 NS_23 0 2.3218579824508620e-04
GC_10_24 ref NI_10 NS_24 0 5.3323475869833187e-02
GC_10_25 ref NI_10 NS_25 0 -3.6700724298481691e-01
GC_10_26 ref NI_10 NS_26 0 2.8377729318165296e-01
GC_10_27 ref NI_10 NS_27 0 -2.7961677200542112e-01
GC_10_28 ref NI_10 NS_28 0 5.2227488098695846e-02
GC_10_29 ref NI_10 NS_29 0 2.2156315763791496e-04
GC_10_30 ref NI_10 NS_30 0 5.5457609567449134e-02
GC_10_31 ref NI_10 NS_31 0 -3.7375469472566863e-01
GC_10_32 ref NI_10 NS_32 0 2.9404356147378607e-01
GC_10_33 ref NI_10 NS_33 0 -2.9100484340546046e-01
GC_10_34 ref NI_10 NS_34 0 5.6919863420329786e-02
GC_10_35 ref NI_10 NS_35 0 2.3075664288877874e-04
GC_10_36 ref NI_10 NS_36 0 5.4928758672202510e-02
GC_10_37 ref NI_10 NS_37 0 -3.2884406459741450e-01
GC_10_38 ref NI_10 NS_38 0 2.4757778575375738e-01
GC_10_39 ref NI_10 NS_39 0 -2.6625811026572643e-01
GC_10_40 ref NI_10 NS_40 0 6.7396069800429614e-02
GC_10_41 ref NI_10 NS_41 0 2.1665574016253557e-04
GC_10_42 ref NI_10 NS_42 0 5.0595472008993649e-02
GC_10_43 ref NI_10 NS_43 0 -7.3753501852136791e-02
GC_10_44 ref NI_10 NS_44 0 -5.7119869574309111e-02
GC_10_45 ref NI_10 NS_45 0 -8.9655940944502063e-02
GC_10_46 ref NI_10 NS_46 0 1.7951353939342266e-01
GC_10_47 ref NI_10 NS_47 0 3.7638342852648440e-05
GC_10_48 ref NI_10 NS_48 0 3.4742054402490613e-03
GC_10_49 ref NI_10 NS_49 0 2.2458212431895588e-01
GC_10_50 ref NI_10 NS_50 0 -3.8341603096006061e-01
GC_10_51 ref NI_10 NS_51 0 2.1380128799501791e-01
GC_10_52 ref NI_10 NS_52 0 1.1576074013061070e-01
GC_10_53 ref NI_10 NS_53 0 4.6163427298397157e-05
GC_10_54 ref NI_10 NS_54 0 -1.8032172929889360e-03
GC_10_55 ref NI_10 NS_55 0 2.4106916302558976e+00
GC_10_56 ref NI_10 NS_56 0 -4.9547326485882746e+00
GC_10_57 ref NI_10 NS_57 0 -6.2724355423209466e-01
GC_10_58 ref NI_10 NS_58 0 -7.0528332376647607e-01
GC_10_59 ref NI_10 NS_59 0 -5.5129796746878810e-04
GC_10_60 ref NI_10 NS_60 0 -7.3221877998564652e-02
GC_10_61 ref NI_10 NS_61 0 -1.9188346233455646e-02
GC_10_62 ref NI_10 NS_62 0 -1.6499724292896212e-01
GC_10_63 ref NI_10 NS_63 0 5.5943033827395613e-02
GC_10_64 ref NI_10 NS_64 0 1.5333016986051620e-01
GC_10_65 ref NI_10 NS_65 0 4.4282217144669034e-05
GC_10_66 ref NI_10 NS_66 0 -4.5899637789517276e-03
GC_10_67 ref NI_10 NS_67 0 -6.4555627236164614e-01
GC_10_68 ref NI_10 NS_68 0 -1.5575200286402804e-01
GC_10_69 ref NI_10 NS_69 0 1.0552790102133074e+00
GC_10_70 ref NI_10 NS_70 0 -2.9070105946022878e-01
GC_10_71 ref NI_10 NS_71 0 -1.8614058881180929e-04
GC_10_72 ref NI_10 NS_72 0 -2.0733444385068023e-02
GC_10_73 ref NI_10 NS_73 0 1.9656883591621932e-01
GC_10_74 ref NI_10 NS_74 0 -5.1523001652547618e-01
GC_10_75 ref NI_10 NS_75 0 6.8165043561995664e-01
GC_10_76 ref NI_10 NS_76 0 -5.2881797301400815e-02
GC_10_77 ref NI_10 NS_77 0 -7.0036967066994360e-05
GC_10_78 ref NI_10 NS_78 0 -1.4704201806063834e-02
GC_10_79 ref NI_10 NS_79 0 -4.2081634613980018e-01
GC_10_80 ref NI_10 NS_80 0 3.6443750196671471e-01
GC_10_81 ref NI_10 NS_81 0 -5.0956266283538376e-01
GC_10_82 ref NI_10 NS_82 0 2.7698507772042247e-01
GC_10_83 ref NI_10 NS_83 0 -8.4779344718805830e-06
GC_10_84 ref NI_10 NS_84 0 9.8713140175069672e-03
GC_10_85 ref NI_10 NS_85 0 4.4516946620321884e-01
GC_10_86 ref NI_10 NS_86 0 -6.9270140811420156e-01
GC_10_87 ref NI_10 NS_87 0 4.9779728040663762e-01
GC_10_88 ref NI_10 NS_88 0 6.6621841990648176e-02
GC_10_89 ref NI_10 NS_89 0 -2.1148330096836755e-05
GC_10_90 ref NI_10 NS_90 0 -9.0249992556251431e-03
GC_10_91 ref NI_10 NS_91 0 7.9012809601767908e-01
GC_10_92 ref NI_10 NS_92 0 2.0022966945424696e+00
GC_10_93 ref NI_10 NS_93 0 -3.0752272982241046e-02
GC_10_94 ref NI_10 NS_94 0 -3.8698691047497280e-01
GC_10_95 ref NI_10 NS_95 0 -1.5042049149605212e-04
GC_10_96 ref NI_10 NS_96 0 -5.3455952616142673e-02
GC_10_97 ref NI_10 NS_97 0 -1.9540286465401613e-01
GC_10_98 ref NI_10 NS_98 0 -2.4622238937309740e-01
GC_10_99 ref NI_10 NS_99 0 5.1353450618994656e-01
GC_10_100 ref NI_10 NS_100 0 6.3395025691955790e-03
GC_10_101 ref NI_10 NS_101 0 -8.3848247599460971e-06
GC_10_102 ref NI_10 NS_102 0 -2.6612780959080849e-02
GC_10_103 ref NI_10 NS_103 0 -4.9385720421454282e-01
GC_10_104 ref NI_10 NS_104 0 3.7295445038668035e-01
GC_10_105 ref NI_10 NS_105 0 -4.9828543801596054e-01
GC_10_106 ref NI_10 NS_106 0 3.0087899103826377e-01
GC_10_107 ref NI_10 NS_107 0 -6.7530795263991825e-05
GC_10_108 ref NI_10 NS_108 0 -8.0177854340592275e-04
GC_10_109 ref NI_10 NS_109 0 -5.1761807504066903e-01
GC_10_110 ref NI_10 NS_110 0 4.4756913180520286e-01
GC_10_111 ref NI_10 NS_111 0 -5.8443418824819793e-01
GC_10_112 ref NI_10 NS_112 0 3.0942179000191750e-01
GC_10_113 ref NI_10 NS_113 0 -4.8905592034351407e-05
GC_10_114 ref NI_10 NS_114 0 5.2059678796755162e-03
GC_10_115 ref NI_10 NS_115 0 -4.4824331059457634e-01
GC_10_116 ref NI_10 NS_116 0 2.7265245091126916e-01
GC_10_117 ref NI_10 NS_117 0 -3.7445470487764387e-01
GC_10_118 ref NI_10 NS_118 0 2.7949201350672376e-01
GC_10_119 ref NI_10 NS_119 0 -4.7988327858580015e-05
GC_10_120 ref NI_10 NS_120 0 -7.2428546142742720e-03
GC_10_121 ref NI_10 NS_121 0 -6.3321713060241869e-02
GC_10_122 ref NI_10 NS_122 0 -2.8348313054414859e-01
GC_10_123 ref NI_10 NS_123 0 3.1890369698661641e-01
GC_10_124 ref NI_10 NS_124 0 9.0580658555038329e-02
GC_10_125 ref NI_10 NS_125 0 -2.3785450771582130e-05
GC_10_126 ref NI_10 NS_126 0 -1.8155652860244335e-02
GC_10_127 ref NI_10 NS_127 0 -2.1110514487618465e-01
GC_10_128 ref NI_10 NS_128 0 -7.2526183582057493e-02
GC_10_129 ref NI_10 NS_129 0 1.1547207985578625e+00
GC_10_130 ref NI_10 NS_130 0 -3.4952586298405197e-01
GC_10_131 ref NI_10 NS_131 0 -9.9780936111004275e-05
GC_10_132 ref NI_10 NS_132 0 -3.6992195490645439e-02
GC_10_133 ref NI_10 NS_133 0 1.1382632083046671e+00
GC_10_134 ref NI_10 NS_134 0 2.7644698017933074e+00
GC_10_135 ref NI_10 NS_135 0 -4.0086360275418959e-01
GC_10_136 ref NI_10 NS_136 0 -4.7165341081844975e-01
GC_10_137 ref NI_10 NS_137 0 -1.6908116695601720e-04
GC_10_138 ref NI_10 NS_138 0 -5.1214526748215479e-02
GD_10_1 ref NI_10 NA_1 0 4.9172876199815439e-02
GD_10_2 ref NI_10 NA_2 0 4.7415529532657263e-02
GD_10_3 ref NI_10 NA_3 0 4.4859712326336065e-02
GD_10_4 ref NI_10 NA_4 0 6.6639176124854732e-02
GD_10_5 ref NI_10 NA_5 0 6.9048696043268798e-02
GD_10_6 ref NI_10 NA_6 0 6.9680569246331883e-02
GD_10_7 ref NI_10 NA_7 0 6.2896231713640491e-02
GD_10_8 ref NI_10 NA_8 0 2.9428497197374757e-02
GD_10_9 ref NI_10 NA_9 0 -1.6023220519019561e-02
GD_10_10 ref NI_10 NA_10 0 5.6717337599810804e+00
GD_10_11 ref NI_10 NA_11 0 2.2199081607456431e-02
GD_10_12 ref NI_10 NA_12 0 8.4413754915578385e-02
GD_10_13 ref NI_10 NA_13 0 -1.8036076952194301e-02
GD_10_14 ref NI_10 NA_14 0 7.9803717809243446e-02
GD_10_15 ref NI_10 NA_15 0 -4.4269557404943878e-02
GD_10_16 ref NI_10 NA_16 0 -1.3857872097202664e-01
GD_10_17 ref NI_10 NA_17 0 4.7195994943962358e-02
GD_10_18 ref NI_10 NA_18 0 9.4732323522966608e-02
GD_10_19 ref NI_10 NA_19 0 9.5482971277865522e-02
GD_10_20 ref NI_10 NA_20 0 9.0891272810375429e-02
GD_10_21 ref NI_10 NA_21 0 2.9012844355829112e-02
GD_10_22 ref NI_10 NA_22 0 1.5152721850625184e-02
GD_10_23 ref NI_10 NA_23 0 -1.5932487066976386e-01
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -4.2177298614164543e-01
GC_11_2 ref NI_11 NS_2 0 3.6858918916096206e-01
GC_11_3 ref NI_11 NS_3 0 -2.7374108281507180e-02
GC_11_4 ref NI_11 NS_4 0 1.7812798790059470e-02
GC_11_5 ref NI_11 NS_5 0 1.3127513587144445e-04
GC_11_6 ref NI_11 NS_6 0 1.4244648422013562e-02
GC_11_7 ref NI_11 NS_7 0 1.2848174483766878e-01
GC_11_8 ref NI_11 NS_8 0 3.5234370585886254e-01
GC_11_9 ref NI_11 NS_9 0 -3.7245479059273924e-02
GC_11_10 ref NI_11 NS_10 0 -1.1597862736900673e-02
GC_11_11 ref NI_11 NS_11 0 4.8545626740687814e-05
GC_11_12 ref NI_11 NS_12 0 8.6324321656576723e-03
GC_11_13 ref NI_11 NS_13 0 -3.1123683943519984e-02
GC_11_14 ref NI_11 NS_14 0 1.7788480717455593e-01
GC_11_15 ref NI_11 NS_15 0 -5.4682228133873267e-04
GC_11_16 ref NI_11 NS_16 0 2.6711092128942317e-02
GC_11_17 ref NI_11 NS_17 0 9.9108565644877780e-05
GC_11_18 ref NI_11 NS_18 0 1.5448663689130795e-02
GC_11_19 ref NI_11 NS_19 0 -2.0145817598435356e-01
GC_11_20 ref NI_11 NS_20 0 -5.4739811726021888e-02
GC_11_21 ref NI_11 NS_21 0 5.6224218100975184e-03
GC_11_22 ref NI_11 NS_22 0 7.7617216668401851e-02
GC_11_23 ref NI_11 NS_23 0 2.2222547319169470e-04
GC_11_24 ref NI_11 NS_24 0 2.4872444062169204e-02
GC_11_25 ref NI_11 NS_25 0 -1.5649681334231583e-01
GC_11_26 ref NI_11 NS_26 0 -5.2701798606562808e-02
GC_11_27 ref NI_11 NS_27 0 -2.6471433502957425e-02
GC_11_28 ref NI_11 NS_28 0 8.9040141206201115e-02
GC_11_29 ref NI_11 NS_29 0 2.2136743381371131e-04
GC_11_30 ref NI_11 NS_30 0 2.5549851214043660e-02
GC_11_31 ref NI_11 NS_31 0 -1.4002510956428130e-01
GC_11_32 ref NI_11 NS_32 0 -6.0764858653038156e-02
GC_11_33 ref NI_11 NS_33 0 -2.6329668689087024e-02
GC_11_34 ref NI_11 NS_34 0 9.1758026011891675e-02
GC_11_35 ref NI_11 NS_35 0 2.4214618412515883e-04
GC_11_36 ref NI_11 NS_36 0 2.4952737257138629e-02
GC_11_37 ref NI_11 NS_37 0 -1.9334748132458252e-01
GC_11_38 ref NI_11 NS_38 0 -6.3528098061120350e-02
GC_11_39 ref NI_11 NS_39 0 3.0346984957181460e-02
GC_11_40 ref NI_11 NS_40 0 7.1775248120288848e-02
GC_11_41 ref NI_11 NS_41 0 2.1558319523002495e-04
GC_11_42 ref NI_11 NS_42 0 2.3273972191935312e-02
GC_11_43 ref NI_11 NS_43 0 8.4695222755400743e-02
GC_11_44 ref NI_11 NS_44 0 2.0968382762821673e+00
GC_11_45 ref NI_11 NS_45 0 -7.5105431224729491e-01
GC_11_46 ref NI_11 NS_46 0 -1.1984029310119443e-01
GC_11_47 ref NI_11 NS_47 0 -1.4044823633868757e-04
GC_11_48 ref NI_11 NS_48 0 -5.1341248994989652e-03
GC_11_49 ref NI_11 NS_49 0 -3.5929797986326140e-01
GC_11_50 ref NI_11 NS_50 0 2.6788536625005471e-01
GC_11_51 ref NI_11 NS_51 0 2.9751070015278780e-01
GC_11_52 ref NI_11 NS_52 0 -1.0540385953968114e-01
GC_11_53 ref NI_11 NS_53 0 -5.1096748497225172e-05
GC_11_54 ref NI_11 NS_54 0 4.0691452176881146e-03
GC_11_55 ref NI_11 NS_55 0 -1.9188346233455975e-02
GC_11_56 ref NI_11 NS_56 0 -1.6499724292896070e-01
GC_11_57 ref NI_11 NS_57 0 5.5943033827393768e-02
GC_11_58 ref NI_11 NS_58 0 1.5333016986051726e-01
GC_11_59 ref NI_11 NS_59 0 4.4282217144733408e-05
GC_11_60 ref NI_11 NS_60 0 -4.5899637789520078e-03
GC_11_61 ref NI_11 NS_61 0 2.8131184849049986e+00
GC_11_62 ref NI_11 NS_62 0 -4.9522995516187356e+00
GC_11_63 ref NI_11 NS_63 0 -2.0558521799941261e+00
GC_11_64 ref NI_11 NS_64 0 -1.0430018208387637e-01
GC_11_65 ref NI_11 NS_65 0 -6.4430867813629507e-04
GC_11_66 ref NI_11 NS_66 0 -2.8250010315459720e-02
GC_11_67 ref NI_11 NS_67 0 -8.6170549911390948e-02
GC_11_68 ref NI_11 NS_68 0 -8.9206775889317715e-03
GC_11_69 ref NI_11 NS_69 0 1.6921114278392965e-01
GC_11_70 ref NI_11 NS_70 0 3.9994454254203560e-02
GC_11_71 ref NI_11 NS_71 0 2.0218048196413618e-05
GC_11_72 ref NI_11 NS_72 0 2.2386647206169736e-05
GC_11_73 ref NI_11 NS_73 0 -2.9550703970152531e-01
GC_11_74 ref NI_11 NS_74 0 6.3373369798755319e-01
GC_11_75 ref NI_11 NS_75 0 6.9539637427187221e-03
GC_11_76 ref NI_11 NS_76 0 -5.9137636112213593e-02
GC_11_77 ref NI_11 NS_77 0 -6.0379920134857385e-05
GC_11_78 ref NI_11 NS_78 0 -2.5650214993906407e-04
GC_11_79 ref NI_11 NS_79 0 -4.2587974654348004e-01
GC_11_80 ref NI_11 NS_80 0 3.2043398448809729e-01
GC_11_81 ref NI_11 NS_81 0 4.2700025488645410e-01
GC_11_82 ref NI_11 NS_82 0 -1.6271629987655092e-01
GC_11_83 ref NI_11 NS_83 0 -4.7574579393522989e-05
GC_11_84 ref NI_11 NS_84 0 -6.7293017914349454e-03
GC_11_85 ref NI_11 NS_85 0 -4.2560092187472948e-02
GC_11_86 ref NI_11 NS_86 0 -1.6545574404340085e-01
GC_11_87 ref NI_11 NS_87 0 3.3605632561168464e-01
GC_11_88 ref NI_11 NS_88 0 -9.7865086101753072e-03
GC_11_89 ref NI_11 NS_89 0 1.2582440328154348e-05
GC_11_90 ref NI_11 NS_90 0 3.0086696997765412e-03
GC_11_91 ref NI_11 NS_91 0 -1.6633273279156358e-01
GC_11_92 ref NI_11 NS_92 0 4.4862647277966745e-02
GC_11_93 ref NI_11 NS_93 0 9.3541769664792912e-02
GC_11_94 ref NI_11 NS_94 0 8.2548891965219126e-02
GC_11_95 ref NI_11 NS_95 0 -3.1854413847127213e-06
GC_11_96 ref NI_11 NS_96 0 -6.7455008061253312e-03
GC_11_97 ref NI_11 NS_97 0 -6.8293667246917308e-02
GC_11_98 ref NI_11 NS_98 0 -6.5779914875039036e-02
GC_11_99 ref NI_11 NS_99 0 3.7261104576012360e-01
GC_11_100 ref NI_11 NS_100 0 -9.0636837894686045e-03
GC_11_101 ref NI_11 NS_101 0 -8.4528440027952987e-05
GC_11_102 ref NI_11 NS_102 0 -1.4750837113673801e-02
GC_11_103 ref NI_11 NS_103 0 -4.0708952893545293e-02
GC_11_104 ref NI_11 NS_104 0 -3.7537811257482546e-02
GC_11_105 ref NI_11 NS_105 0 4.3244339419049371e-01
GC_11_106 ref NI_11 NS_106 0 -4.9092638277882343e-02
GC_11_107 ref NI_11 NS_107 0 -3.1917970752892323e-06
GC_11_108 ref NI_11 NS_108 0 -1.8565100642994742e-02
GC_11_109 ref NI_11 NS_109 0 -1.4868066433380625e-01
GC_11_110 ref NI_11 NS_110 0 2.3065849120075074e-01
GC_11_111 ref NI_11 NS_111 0 4.0139845936642221e-01
GC_11_112 ref NI_11 NS_112 0 -1.1879736571941119e-01
GC_11_113 ref NI_11 NS_113 0 -1.6880740016942036e-05
GC_11_114 ref NI_11 NS_114 0 -1.4900255516061993e-02
GC_11_115 ref NI_11 NS_115 0 1.7351249474474673e-01
GC_11_116 ref NI_11 NS_116 0 -4.1902150668874261e-01
GC_11_117 ref NI_11 NS_117 0 4.7917554316799826e-01
GC_11_118 ref NI_11 NS_118 0 4.1276987626079988e-02
GC_11_119 ref NI_11 NS_119 0 1.3184186244578239e-05
GC_11_120 ref NI_11 NS_120 0 -2.2120378376005993e-02
GC_11_121 ref NI_11 NS_121 0 5.5408713858413061e-02
GC_11_122 ref NI_11 NS_122 0 1.3848565328667013e+00
GC_11_123 ref NI_11 NS_123 0 -3.4058553334180830e-01
GC_11_124 ref NI_11 NS_124 0 -8.4469042282669632e-02
GC_11_125 ref NI_11 NS_125 0 -1.9558587742513390e-04
GC_11_126 ref NI_11 NS_126 0 -1.3988321966393264e-02
GC_11_127 ref NI_11 NS_127 0 -2.4682577450119303e-01
GC_11_128 ref NI_11 NS_128 0 2.9051002603113935e-01
GC_11_129 ref NI_11 NS_129 0 4.9189048037771133e-02
GC_11_130 ref NI_11 NS_130 0 3.2304709808970024e-02
GC_11_131 ref NI_11 NS_131 0 -6.3668029326611145e-07
GC_11_132 ref NI_11 NS_132 0 -5.2501261208781642e-03
GC_11_133 ref NI_11 NS_133 0 -4.2518254710059634e-02
GC_11_134 ref NI_11 NS_134 0 -1.2320155513677972e-01
GC_11_135 ref NI_11 NS_135 0 1.0641883413892450e-01
GC_11_136 ref NI_11 NS_136 0 1.1285636016221315e-01
GC_11_137 ref NI_11 NS_137 0 9.6027565077013489e-06
GC_11_138 ref NI_11 NS_138 0 -3.0758695958663785e-03
GD_11_1 ref NI_11 NA_1 0 2.7063371201476942e-02
GD_11_2 ref NI_11 NA_2 0 3.4354148756994794e-02
GD_11_3 ref NI_11 NA_3 0 1.2255736642646701e-02
GD_11_4 ref NI_11 NA_4 0 4.5441463876781760e-02
GD_11_5 ref NI_11 NA_5 0 3.9582387663658285e-02
GD_11_6 ref NI_11 NA_6 0 3.6995658028465307e-02
GD_11_7 ref NI_11 NA_7 0 4.0707766801397913e-02
GD_11_8 ref NI_11 NA_8 0 -3.2160052728370206e-02
GD_11_9 ref NI_11 NA_9 0 5.0149639000035481e-02
GD_11_10 ref NI_11 NA_10 0 2.2199081607456431e-02
GD_11_11 ref NI_11 NA_11 0 5.6711242379185114e+00
GD_11_12 ref NI_11 NA_12 0 2.0700322287361069e-02
GD_11_13 ref NI_11 NA_13 0 4.4230891141268769e-02
GD_11_14 ref NI_11 NA_14 0 7.2868012736011081e-02
GD_11_15 ref NI_11 NA_15 0 1.2718660792775512e-02
GD_11_16 ref NI_11 NA_16 0 4.3899032410435843e-02
GD_11_17 ref NI_11 NA_17 0 1.2703420676420713e-02
GD_11_18 ref NI_11 NA_18 0 2.5491312482323090e-02
GD_11_19 ref NI_11 NA_19 0 3.7246725788008375e-02
GD_11_20 ref NI_11 NA_20 0 -3.9489990179700507e-03
GD_11_21 ref NI_11 NA_21 0 -3.8976400995197197e-02
GD_11_22 ref NI_11 NA_22 0 4.9676292418278055e-02
GD_11_23 ref NI_11 NA_23 0 2.0556237777363720e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -3.0781322290695856e-01
GC_12_2 ref NI_12 NS_2 0 4.2018354043215833e-01
GC_12_3 ref NI_12 NS_3 0 -7.9427154615393319e-02
GC_12_4 ref NI_12 NS_4 0 3.8849796168909163e-02
GC_12_5 ref NI_12 NS_5 0 2.3072388375170886e-04
GC_12_6 ref NI_12 NS_6 0 8.5373770849702657e-03
GC_12_7 ref NI_12 NS_7 0 3.0114683481360183e-01
GC_12_8 ref NI_12 NS_8 0 3.1338872577606719e-01
GC_12_9 ref NI_12 NS_9 0 -5.0497807750310222e-02
GC_12_10 ref NI_12 NS_10 0 4.2870565511222494e-03
GC_12_11 ref NI_12 NS_11 0 1.5605853991682822e-04
GC_12_12 ref NI_12 NS_12 0 4.7780171908117794e-03
GC_12_13 ref NI_12 NS_13 0 1.4417816930437147e-01
GC_12_14 ref NI_12 NS_14 0 1.8855404567052989e-01
GC_12_15 ref NI_12 NS_15 0 -2.8827246224850445e-02
GC_12_16 ref NI_12 NS_16 0 3.9707521950647244e-02
GC_12_17 ref NI_12 NS_17 0 1.8890392163310407e-04
GC_12_18 ref NI_12 NS_18 0 9.5053623762552698e-03
GC_12_19 ref NI_12 NS_19 0 -2.9497389302899657e-01
GC_12_20 ref NI_12 NS_20 0 1.1770276269038616e-02
GC_12_21 ref NI_12 NS_21 0 -3.1677515027506202e-02
GC_12_22 ref NI_12 NS_22 0 1.0193253916291255e-01
GC_12_23 ref NI_12 NS_23 0 3.0572868876911077e-04
GC_12_24 ref NI_12 NS_24 0 1.7857807069020300e-02
GC_12_25 ref NI_12 NS_25 0 -2.4525996917133980e-01
GC_12_26 ref NI_12 NS_26 0 4.5166534560283893e-03
GC_12_27 ref NI_12 NS_27 0 -6.0121052820383783e-02
GC_12_28 ref NI_12 NS_28 0 1.1416783531000901e-01
GC_12_29 ref NI_12 NS_29 0 3.0296601740205039e-04
GC_12_30 ref NI_12 NS_30 0 1.8413566028969576e-02
GC_12_31 ref NI_12 NS_31 0 -2.2955236658065134e-01
GC_12_32 ref NI_12 NS_32 0 -5.3535109119755677e-03
GC_12_33 ref NI_12 NS_33 0 -5.8344295575146761e-02
GC_12_34 ref NI_12 NS_34 0 1.1694019019173323e-01
GC_12_35 ref NI_12 NS_35 0 3.2099042616528600e-04
GC_12_36 ref NI_12 NS_36 0 1.7704575318128541e-02
GC_12_37 ref NI_12 NS_37 0 -2.8147612810799510e-01
GC_12_38 ref NI_12 NS_38 0 6.2542519143232158e-03
GC_12_39 ref NI_12 NS_39 0 -5.9422016911847685e-03
GC_12_40 ref NI_12 NS_40 0 9.4433616708264861e-02
GC_12_41 ref NI_12 NS_41 0 2.9432413628018706e-04
GC_12_42 ref NI_12 NS_42 0 1.6261201357987653e-02
GC_12_43 ref NI_12 NS_43 0 -1.9010166797349010e-01
GC_12_44 ref NI_12 NS_44 0 8.8504326444243622e-02
GC_12_45 ref NI_12 NS_45 0 1.8978698282454837e-01
GC_12_46 ref NI_12 NS_46 0 8.6118199958409511e-04
GC_12_47 ref NI_12 NS_47 0 4.2124610234400566e-05
GC_12_48 ref NI_12 NS_48 0 2.0124606787445855e-03
GC_12_49 ref NI_12 NS_49 0 -1.1928159122859983e-01
GC_12_50 ref NI_12 NS_50 0 2.1343867192022328e-01
GC_12_51 ref NI_12 NS_51 0 4.3457777992555202e-01
GC_12_52 ref NI_12 NS_52 0 -1.5547314878150451e-01
GC_12_53 ref NI_12 NS_53 0 -4.0769561200017015e-05
GC_12_54 ref NI_12 NS_54 0 -2.9235324264700068e-03
GC_12_55 ref NI_12 NS_55 0 -6.4555627236164648e-01
GC_12_56 ref NI_12 NS_56 0 -1.5575200286402655e-01
GC_12_57 ref NI_12 NS_57 0 1.0552790102133052e+00
GC_12_58 ref NI_12 NS_58 0 -2.9070105946022762e-01
GC_12_59 ref NI_12 NS_59 0 -1.8614058881173641e-04
GC_12_60 ref NI_12 NS_60 0 -2.0733444385068342e-02
GC_12_61 ref NI_12 NS_61 0 -8.6170549911390976e-02
GC_12_62 ref NI_12 NS_62 0 -8.9206775889315998e-03
GC_12_63 ref NI_12 NS_63 0 1.6921114278392946e-01
GC_12_64 ref NI_12 NS_64 0 3.9994454254203685e-02
GC_12_65 ref NI_12 NS_65 0 2.0218048196422166e-05
GC_12_66 ref NI_12 NS_66 0 2.2386647206133239e-05
GC_12_67 ref NI_12 NS_67 0 2.5085883078688411e+00
GC_12_68 ref NI_12 NS_68 0 -5.4839510454079239e+00
GC_12_69 ref NI_12 NS_69 0 -1.3394641256070052e+00
GC_12_70 ref NI_12 NS_70 0 -2.8986001735374134e-01
GC_12_71 ref NI_12 NS_71 0 -8.0753501227169957e-04
GC_12_72 ref NI_12 NS_72 0 -3.1836800775878603e-02
GC_12_73 ref NI_12 NS_73 0 3.3332608257415970e-02
GC_12_74 ref NI_12 NS_74 0 5.3262505130843707e-01
GC_12_75 ref NI_12 NS_75 0 2.6907186682313711e-01
GC_12_76 ref NI_12 NS_76 0 -1.5875767853606890e-01
GC_12_77 ref NI_12 NS_77 0 -7.1450139596133605e-05
GC_12_78 ref NI_12 NS_78 0 -9.2977973539772520e-03
GC_12_79 ref NI_12 NS_79 0 -2.9011142306508503e-01
GC_12_80 ref NI_12 NS_80 0 7.7955975472379216e-02
GC_12_81 ref NI_12 NS_81 0 -5.6942566349412999e-02
GC_12_82 ref NI_12 NS_82 0 1.2298756726415644e-01
GC_12_83 ref NI_12 NS_83 0 6.2614875280669850e-05
GC_12_84 ref NI_12 NS_84 0 8.1646771780892156e-03
GC_12_85 ref NI_12 NS_85 0 -3.1287259094088776e-01
GC_12_86 ref NI_12 NS_86 0 1.5908930398291170e+00
GC_12_87 ref NI_12 NS_87 0 8.6258419938934090e-03
GC_12_88 ref NI_12 NS_88 0 -3.3921729011756591e-01
GC_12_89 ref NI_12 NS_89 0 -1.9174552212534863e-04
GC_12_90 ref NI_12 NS_90 0 -6.6069858098780840e-03
GC_12_91 ref NI_12 NS_91 0 7.5413326293690297e-02
GC_12_92 ref NI_12 NS_92 0 -4.7364735265221453e-01
GC_12_93 ref NI_12 NS_93 0 8.0360862693503099e-01
GC_12_94 ref NI_12 NS_94 0 -1.1880865629781863e-01
GC_12_95 ref NI_12 NS_95 0 -1.0999638081137702e-04
GC_12_96 ref NI_12 NS_96 0 -1.6823453968085444e-02
GC_12_97 ref NI_12 NS_97 0 2.8740354785253615e-02
GC_12_98 ref NI_12 NS_98 0 -1.8680853032297529e-01
GC_12_99 ref NI_12 NS_99 0 3.3794781375814591e-02
GC_12_100 ref NI_12 NS_100 0 1.6792118908166051e-01
GC_12_101 ref NI_12 NS_101 0 -4.6963524744996354e-05
GC_12_102 ref NI_12 NS_102 0 -3.6772876665645076e-03
GC_12_103 ref NI_12 NS_103 0 -3.9754448710364382e-01
GC_12_104 ref NI_12 NS_104 0 3.0763929147292729e-01
GC_12_105 ref NI_12 NS_105 0 -4.1762205029737348e-01
GC_12_106 ref NI_12 NS_106 0 2.4056945060495086e-01
GC_12_107 ref NI_12 NS_107 0 -3.0979422538864957e-05
GC_12_108 ref NI_12 NS_108 0 1.1446249514190295e-02
GC_12_109 ref NI_12 NS_109 0 -3.2713942723469730e-01
GC_12_110 ref NI_12 NS_110 0 1.9662071751724461e-01
GC_12_111 ref NI_12 NS_111 0 -2.8120576517372697e-01
GC_12_112 ref NI_12 NS_112 0 2.0108306189481293e-01
GC_12_113 ref NI_12 NS_113 0 7.1022763771422312e-06
GC_12_114 ref NI_12 NS_114 0 1.0456261497651199e-02
GC_12_115 ref NI_12 NS_115 0 -4.5033374434756596e-01
GC_12_116 ref NI_12 NS_116 0 3.8818602346641878e-01
GC_12_117 ref NI_12 NS_117 0 -5.1260468592123076e-01
GC_12_118 ref NI_12 NS_118 0 2.6944864504845184e-01
GC_12_119 ref NI_12 NS_119 0 -4.5882045325308020e-05
GC_12_120 ref NI_12 NS_120 0 1.1465817068495091e-02
GC_12_121 ref NI_12 NS_121 0 -2.1591121195195410e-02
GC_12_122 ref NI_12 NS_122 0 -1.1267388192194726e-01
GC_12_123 ref NI_12 NS_123 0 6.2094077659450901e-02
GC_12_124 ref NI_12 NS_124 0 1.2912581261512521e-01
GC_12_125 ref NI_12 NS_125 0 -4.4872642675572855e-05
GC_12_126 ref NI_12 NS_126 0 -1.6815635879451937e-03
GC_12_127 ref NI_12 NS_127 0 1.8759919780049264e-01
GC_12_128 ref NI_12 NS_128 0 -1.4215501013076334e-01
GC_12_129 ref NI_12 NS_129 0 6.1886683547861332e-01
GC_12_130 ref NI_12 NS_130 0 -1.2647315965528549e-01
GC_12_131 ref NI_12 NS_131 0 -1.4093748961945939e-04
GC_12_132 ref NI_12 NS_132 0 -1.6386217916317600e-02
GC_12_133 ref NI_12 NS_133 0 1.1466713225419913e+00
GC_12_134 ref NI_12 NS_134 0 2.2227798363128364e+00
GC_12_135 ref NI_12 NS_135 0 -7.2237341389953724e-01
GC_12_136 ref NI_12 NS_136 0 -2.0076191462313839e-01
GC_12_137 ref NI_12 NS_137 0 -1.8836735961021191e-04
GC_12_138 ref NI_12 NS_138 0 -2.6854830614488283e-02
GD_12_1 ref NI_12 NA_1 0 1.8826814727583698e-03
GD_12_2 ref NI_12 NA_2 0 1.8758992449274193e-02
GD_12_3 ref NI_12 NA_3 0 2.4105130401248659e-04
GD_12_4 ref NI_12 NA_4 0 5.6432015358776393e-02
GD_12_5 ref NI_12 NA_5 0 5.0853376241704426e-02
GD_12_6 ref NI_12 NA_6 0 4.8545086274332551e-02
GD_12_7 ref NI_12 NA_7 0 5.0095360429540894e-02
GD_12_8 ref NI_12 NA_8 0 3.0806308514322714e-02
GD_12_9 ref NI_12 NA_9 0 6.8053496614447952e-03
GD_12_10 ref NI_12 NA_10 0 8.4413754915578385e-02
GD_12_11 ref NI_12 NA_11 0 2.0700322287361069e-02
GD_12_12 ref NI_12 NA_12 0 5.7030545356496614e+00
GD_12_13 ref NI_12 NA_13 0 -2.0155605090326469e-02
GD_12_14 ref NI_12 NA_14 0 5.4868903484503510e-02
GD_12_15 ref NI_12 NA_15 0 3.4462798114729097e-02
GD_12_16 ref NI_12 NA_16 0 1.7444726931764686e-03
GD_12_17 ref NI_12 NA_17 0 1.4862629704763652e-02
GD_12_18 ref NI_12 NA_18 0 7.6069632221203082e-02
GD_12_19 ref NI_12 NA_19 0 6.4412958406274201e-02
GD_12_20 ref NI_12 NA_20 0 8.3489305577234441e-02
GD_12_21 ref NI_12 NA_21 0 1.7240089275051565e-02
GD_12_22 ref NI_12 NA_22 0 -3.3157804271551829e-02
GD_12_23 ref NI_12 NA_23 0 -1.4086133989071442e-01
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -3.8702097558609788e-01
GC_13_2 ref NI_13 NS_2 0 4.9546184474753896e-01
GC_13_3 ref NI_13 NS_3 0 -7.4925020060312680e-02
GC_13_4 ref NI_13 NS_4 0 2.2538054364362223e-02
GC_13_5 ref NI_13 NS_5 0 1.9397277757268765e-04
GC_13_6 ref NI_13 NS_6 0 7.1802317747655959e-03
GC_13_7 ref NI_13 NS_7 0 2.9458397142923570e-01
GC_13_8 ref NI_13 NS_8 0 4.1236438694447008e-01
GC_13_9 ref NI_13 NS_9 0 -7.7329774100819260e-02
GC_13_10 ref NI_13 NS_10 0 -1.2067559817462731e-02
GC_13_11 ref NI_13 NS_11 0 1.1775929099474938e-04
GC_13_12 ref NI_13 NS_12 0 3.9611596252883104e-03
GC_13_13 ref NI_13 NS_13 0 1.2630963384612653e-01
GC_13_14 ref NI_13 NS_14 0 2.2273567479798906e-01
GC_13_15 ref NI_13 NS_15 0 -1.3748593273190373e-02
GC_13_16 ref NI_13 NS_16 0 2.6020492774444001e-02
GC_13_17 ref NI_13 NS_17 0 1.5307730587713861e-04
GC_13_18 ref NI_13 NS_18 0 8.0045118432013757e-03
GC_13_19 ref NI_13 NS_19 0 -2.6326319896885941e-01
GC_13_20 ref NI_13 NS_20 0 -6.0974196848952965e-02
GC_13_21 ref NI_13 NS_21 0 4.0622258130187001e-02
GC_13_22 ref NI_13 NS_22 0 9.1280848117977459e-02
GC_13_23 ref NI_13 NS_23 0 2.7954910593869746e-04
GC_13_24 ref NI_13 NS_24 0 1.4899682911590505e-02
GC_13_25 ref NI_13 NS_25 0 -1.9766999961927509e-01
GC_13_26 ref NI_13 NS_26 0 -7.5434922244809591e-02
GC_13_27 ref NI_13 NS_27 0 1.1536587897113161e-02
GC_13_28 ref NI_13 NS_28 0 1.0566519796646200e-01
GC_13_29 ref NI_13 NS_29 0 2.7997308611390272e-04
GC_13_30 ref NI_13 NS_30 0 1.5209383326348393e-02
GC_13_31 ref NI_13 NS_31 0 -1.7725513284958730e-01
GC_13_32 ref NI_13 NS_32 0 -8.8615623870842444e-02
GC_13_33 ref NI_13 NS_33 0 1.5474520771874899e-02
GC_13_34 ref NI_13 NS_34 0 1.0778055422778751e-01
GC_13_35 ref NI_13 NS_35 0 3.0627598007771625e-04
GC_13_36 ref NI_13 NS_36 0 1.4528938981821893e-02
GC_13_37 ref NI_13 NS_37 0 -2.5766120849426588e-01
GC_13_38 ref NI_13 NS_38 0 -6.1524891313336057e-02
GC_13_39 ref NI_13 NS_39 0 6.7121888026959065e-02
GC_13_40 ref NI_13 NS_40 0 8.1683888831593832e-02
GC_13_41 ref NI_13 NS_41 0 2.7913784444915182e-04
GC_13_42 ref NI_13 NS_42 0 1.3481079682959220e-02
GC_13_43 ref NI_13 NS_43 0 -3.8204756226733261e-01
GC_13_44 ref NI_13 NS_44 0 6.3613400046341562e-01
GC_13_45 ref NI_13 NS_45 0 5.0706399140368320e-02
GC_13_46 ref NI_13 NS_46 0 -8.2573554881967104e-02
GC_13_47 ref NI_13 NS_47 0 -1.7485392188126995e-05
GC_13_48 ref NI_13 NS_48 0 1.5493639460441790e-03
GC_13_49 ref NI_13 NS_49 0 -4.4359594892251258e-01
GC_13_50 ref NI_13 NS_50 0 1.5122078285890681e+00
GC_13_51 ref NI_13 NS_51 0 -2.0315523846917133e-01
GC_13_52 ref NI_13 NS_52 0 -2.0553118583614075e-01
GC_13_53 ref NI_13 NS_53 0 -1.2634421571012136e-04
GC_13_54 ref NI_13 NS_54 0 -9.8744104074235299e-04
GC_13_55 ref NI_13 NS_55 0 1.9656883591621910e-01
GC_13_56 ref NI_13 NS_56 0 -5.1523001652547529e-01
GC_13_57 ref NI_13 NS_57 0 6.8165043561995531e-01
GC_13_58 ref NI_13 NS_58 0 -5.2881797301400114e-02
GC_13_59 ref NI_13 NS_59 0 -7.0036967066950030e-05
GC_13_60 ref NI_13 NS_60 0 -1.4704201806064026e-02
GC_13_61 ref NI_13 NS_61 0 -2.9550703970152520e-01
GC_13_62 ref NI_13 NS_62 0 6.3373369798755264e-01
GC_13_63 ref NI_13 NS_63 0 6.9539637427193284e-03
GC_13_64 ref NI_13 NS_64 0 -5.9137636112213933e-02
GC_13_65 ref NI_13 NS_65 0 -6.0379920134878873e-05
GC_13_66 ref NI_13 NS_66 0 -2.5650214993897110e-04
GC_13_67 ref NI_13 NS_67 0 3.3332608257415852e-02
GC_13_68 ref NI_13 NS_68 0 5.3262505130843751e-01
GC_13_69 ref NI_13 NS_69 0 2.6907186682313655e-01
GC_13_70 ref NI_13 NS_70 0 -1.5875767853606851e-01
GC_13_71 ref NI_13 NS_71 0 -7.1450139596112165e-05
GC_13_72 ref NI_13 NS_72 0 -9.2977973539773474e-03
GC_13_73 ref NI_13 NS_73 0 2.9947868856847637e+00
GC_13_74 ref NI_13 NS_74 0 -4.7238114954560997e+00
GC_13_75 ref NI_13 NS_75 0 -2.2729585913272699e+00
GC_13_76 ref NI_13 NS_76 0 -8.3932269498747020e-02
GC_13_77 ref NI_13 NS_77 0 -6.4391007227245216e-04
GC_13_78 ref NI_13 NS_78 0 -2.7687236733985422e-02
GC_13_79 ref NI_13 NS_79 0 -2.7002796368886772e-01
GC_13_80 ref NI_13 NS_80 0 -5.7800168449222041e-02
GC_13_81 ref NI_13 NS_81 0 2.1327735976609191e-01
GC_13_82 ref NI_13 NS_82 0 3.0025650634850375e-02
GC_13_83 ref NI_13 NS_83 0 3.8299321313008258e-05
GC_13_84 ref NI_13 NS_84 0 4.1170057372297798e-03
GC_13_85 ref NI_13 NS_85 0 -1.0370970235345989e-01
GC_13_86 ref NI_13 NS_86 0 6.2118278232870479e-02
GC_13_87 ref NI_13 NS_87 0 6.2472886276674988e-01
GC_13_88 ref NI_13 NS_88 0 -2.0813003072963060e-01
GC_13_89 ref NI_13 NS_89 0 -6.8315921283257120e-05
GC_13_90 ref NI_13 NS_90 0 -3.8805299211396530e-03
GC_13_91 ref NI_13 NS_91 0 9.4212525639649526e-03
GC_13_92 ref NI_13 NS_92 0 -7.5865974451797311e-02
GC_13_93 ref NI_13 NS_93 0 3.7686187683821809e-01
GC_13_94 ref NI_13 NS_94 0 -2.9546272874614692e-02
GC_13_95 ref NI_13 NS_95 0 -8.9733817973145289e-05
GC_13_96 ref NI_13 NS_96 0 -9.5652474782727086e-03
GC_13_97 ref NI_13 NS_97 0 -9.7836420831738505e-02
GC_13_98 ref NI_13 NS_98 0 -8.0020918112350070e-02
GC_13_99 ref NI_13 NS_99 0 1.1425920408448893e-01
GC_13_100 ref NI_13 NS_100 0 9.8604150007079436e-02
GC_13_101 ref NI_13 NS_101 0 -6.4890498093853174e-05
GC_13_102 ref NI_13 NS_102 0 -2.8803064258666063e-03
GC_13_103 ref NI_13 NS_103 0 -2.0583701390309866e-01
GC_13_104 ref NI_13 NS_104 0 3.1752081211931855e-02
GC_13_105 ref NI_13 NS_105 0 -1.0445222756793128e-01
GC_13_106 ref NI_13 NS_106 0 1.6518707049543704e-01
GC_13_107 ref NI_13 NS_107 0 -1.9558096770986750e-05
GC_13_108 ref NI_13 NS_108 0 4.3147056744636016e-03
GC_13_109 ref NI_13 NS_109 0 -1.7585189466765272e-01
GC_13_110 ref NI_13 NS_110 0 -6.0203569948158266e-02
GC_13_111 ref NI_13 NS_111 0 4.6516927733970113e-02
GC_13_112 ref NI_13 NS_112 0 1.1272490167447534e-01
GC_13_113 ref NI_13 NS_113 0 8.9243381793139603e-06
GC_13_114 ref NI_13 NS_114 0 4.0161149340071063e-03
GC_13_115 ref NI_13 NS_115 0 -2.2956886750385189e-01
GC_13_116 ref NI_13 NS_116 0 1.0757495465306589e-01
GC_13_117 ref NI_13 NS_117 0 -2.2945523064168064e-01
GC_13_118 ref NI_13 NS_118 0 2.1057213825159132e-01
GC_13_119 ref NI_13 NS_119 0 -2.9813058418109838e-05
GC_13_120 ref NI_13 NS_120 0 4.0853041026290325e-03
GC_13_121 ref NI_13 NS_121 0 -1.9966053204539580e-01
GC_13_122 ref NI_13 NS_122 0 2.2517102077448234e-01
GC_13_123 ref NI_13 NS_123 0 6.5630930559689604e-02
GC_13_124 ref NI_13 NS_124 0 3.4157338161594518e-02
GC_13_125 ref NI_13 NS_125 0 -7.6317247199760249e-05
GC_13_126 ref NI_13 NS_126 0 -1.6779492146914651e-03
GC_13_127 ref NI_13 NS_127 0 1.1607736814714727e-01
GC_13_128 ref NI_13 NS_128 0 9.1605292433374919e-01
GC_13_129 ref NI_13 NS_129 0 -8.5331747255300447e-02
GC_13_130 ref NI_13 NS_130 0 -8.7974548501346020e-02
GC_13_131 ref NI_13 NS_131 0 -2.0321394521946508e-04
GC_13_132 ref NI_13 NS_132 0 -1.0951480015696553e-02
GC_13_133 ref NI_13 NS_133 0 1.5468134746198173e-01
GC_13_134 ref NI_13 NS_134 0 5.9229201123953646e-03
GC_13_135 ref NI_13 NS_135 0 4.7844520054899786e-01
GC_13_136 ref NI_13 NS_136 0 -1.0411219128577204e-01
GC_13_137 ref NI_13 NS_137 0 -9.1116685561720606e-05
GC_13_138 ref NI_13 NS_138 0 -1.3636202547221457e-02
GD_13_1 ref NI_13 NA_1 0 7.1498621951984215e-03
GD_13_2 ref NI_13 NA_2 0 2.7884558551177208e-02
GD_13_3 ref NI_13 NA_3 0 1.3423859551646080e-03
GD_13_4 ref NI_13 NA_4 0 5.3052040549810428e-02
GD_13_5 ref NI_13 NA_5 0 4.5279125357003208e-02
GD_13_6 ref NI_13 NA_6 0 4.2309896929411936e-02
GD_13_7 ref NI_13 NA_7 0 4.7595286356873066e-02
GD_13_8 ref NI_13 NA_8 0 5.5266326634729357e-02
GD_13_9 ref NI_13 NA_9 0 4.4381355263388704e-02
GD_13_10 ref NI_13 NA_10 0 -1.8036076952194301e-02
GD_13_11 ref NI_13 NA_11 0 4.4230891141268769e-02
GD_13_12 ref NI_13 NA_12 0 -2.0155605090326469e-02
GD_13_13 ref NI_13 NA_13 0 5.6689160947606254e+00
GD_13_14 ref NI_13 NA_14 0 5.4304046620955934e-02
GD_13_15 ref NI_13 NA_15 0 7.3470536901097108e-03
GD_13_16 ref NI_13 NA_16 0 7.8611891108479222e-03
GD_13_17 ref NI_13 NA_17 0 2.9671840935450958e-02
GD_13_18 ref NI_13 NA_18 0 5.1626297715263308e-02
GD_13_19 ref NI_13 NA_19 0 4.5934473380228567e-02
GD_13_20 ref NI_13 NA_20 0 5.4091130572615477e-02
GD_13_21 ref NI_13 NA_21 0 3.6131627444514862e-02
GD_13_22 ref NI_13 NA_22 0 -4.0558584220516600e-02
GD_13_23 ref NI_13 NA_23 0 -2.7335479040232667e-02
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 -4.0432832632723947e-01
GC_14_2 ref NI_14 NS_2 0 6.2945472176712880e-01
GC_14_3 ref NI_14 NS_3 0 -1.5009394070302057e-01
GC_14_4 ref NI_14 NS_4 0 1.7676513504457141e-02
GC_14_5 ref NI_14 NS_5 0 1.4739524728234492e-04
GC_14_6 ref NI_14 NS_6 0 9.6532236922230886e-03
GC_14_7 ref NI_14 NS_7 0 8.8577780951543594e-01
GC_14_8 ref NI_14 NS_8 0 4.2079382628863998e-01
GC_14_9 ref NI_14 NS_9 0 -1.5648784849359121e-01
GC_14_10 ref NI_14 NS_10 0 -2.6339969253522083e-02
GC_14_11 ref NI_14 NS_11 0 3.7483704943346413e-05
GC_14_12 ref NI_14 NS_12 0 5.1430015188595789e-03
GC_14_13 ref NI_14 NS_13 0 -9.5385706714877380e-02
GC_14_14 ref NI_14 NS_14 0 3.3422527635407917e-01
GC_14_15 ref NI_14 NS_15 0 -4.8004688223017067e-02
GC_14_16 ref NI_14 NS_16 0 2.6363492590246319e-02
GC_14_17 ref NI_14 NS_17 0 1.2797494030626088e-04
GC_14_18 ref NI_14 NS_18 0 1.1011087649907551e-02
GC_14_19 ref NI_14 NS_19 0 -2.6455386298652472e-01
GC_14_20 ref NI_14 NS_20 0 -1.0850935916006063e-01
GC_14_21 ref NI_14 NS_21 0 8.2230608269369246e-02
GC_14_22 ref NI_14 NS_22 0 7.2280062894554326e-02
GC_14_23 ref NI_14 NS_23 0 2.3421072967244567e-04
GC_14_24 ref NI_14 NS_24 0 1.9236826003264491e-02
GC_14_25 ref NI_14 NS_25 0 -1.7846707658956715e-01
GC_14_26 ref NI_14 NS_26 0 -1.2873130002843150e-01
GC_14_27 ref NI_14 NS_27 0 5.3990469547836067e-02
GC_14_28 ref NI_14 NS_28 0 8.6592732565934472e-02
GC_14_29 ref NI_14 NS_29 0 2.3313950918001263e-04
GC_14_30 ref NI_14 NS_30 0 1.9615466843238220e-02
GC_14_31 ref NI_14 NS_31 0 -1.5133877372092222e-01
GC_14_32 ref NI_14 NS_32 0 -1.4453807766435525e-01
GC_14_33 ref NI_14 NS_33 0 5.8952571478020362e-02
GC_14_34 ref NI_14 NS_34 0 8.8502880760858688e-02
GC_14_35 ref NI_14 NS_35 0 2.3570091981311910e-04
GC_14_36 ref NI_14 NS_36 0 1.9140525500731646e-02
GC_14_37 ref NI_14 NS_37 0 -2.6369435673121205e-01
GC_14_38 ref NI_14 NS_38 0 -1.1558514210351660e-01
GC_14_39 ref NI_14 NS_39 0 1.1167050416819942e-01
GC_14_40 ref NI_14 NS_40 0 6.3158983621599829e-02
GC_14_41 ref NI_14 NS_41 0 2.0414318056341220e-04
GC_14_42 ref NI_14 NS_42 0 1.8154706670957897e-02
GC_14_43 ref NI_14 NS_43 0 -4.7923381191307418e-01
GC_14_44 ref NI_14 NS_44 0 1.2939762227250486e+00
GC_14_45 ref NI_14 NS_45 0 -7.4229036569052345e-02
GC_14_46 ref NI_14 NS_46 0 -2.0420404510882448e-01
GC_14_47 ref NI_14 NS_47 0 -2.6136477938995253e-05
GC_14_48 ref NI_14 NS_48 0 -4.1501193912463893e-03
GC_14_49 ref NI_14 NS_49 0 -3.0366721929492863e-01
GC_14_50 ref NI_14 NS_50 0 -1.3590364643880635e-02
GC_14_51 ref NI_14 NS_51 0 3.5191420064768858e-01
GC_14_52 ref NI_14 NS_52 0 -5.4248022463293404e-02
GC_14_53 ref NI_14 NS_53 0 2.5846170874409761e-05
GC_14_54 ref NI_14 NS_54 0 4.6242808339523088e-03
GC_14_55 ref NI_14 NS_55 0 -4.2081634613980023e-01
GC_14_56 ref NI_14 NS_56 0 3.6443750196671482e-01
GC_14_57 ref NI_14 NS_57 0 -5.0956266283538398e-01
GC_14_58 ref NI_14 NS_58 0 2.7698507772042258e-01
GC_14_59 ref NI_14 NS_59 0 -8.4779344718719010e-06
GC_14_60 ref NI_14 NS_60 0 9.8713140175069273e-03
GC_14_61 ref NI_14 NS_61 0 -4.2587974654348032e-01
GC_14_62 ref NI_14 NS_62 0 3.2043398448809823e-01
GC_14_63 ref NI_14 NS_63 0 4.2700025488645288e-01
GC_14_64 ref NI_14 NS_64 0 -1.6271629987655017e-01
GC_14_65 ref NI_14 NS_65 0 -4.7574579393477222e-05
GC_14_66 ref NI_14 NS_66 0 -6.7293017914351414e-03
GC_14_67 ref NI_14 NS_67 0 -2.9011142306508536e-01
GC_14_68 ref NI_14 NS_68 0 7.7955975472380243e-02
GC_14_69 ref NI_14 NS_69 0 -5.6942566349414386e-02
GC_14_70 ref NI_14 NS_70 0 1.2298756726415720e-01
GC_14_71 ref NI_14 NS_71 0 6.2614875280718544e-05
GC_14_72 ref NI_14 NS_72 0 8.1646771780890075e-03
GC_14_73 ref NI_14 NS_73 0 -2.7002796368886800e-01
GC_14_74 ref NI_14 NS_74 0 -5.7800168449220868e-02
GC_14_75 ref NI_14 NS_75 0 2.1327735976609033e-01
GC_14_76 ref NI_14 NS_76 0 3.0025650634851252e-02
GC_14_77 ref NI_14 NS_77 0 3.8299321313064074e-05
GC_14_78 ref NI_14 NS_78 0 4.1170057372295378e-03
GC_14_79 ref NI_14 NS_79 0 3.0016843733282048e+00
GC_14_80 ref NI_14 NS_80 0 -3.3308291349894152e+00
GC_14_81 ref NI_14 NS_81 0 -2.3569428759545494e+00
GC_14_82 ref NI_14 NS_82 0 -4.3119227880111399e-01
GC_14_83 ref NI_14 NS_83 0 -8.4081159292423034e-04
GC_14_84 ref NI_14 NS_84 0 -3.6056333822944882e-02
GC_14_85 ref NI_14 NS_85 0 -1.5678656293044033e-01
GC_14_86 ref NI_14 NS_86 0 -1.1184249066849292e-01
GC_14_87 ref NI_14 NS_87 0 1.8914817772292367e-01
GC_14_88 ref NI_14 NS_88 0 4.7556873678274228e-02
GC_14_89 ref NI_14 NS_89 0 7.5930263317845514e-05
GC_14_90 ref NI_14 NS_90 0 6.7377883331066601e-03
GC_14_91 ref NI_14 NS_91 0 -2.6398684598329375e-01
GC_14_92 ref NI_14 NS_92 0 1.3473205082619205e-01
GC_14_93 ref NI_14 NS_93 0 -2.5916299881369365e-01
GC_14_94 ref NI_14 NS_94 0 2.2133762416471064e-01
GC_14_95 ref NI_14 NS_95 0 -1.2069211188561653e-07
GC_14_96 ref NI_14 NS_96 0 3.0922539733354336e-03
GC_14_97 ref NI_14 NS_97 0 2.2289869442593599e-01
GC_14_98 ref NI_14 NS_98 0 -3.8215485834197482e-01
GC_14_99 ref NI_14 NS_99 0 2.2547610022166253e-01
GC_14_100 ref NI_14 NS_100 0 1.4662201186821991e-01
GC_14_101 ref NI_14 NS_101 0 -1.8985020285505429e-06
GC_14_102 ref NI_14 NS_102 0 -1.5912629090068416e-02
GC_14_103 ref NI_14 NS_103 0 6.9315437550123947e-03
GC_14_104 ref NI_14 NS_104 0 -1.6037617043667624e-01
GC_14_105 ref NI_14 NS_105 0 9.3805970481767331e-01
GC_14_106 ref NI_14 NS_106 0 -2.5800531884328731e-01
GC_14_107 ref NI_14 NS_107 0 -1.2252654351971394e-04
GC_14_108 ref NI_14 NS_108 0 -2.4441923431187642e-02
GC_14_109 ref NI_14 NS_109 0 -5.1499739631186682e-02
GC_14_110 ref NI_14 NS_110 0 1.8395120586279461e+00
GC_14_111 ref NI_14 NS_111 0 1.7414886746290545e-01
GC_14_112 ref NI_14 NS_112 0 -4.6515034099607350e-01
GC_14_113 ref NI_14 NS_113 0 -3.4633736643839569e-04
GC_14_114 ref NI_14 NS_114 0 -2.1533763637686901e-02
GC_14_115 ref NI_14 NS_115 0 6.1335247867497256e-01
GC_14_116 ref NI_14 NS_116 0 -8.3661513781961694e-01
GC_14_117 ref NI_14 NS_117 0 8.0154371516575174e-01
GC_14_118 ref NI_14 NS_118 0 5.1451827550185868e-04
GC_14_119 ref NI_14 NS_119 0 -4.9407776649127012e-05
GC_14_120 ref NI_14 NS_120 0 -3.0494437857094662e-02
GC_14_121 ref NI_14 NS_121 0 3.1743172961963960e-02
GC_14_122 ref NI_14 NS_122 0 -3.0673855922958748e-01
GC_14_123 ref NI_14 NS_123 0 4.5628665432185178e-01
GC_14_124 ref NI_14 NS_124 0 2.0810804296755286e-03
GC_14_125 ref NI_14 NS_125 0 1.6244890328114865e-05
GC_14_126 ref NI_14 NS_126 0 -1.2542043801456400e-02
GC_14_127 ref NI_14 NS_127 0 -2.3078906723142972e-01
GC_14_128 ref NI_14 NS_128 0 5.1368120843711763e-02
GC_14_129 ref NI_14 NS_129 0 -1.3054331503415093e-01
GC_14_130 ref NI_14 NS_130 0 1.7673516802606662e-01
GC_14_131 ref NI_14 NS_131 0 3.1157913970891252e-05
GC_14_132 ref NI_14 NS_132 0 3.3400651524718439e-03
GC_14_133 ref NI_14 NS_133 0 -3.6217303612367707e-01
GC_14_134 ref NI_14 NS_134 0 2.4655809935853717e-01
GC_14_135 ref NI_14 NS_135 0 -3.4836915632821575e-01
GC_14_136 ref NI_14 NS_136 0 2.2523981113495564e-01
GC_14_137 ref NI_14 NS_137 0 -8.1673339756675967e-07
GC_14_138 ref NI_14 NS_138 0 9.7282625989888530e-03
GD_14_1 ref NI_14 NA_1 0 -2.6905444672572099e-03
GD_14_2 ref NI_14 NA_2 0 -1.5902630717779160e-03
GD_14_3 ref NI_14 NA_3 0 -1.5247028604070966e-02
GD_14_4 ref NI_14 NA_4 0 5.5363975522177727e-02
GD_14_5 ref NI_14 NA_5 0 4.4422133307015263e-02
GD_14_6 ref NI_14 NA_6 0 4.0312410242453321e-02
GD_14_7 ref NI_14 NA_7 0 5.0700720270001748e-02
GD_14_8 ref NI_14 NA_8 0 7.2948042108773883e-02
GD_14_9 ref NI_14 NA_9 0 4.8381997146387086e-02
GD_14_10 ref NI_14 NA_10 0 7.9803717809243446e-02
GD_14_11 ref NI_14 NA_11 0 7.2868012736011081e-02
GD_14_12 ref NI_14 NA_12 0 5.4868903484503510e-02
GD_14_13 ref NI_14 NA_13 0 5.4304046620955934e-02
GD_14_14 ref NI_14 NA_14 0 5.5943573855900937e+00
GD_14_15 ref NI_14 NA_15 0 3.0787842951940772e-02
GD_14_16 ref NI_14 NA_16 0 6.1205139157186207e-02
GD_14_17 ref NI_14 NA_17 0 -1.2645273890134956e-02
GD_14_18 ref NI_14 NA_18 0 -2.4137528559685549e-04
GD_14_19 ref NI_14 NA_19 0 -5.0742007440451313e-02
GD_14_20 ref NI_14 NA_20 0 -7.6936428961764419e-02
GD_14_21 ref NI_14 NA_21 0 1.6379199240679015e-02
GD_14_22 ref NI_14 NA_22 0 5.4831851895684180e-02
GD_14_23 ref NI_14 NA_23 0 6.9699106985483372e-02
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -3.8479582149003499e-01
GC_15_2 ref NI_15 NS_2 0 5.9418583007210368e-01
GC_15_3 ref NI_15 NS_3 0 -3.8230752932825636e-02
GC_15_4 ref NI_15 NS_4 0 7.5423262341927201e-03
GC_15_5 ref NI_15 NS_5 0 1.9011592827666268e-04
GC_15_6 ref NI_15 NS_6 0 -3.8472481034819363e-03
GC_15_7 ref NI_15 NS_7 0 6.8888637831491906e-01
GC_15_8 ref NI_15 NS_8 0 4.4481844870665227e-01
GC_15_9 ref NI_15 NS_9 0 -4.3808815810287977e-02
GC_15_10 ref NI_15 NS_10 0 -5.1923759474371466e-02
GC_15_11 ref NI_15 NS_11 0 9.2249614641358443e-05
GC_15_12 ref NI_15 NS_12 0 -3.4626224335738854e-03
GC_15_13 ref NI_15 NS_13 0 2.0317975878924155e-01
GC_15_14 ref NI_15 NS_14 0 2.4934436156093487e-01
GC_15_15 ref NI_15 NS_15 0 4.6591683306146749e-02
GC_15_16 ref NI_15 NS_16 0 1.6469463068910426e-02
GC_15_17 ref NI_15 NS_17 0 1.4952681502569014e-04
GC_15_18 ref NI_15 NS_18 0 -3.7734503266905672e-03
GC_15_19 ref NI_15 NS_19 0 -2.2476575823454298e-01
GC_15_20 ref NI_15 NS_20 0 -1.7059014182641644e-01
GC_15_21 ref NI_15 NS_21 0 1.1152138453239632e-01
GC_15_22 ref NI_15 NS_22 0 1.3101412700059761e-01
GC_15_23 ref NI_15 NS_23 0 2.8450467199503474e-04
GC_15_24 ref NI_15 NS_24 0 -1.8283506628161735e-03
GC_15_25 ref NI_15 NS_25 0 -1.3463575389011084e-01
GC_15_26 ref NI_15 NS_26 0 -1.8799968050965229e-01
GC_15_27 ref NI_15 NS_27 0 6.7651028549355952e-02
GC_15_28 ref NI_15 NS_28 0 1.5426093700932059e-01
GC_15_29 ref NI_15 NS_29 0 2.8602880412107986e-04
GC_15_30 ref NI_15 NS_30 0 -2.1803204162063505e-03
GC_15_31 ref NI_15 NS_31 0 -1.0319524727855578e-01
GC_15_32 ref NI_15 NS_32 0 -2.0935152863626405e-01
GC_15_33 ref NI_15 NS_33 0 7.6206155842735546e-02
GC_15_34 ref NI_15 NS_34 0 1.5618314633218394e-01
GC_15_35 ref NI_15 NS_35 0 3.0636035791826923e-04
GC_15_36 ref NI_15 NS_36 0 -2.9764388751478150e-03
GC_15_37 ref NI_15 NS_37 0 -2.1393146418643980e-01
GC_15_38 ref NI_15 NS_38 0 -1.8160157916730349e-01
GC_15_39 ref NI_15 NS_39 0 1.5876269641177213e-01
GC_15_40 ref NI_15 NS_40 0 1.1237014943283483e-01
GC_15_41 ref NI_15 NS_41 0 2.7287647789466164e-04
GC_15_42 ref NI_15 NS_42 0 -2.7147582886357189e-03
GC_15_43 ref NI_15 NS_43 0 -1.6225946451111750e-01
GC_15_44 ref NI_15 NS_44 0 -2.7875674756956542e-02
GC_15_45 ref NI_15 NS_45 0 4.3171013798279928e-01
GC_15_46 ref NI_15 NS_46 0 -8.8765708472319418e-02
GC_15_47 ref NI_15 NS_47 0 8.9957171234689357e-06
GC_15_48 ref NI_15 NS_48 0 1.1688518877842982e-03
GC_15_49 ref NI_15 NS_49 0 -1.9687640332622877e-01
GC_15_50 ref NI_15 NS_50 0 2.5375427036011250e-01
GC_15_51 ref NI_15 NS_51 0 7.1688050215101251e-01
GC_15_52 ref NI_15 NS_52 0 -3.0843538170508744e-01
GC_15_53 ref NI_15 NS_53 0 -1.3708428197848081e-04
GC_15_54 ref NI_15 NS_54 0 -3.0076127805224702e-03
GC_15_55 ref NI_15 NS_55 0 4.4516946620321857e-01
GC_15_56 ref NI_15 NS_56 0 -6.9270140811420045e-01
GC_15_57 ref NI_15 NS_57 0 4.9779728040663590e-01
GC_15_58 ref NI_15 NS_58 0 6.6621841990649119e-02
GC_15_59 ref NI_15 NS_59 0 -2.1148330096778069e-05
GC_15_60 ref NI_15 NS_60 0 -9.0249992556253999e-03
GC_15_61 ref NI_15 NS_61 0 -4.2560092187472739e-02
GC_15_62 ref NI_15 NS_62 0 -1.6545574404340174e-01
GC_15_63 ref NI_15 NS_63 0 3.3605632561168575e-01
GC_15_64 ref NI_15 NS_64 0 -9.7865086101759334e-03
GC_15_65 ref NI_15 NS_65 0 1.2582440328114336e-05
GC_15_66 ref NI_15 NS_66 0 3.0086696997767143e-03
GC_15_67 ref NI_15 NS_67 0 -3.1287259094088798e-01
GC_15_68 ref NI_15 NS_68 0 1.5908930398291183e+00
GC_15_69 ref NI_15 NS_69 0 8.6258419938921131e-03
GC_15_70 ref NI_15 NS_70 0 -3.3921729011756513e-01
GC_15_71 ref NI_15 NS_71 0 -1.9174552212530287e-04
GC_15_72 ref NI_15 NS_72 0 -6.6069858098782835e-03
GC_15_73 ref NI_15 NS_73 0 -1.0370970235345997e-01
GC_15_74 ref NI_15 NS_74 0 6.2118278232870909e-02
GC_15_75 ref NI_15 NS_75 0 6.2472886276674933e-01
GC_15_76 ref NI_15 NS_76 0 -2.0813003072963029e-01
GC_15_77 ref NI_15 NS_77 0 -6.8315921283237089e-05
GC_15_78 ref NI_15 NS_78 0 -3.8805299211397402e-03
GC_15_79 ref NI_15 NS_79 0 -1.5678656293043999e-01
GC_15_80 ref NI_15 NS_80 0 -1.1184249066849429e-01
GC_15_81 ref NI_15 NS_81 0 1.8914817772292553e-01
GC_15_82 ref NI_15 NS_82 0 4.7556873678273222e-02
GC_15_83 ref NI_15 NS_83 0 7.5930263317781154e-05
GC_15_84 ref NI_15 NS_84 0 6.7377883331069385e-03
GC_15_85 ref NI_15 NS_85 0 1.7889958235261572e+00
GC_15_86 ref NI_15 NS_86 0 -1.2044495588450779e+00
GC_15_87 ref NI_15 NS_87 0 -3.1491543972502067e+00
GC_15_88 ref NI_15 NS_88 0 -6.5132825316985965e-01
GC_15_89 ref NI_15 NS_89 0 -1.0574982334573251e-03
GC_15_90 ref NI_15 NS_90 0 -2.4937264767917269e-02
GC_15_91 ref NI_15 NS_91 0 2.7164600036039172e-01
GC_15_92 ref NI_15 NS_92 0 -3.9347119751399257e-01
GC_15_93 ref NI_15 NS_93 0 2.3064977781213664e-01
GC_15_94 ref NI_15 NS_94 0 1.1000420515609975e-01
GC_15_95 ref NI_15 NS_95 0 4.9243984572544974e-06
GC_15_96 ref NI_15 NS_96 0 -2.8694914743656983e-03
GC_15_97 ref NI_15 NS_97 0 -1.5678969931174561e-01
GC_15_98 ref NI_15 NS_98 0 1.2878875185938810e-01
GC_15_99 ref NI_15 NS_99 0 -2.9194608096493613e-01
GC_15_100 ref NI_15 NS_100 0 2.1961244140255878e-01
GC_15_101 ref NI_15 NS_101 0 -2.8315978683632354e-05
GC_15_102 ref NI_15 NS_102 0 1.0084130474037769e-02
GC_15_103 ref NI_15 NS_103 0 -3.3100150697460418e-01
GC_15_104 ref NI_15 NS_104 0 2.4543021795985120e-01
GC_15_105 ref NI_15 NS_105 0 -3.4564993459064242e-01
GC_15_106 ref NI_15 NS_106 0 2.0047488188268661e-01
GC_15_107 ref NI_15 NS_107 0 -1.0455047969789144e-05
GC_15_108 ref NI_15 NS_108 0 1.8054188863731162e-02
GC_15_109 ref NI_15 NS_109 0 -1.7950399203986758e-01
GC_15_110 ref NI_15 NS_110 0 2.8771044402200553e-02
GC_15_111 ref NI_15 NS_111 0 -1.1088612144220501e-01
GC_15_112 ref NI_15 NS_112 0 1.4735263217577216e-01
GC_15_113 ref NI_15 NS_113 0 3.1694665501868869e-05
GC_15_114 ref NI_15 NS_114 0 1.2895283897943447e-02
GC_15_115 ref NI_15 NS_115 0 -4.8393324082754768e-01
GC_15_116 ref NI_15 NS_116 0 4.4267134813850539e-01
GC_15_117 ref NI_15 NS_117 0 -5.3523163922187433e-01
GC_15_118 ref NI_15 NS_118 0 2.3974387335879754e-01
GC_15_119 ref NI_15 NS_119 0 -3.9328243101288205e-05
GC_15_120 ref NI_15 NS_120 0 2.2055585601526297e-02
GC_15_121 ref NI_15 NS_121 0 -7.2939689634133956e-02
GC_15_122 ref NI_15 NS_122 0 -2.5091100618762800e-02
GC_15_123 ref NI_15 NS_123 0 -5.5408355063637199e-02
GC_15_124 ref NI_15 NS_124 0 1.4301641580475735e-01
GC_15_125 ref NI_15 NS_125 0 -1.5120508689814719e-05
GC_15_126 ref NI_15 NS_126 0 7.7863423907113859e-03
GC_15_127 ref NI_15 NS_127 0 2.2453633716028518e-01
GC_15_128 ref NI_15 NS_128 0 -3.7299553076755038e-01
GC_15_129 ref NI_15 NS_129 0 3.9715430983516248e-01
GC_15_130 ref NI_15 NS_130 0 2.6075918648854460e-02
GC_15_131 ref NI_15 NS_131 0 -3.8480282879061373e-05
GC_15_132 ref NI_15 NS_132 0 -4.4787136210384104e-03
GC_15_133 ref NI_15 NS_133 0 -1.3517679891913029e-01
GC_15_134 ref NI_15 NS_134 0 -2.9167240914479575e-01
GC_15_135 ref NI_15 NS_135 0 6.7674076555116147e-01
GC_15_136 ref NI_15 NS_136 0 -1.1838519499521005e-01
GC_15_137 ref NI_15 NS_137 0 -7.6567417106946774e-05
GC_15_138 ref NI_15 NS_138 0 -6.6549734758066491e-03
GD_15_1 ref NI_15 NA_1 0 -1.8133545397743610e-02
GD_15_2 ref NI_15 NA_2 0 1.7565446769250391e-03
GD_15_3 ref NI_15 NA_3 0 -2.6631376097196065e-02
GD_15_4 ref NI_15 NA_4 0 4.6975843950712540e-02
GD_15_5 ref NI_15 NA_5 0 3.6156794956869090e-02
GD_15_6 ref NI_15 NA_6 0 3.1603587089529303e-02
GD_15_7 ref NI_15 NA_7 0 3.9525233533437357e-02
GD_15_8 ref NI_15 NA_8 0 1.9300633595979437e-02
GD_15_9 ref NI_15 NA_9 0 5.5050897514363874e-03
GD_15_10 ref NI_15 NA_10 0 -4.4269557404943878e-02
GD_15_11 ref NI_15 NA_11 0 1.2718660792775512e-02
GD_15_12 ref NI_15 NA_12 0 3.4462798114729097e-02
GD_15_13 ref NI_15 NA_13 0 7.3470536901097108e-03
GD_15_14 ref NI_15 NA_14 0 3.0787842951940772e-02
GD_15_15 ref NI_15 NA_15 0 5.8145364300230300e+00
GD_15_16 ref NI_15 NA_16 0 -2.3118312183967888e-02
GD_15_17 ref NI_15 NA_17 0 3.5949750744675019e-02
GD_15_18 ref NI_15 NA_18 0 6.4125134714658832e-02
GD_15_19 ref NI_15 NA_19 0 4.0922853421658675e-02
GD_15_20 ref NI_15 NA_20 0 8.4843834254046485e-02
GD_15_21 ref NI_15 NA_21 0 2.2070692146944081e-02
GD_15_22 ref NI_15 NA_22 0 -2.5829271958173236e-02
GD_15_23 ref NI_15 NA_23 0 2.0424374710594474e-02
*
* Port 16
VI_16 a_16 NI_16 0
RI_16 NI_16 ref 1.0000000000000001e-01
GC_16_1 ref NI_16 NS_1 0 -2.5535249513390079e-01
GC_16_2 ref NI_16 NS_2 0 1.1007199068679160e-01
GC_16_3 ref NI_16 NS_3 0 -1.1242365235454892e-01
GC_16_4 ref NI_16 NS_4 0 7.3855394376870998e-02
GC_16_5 ref NI_16 NS_5 0 1.5433867083532892e-04
GC_16_6 ref NI_16 NS_6 0 3.2448921333429769e-02
GC_16_7 ref NI_16 NS_7 0 -1.5871170719539524e-01
GC_16_8 ref NI_16 NS_8 0 6.0289637315428121e-02
GC_16_9 ref NI_16 NS_9 0 -5.5610849465047206e-02
GC_16_10 ref NI_16 NS_10 0 7.9952225105205138e-02
GC_16_11 ref NI_16 NS_11 0 9.6728574548747825e-05
GC_16_12 ref NI_16 NS_12 0 2.1142142590921290e-02
GC_16_13 ref NI_16 NS_13 0 -1.9450875053112007e-01
GC_16_14 ref NI_16 NS_14 0 1.1828101275784958e-01
GC_16_15 ref NI_16 NS_15 0 -1.2249430668249514e-01
GC_16_16 ref NI_16 NS_16 0 6.6158590153734945e-02
GC_16_17 ref NI_16 NS_17 0 1.2286314962139201e-04
GC_16_18 ref NI_16 NS_18 0 3.4911529360836184e-02
GC_16_19 ref NI_16 NS_19 0 -3.2609709607804649e-01
GC_16_20 ref NI_16 NS_20 0 2.2309462347182360e-01
GC_16_21 ref NI_16 NS_21 0 -2.2086004369618448e-01
GC_16_22 ref NI_16 NS_22 0 4.0178898299297591e-02
GC_16_23 ref NI_16 NS_23 0 2.0666424029507619e-04
GC_16_24 ref NI_16 NS_24 0 5.4146636660904128e-02
GC_16_25 ref NI_16 NS_25 0 -3.3814920238897955e-01
GC_16_26 ref NI_16 NS_26 0 2.4095852576278440e-01
GC_16_27 ref NI_16 NS_27 0 -2.3082960934178315e-01
GC_16_28 ref NI_16 NS_28 0 3.5208606113846713e-02
GC_16_29 ref NI_16 NS_29 0 1.9701205891052836e-04
GC_16_30 ref NI_16 NS_30 0 5.6214386724344395e-02
GC_16_31 ref NI_16 NS_31 0 -3.4398972177040865e-01
GC_16_32 ref NI_16 NS_32 0 2.5003944823802332e-01
GC_16_33 ref NI_16 NS_33 0 -2.4114126098703867e-01
GC_16_34 ref NI_16 NS_34 0 3.9550816662163125e-02
GC_16_35 ref NI_16 NS_35 0 2.0551386879057707e-04
GC_16_36 ref NI_16 NS_36 0 5.5720379591632445e-02
GC_16_37 ref NI_16 NS_37 0 -3.1299839762002390e-01
GC_16_38 ref NI_16 NS_38 0 2.1609704816928663e-01
GC_16_39 ref NI_16 NS_39 0 -2.2305519593276910e-01
GC_16_40 ref NI_16 NS_40 0 5.0252025992706992e-02
GC_16_41 ref NI_16 NS_41 0 1.8955899475270530e-04
GC_16_42 ref NI_16 NS_42 0 5.1534640215773232e-02
GC_16_43 ref NI_16 NS_43 0 -1.3176255366588421e-01
GC_16_44 ref NI_16 NS_44 0 -3.0380117436227053e-02
GC_16_45 ref NI_16 NS_45 0 -1.3802064249562422e-02
GC_16_46 ref NI_16 NS_46 0 1.3614458431006329e-01
GC_16_47 ref NI_16 NS_47 0 2.2601823138866854e-05
GC_16_48 ref NI_16 NS_48 0 2.5388425978248030e-03
GC_16_49 ref NI_16 NS_49 0 6.8199207233322595e-02
GC_16_50 ref NI_16 NS_50 0 -2.1193256520726192e-01
GC_16_51 ref NI_16 NS_51 0 1.2798739687421465e-01
GC_16_52 ref NI_16 NS_52 0 1.0790292422774268e-01
GC_16_53 ref NI_16 NS_53 0 1.9729154158184529e-05
GC_16_54 ref NI_16 NS_54 0 1.9440482255600033e-03
GC_16_55 ref NI_16 NS_55 0 7.9012809601767886e-01
GC_16_56 ref NI_16 NS_56 0 2.0022966945424705e+00
GC_16_57 ref NI_16 NS_57 0 -3.0752272982241924e-02
GC_16_58 ref NI_16 NS_58 0 -3.8698691047497219e-01
GC_16_59 ref NI_16 NS_59 0 -1.5042049149602198e-04
GC_16_60 ref NI_16 NS_60 0 -5.3455952616142798e-02
GC_16_61 ref NI_16 NS_61 0 -1.6633273279156352e-01
GC_16_62 ref NI_16 NS_62 0 4.4862647277966509e-02
GC_16_63 ref NI_16 NS_63 0 9.3541769664793217e-02
GC_16_64 ref NI_16 NS_64 0 8.2548891965218946e-02
GC_16_65 ref NI_16 NS_65 0 -3.1854413847241084e-06
GC_16_66 ref NI_16 NS_66 0 -6.7455008061252826e-03
GC_16_67 ref NI_16 NS_67 0 7.5413326293690436e-02
GC_16_68 ref NI_16 NS_68 0 -4.7364735265221514e-01
GC_16_69 ref NI_16 NS_69 0 8.0360862693503210e-01
GC_16_70 ref NI_16 NS_70 0 -1.1880865629781916e-01
GC_16_71 ref NI_16 NS_71 0 -1.0999638081140981e-04
GC_16_72 ref NI_16 NS_72 0 -1.6823453968085305e-02
GC_16_73 ref NI_16 NS_73 0 9.4212525639653395e-03
GC_16_74 ref NI_16 NS_74 0 -7.5865974451798934e-02
GC_16_75 ref NI_16 NS_75 0 3.7686187683822031e-01
GC_16_76 ref NI_16 NS_76 0 -2.9546272874615892e-02
GC_16_77 ref NI_16 NS_77 0 -8.9733817973222402e-05
GC_16_78 ref NI_16 NS_78 0 -9.5652474782723772e-03
GC_16_79 ref NI_16 NS_79 0 -2.6398684598329375e-01
GC_16_80 ref NI_16 NS_80 0 1.3473205082619202e-01
GC_16_81 ref NI_16 NS_81 0 -2.5916299881369365e-01
GC_16_82 ref NI_16 NS_82 0 2.2133762416471059e-01
GC_16_83 ref NI_16 NS_83 0 -1.2069211188704992e-07
GC_16_84 ref NI_16 NS_84 0 3.0922539733354406e-03
GC_16_85 ref NI_16 NS_85 0 2.7164600036039199e-01
GC_16_86 ref NI_16 NS_86 0 -3.9347119751399379e-01
GC_16_87 ref NI_16 NS_87 0 2.3064977781213838e-01
GC_16_88 ref NI_16 NS_88 0 1.1000420515609879e-01
GC_16_89 ref NI_16 NS_89 0 4.9243984571930647e-06
GC_16_90 ref NI_16 NS_90 0 -2.8694914743654328e-03
GC_16_91 ref NI_16 NS_91 0 2.7641218592794843e+00
GC_16_92 ref NI_16 NS_92 0 -6.6243791705515269e+00
GC_16_93 ref NI_16 NS_93 0 -3.6045240551638719e-01
GC_16_94 ref NI_16 NS_94 0 -3.5619091784039453e-01
GC_16_95 ref NI_16 NS_95 0 -5.8648144976525848e-04
GC_16_96 ref NI_16 NS_96 0 -6.2033670050940889e-02
GC_16_97 ref NI_16 NS_97 0 -2.3305997208191301e-01
GC_16_98 ref NI_16 NS_98 0 1.2427269019177474e+00
GC_16_99 ref NI_16 NS_99 0 -1.3328223477876702e-01
GC_16_100 ref NI_16 NS_100 0 -1.0175339482327542e-01
GC_16_101 ref NI_16 NS_101 0 8.2186013169000476e-06
GC_16_102 ref NI_16 NS_102 0 -3.2003888657063551e-02
GC_16_103 ref NI_16 NS_103 0 -3.5851730611504523e-01
GC_16_104 ref NI_16 NS_104 0 1.2682473665252494e-01
GC_16_105 ref NI_16 NS_105 0 -9.4601970234252597e-02
GC_16_106 ref NI_16 NS_106 0 1.8118510950494396e-01
GC_16_107 ref NI_16 NS_107 0 -3.1520133150683374e-05
GC_16_108 ref NI_16 NS_108 0 -1.2201902665245894e-02
GC_16_109 ref NI_16 NS_109 0 -3.1903988713718862e-01
GC_16_110 ref NI_16 NS_110 0 1.4224104679844488e-01
GC_16_111 ref NI_16 NS_111 0 -2.2163517898179350e-01
GC_16_112 ref NI_16 NS_112 0 2.2289236582879188e-01
GC_16_113 ref NI_16 NS_113 0 -1.4840683932016883e-05
GC_16_114 ref NI_16 NS_114 0 -4.9582719678100710e-03
GC_16_115 ref NI_16 NS_115 0 -3.8326594342820841e-01
GC_16_116 ref NI_16 NS_116 0 1.4566792983922550e-01
GC_16_117 ref NI_16 NS_117 0 2.8456636487619754e-02
GC_16_118 ref NI_16 NS_118 0 1.2788879123127297e-01
GC_16_119 ref NI_16 NS_119 0 1.9915959448939529e-05
GC_16_120 ref NI_16 NS_120 0 -1.9246143679346482e-02
GC_16_121 ref NI_16 NS_121 0 -2.7548079245385443e-01
GC_16_122 ref NI_16 NS_122 0 4.9380150034678733e-01
GC_16_123 ref NI_16 NS_123 0 1.2123400847844301e-01
GC_16_124 ref NI_16 NS_124 0 -2.8462404879771343e-02
GC_16_125 ref NI_16 NS_125 0 1.1843274152252986e-05
GC_16_126 ref NI_16 NS_126 0 -2.0829922586333892e-02
GC_16_127 ref NI_16 NS_127 0 3.9892489249024959e-01
GC_16_128 ref NI_16 NS_128 0 1.7249026796626710e+00
GC_16_129 ref NI_16 NS_129 0 -2.6082923414354742e-01
GC_16_130 ref NI_16 NS_130 0 -2.0682653048656247e-01
GC_16_131 ref NI_16 NS_131 0 -8.3962378302035727e-05
GC_16_132 ref NI_16 NS_132 0 -3.6181189527416384e-02
GC_16_133 ref NI_16 NS_133 0 -2.2857238193283780e-01
GC_16_134 ref NI_16 NS_134 0 5.3480274387602789e-01
GC_16_135 ref NI_16 NS_135 0 7.8659104121149559e-01
GC_16_136 ref NI_16 NS_136 0 -3.4098022811233109e-01
GC_16_137 ref NI_16 NS_137 0 -1.5294379396268157e-04
GC_16_138 ref NI_16 NS_138 0 -3.7032094111822171e-02
GD_16_1 ref NI_16 NA_1 0 4.8095124058079586e-02
GD_16_2 ref NI_16 NA_2 0 4.8854670325561164e-02
GD_16_3 ref NI_16 NA_3 0 4.3963531100699053e-02
GD_16_4 ref NI_16 NA_4 0 6.3685154385703366e-02
GD_16_5 ref NI_16 NA_5 0 6.5057960760121283e-02
GD_16_6 ref NI_16 NA_6 0 6.5595682997974081e-02
GD_16_7 ref NI_16 NA_7 0 6.0537331262040438e-02
GD_16_8 ref NI_16 NA_8 0 3.9232921450762383e-02
GD_16_9 ref NI_16 NA_9 0 6.1818165654722651e-03
GD_16_10 ref NI_16 NA_10 0 -1.3857872097202664e-01
GD_16_11 ref NI_16 NA_11 0 4.3899032410435843e-02
GD_16_12 ref NI_16 NA_12 0 1.7444726931764686e-03
GD_16_13 ref NI_16 NA_13 0 7.8611891108479222e-03
GD_16_14 ref NI_16 NA_14 0 6.1205139157186207e-02
GD_16_15 ref NI_16 NA_15 0 -2.3118312183967888e-02
GD_16_16 ref NI_16 NA_16 0 5.5907918482317092e+00
GD_16_17 ref NI_16 NA_17 0 5.1390485849552983e-02
GD_16_18 ref NI_16 NA_18 0 8.1219297238551633e-02
GD_16_19 ref NI_16 NA_19 0 7.2679963689454702e-02
GD_16_20 ref NI_16 NA_20 0 8.9024782644855277e-02
GD_16_21 ref NI_16 NA_21 0 5.6175418949509406e-02
GD_16_22 ref NI_16 NA_22 0 -5.3245119058687777e-02
GD_16_23 ref NI_16 NA_23 0 5.4857707973052505e-03
*
* Port 17
VI_17 a_17 NI_17 0
RI_17 NI_17 ref 1.0000000000000001e-01
GC_17_1 ref NI_17 NS_1 0 -2.4190104547637495e-01
GC_17_2 ref NI_17 NS_2 0 1.1842638415934932e-01
GC_17_3 ref NI_17 NS_3 0 -1.3839045499947200e-01
GC_17_4 ref NI_17 NS_4 0 6.9274418068891216e-02
GC_17_5 ref NI_17 NS_5 0 1.2067531001631888e-04
GC_17_6 ref NI_17 NS_6 0 3.8292931086164626e-02
GC_17_7 ref NI_17 NS_7 0 -1.5348258309074575e-01
GC_17_8 ref NI_17 NS_8 0 6.2004572866819048e-02
GC_17_9 ref NI_17 NS_9 0 -8.5179269368224911e-02
GC_17_10 ref NI_17 NS_10 0 8.6672856418892802e-02
GC_17_11 ref NI_17 NS_11 0 5.6258109288107876e-05
GC_17_12 ref NI_17 NS_12 0 2.4975776595230918e-02
GC_17_13 ref NI_17 NS_13 0 -2.0950838253639692e-01
GC_17_14 ref NI_17 NS_14 0 1.3469028238048864e-01
GC_17_15 ref NI_17 NS_15 0 -1.4818897519246860e-01
GC_17_16 ref NI_17 NS_16 0 5.9823317089860210e-02
GC_17_17 ref NI_17 NS_17 0 9.1840195664855901e-05
GC_17_18 ref NI_17 NS_18 0 4.1406910506057569e-02
GC_17_19 ref NI_17 NS_19 0 -3.1055119075023757e-01
GC_17_20 ref NI_17 NS_20 0 2.1883655892577053e-01
GC_17_21 ref NI_17 NS_21 0 -1.9334990368099433e-01
GC_17_22 ref NI_17 NS_22 0 4.0118407082243056e-03
GC_17_23 ref NI_17 NS_23 0 1.7912527287189181e-04
GC_17_24 ref NI_17 NS_24 0 6.2697170102197386e-02
GC_17_25 ref NI_17 NS_25 0 -3.2005199313289978e-01
GC_17_26 ref NI_17 NS_26 0 2.2948954835493432e-01
GC_17_27 ref NI_17 NS_27 0 -1.9365096133740045e-01
GC_17_28 ref NI_17 NS_28 0 -4.6412701951810487e-03
GC_17_29 ref NI_17 NS_29 0 1.6994491166853407e-04
GC_17_30 ref NI_17 NS_30 0 6.4990834722253130e-02
GC_17_31 ref NI_17 NS_31 0 -3.2863483629745899e-01
GC_17_32 ref NI_17 NS_32 0 2.4030033805103473e-01
GC_17_33 ref NI_17 NS_33 0 -2.0461508488091920e-01
GC_17_34 ref NI_17 NS_34 0 -4.9848206645148490e-04
GC_17_35 ref NI_17 NS_35 0 1.7625767151145468e-04
GC_17_36 ref NI_17 NS_36 0 6.4580246127822205e-02
GC_17_37 ref NI_17 NS_37 0 -3.0554295869533266e-01
GC_17_38 ref NI_17 NS_38 0 2.2130580659211019e-01
GC_17_39 ref NI_17 NS_39 0 -2.0613508873511091e-01
GC_17_40 ref NI_17 NS_40 0 1.7491567978731169e-02
GC_17_41 ref NI_17 NS_41 0 1.5884859281365673e-04
GC_17_42 ref NI_17 NS_42 0 6.0023113637104636e-02
GC_17_43 ref NI_17 NS_43 0 3.8577997337256556e-03
GC_17_44 ref NI_17 NS_44 0 -1.7728671142050001e-01
GC_17_45 ref NI_17 NS_45 0 1.2166837405297559e-01
GC_17_46 ref NI_17 NS_46 0 1.1646368845622014e-01
GC_17_47 ref NI_17 NS_47 0 1.3448432040784058e-05
GC_17_48 ref NI_17 NS_48 0 -2.4856982525697257e-03
GC_17_49 ref NI_17 NS_49 0 -8.3950137269648284e-02
GC_17_50 ref NI_17 NS_50 0 -5.5772776593667546e-04
GC_17_51 ref NI_17 NS_51 0 -1.2843906725573745e-01
GC_17_52 ref NI_17 NS_52 0 1.7244344801731443e-01
GC_17_53 ref NI_17 NS_53 0 -5.5699436804058413e-06
GC_17_54 ref NI_17 NS_54 0 8.1556261965438637e-03
GC_17_55 ref NI_17 NS_55 0 -1.9540286465401585e-01
GC_17_56 ref NI_17 NS_56 0 -2.4622238937309859e-01
GC_17_57 ref NI_17 NS_57 0 5.1353450618994823e-01
GC_17_58 ref NI_17 NS_58 0 6.3395025691946483e-03
GC_17_59 ref NI_17 NS_59 0 -8.3848247600060552e-06
GC_17_60 ref NI_17 NS_60 0 -2.6612780959080592e-02
GC_17_61 ref NI_17 NS_61 0 -6.8293667246917378e-02
GC_17_62 ref NI_17 NS_62 0 -6.5779914875038689e-02
GC_17_63 ref NI_17 NS_63 0 3.7261104576012311e-01
GC_17_64 ref NI_17 NS_64 0 -9.0636837894683582e-03
GC_17_65 ref NI_17 NS_65 0 -8.4528440027937266e-05
GC_17_66 ref NI_17 NS_66 0 -1.4750837113673866e-02
GC_17_67 ref NI_17 NS_67 0 2.8740354785253747e-02
GC_17_68 ref NI_17 NS_68 0 -1.8680853032297579e-01
GC_17_69 ref NI_17 NS_69 0 3.3794781375815278e-02
GC_17_70 ref NI_17 NS_70 0 1.6792118908166015e-01
GC_17_71 ref NI_17 NS_71 0 -4.6963524745020627e-05
GC_17_72 ref NI_17 NS_72 0 -3.6772876665644026e-03
GC_17_73 ref NI_17 NS_73 0 -9.7836420831738477e-02
GC_17_74 ref NI_17 NS_74 0 -8.0020918112350320e-02
GC_17_75 ref NI_17 NS_75 0 1.1425920408448928e-01
GC_17_76 ref NI_17 NS_76 0 9.8604150007079228e-02
GC_17_77 ref NI_17 NS_77 0 -6.4890498093866022e-05
GC_17_78 ref NI_17 NS_78 0 -2.8803064258665512e-03
GC_17_79 ref NI_17 NS_79 0 2.2289869442593604e-01
GC_17_80 ref NI_17 NS_80 0 -3.8215485834197493e-01
GC_17_81 ref NI_17 NS_81 0 2.2547610022166281e-01
GC_17_82 ref NI_17 NS_82 0 1.4662201186821983e-01
GC_17_83 ref NI_17 NS_83 0 -1.8985020285591532e-06
GC_17_84 ref NI_17 NS_84 0 -1.5912629090068381e-02
GC_17_85 ref NI_17 NS_85 0 -1.5678969931174555e-01
GC_17_86 ref NI_17 NS_86 0 1.2878875185938776e-01
GC_17_87 ref NI_17 NS_87 0 -2.9194608096493574e-01
GC_17_88 ref NI_17 NS_88 0 2.1961244140255856e-01
GC_17_89 ref NI_17 NS_89 0 -2.8315978683646659e-05
GC_17_90 ref NI_17 NS_90 0 1.0084130474037828e-02
GC_17_91 ref NI_17 NS_91 0 -2.3305997208191287e-01
GC_17_92 ref NI_17 NS_92 0 1.2427269019177467e+00
GC_17_93 ref NI_17 NS_93 0 -1.3328223477876619e-01
GC_17_94 ref NI_17 NS_94 0 -1.0175339482327586e-01
GC_17_95 ref NI_17 NS_95 0 8.2186013168714348e-06
GC_17_96 ref NI_17 NS_96 0 -3.2003888657063419e-02
GC_17_97 ref NI_17 NS_97 0 2.8480817959213245e+00
GC_17_98 ref NI_17 NS_98 0 -2.5447326915119994e+00
GC_17_99 ref NI_17 NS_99 0 -2.7532772787606130e+00
GC_17_100 ref NI_17 NS_100 0 -3.7868615357146002e-01
GC_17_101 ref NI_17 NS_101 0 -5.4031616204519909e-04
GC_17_102 ref NI_17 NS_102 0 -6.8346077988995127e-02
GC_17_103 ref NI_17 NS_103 0 1.3447695235920681e-01
GC_17_104 ref NI_17 NS_104 0 -2.4113173460577889e-01
GC_17_105 ref NI_17 NS_105 0 8.0971752257212204e-01
GC_17_106 ref NI_17 NS_106 0 -1.2005618007350334e-01
GC_17_107 ref NI_17 NS_107 0 1.3876561206924193e-05
GC_17_108 ref NI_17 NS_108 0 -4.6090236445526393e-02
GC_17_109 ref NI_17 NS_109 0 2.7130808428096465e-01
GC_17_110 ref NI_17 NS_110 0 -5.3164594313420643e-01
GC_17_111 ref NI_17 NS_111 0 5.9425077864142906e-01
GC_17_112 ref NI_17 NS_112 0 4.0312534257682178e-02
GC_17_113 ref NI_17 NS_113 0 3.3793393224061467e-05
GC_17_114 ref NI_17 NS_114 0 -3.3465382788535052e-02
GC_17_115 ref NI_17 NS_115 0 -1.0203616307538772e-01
GC_17_116 ref NI_17 NS_116 0 3.8385130593890382e-01
GC_17_117 ref NI_17 NS_117 0 8.7460614171180939e-01
GC_17_118 ref NI_17 NS_118 0 -3.0932225452374068e-01
GC_17_119 ref NI_17 NS_119 0 4.1220475515096667e-05
GC_17_120 ref NI_17 NS_120 0 -5.5553880299155527e-02
GC_17_121 ref NI_17 NS_121 0 -1.4285643159998865e-01
GC_17_122 ref NI_17 NS_122 0 1.5474039315645141e+00
GC_17_123 ref NI_17 NS_123 0 8.7850568475960331e-02
GC_17_124 ref NI_17 NS_124 0 -2.8775289593272907e-01
GC_17_125 ref NI_17 NS_125 0 -2.1542926060559131e-04
GC_17_126 ref NI_17 NS_126 0 -3.4552134169570779e-02
GC_17_127 ref NI_17 NS_127 0 -5.0612977602557629e-01
GC_17_128 ref NI_17 NS_128 0 3.2559466057777914e-01
GC_17_129 ref NI_17 NS_129 0 3.3152148043093049e-01
GC_17_130 ref NI_17 NS_130 0 -7.4042080133152804e-02
GC_17_131 ref NI_17 NS_131 0 3.3082304904640565e-06
GC_17_132 ref NI_17 NS_132 0 -2.0687862993319456e-02
GC_17_133 ref NI_17 NS_133 0 1.0312692767274536e-02
GC_17_134 ref NI_17 NS_134 0 -3.9006053741738533e-01
GC_17_135 ref NI_17 NS_135 0 3.8279253238247551e-01
GC_17_136 ref NI_17 NS_136 0 8.5670674083386605e-02
GC_17_137 ref NI_17 NS_137 0 -3.6396218488345094e-05
GC_17_138 ref NI_17 NS_138 0 -1.8332983456284545e-02
GD_17_1 ref NI_17 NA_1 0 4.6722942171464416e-02
GD_17_2 ref NI_17 NA_2 0 4.3194806671855011e-02
GD_17_3 ref NI_17 NA_3 0 4.3093360989765794e-02
GD_17_4 ref NI_17 NA_4 0 5.9897635825922765e-02
GD_17_5 ref NI_17 NA_5 0 6.0955740164240796e-02
GD_17_6 ref NI_17 NA_6 0 6.1912081676294424e-02
GD_17_7 ref NI_17 NA_7 0 5.8064095129001313e-02
GD_17_8 ref NI_17 NA_8 0 1.6222684500992776e-02
GD_17_9 ref NI_17 NA_9 0 2.6660567993463346e-02
GD_17_10 ref NI_17 NA_10 0 4.7195994943962358e-02
GD_17_11 ref NI_17 NA_11 0 1.2703420676420713e-02
GD_17_12 ref NI_17 NA_12 0 1.4862629704763652e-02
GD_17_13 ref NI_17 NA_13 0 2.9671840935450958e-02
GD_17_14 ref NI_17 NA_14 0 -1.2645273890134956e-02
GD_17_15 ref NI_17 NA_15 0 3.5949750744675019e-02
GD_17_16 ref NI_17 NA_16 0 5.1390485849552983e-02
GD_17_17 ref NI_17 NA_17 0 5.6313529669439442e+00
GD_17_18 ref NI_17 NA_18 0 -9.3225058520747493e-03
GD_17_19 ref NI_17 NA_19 0 -1.9837049148323176e-02
GD_17_20 ref NI_17 NA_20 0 1.8634301802272404e-02
GD_17_21 ref NI_17 NA_21 0 -3.4834970961015503e-02
GD_17_22 ref NI_17 NA_22 0 9.5237128678556424e-02
GD_17_23 ref NI_17 NA_23 0 1.9087225269622730e-02
*
* Port 18
VI_18 a_18 NI_18 0
RI_18 NI_18 ref 1.0000000000000001e-01
GC_18_1 ref NI_18 NS_1 0 -2.7025694441665332e-01
GC_18_2 ref NI_18 NS_2 0 8.2571790816240678e-02
GC_18_3 ref NI_18 NS_3 0 -4.4770343833529958e-02
GC_18_4 ref NI_18 NS_4 0 4.2858054316382482e-02
GC_18_5 ref NI_18 NS_5 0 1.3709523597158610e-04
GC_18_6 ref NI_18 NS_6 0 3.4261863440170563e-02
GC_18_7 ref NI_18 NS_7 0 -1.3587899632288097e-01
GC_18_8 ref NI_18 NS_8 0 5.9278404488636229e-02
GC_18_9 ref NI_18 NS_9 0 1.0086531812562879e-02
GC_18_10 ref NI_18 NS_10 0 3.9817514758436805e-02
GC_18_11 ref NI_18 NS_11 0 5.2037233622378906e-05
GC_18_12 ref NI_18 NS_12 0 2.2503193053595449e-02
GC_18_13 ref NI_18 NS_13 0 -2.0698293650130162e-01
GC_18_14 ref NI_18 NS_14 0 9.0597519389836637e-02
GC_18_15 ref NI_18 NS_15 0 -7.4860768576248363e-02
GC_18_16 ref NI_18 NS_16 0 4.5605520155114473e-02
GC_18_17 ref NI_18 NS_17 0 1.1709268685895767e-04
GC_18_18 ref NI_18 NS_18 0 3.7034238871495082e-02
GC_18_19 ref NI_18 NS_19 0 -2.3814986372449859e-01
GC_18_20 ref NI_18 NS_20 0 1.3648362215711110e-01
GC_18_21 ref NI_18 NS_21 0 -1.5164601775794656e-01
GC_18_22 ref NI_18 NS_22 0 2.1262184388646705e-02
GC_18_23 ref NI_18 NS_23 0 2.1358322400188306e-04
GC_18_24 ref NI_18 NS_24 0 5.5289342027617164e-02
GC_18_25 ref NI_18 NS_25 0 -2.4644619767112841e-01
GC_18_26 ref NI_18 NS_26 0 1.5593859421177450e-01
GC_18_27 ref NI_18 NS_27 0 -1.6499544496268712e-01
GC_18_28 ref NI_18 NS_28 0 1.7671696592383785e-02
GC_18_29 ref NI_18 NS_29 0 2.0529758446457711e-04
GC_18_30 ref NI_18 NS_30 0 5.7243809598036523e-02
GC_18_31 ref NI_18 NS_31 0 -2.5036269052159005e-01
GC_18_32 ref NI_18 NS_32 0 1.6401165302010165e-01
GC_18_33 ref NI_18 NS_33 0 -1.7461111024312967e-01
GC_18_34 ref NI_18 NS_34 0 2.1699714102415248e-02
GC_18_35 ref NI_18 NS_35 0 2.0946182219877348e-04
GC_18_36 ref NI_18 NS_36 0 5.6835713015962130e-02
GC_18_37 ref NI_18 NS_37 0 -2.2809850872596446e-01
GC_18_38 ref NI_18 NS_38 0 1.2954442527036353e-01
GC_18_39 ref NI_18 NS_39 0 -1.5273091686398796e-01
GC_18_40 ref NI_18 NS_40 0 3.0287377233556196e-02
GC_18_41 ref NI_18 NS_41 0 1.8983965772373626e-04
GC_18_42 ref NI_18 NS_42 0 5.2960642648933028e-02
GC_18_43 ref NI_18 NS_43 0 -9.3811380773524383e-02
GC_18_44 ref NI_18 NS_44 0 -1.9834944996978293e-01
GC_18_45 ref NI_18 NS_45 0 4.0485878369902339e-01
GC_18_46 ref NI_18 NS_46 0 -1.7123060327551353e-02
GC_18_47 ref NI_18 NS_47 0 1.6067248324794237e-05
GC_18_48 ref NI_18 NS_48 0 -5.2335437269731677e-03
GC_18_49 ref NI_18 NS_49 0 -1.3876085234025384e-01
GC_18_50 ref NI_18 NS_50 0 -1.6853367267074860e-02
GC_18_51 ref NI_18 NS_51 0 -7.4242088951721241e-02
GC_18_52 ref NI_18 NS_52 0 1.4228033656603303e-01
GC_18_53 ref NI_18 NS_53 0 1.5720358289678317e-05
GC_18_54 ref NI_18 NS_54 0 1.1149699738344324e-02
GC_18_55 ref NI_18 NS_55 0 -4.9385720421454238e-01
GC_18_56 ref NI_18 NS_56 0 3.7295445038667857e-01
GC_18_57 ref NI_18 NS_57 0 -4.9828543801595809e-01
GC_18_58 ref NI_18 NS_58 0 3.0087899103826249e-01
GC_18_59 ref NI_18 NS_59 0 -6.7530795264076054e-05
GC_18_60 ref NI_18 NS_60 0 -8.0177854340556030e-04
GC_18_61 ref NI_18 NS_61 0 -4.0708952893545182e-02
GC_18_62 ref NI_18 NS_62 0 -3.7537811257483011e-02
GC_18_63 ref NI_18 NS_63 0 4.3244339419049421e-01
GC_18_64 ref NI_18 NS_64 0 -4.9092638277882690e-02
GC_18_65 ref NI_18 NS_65 0 -3.1917970753120691e-06
GC_18_66 ref NI_18 NS_66 0 -1.8565100642994641e-02
GC_18_67 ref NI_18 NS_67 0 -3.9754448710364398e-01
GC_18_68 ref NI_18 NS_68 0 3.0763929147292773e-01
GC_18_69 ref NI_18 NS_69 0 -4.1762205029737426e-01
GC_18_70 ref NI_18 NS_70 0 2.4056945060495119e-01
GC_18_71 ref NI_18 NS_71 0 -3.0979422538840610e-05
GC_18_72 ref NI_18 NS_72 0 1.1446249514190187e-02
GC_18_73 ref NI_18 NS_73 0 -2.0583701390309878e-01
GC_18_74 ref NI_18 NS_74 0 3.1752081211932327e-02
GC_18_75 ref NI_18 NS_75 0 -1.0445222756793192e-01
GC_18_76 ref NI_18 NS_76 0 1.6518707049543740e-01
GC_18_77 ref NI_18 NS_77 0 -1.9558096770963833e-05
GC_18_78 ref NI_18 NS_78 0 4.3147056744635027e-03
GC_18_79 ref NI_18 NS_79 0 6.9315437550122039e-03
GC_18_80 ref NI_18 NS_80 0 -1.6037617043667546e-01
GC_18_81 ref NI_18 NS_81 0 9.3805970481767231e-01
GC_18_82 ref NI_18 NS_82 0 -2.5800531884328681e-01
GC_18_83 ref NI_18 NS_83 0 -1.2252654351967536e-04
GC_18_84 ref NI_18 NS_84 0 -2.4441923431187808e-02
GC_18_85 ref NI_18 NS_85 0 -3.3100150697460445e-01
GC_18_86 ref NI_18 NS_86 0 2.4543021795985218e-01
GC_18_87 ref NI_18 NS_87 0 -3.4564993459064375e-01
GC_18_88 ref NI_18 NS_88 0 2.0047488188268731e-01
GC_18_89 ref NI_18 NS_89 0 -1.0455047969743380e-05
GC_18_90 ref NI_18 NS_90 0 1.8054188863730964e-02
GC_18_91 ref NI_18 NS_91 0 -3.5851730611504468e-01
GC_18_92 ref NI_18 NS_92 0 1.2682473665252278e-01
GC_18_93 ref NI_18 NS_93 0 -9.4601970234249613e-02
GC_18_94 ref NI_18 NS_94 0 1.8118510950494229e-01
GC_18_95 ref NI_18 NS_95 0 -3.1520133150789124e-05
GC_18_96 ref NI_18 NS_96 0 -1.2201902665245436e-02
GC_18_97 ref NI_18 NS_97 0 1.3447695235920706e-01
GC_18_98 ref NI_18 NS_98 0 -2.4113173460577977e-01
GC_18_99 ref NI_18 NS_99 0 8.0971752257212326e-01
GC_18_100 ref NI_18 NS_100 0 -1.2005618007350402e-01
GC_18_101 ref NI_18 NS_101 0 1.3876561206879913e-05
GC_18_102 ref NI_18 NS_102 0 -4.6090236445526199e-02
GC_18_103 ref NI_18 NS_103 0 3.6296763388577129e+00
GC_18_104 ref NI_18 NS_104 0 -4.6167689485533128e+00
GC_18_105 ref NI_18 NS_105 0 -1.4374597869301962e+00
GC_18_106 ref NI_18 NS_106 0 -4.1771719516654848e-01
GC_18_107 ref NI_18 NS_107 0 -4.7310495848023188e-04
GC_18_108 ref NI_18 NS_108 0 -9.1189483438088761e-02
GC_18_109 ref NI_18 NS_109 0 2.4451924632446206e-01
GC_18_110 ref NI_18 NS_110 0 1.7216789752021120e+00
GC_18_111 ref NI_18 NS_111 0 2.3455088108887920e-01
GC_18_112 ref NI_18 NS_112 0 -4.1100031779197765e-01
GC_18_113 ref NI_18 NS_113 0 -1.0722912391610352e-04
GC_18_114 ref NI_18 NS_114 0 -4.9960346889858391e-02
GC_18_115 ref NI_18 NS_115 0 4.9397174956515022e-01
GC_18_116 ref NI_18 NS_116 0 9.5048897253053199e-01
GC_18_117 ref NI_18 NS_117 0 1.0448851664071865e+00
GC_18_118 ref NI_18 NS_118 0 -5.4360361616429886e-01
GC_18_119 ref NI_18 NS_119 0 -2.4859266988167331e-04
GC_18_120 ref NI_18 NS_120 0 -7.2065201961357475e-02
GC_18_121 ref NI_18 NS_121 0 -2.0319962801899381e-02
GC_18_122 ref NI_18 NS_122 0 2.3883883625839428e-01
GC_18_123 ref NI_18 NS_123 0 4.8213783404095695e-01
GC_18_124 ref NI_18 NS_124 0 -1.1217574519208513e-01
GC_18_125 ref NI_18 NS_125 0 4.8201670518494807e-05
GC_18_126 ref NI_18 NS_126 0 -3.8006455885020031e-02
GC_18_127 ref NI_18 NS_127 0 -3.1320317488266408e-01
GC_18_128 ref NI_18 NS_128 0 8.0307336505167554e-02
GC_18_129 ref NI_18 NS_129 0 -1.1639956775029482e-01
GC_18_130 ref NI_18 NS_130 0 1.9117838342071333e-01
GC_18_131 ref NI_18 NS_131 0 9.7625676133977350e-06
GC_18_132 ref NI_18 NS_132 0 -7.2520214516987071e-03
GC_18_133 ref NI_18 NS_133 0 -4.6731360363990782e-01
GC_18_134 ref NI_18 NS_134 0 3.7979963065086353e-01
GC_18_135 ref NI_18 NS_135 0 -5.1515254304794877e-01
GC_18_136 ref NI_18 NS_136 0 2.9293007319066722e-01
GC_18_137 ref NI_18 NS_137 0 -7.2046277038656644e-05
GC_18_138 ref NI_18 NS_138 0 4.4345324468992023e-03
GD_18_1 ref NI_18 NA_1 0 4.8981565717157290e-02
GD_18_2 ref NI_18 NA_2 0 4.9283336592269487e-02
GD_18_3 ref NI_18 NA_3 0 4.1019278948526111e-02
GD_18_4 ref NI_18 NA_4 0 5.1466822636001275e-02
GD_18_5 ref NI_18 NA_5 0 5.2082220977809103e-02
GD_18_6 ref NI_18 NA_6 0 5.2303825800489583e-02
GD_18_7 ref NI_18 NA_7 0 4.8848380197813832e-02
GD_18_8 ref NI_18 NA_8 0 3.7043377189249306e-02
GD_18_9 ref NI_18 NA_9 0 3.9017639029203889e-02
GD_18_10 ref NI_18 NA_10 0 9.4732323522966608e-02
GD_18_11 ref NI_18 NA_11 0 2.5491312482323090e-02
GD_18_12 ref NI_18 NA_12 0 7.6069632221203082e-02
GD_18_13 ref NI_18 NA_13 0 5.1626297715263308e-02
GD_18_14 ref NI_18 NA_14 0 -2.4137528559685549e-04
GD_18_15 ref NI_18 NA_15 0 6.4125134714658832e-02
GD_18_16 ref NI_18 NA_16 0 8.1219297238551633e-02
GD_18_17 ref NI_18 NA_17 0 -9.3225058520747493e-03
GD_18_18 ref NI_18 NA_18 0 5.5235157644244968e+00
GD_18_19 ref NI_18 NA_19 0 -7.5020019762362139e-02
GD_18_20 ref NI_18 NA_20 0 -1.4493857816713096e-01
GD_18_21 ref NI_18 NA_21 0 2.1752031463275402e-02
GD_18_22 ref NI_18 NA_22 0 7.4426281916498152e-02
GD_18_23 ref NI_18 NA_23 0 8.8108189855709479e-02
*
* Port 19
VI_19 a_19 NI_19 0
RI_19 NI_19 ref 1.0000000000000001e-01
GC_19_1 ref NI_19 NS_1 0 -3.5594706045532853e-01
GC_19_2 ref NI_19 NS_2 0 1.5172246835881023e-01
GC_19_3 ref NI_19 NS_3 0 1.5777917358996280e-02
GC_19_4 ref NI_19 NS_4 0 2.4086665602123716e-02
GC_19_5 ref NI_19 NS_5 0 1.3504919675391317e-04
GC_19_6 ref NI_19 NS_6 0 2.4697256272081726e-02
GC_19_7 ref NI_19 NS_7 0 -1.4435216589523261e-02
GC_19_8 ref NI_19 NS_8 0 1.5982686661130832e-01
GC_19_9 ref NI_19 NS_9 0 4.4026304177366603e-02
GC_19_10 ref NI_19 NS_10 0 -1.8333766233662517e-03
GC_19_11 ref NI_19 NS_11 0 4.1118748290318064e-05
GC_19_12 ref NI_19 NS_12 0 1.5777953058230678e-02
GC_19_13 ref NI_19 NS_13 0 -1.9710099990668889e-01
GC_19_14 ref NI_19 NS_14 0 9.6536882585412293e-02
GC_19_15 ref NI_19 NS_15 0 -7.3685608819752052e-03
GC_19_16 ref NI_19 NS_16 0 3.7732924961805213e-02
GC_19_17 ref NI_19 NS_17 0 1.2023354825080608e-04
GC_19_18 ref NI_19 NS_18 0 2.6587954700034156e-02
GC_19_19 ref NI_19 NS_19 0 -1.8118278932731821e-01
GC_19_20 ref NI_19 NS_20 0 3.2149642901430735e-02
GC_19_21 ref NI_19 NS_21 0 -9.8147397099790645e-02
GC_19_22 ref NI_19 NS_22 0 6.1832924465523659e-02
GC_19_23 ref NI_19 NS_23 0 2.2485939062516814e-04
GC_19_24 ref NI_19 NS_24 0 4.0402572388239751e-02
GC_19_25 ref NI_19 NS_25 0 -1.7684146988403854e-01
GC_19_26 ref NI_19 NS_26 0 5.8170537914004380e-02
GC_19_27 ref NI_19 NS_27 0 -1.3059467326196778e-01
GC_19_28 ref NI_19 NS_28 0 6.7191649721819888e-02
GC_19_29 ref NI_19 NS_29 0 2.1964610742566230e-04
GC_19_30 ref NI_19 NS_30 0 4.1709604817048503e-02
GC_19_31 ref NI_19 NS_31 0 -1.6926320631764291e-01
GC_19_32 ref NI_19 NS_32 0 5.8721951257502514e-02
GC_19_33 ref NI_19 NS_33 0 -1.3608123742507536e-01
GC_19_34 ref NI_19 NS_34 0 7.0766972298383676e-02
GC_19_35 ref NI_19 NS_35 0 2.2367328646006918e-04
GC_19_36 ref NI_19 NS_36 0 4.1262532743851776e-02
GC_19_37 ref NI_19 NS_37 0 -1.6543972371101900e-01
GC_19_38 ref NI_19 NS_38 0 1.3147196435489743e-02
GC_19_39 ref NI_19 NS_39 0 -8.0170756908373275e-02
GC_19_40 ref NI_19 NS_40 0 6.3174802369236699e-02
GC_19_41 ref NI_19 NS_41 0 2.0031296893146958e-04
GC_19_42 ref NI_19 NS_42 0 3.8481998366684880e-02
GC_19_43 ref NI_19 NS_43 0 -3.2517095563571741e-01
GC_19_44 ref NI_19 NS_44 0 2.4761214562230499e-01
GC_19_45 ref NI_19 NS_45 0 4.1001898497120692e-01
GC_19_46 ref NI_19 NS_46 0 -1.4451840985235373e-01
GC_19_47 ref NI_19 NS_47 0 1.9006880128612138e-06
GC_19_48 ref NI_19 NS_48 0 -4.6133486758173957e-03
GC_19_49 ref NI_19 NS_49 0 -9.8339946074933932e-02
GC_19_50 ref NI_19 NS_50 0 -1.6547362487027611e-01
GC_19_51 ref NI_19 NS_51 0 1.8250133713882477e-01
GC_19_52 ref NI_19 NS_52 0 5.8939612183798742e-02
GC_19_53 ref NI_19 NS_53 0 2.8555714850460256e-05
GC_19_54 ref NI_19 NS_54 0 7.8686346172699203e-03
GC_19_55 ref NI_19 NS_55 0 -5.1761807504066892e-01
GC_19_56 ref NI_19 NS_56 0 4.4756913180520225e-01
GC_19_57 ref NI_19 NS_57 0 -5.8443418824819715e-01
GC_19_58 ref NI_19 NS_58 0 3.0942179000191705e-01
GC_19_59 ref NI_19 NS_59 0 -4.8905592034382768e-05
GC_19_60 ref NI_19 NS_60 0 5.2059678796756497e-03
GC_19_61 ref NI_19 NS_61 0 -1.4868066433380656e-01
GC_19_62 ref NI_19 NS_62 0 2.3065849120075191e-01
GC_19_63 ref NI_19 NS_63 0 4.0139845936642055e-01
GC_19_64 ref NI_19 NS_64 0 -1.1879736571941027e-01
GC_19_65 ref NI_19 NS_65 0 -1.6880740016883398e-05
GC_19_66 ref NI_19 NS_66 0 -1.4900255516062246e-02
GC_19_67 ref NI_19 NS_67 0 -3.2713942723469741e-01
GC_19_68 ref NI_19 NS_68 0 1.9662071751724508e-01
GC_19_69 ref NI_19 NS_69 0 -2.8120576517372753e-01
GC_19_70 ref NI_19 NS_70 0 2.0108306189481326e-01
GC_19_71 ref NI_19 NS_71 0 7.1022763771623008e-06
GC_19_72 ref NI_19 NS_72 0 1.0456261497651113e-02
GC_19_73 ref NI_19 NS_73 0 -1.7585189466765264e-01
GC_19_74 ref NI_19 NS_74 0 -6.0203569948158606e-02
GC_19_75 ref NI_19 NS_75 0 4.6516927733970585e-02
GC_19_76 ref NI_19 NS_76 0 1.1272490167447506e-01
GC_19_77 ref NI_19 NS_77 0 8.9243381792968774e-06
GC_19_78 ref NI_19 NS_78 0 4.0161149340071801e-03
GC_19_79 ref NI_19 NS_79 0 -5.1499739631186925e-02
GC_19_80 ref NI_19 NS_80 0 1.8395120586279472e+00
GC_19_81 ref NI_19 NS_81 0 1.7414886746290409e-01
GC_19_82 ref NI_19 NS_82 0 -4.6515034099607278e-01
GC_19_83 ref NI_19 NS_83 0 -3.4633736643834858e-04
GC_19_84 ref NI_19 NS_84 0 -2.1533763637687102e-02
GC_19_85 ref NI_19 NS_85 0 -1.7950399203986764e-01
GC_19_86 ref NI_19 NS_86 0 2.8771044402200921e-02
GC_19_87 ref NI_19 NS_87 0 -1.1088612144220548e-01
GC_19_88 ref NI_19 NS_88 0 1.4735263217577249e-01
GC_19_89 ref NI_19 NS_89 0 3.1694665501886053e-05
GC_19_90 ref NI_19 NS_90 0 1.2895283897943376e-02
GC_19_91 ref NI_19 NS_91 0 -3.1903988713718862e-01
GC_19_92 ref NI_19 NS_92 0 1.4224104679844474e-01
GC_19_93 ref NI_19 NS_93 0 -2.2163517898179327e-01
GC_19_94 ref NI_19 NS_94 0 2.2289236582879174e-01
GC_19_95 ref NI_19 NS_95 0 -1.4840683932024027e-05
GC_19_96 ref NI_19 NS_96 0 -4.9582719678100406e-03
GC_19_97 ref NI_19 NS_97 0 2.7130808428096498e-01
GC_19_98 ref NI_19 NS_98 0 -5.3164594313420832e-01
GC_19_99 ref NI_19 NS_99 0 5.9425077864143139e-01
GC_19_100 ref NI_19 NS_100 0 4.0312534257680915e-02
GC_19_101 ref NI_19 NS_101 0 3.3793393223981466e-05
GC_19_102 ref NI_19 NS_102 0 -3.3465382788534712e-02
GC_19_103 ref NI_19 NS_103 0 2.4451924632446229e-01
GC_19_104 ref NI_19 NS_104 0 1.7216789752021113e+00
GC_19_105 ref NI_19 NS_105 0 2.3455088108888020e-01
GC_19_106 ref NI_19 NS_106 0 -4.1100031779197815e-01
GC_19_107 ref NI_19 NS_107 0 -1.0722912391613924e-04
GC_19_108 ref NI_19 NS_108 0 -4.9960346889858238e-02
GC_19_109 ref NI_19 NS_109 0 3.1702338855928898e+00
GC_19_110 ref NI_19 NS_110 0 -4.2754778228593944e+00
GC_19_111 ref NI_19 NS_111 0 -1.6753882621128011e+00
GC_19_112 ref NI_19 NS_112 0 -4.4622263368822163e-01
GC_19_113 ref NI_19 NS_113 0 -6.6173829487171649e-04
GC_19_114 ref NI_19 NS_114 0 -6.3097989206127039e-02
GC_19_115 ref NI_19 NS_115 0 5.3631345045454115e-01
GC_19_116 ref NI_19 NS_116 0 -7.7385988060276878e-01
GC_19_117 ref NI_19 NS_117 0 1.3807006177265557e+00
GC_19_118 ref NI_19 NS_118 0 -2.5198228263617967e-01
GC_19_119 ref NI_19 NS_119 0 -6.3218079140805336e-05
GC_19_120 ref NI_19 NS_120 0 -5.4841813640453395e-02
GC_19_121 ref NI_19 NS_121 0 -5.6581047630990212e-03
GC_19_122 ref NI_19 NS_122 0 -8.5075944510977150e-02
GC_19_123 ref NI_19 NS_123 0 5.1406467965730007e-01
GC_19_124 ref NI_19 NS_124 0 -5.6031409000716695e-02
GC_19_125 ref NI_19 NS_125 0 4.9653806026729560e-05
GC_19_126 ref NI_19 NS_126 0 -2.7777970485270340e-02
GC_19_127 ref NI_19 NS_127 0 -2.7742248391749053e-01
GC_19_128 ref NI_19 NS_128 0 9.2830795460526250e-02
GC_19_129 ref NI_19 NS_129 0 -1.7267468680419296e-01
GC_19_130 ref NI_19 NS_130 0 2.0288355793398480e-01
GC_19_131 ref NI_19 NS_131 0 1.4152562950390217e-05
GC_19_132 ref NI_19 NS_132 0 -2.2682515282999812e-03
GC_19_133 ref NI_19 NS_133 0 -4.5472488422323415e-01
GC_19_134 ref NI_19 NS_134 0 3.7749666054006886e-01
GC_19_135 ref NI_19 NS_135 0 -5.0601781692643288e-01
GC_19_136 ref NI_19 NS_136 0 2.7938431358428867e-01
GC_19_137 ref NI_19 NS_137 0 -4.6856966876176792e-05
GC_19_138 ref NI_19 NS_138 0 7.7860792943481383e-03
GD_19_1 ref NI_19 NA_1 0 4.5174813533013794e-02
GD_19_2 ref NI_19 NA_2 0 4.3132014646401463e-02
GD_19_3 ref NI_19 NA_3 0 2.9529317680593865e-02
GD_19_4 ref NI_19 NA_4 0 4.4317602641461125e-02
GD_19_5 ref NI_19 NA_5 0 4.3201313950942996e-02
GD_19_6 ref NI_19 NA_6 0 4.1640565374859342e-02
GD_19_7 ref NI_19 NA_7 0 4.0174910803080187e-02
GD_19_8 ref NI_19 NA_8 0 6.1218605747786814e-02
GD_19_9 ref NI_19 NA_9 0 3.0693503746006729e-02
GD_19_10 ref NI_19 NA_10 0 9.5482971277865522e-02
GD_19_11 ref NI_19 NA_11 0 3.7246725788008375e-02
GD_19_12 ref NI_19 NA_12 0 6.4412958406274201e-02
GD_19_13 ref NI_19 NA_13 0 4.5934473380228567e-02
GD_19_14 ref NI_19 NA_14 0 -5.0742007440451313e-02
GD_19_15 ref NI_19 NA_15 0 4.0922853421658675e-02
GD_19_16 ref NI_19 NA_16 0 7.2679963689454702e-02
GD_19_17 ref NI_19 NA_17 0 -1.9837049148323176e-02
GD_19_18 ref NI_19 NA_18 0 -7.5020019762362139e-02
GD_19_19 ref NI_19 NA_19 0 5.6037088112792910e+00
GD_19_20 ref NI_19 NA_20 0 -8.3126753431886011e-02
GD_19_21 ref NI_19 NA_21 0 2.0844090969020620e-02
GD_19_22 ref NI_19 NA_22 0 6.5634333000833753e-02
GD_19_23 ref NI_19 NA_23 0 8.4498873401470304e-02
*
* Port 20
VI_20 a_20 NI_20 0
RI_20 NI_20 ref 1.0000000000000001e-01
GC_20_1 ref NI_20 NS_1 0 -2.4100864812124406e-01
GC_20_2 ref NI_20 NS_2 0 1.1658549013891062e-01
GC_20_3 ref NI_20 NS_3 0 -1.3818434594349963e-01
GC_20_4 ref NI_20 NS_4 0 5.9471642872027747e-02
GC_20_5 ref NI_20 NS_5 0 1.3711391774097104e-04
GC_20_6 ref NI_20 NS_6 0 4.1708122990769529e-02
GC_20_7 ref NI_20 NS_7 0 -1.5567517452819851e-01
GC_20_8 ref NI_20 NS_8 0 5.8454275541659065e-02
GC_20_9 ref NI_20 NS_9 0 -8.5140652899250185e-02
GC_20_10 ref NI_20 NS_10 0 8.0843242785318570e-02
GC_20_11 ref NI_20 NS_11 0 5.5978043963535996e-05
GC_20_12 ref NI_20 NS_12 0 2.7464712060927109e-02
GC_20_13 ref NI_20 NS_13 0 -2.2806636118337048e-01
GC_20_14 ref NI_20 NS_14 0 1.3881785925506906e-01
GC_20_15 ref NI_20 NS_15 0 -1.5206753930719599e-01
GC_20_16 ref NI_20 NS_16 0 5.0967120888923662e-02
GC_20_17 ref NI_20 NS_17 0 1.1333874876750695e-04
GC_20_18 ref NI_20 NS_18 0 4.5201899545862879e-02
GC_20_19 ref NI_20 NS_19 0 -2.9241587956551723e-01
GC_20_20 ref NI_20 NS_20 0 2.0087801214132370e-01
GC_20_21 ref NI_20 NS_21 0 -1.6285911615381160e-01
GC_20_22 ref NI_20 NS_22 0 -2.0622579296482851e-02
GC_20_23 ref NI_20 NS_23 0 2.0296003080625866e-04
GC_20_24 ref NI_20 NS_24 0 6.7185166932875573e-02
GC_20_25 ref NI_20 NS_25 0 -2.9932336791596825e-01
GC_20_26 ref NI_20 NS_26 0 2.0719992450716526e-01
GC_20_27 ref NI_20 NS_27 0 -1.5797162762486838e-01
GC_20_28 ref NI_20 NS_28 0 -3.1081399976185212e-02
GC_20_29 ref NI_20 NS_29 0 1.9391236190806029e-04
GC_20_30 ref NI_20 NS_30 0 6.9566131493551495e-02
GC_20_31 ref NI_20 NS_31 0 -3.0893302151807472e-01
GC_20_32 ref NI_20 NS_32 0 2.1856863663777282e-01
GC_20_33 ref NI_20 NS_33 0 -1.6895018740799120e-01
GC_20_34 ref NI_20 NS_34 0 -2.7185763129056923e-02
GC_20_35 ref NI_20 NS_35 0 1.9763446431230632e-04
GC_20_36 ref NI_20 NS_36 0 6.9229392835896020e-02
GC_20_37 ref NI_20 NS_37 0 -2.9247368774657090e-01
GC_20_38 ref NI_20 NS_38 0 2.0861985644027808e-01
GC_20_39 ref NI_20 NS_39 0 -1.8115579484713656e-01
GC_20_40 ref NI_20 NS_40 0 -5.6567601861058350e-03
GC_20_41 ref NI_20 NS_41 0 1.7909425833502387e-04
GC_20_42 ref NI_20 NS_42 0 6.4576251065483523e-02
GC_20_43 ref NI_20 NS_43 0 1.2045776509857528e-01
GC_20_44 ref NI_20 NS_44 0 -3.0530042316980111e-01
GC_20_45 ref NI_20 NS_45 0 1.9512579444033099e-01
GC_20_46 ref NI_20 NS_46 0 1.1809311706597024e-01
GC_20_47 ref NI_20 NS_47 0 4.7152841338279459e-05
GC_20_48 ref NI_20 NS_48 0 -6.5713986606689041e-03
GC_20_49 ref NI_20 NS_49 0 -2.3540757739380097e-01
GC_20_50 ref NI_20 NS_50 0 1.7582226511222177e-01
GC_20_51 ref NI_20 NS_51 0 -3.1527272830733583e-01
GC_20_52 ref NI_20 NS_52 0 2.1010293419468556e-01
GC_20_53 ref NI_20 NS_53 0 -1.5477264626650899e-06
GC_20_54 ref NI_20 NS_54 0 1.3923885412286991e-02
GC_20_55 ref NI_20 NS_55 0 -4.4824331059457606e-01
GC_20_56 ref NI_20 NS_56 0 2.7265245091126789e-01
GC_20_57 ref NI_20 NS_57 0 -3.7445470487764215e-01
GC_20_58 ref NI_20 NS_58 0 2.7949201350672281e-01
GC_20_59 ref NI_20 NS_59 0 -4.7988327858642791e-05
GC_20_60 ref NI_20 NS_60 0 -7.2428546142740031e-03
GC_20_61 ref NI_20 NS_61 0 1.7351249474474661e-01
GC_20_62 ref NI_20 NS_62 0 -4.1902150668874222e-01
GC_20_63 ref NI_20 NS_63 0 4.7917554316799771e-01
GC_20_64 ref NI_20 NS_64 0 4.1276987626080286e-02
GC_20_65 ref NI_20 NS_65 0 1.3184186244596860e-05
GC_20_66 ref NI_20 NS_66 0 -2.2120378376006073e-02
GC_20_67 ref NI_20 NS_67 0 -4.5033374434756607e-01
GC_20_68 ref NI_20 NS_68 0 3.8818602346641878e-01
GC_20_69 ref NI_20 NS_69 0 -5.1260468592123098e-01
GC_20_70 ref NI_20 NS_70 0 2.6944864504845184e-01
GC_20_71 ref NI_20 NS_71 0 -4.5882045325306529e-05
GC_20_72 ref NI_20 NS_72 0 1.1465817068495084e-02
GC_20_73 ref NI_20 NS_73 0 -2.2956886750385216e-01
GC_20_74 ref NI_20 NS_74 0 1.0757495465306717e-01
GC_20_75 ref NI_20 NS_75 0 -2.2945523064168236e-01
GC_20_76 ref NI_20 NS_76 0 2.1057213825159224e-01
GC_20_77 ref NI_20 NS_77 0 -2.9813058418049736e-05
GC_20_78 ref NI_20 NS_78 0 4.0853041026287723e-03
GC_20_79 ref NI_20 NS_79 0 6.1335247867497211e-01
GC_20_80 ref NI_20 NS_80 0 -8.3661513781961538e-01
GC_20_81 ref NI_20 NS_81 0 8.0154371516574963e-01
GC_20_82 ref NI_20 NS_82 0 5.1451827550304328e-04
GC_20_83 ref NI_20 NS_83 0 -4.9407776649051274e-05
GC_20_84 ref NI_20 NS_84 0 -3.0494437857094988e-02
GC_20_85 ref NI_20 NS_85 0 -4.8393324082754774e-01
GC_20_86 ref NI_20 NS_86 0 4.4267134813850584e-01
GC_20_87 ref NI_20 NS_87 0 -5.3523163922187500e-01
GC_20_88 ref NI_20 NS_88 0 2.3974387335879796e-01
GC_20_89 ref NI_20 NS_89 0 -3.9328243101263851e-05
GC_20_90 ref NI_20 NS_90 0 2.2055585601526193e-02
GC_20_91 ref NI_20 NS_91 0 -3.8326594342820758e-01
GC_20_92 ref NI_20 NS_92 0 1.4566792983922247e-01
GC_20_93 ref NI_20 NS_93 0 2.8456636487623799e-02
GC_20_94 ref NI_20 NS_94 0 1.2788879123127070e-01
GC_20_95 ref NI_20 NS_95 0 1.9915959448796621e-05
GC_20_96 ref NI_20 NS_96 0 -1.9246143679345865e-02
GC_20_97 ref NI_20 NS_97 0 -1.0203616307538724e-01
GC_20_98 ref NI_20 NS_98 0 3.8385130593890193e-01
GC_20_99 ref NI_20 NS_99 0 8.7460614171181195e-01
GC_20_100 ref NI_20 NS_100 0 -3.0932225452374212e-01
GC_20_101 ref NI_20 NS_101 0 4.1220475515003812e-05
GC_20_102 ref NI_20 NS_102 0 -5.5553880299155117e-02
GC_20_103 ref NI_20 NS_103 0 4.9397174956514994e-01
GC_20_104 ref NI_20 NS_104 0 9.5048897253053333e-01
GC_20_105 ref NI_20 NS_105 0 1.0448851664071848e+00
GC_20_106 ref NI_20 NS_106 0 -5.4360361616429786e-01
GC_20_107 ref NI_20 NS_107 0 -2.4859266988160473e-04
GC_20_108 ref NI_20 NS_108 0 -7.2065201961357794e-02
GC_20_109 ref NI_20 NS_109 0 5.3631345045454093e-01
GC_20_110 ref NI_20 NS_110 0 -7.7385988060276767e-01
GC_20_111 ref NI_20 NS_111 0 1.3807006177265539e+00
GC_20_112 ref NI_20 NS_112 0 -2.5198228263617883e-01
GC_20_113 ref NI_20 NS_113 0 -6.3218079140749567e-05
GC_20_114 ref NI_20 NS_114 0 -5.4841813640453638e-02
GC_20_115 ref NI_20 NS_115 0 2.9985298464504226e+00
GC_20_116 ref NI_20 NS_116 0 -1.8728712886759853e+00
GC_20_117 ref NI_20 NS_117 0 -2.1681081103615729e+00
GC_20_118 ref NI_20 NS_118 0 -7.8329502714144006e-01
GC_20_119 ref NI_20 NS_119 0 -6.6541705647169252e-04
GC_20_120 ref NI_20 NS_120 0 -1.1255548096805973e-01
GC_20_121 ref NI_20 NS_121 0 2.0151303588418986e-02
GC_20_122 ref NI_20 NS_122 0 -1.4583815339179187e-01
GC_20_123 ref NI_20 NS_123 0 8.5862280716516681e-01
GC_20_124 ref NI_20 NS_124 0 -1.7824294773203542e-01
GC_20_125 ref NI_20 NS_125 0 7.2045300997220914e-05
GC_20_126 ref NI_20 NS_126 0 -4.4217931443639849e-02
GC_20_127 ref NI_20 NS_127 0 -2.9509463656929125e-01
GC_20_128 ref NI_20 NS_128 0 5.7520645797128943e-03
GC_20_129 ref NI_20 NS_129 0 -1.7991788011872088e-02
GC_20_130 ref NI_20 NS_130 0 1.7273875410878911e-01
GC_20_131 ref NI_20 NS_131 0 2.0667653333533321e-05
GC_20_132 ref NI_20 NS_132 0 -1.2092393911759973e-02
GC_20_133 ref NI_20 NS_133 0 -4.4803513255461891e-01
GC_20_134 ref NI_20 NS_134 0 3.3893023009324058e-01
GC_20_135 ref NI_20 NS_135 0 -4.7862133241061877e-01
GC_20_136 ref NI_20 NS_136 0 2.9530585589167935e-01
GC_20_137 ref NI_20 NS_137 0 -6.4464579758383985e-05
GC_20_138 ref NI_20 NS_138 0 3.6546749985887067e-04
GD_20_1 ref NI_20 NA_1 0 4.8723166017612431e-02
GD_20_2 ref NI_20 NA_2 0 4.4216380779000246e-02
GD_20_3 ref NI_20 NA_3 0 4.5935572097557678e-02
GD_20_4 ref NI_20 NA_4 0 5.7584430204278766e-02
GD_20_5 ref NI_20 NA_5 0 5.8235671453367333e-02
GD_20_6 ref NI_20 NA_6 0 5.9350113253808096e-02
GD_20_7 ref NI_20 NA_7 0 5.6639330375089107e-02
GD_20_8 ref NI_20 NA_8 0 4.7891796702107655e-03
GD_20_9 ref NI_20 NA_9 0 5.0699508953413769e-02
GD_20_10 ref NI_20 NA_10 0 9.0891272810375429e-02
GD_20_11 ref NI_20 NA_11 0 -3.9489990179700507e-03
GD_20_12 ref NI_20 NA_12 0 8.3489305577234441e-02
GD_20_13 ref NI_20 NA_13 0 5.4091130572615477e-02
GD_20_14 ref NI_20 NA_14 0 -7.6936428961764419e-02
GD_20_15 ref NI_20 NA_15 0 8.4843834254046485e-02
GD_20_16 ref NI_20 NA_16 0 8.9024782644855277e-02
GD_20_17 ref NI_20 NA_17 0 1.8634301802272404e-02
GD_20_18 ref NI_20 NA_18 0 -1.4493857816713096e-01
GD_20_19 ref NI_20 NA_19 0 -8.3126753431886011e-02
GD_20_20 ref NI_20 NA_20 0 5.5807572907780587e+00
GD_20_21 ref NI_20 NA_21 0 1.6687784173836238e-02
GD_20_22 ref NI_20 NA_22 0 7.5254636150351883e-02
GD_20_23 ref NI_20 NA_23 0 8.6742346757055916e-02
*
* Port 21
VI_21 a_21 NI_21 0
RI_21 NI_21 ref 1.0000000000000001e-01
GC_21_1 ref NI_21 NS_1 0 -2.7130070015540569e-01
GC_21_2 ref NI_21 NS_2 0 1.1766696109763139e-01
GC_21_3 ref NI_21 NS_3 0 -5.2255745903259029e-02
GC_21_4 ref NI_21 NS_4 0 4.8731961432122127e-02
GC_21_5 ref NI_21 NS_5 0 1.2973968409609726e-04
GC_21_6 ref NI_21 NS_6 0 3.0437395145976518e-02
GC_21_7 ref NI_21 NS_7 0 -1.0924691784930884e-01
GC_21_8 ref NI_21 NS_8 0 9.1131772870259753e-02
GC_21_9 ref NI_21 NS_9 0 -6.3650908843639799e-03
GC_21_10 ref NI_21 NS_10 0 4.5370379331733081e-02
GC_21_11 ref NI_21 NS_11 0 6.0928152918005329e-05
GC_21_12 ref NI_21 NS_12 0 1.9789479605078139e-02
GC_21_13 ref NI_21 NS_13 0 -1.4819480619266551e-01
GC_21_14 ref NI_21 NS_14 0 1.0143799480907377e-01
GC_21_15 ref NI_21 NS_15 0 -7.1420593164370230e-02
GC_21_16 ref NI_21 NS_16 0 4.8704480436739084e-02
GC_21_17 ref NI_21 NS_17 0 9.9166828288178082e-05
GC_21_18 ref NI_21 NS_18 0 3.2825427348997550e-02
GC_21_19 ref NI_21 NS_19 0 -2.4576937034615121e-01
GC_21_20 ref NI_21 NS_20 0 1.2923061555280604e-01
GC_21_21 ref NI_21 NS_21 0 -1.4915929736631081e-01
GC_21_22 ref NI_21 NS_22 0 3.8316288690573734e-02
GC_21_23 ref NI_21 NS_23 0 2.0099926936383456e-04
GC_21_24 ref NI_21 NS_24 0 4.9933756523238053e-02
GC_21_25 ref NI_21 NS_25 0 -2.4763427856419376e-01
GC_21_26 ref NI_21 NS_26 0 1.4600241342622086e-01
GC_21_27 ref NI_21 NS_27 0 -1.6478374037408050e-01
GC_21_28 ref NI_21 NS_28 0 3.6676633981741182e-02
GC_21_29 ref NI_21 NS_29 0 1.9223035762851439e-04
GC_21_30 ref NI_21 NS_30 0 5.1752919400152031e-02
GC_21_31 ref NI_21 NS_31 0 -2.4910639520860292e-01
GC_21_32 ref NI_21 NS_32 0 1.5182847527897575e-01
GC_21_33 ref NI_21 NS_33 0 -1.7305120757632131e-01
GC_21_34 ref NI_21 NS_34 0 4.0655788555881853e-02
GC_21_35 ref NI_21 NS_35 0 2.0074457113289333e-04
GC_21_36 ref NI_21 NS_36 0 5.1263532861280561e-02
GC_21_37 ref NI_21 NS_37 0 -2.3336021066638038e-01
GC_21_38 ref NI_21 NS_38 0 1.2062801039830236e-01
GC_21_39 ref NI_21 NS_39 0 -1.4504823026163874e-01
GC_21_40 ref NI_21 NS_40 0 4.4895572264395958e-02
GC_21_41 ref NI_21 NS_41 0 1.8120474754823628e-04
GC_21_42 ref NI_21 NS_42 0 4.7631186886656379e-02
GC_21_43 ref NI_21 NS_43 0 -2.8605774526610145e-01
GC_21_44 ref NI_21 NS_44 0 1.2679488512372269e-01
GC_21_45 ref NI_21 NS_45 0 2.2608495131844750e-01
GC_21_46 ref NI_21 NS_46 0 -1.5433881858647301e-02
GC_21_47 ref NI_21 NS_47 0 -1.7141321520478960e-05
GC_21_48 ref NI_21 NS_48 0 -1.2338763770782728e-03
GC_21_49 ref NI_21 NS_49 0 -1.1221762058592177e-01
GC_21_50 ref NI_21 NS_50 0 -5.3573732958414236e-02
GC_21_51 ref NI_21 NS_51 0 1.0710816900544753e-01
GC_21_52 ref NI_21 NS_52 0 7.0201422610352948e-02
GC_21_53 ref NI_21 NS_53 0 -1.6151314557692324e-05
GC_21_54 ref NI_21 NS_54 0 6.8191304402380011e-03
GC_21_55 ref NI_21 NS_55 0 -6.3321713060241716e-02
GC_21_56 ref NI_21 NS_56 0 -2.8348313054414931e-01
GC_21_57 ref NI_21 NS_57 0 3.1890369698661741e-01
GC_21_58 ref NI_21 NS_58 0 9.0580658555037788e-02
GC_21_59 ref NI_21 NS_59 0 -2.3785450771616350e-05
GC_21_60 ref NI_21 NS_60 0 -1.8155652860244186e-02
GC_21_61 ref NI_21 NS_61 0 5.5408713858412950e-02
GC_21_62 ref NI_21 NS_62 0 1.3848565328667017e+00
GC_21_63 ref NI_21 NS_63 0 -3.4058553334180891e-01
GC_21_64 ref NI_21 NS_64 0 -8.4469042282669327e-02
GC_21_65 ref NI_21 NS_65 0 -1.9558587742511384e-04
GC_21_66 ref NI_21 NS_66 0 -1.3988321966393352e-02
GC_21_67 ref NI_21 NS_67 0 -2.1591121195195344e-02
GC_21_68 ref NI_21 NS_68 0 -1.1267388192194754e-01
GC_21_69 ref NI_21 NS_69 0 6.2094077659451297e-02
GC_21_70 ref NI_21 NS_70 0 1.2912581261512499e-01
GC_21_71 ref NI_21 NS_71 0 -4.4872642675587112e-05
GC_21_72 ref NI_21 NS_72 0 -1.6815635879451328e-03
GC_21_73 ref NI_21 NS_73 0 -1.9966053204539586e-01
GC_21_74 ref NI_21 NS_74 0 2.2517102077448248e-01
GC_21_75 ref NI_21 NS_75 0 6.5630930559689493e-02
GC_21_76 ref NI_21 NS_76 0 3.4157338161594566e-02
GC_21_77 ref NI_21 NS_77 0 -7.6317247199757335e-05
GC_21_78 ref NI_21 NS_78 0 -1.6779492146914783e-03
GC_21_79 ref NI_21 NS_79 0 3.1743172961963759e-02
GC_21_80 ref NI_21 NS_80 0 -3.0673855922958659e-01
GC_21_81 ref NI_21 NS_81 0 4.5628665432185062e-01
GC_21_82 ref NI_21 NS_82 0 2.0810804296761565e-03
GC_21_83 ref NI_21 NS_83 0 1.6244890328154879e-05
GC_21_84 ref NI_21 NS_84 0 -1.2542043801456574e-02
GC_21_85 ref NI_21 NS_85 0 -7.2939689634133775e-02
GC_21_86 ref NI_21 NS_86 0 -2.5091100618763497e-02
GC_21_87 ref NI_21 NS_87 0 -5.5408355063636276e-02
GC_21_88 ref NI_21 NS_88 0 1.4301641580475685e-01
GC_21_89 ref NI_21 NS_89 0 -1.5120508689847575e-05
GC_21_90 ref NI_21 NS_90 0 7.7863423907115299e-03
GC_21_91 ref NI_21 NS_91 0 -2.7548079245385437e-01
GC_21_92 ref NI_21 NS_92 0 4.9380150034678666e-01
GC_21_93 ref NI_21 NS_93 0 1.2123400847844396e-01
GC_21_94 ref NI_21 NS_94 0 -2.8462404879771856e-02
GC_21_95 ref NI_21 NS_95 0 1.1843274152220101e-05
GC_21_96 ref NI_21 NS_96 0 -2.0829922586333746e-02
GC_21_97 ref NI_21 NS_97 0 -1.4285643159998865e-01
GC_21_98 ref NI_21 NS_98 0 1.5474039315645141e+00
GC_21_99 ref NI_21 NS_99 0 8.7850568475960358e-02
GC_21_100 ref NI_21 NS_100 0 -2.8775289593272912e-01
GC_21_101 ref NI_21 NS_101 0 -2.1542926060559274e-04
GC_21_102 ref NI_21 NS_102 0 -3.4552134169570772e-02
GC_21_103 ref NI_21 NS_103 0 -2.0319962801899509e-02
GC_21_104 ref NI_21 NS_104 0 2.3883883625839480e-01
GC_21_105 ref NI_21 NS_105 0 4.8213783404095617e-01
GC_21_106 ref NI_21 NS_106 0 -1.1217574519208472e-01
GC_21_107 ref NI_21 NS_107 0 4.8201670518520523e-05
GC_21_108 ref NI_21 NS_108 0 -3.8006455885020149e-02
GC_21_109 ref NI_21 NS_109 0 -5.6581047630989492e-03
GC_21_110 ref NI_21 NS_110 0 -8.5075944510977441e-02
GC_21_111 ref NI_21 NS_111 0 5.1406467965730041e-01
GC_21_112 ref NI_21 NS_112 0 -5.6031409000716896e-02
GC_21_113 ref NI_21 NS_113 0 4.9653806026716671e-05
GC_21_114 ref NI_21 NS_114 0 -2.7777970485270278e-02
GC_21_115 ref NI_21 NS_115 0 2.0151303588418872e-02
GC_21_116 ref NI_21 NS_116 0 -1.4583815339179140e-01
GC_21_117 ref NI_21 NS_117 0 8.5862280716516615e-01
GC_21_118 ref NI_21 NS_118 0 -1.7824294773203503e-01
GC_21_119 ref NI_21 NS_119 0 7.2045300997243737e-05
GC_21_120 ref NI_21 NS_120 0 -4.4217931443639946e-02
GC_21_121 ref NI_21 NS_121 0 3.0587262241622688e+00
GC_21_122 ref NI_21 NS_122 0 -4.2357722518773446e+00
GC_21_123 ref NI_21 NS_123 0 -2.3778906051345761e+00
GC_21_124 ref NI_21 NS_124 0 -1.0359272882378515e-01
GC_21_125 ref NI_21 NS_125 0 -5.7619481394336532e-04
GC_21_126 ref NI_21 NS_126 0 -5.5689130573604306e-02
GC_21_127 ref NI_21 NS_127 0 -3.8403624941229364e-01
GC_21_128 ref NI_21 NS_128 0 6.3394764067308340e-01
GC_21_129 ref NI_21 NS_129 0 1.0375104368292037e-02
GC_21_130 ref NI_21 NS_130 0 -1.9836447835691710e-02
GC_21_131 ref NI_21 NS_131 0 -4.1711832980648024e-06
GC_21_132 ref NI_21 NS_132 0 -1.5706896174935852e-02
GC_21_133 ref NI_21 NS_133 0 1.1159407840078442e-02
GC_21_134 ref NI_21 NS_134 0 -2.5916526497704084e-01
GC_21_135 ref NI_21 NS_135 0 2.1754529609276974e-01
GC_21_136 ref NI_21 NS_136 0 1.1754123506931194e-01
GC_21_137 ref NI_21 NS_137 0 -4.9794504390933058e-05
GC_21_138 ref NI_21 NS_138 0 -1.2256191533224938e-02
GD_21_1 ref NI_21 NA_1 0 4.1125165840779479e-02
GD_21_2 ref NI_21 NA_2 0 4.2025253040731764e-02
GD_21_3 ref NI_21 NA_3 0 3.2702930541577947e-02
GD_21_4 ref NI_21 NA_4 0 5.1008575663296647e-02
GD_21_5 ref NI_21 NA_5 0 5.0974310252795078e-02
GD_21_6 ref NI_21 NA_6 0 5.0872537367087259e-02
GD_21_7 ref NI_21 NA_7 0 4.7516813669487186e-02
GD_21_8 ref NI_21 NA_8 0 4.5937647981590578e-02
GD_21_9 ref NI_21 NA_9 0 2.6828135929833841e-02
GD_21_10 ref NI_21 NA_10 0 2.9012844355829112e-02
GD_21_11 ref NI_21 NA_11 0 -3.8976400995197197e-02
GD_21_12 ref NI_21 NA_12 0 1.7240089275051565e-02
GD_21_13 ref NI_21 NA_13 0 3.6131627444514862e-02
GD_21_14 ref NI_21 NA_14 0 1.6379199240679015e-02
GD_21_15 ref NI_21 NA_15 0 2.2070692146944081e-02
GD_21_16 ref NI_21 NA_16 0 5.6175418949509406e-02
GD_21_17 ref NI_21 NA_17 0 -3.4834970961015503e-02
GD_21_18 ref NI_21 NA_18 0 2.1752031463275402e-02
GD_21_19 ref NI_21 NA_19 0 2.0844090969020620e-02
GD_21_20 ref NI_21 NA_20 0 1.6687784173836238e-02
GD_21_21 ref NI_21 NA_21 0 5.6437480784599794e+00
GD_21_22 ref NI_21 NA_22 0 7.3236462764819141e-02
GD_21_23 ref NI_21 NA_23 0 1.5748495729154755e-02
*
* Port 22
VI_22 a_22 NI_22 0
RI_22 NI_22 ref 1.0000000000000001e-01
GC_22_1 ref NI_22 NS_1 0 -2.7788959523966794e-01
GC_22_2 ref NI_22 NS_2 0 1.4598328769697003e-01
GC_22_3 ref NI_22 NS_3 0 -6.8049162264507607e-02
GC_22_4 ref NI_22 NS_4 0 6.1116702917712533e-02
GC_22_5 ref NI_22 NS_5 0 1.5441795604818879e-04
GC_22_6 ref NI_22 NS_6 0 2.6092998627833534e-02
GC_22_7 ref NI_22 NS_7 0 -9.0097765333876950e-02
GC_22_8 ref NI_22 NS_8 0 1.0647374900338154e-01
GC_22_9 ref NI_22 NS_9 0 -1.9730478324304471e-02
GC_22_10 ref NI_22 NS_10 0 5.4081999794318970e-02
GC_22_11 ref NI_22 NS_11 0 9.3914290273051590e-05
GC_22_12 ref NI_22 NS_12 0 1.6728503145072540e-02
GC_22_13 ref NI_22 NS_13 0 -1.2307195692529208e-01
GC_22_14 ref NI_22 NS_14 0 1.1407349886045966e-01
GC_22_15 ref NI_22 NS_15 0 -7.7631243920408557e-02
GC_22_16 ref NI_22 NS_16 0 5.8658801644169728e-02
GC_22_17 ref NI_22 NS_17 0 1.1939921300204557e-04
GC_22_18 ref NI_22 NS_18 0 2.8073958875494638e-02
GC_22_19 ref NI_22 NS_19 0 -2.8469487893214185e-01
GC_22_20 ref NI_22 NS_20 0 1.5305011823865458e-01
GC_22_21 ref NI_22 NS_21 0 -1.7684199986784596e-01
GC_22_22 ref NI_22 NS_22 0 6.3492224267552536e-02
GC_22_23 ref NI_22 NS_23 0 2.1556821577149217e-04
GC_22_24 ref NI_22 NS_24 0 4.4280697477141077e-02
GC_22_25 ref NI_22 NS_25 0 -2.8533483410865357e-01
GC_22_26 ref NI_22 NS_26 0 1.7078782424939998e-01
GC_22_27 ref NI_22 NS_27 0 -1.9623670580495334e-01
GC_22_28 ref NI_22 NS_28 0 6.3819911634704490e-02
GC_22_29 ref NI_22 NS_29 0 2.0809179242917318e-04
GC_22_30 ref NI_22 NS_30 0 4.5950697008816106e-02
GC_22_31 ref NI_22 NS_31 0 -2.8550128007575193e-01
GC_22_32 ref NI_22 NS_32 0 1.7535126367567522e-01
GC_22_33 ref NI_22 NS_33 0 -2.0388508411537809e-01
GC_22_34 ref NI_22 NS_34 0 6.7912333720942950e-02
GC_22_35 ref NI_22 NS_35 0 2.1803765235154073e-04
GC_22_36 ref NI_22 NS_36 0 4.5397334153378224e-02
GC_22_37 ref NI_22 NS_37 0 -2.6872145194029756e-01
GC_22_38 ref NI_22 NS_38 0 1.4127414120547510e-01
GC_22_39 ref NI_22 NS_39 0 -1.6778737139072211e-01
GC_22_40 ref NI_22 NS_40 0 6.8281022083037352e-02
GC_22_41 ref NI_22 NS_41 0 1.9898045416201284e-04
GC_22_42 ref NI_22 NS_42 0 4.1941011612658910e-02
GC_22_43 ref NI_22 NS_43 0 -2.0269937110815051e-01
GC_22_44 ref NI_22 NS_44 0 4.3946949587380810e-02
GC_22_45 ref NI_22 NS_45 0 8.4041241057693089e-02
GC_22_46 ref NI_22 NS_46 0 6.8410470923666547e-02
GC_22_47 ref NI_22 NS_47 0 1.8391775111928533e-05
GC_22_48 ref NI_22 NS_48 0 2.3143995815752701e-03
GC_22_49 ref NI_22 NS_49 0 -5.3413632689881342e-02
GC_22_50 ref NI_22 NS_50 0 -1.2315034114684205e-01
GC_22_51 ref NI_22 NS_51 0 2.8355994118448907e-01
GC_22_52 ref NI_22 NS_52 0 1.1643339537188177e-02
GC_22_53 ref NI_22 NS_53 0 -2.7010709903307831e-05
GC_22_54 ref NI_22 NS_54 0 1.0699440907245368e-03
GC_22_55 ref NI_22 NS_55 0 -2.1110514487618487e-01
GC_22_56 ref NI_22 NS_56 0 -7.2526183582056605e-02
GC_22_57 ref NI_22 NS_57 0 1.1547207985578611e+00
GC_22_58 ref NI_22 NS_58 0 -3.4952586298405131e-01
GC_22_59 ref NI_22 NS_59 0 -9.9780936110962818e-05
GC_22_60 ref NI_22 NS_60 0 -3.6992195490645627e-02
GC_22_61 ref NI_22 NS_61 0 -2.4682577450119289e-01
GC_22_62 ref NI_22 NS_62 0 2.9051002603113907e-01
GC_22_63 ref NI_22 NS_63 0 4.9189048037771514e-02
GC_22_64 ref NI_22 NS_64 0 3.2304709808969830e-02
GC_22_65 ref NI_22 NS_65 0 -6.3668029327900118e-07
GC_22_66 ref NI_22 NS_66 0 -5.2501261208781095e-03
GC_22_67 ref NI_22 NS_67 0 1.8759919780049297e-01
GC_22_68 ref NI_22 NS_68 0 -1.4215501013076451e-01
GC_22_69 ref NI_22 NS_69 0 6.1886683547861498e-01
GC_22_70 ref NI_22 NS_70 0 -1.2647315965528635e-01
GC_22_71 ref NI_22 NS_71 0 -1.4093748961951512e-04
GC_22_72 ref NI_22 NS_72 0 -1.6386217916317357e-02
GC_22_73 ref NI_22 NS_73 0 1.1607736814714767e-01
GC_22_74 ref NI_22 NS_74 0 9.1605292433374785e-01
GC_22_75 ref NI_22 NS_75 0 -8.5331747255298240e-02
GC_22_76 ref NI_22 NS_76 0 -8.7974548501347269e-02
GC_22_77 ref NI_22 NS_77 0 -2.0321394521954369e-04
GC_22_78 ref NI_22 NS_78 0 -1.0951480015696213e-02
GC_22_79 ref NI_22 NS_79 0 -2.3078906723142950e-01
GC_22_80 ref NI_22 NS_80 0 5.1368120843710820e-02
GC_22_81 ref NI_22 NS_81 0 -1.3054331503414965e-01
GC_22_82 ref NI_22 NS_82 0 1.7673516802606590e-01
GC_22_83 ref NI_22 NS_83 0 3.1157913970846854e-05
GC_22_84 ref NI_22 NS_84 0 3.3400651524720377e-03
GC_22_85 ref NI_22 NS_85 0 2.2453633716028543e-01
GC_22_86 ref NI_22 NS_86 0 -3.7299553076755149e-01
GC_22_87 ref NI_22 NS_87 0 3.9715430983516387e-01
GC_22_88 ref NI_22 NS_88 0 2.6075918648853669e-02
GC_22_89 ref NI_22 NS_89 0 -3.8480282879111436e-05
GC_22_90 ref NI_22 NS_90 0 -4.4787136210381927e-03
GC_22_91 ref NI_22 NS_91 0 3.9892489249024965e-01
GC_22_92 ref NI_22 NS_92 0 1.7249026796626705e+00
GC_22_93 ref NI_22 NS_93 0 -2.6082923414354714e-01
GC_22_94 ref NI_22 NS_94 0 -2.0682653048656269e-01
GC_22_95 ref NI_22 NS_95 0 -8.3962378302047220e-05
GC_22_96 ref NI_22 NS_96 0 -3.6181189527416328e-02
GC_22_97 ref NI_22 NS_97 0 -5.0612977602557663e-01
GC_22_98 ref NI_22 NS_98 0 3.2559466057777992e-01
GC_22_99 ref NI_22 NS_99 0 3.3152148043092938e-01
GC_22_100 ref NI_22 NS_100 0 -7.4042080133152235e-02
GC_22_101 ref NI_22 NS_101 0 3.3082304905011727e-06
GC_22_102 ref NI_22 NS_102 0 -2.0687862993319615e-02
GC_22_103 ref NI_22 NS_103 0 -3.1320317488266408e-01
GC_22_104 ref NI_22 NS_104 0 8.0307336505167942e-02
GC_22_105 ref NI_22 NS_105 0 -1.1639956775029534e-01
GC_22_106 ref NI_22 NS_106 0 1.9117838342071358e-01
GC_22_107 ref NI_22 NS_107 0 9.7625676134162443e-06
GC_22_108 ref NI_22 NS_108 0 -7.2520214516987851e-03
GC_22_109 ref NI_22 NS_109 0 -2.7742248391749036e-01
GC_22_110 ref NI_22 NS_110 0 9.2830795460525486e-02
GC_22_111 ref NI_22 NS_111 0 -1.7267468680419187e-01
GC_22_112 ref NI_22 NS_112 0 2.0288355793398422e-01
GC_22_113 ref NI_22 NS_113 0 1.4152562950354394e-05
GC_22_114 ref NI_22 NS_114 0 -2.2682515282998242e-03
GC_22_115 ref NI_22 NS_115 0 -2.9509463656929152e-01
GC_22_116 ref NI_22 NS_116 0 5.7520645797145007e-03
GC_22_117 ref NI_22 NS_117 0 -1.7991788011874257e-02
GC_22_118 ref NI_22 NS_118 0 1.7273875410879028e-01
GC_22_119 ref NI_22 NS_119 0 2.0667653333610415e-05
GC_22_120 ref NI_22 NS_120 0 -1.2092393911760308e-02
GC_22_121 ref NI_22 NS_121 0 -3.8403624941229375e-01
GC_22_122 ref NI_22 NS_122 0 6.3394764067308429e-01
GC_22_123 ref NI_22 NS_123 0 1.0375104368290958e-02
GC_22_124 ref NI_22 NS_124 0 -1.9836447835691117e-02
GC_22_125 ref NI_22 NS_125 0 -4.1711832980262726e-06
GC_22_126 ref NI_22 NS_126 0 -1.5706896174936019e-02
GC_22_127 ref NI_22 NS_127 0 3.1508171472875706e+00
GC_22_128 ref NI_22 NS_128 0 -4.5282233543164176e+00
GC_22_129 ref NI_22 NS_129 0 -2.0639494067334043e+00
GC_22_130 ref NI_22 NS_130 0 -1.8571500382167891e-01
GC_22_131 ref NI_22 NS_131 0 -6.1346856460836022e-04
GC_22_132 ref NI_22 NS_132 0 -5.4940161933592115e-02
GC_22_133 ref NI_22 NS_133 0 3.5596700107178075e-01
GC_22_134 ref NI_22 NS_134 0 6.7840227000729419e-02
GC_22_135 ref NI_22 NS_135 0 8.2108696768790956e-01
GC_22_136 ref NI_22 NS_136 0 -2.6497176386875793e-01
GC_22_137 ref NI_22 NS_137 0 -6.8730017653320877e-05
GC_22_138 ref NI_22 NS_138 0 -3.2065866951135065e-02
GD_22_1 ref NI_22 NA_1 0 3.8784598235643279e-02
GD_22_2 ref NI_22 NA_2 0 4.1296069638525459e-02
GD_22_3 ref NI_22 NA_3 0 3.1542663324270553e-02
GD_22_4 ref NI_22 NA_4 0 5.6741517320112698e-02
GD_22_5 ref NI_22 NA_5 0 5.6681749443423031e-02
GD_22_6 ref NI_22 NA_6 0 5.6433853631729196e-02
GD_22_7 ref NI_22 NA_7 0 5.2473097745503836e-02
GD_22_8 ref NI_22 NA_8 0 4.2638161180709157e-02
GD_22_9 ref NI_22 NA_9 0 1.2889784466917013e-02
GD_22_10 ref NI_22 NA_10 0 1.5152721850625184e-02
GD_22_11 ref NI_22 NA_11 0 4.9676292418278055e-02
GD_22_12 ref NI_22 NA_12 0 -3.3157804271551829e-02
GD_22_13 ref NI_22 NA_13 0 -4.0558584220516600e-02
GD_22_14 ref NI_22 NA_14 0 5.4831851895684180e-02
GD_22_15 ref NI_22 NA_15 0 -2.5829271958173236e-02
GD_22_16 ref NI_22 NA_16 0 -5.3245119058687777e-02
GD_22_17 ref NI_22 NA_17 0 9.5237128678556424e-02
GD_22_18 ref NI_22 NA_18 0 7.4426281916498152e-02
GD_22_19 ref NI_22 NA_19 0 6.5634333000833753e-02
GD_22_20 ref NI_22 NA_20 0 7.5254636150351883e-02
GD_22_21 ref NI_22 NA_21 0 7.3236462764819141e-02
GD_22_22 ref NI_22 NA_22 0 5.6093623696964556e+00
GD_22_23 ref NI_22 NA_23 0 -7.0000853849524924e-02
*
* Port 23
VI_23 a_23 NI_23 0
RI_23 NI_23 ref 1.0000000000000001e-01
GC_23_1 ref NI_23 NS_1 0 -3.1736557929819670e-01
GC_23_2 ref NI_23 NS_2 0 1.5224606068889401e-01
GC_23_3 ref NI_23 NS_3 0 -5.9341238623397671e-02
GC_23_4 ref NI_23 NS_4 0 6.3703565407334836e-02
GC_23_5 ref NI_23 NS_5 0 1.7687275088863671e-04
GC_23_6 ref NI_23 NS_6 0 2.3626366286836866e-02
GC_23_7 ref NI_23 NS_7 0 -1.2744926517793059e-01
GC_23_8 ref NI_23 NS_8 0 1.2374366550819833e-01
GC_23_9 ref NI_23 NS_9 0 -1.4435214061497432e-02
GC_23_10 ref NI_23 NS_10 0 5.3317596122806274e-02
GC_23_11 ref NI_23 NS_11 0 1.1481253392702329e-04
GC_23_12 ref NI_23 NS_12 0 1.4997235712713075e-02
GC_23_13 ref NI_23 NS_13 0 -1.4350508299895195e-01
GC_23_14 ref NI_23 NS_14 0 1.2050154062343066e-01
GC_23_15 ref NI_23 NS_15 0 -7.2014058085039120e-02
GC_23_16 ref NI_23 NS_16 0 6.2263440680614554e-02
GC_23_17 ref NI_23 NS_17 0 1.4395539855353303e-04
GC_23_18 ref NI_23 NS_18 0 2.5320474964846414e-02
GC_23_19 ref NI_23 NS_19 0 -2.9407138231517732e-01
GC_23_20 ref NI_23 NS_20 0 1.5264566235762941e-01
GC_23_21 ref NI_23 NS_21 0 -1.8716600422873045e-01
GC_23_22 ref NI_23 NS_22 0 7.8910873312284857e-02
GC_23_23 ref NI_23 NS_23 0 2.3932000609766329e-04
GC_23_24 ref NI_23 NS_24 0 4.0724442197004752e-02
GC_23_25 ref NI_23 NS_25 0 -2.9526954540030875e-01
GC_23_26 ref NI_23 NS_26 0 1.7385562726744799e-01
GC_23_27 ref NI_23 NS_27 0 -2.1119305788785320e-01
GC_23_28 ref NI_23 NS_28 0 8.0946629292581798e-02
GC_23_29 ref NI_23 NS_29 0 2.3133482615060388e-04
GC_23_30 ref NI_23 NS_30 0 4.2293595516819771e-02
GC_23_31 ref NI_23 NS_31 0 -2.9345597499872877e-01
GC_23_32 ref NI_23 NS_32 0 1.7727288775999092e-01
GC_23_33 ref NI_23 NS_33 0 -2.1835473690768914e-01
GC_23_34 ref NI_23 NS_34 0 8.5101201682318897e-02
GC_23_35 ref NI_23 NS_35 0 2.4244324952166704e-04
GC_23_36 ref NI_23 NS_36 0 4.1702338034090319e-02
GC_23_37 ref NI_23 NS_37 0 -2.7629436110116629e-01
GC_23_38 ref NI_23 NS_38 0 1.3719759456785091e-01
GC_23_39 ref NI_23 NS_39 0 -1.7345757011613147e-01
GC_23_40 ref NI_23 NS_40 0 8.2170689729553062e-02
GC_23_41 ref NI_23 NS_41 0 2.2367652577506099e-04
GC_23_42 ref NI_23 NS_42 0 3.8415153944451601e-02
GC_23_43 ref NI_23 NS_43 0 -1.2410619114289648e-01
GC_23_44 ref NI_23 NS_44 0 -4.7028074423936334e-02
GC_23_45 ref NI_23 NS_45 0 4.4877400922569075e-02
GC_23_46 ref NI_23 NS_46 0 1.1052247416105464e-01
GC_23_47 ref NI_23 NS_47 0 2.6501599605220407e-05
GC_23_48 ref NI_23 NS_48 0 3.1590132163575937e-03
GC_23_49 ref NI_23 NS_49 0 4.5401090516709201e-02
GC_23_50 ref NI_23 NS_50 0 -2.6185974510163179e-01
GC_23_51 ref NI_23 NS_51 0 3.8436221693710348e-01
GC_23_52 ref NI_23 NS_52 0 2.5416438750600697e-03
GC_23_53 ref NI_23 NS_53 0 -2.8728008524335225e-07
GC_23_54 ref NI_23 NS_54 0 -2.1554130968700911e-03
GC_23_55 ref NI_23 NS_55 0 1.1382632083046671e+00
GC_23_56 ref NI_23 NS_56 0 2.7644698017933074e+00
GC_23_57 ref NI_23 NS_57 0 -4.0086360275418936e-01
GC_23_58 ref NI_23 NS_58 0 -4.7165341081844986e-01
GC_23_59 ref NI_23 NS_59 0 -1.6908116695602576e-04
GC_23_60 ref NI_23 NS_60 0 -5.1214526748215437e-02
GC_23_61 ref NI_23 NS_61 0 -4.2518254710059392e-02
GC_23_62 ref NI_23 NS_62 0 -1.2320155513678074e-01
GC_23_63 ref NI_23 NS_63 0 1.0641883413892593e-01
GC_23_64 ref NI_23 NS_64 0 1.1285636016221236e-01
GC_23_65 ref NI_23 NS_65 0 9.6027565076512858e-06
GC_23_66 ref NI_23 NS_66 0 -3.0758695958661608e-03
GC_23_67 ref NI_23 NS_67 0 1.1466713225419916e+00
GC_23_68 ref NI_23 NS_68 0 2.2227798363128359e+00
GC_23_69 ref NI_23 NS_69 0 -7.2237341389953658e-01
GC_23_70 ref NI_23 NS_70 0 -2.0076191462313880e-01
GC_23_71 ref NI_23 NS_71 0 -1.8836735961023766e-04
GC_23_72 ref NI_23 NS_72 0 -2.6854830614488172e-02
GC_23_73 ref NI_23 NS_73 0 1.5468134746198192e-01
GC_23_74 ref NI_23 NS_74 0 5.9229201123945554e-03
GC_23_75 ref NI_23 NS_75 0 4.7844520054899892e-01
GC_23_76 ref NI_23 NS_76 0 -1.0411219128577262e-01
GC_23_77 ref NI_23 NS_77 0 -9.1116685561759217e-05
GC_23_78 ref NI_23 NS_78 0 -1.3636202547221291e-02
GC_23_79 ref NI_23 NS_79 0 -3.6217303612367691e-01
GC_23_80 ref NI_23 NS_80 0 2.4655809935853701e-01
GC_23_81 ref NI_23 NS_81 0 -3.4836915632821547e-01
GC_23_82 ref NI_23 NS_82 0 2.2523981113495550e-01
GC_23_83 ref NI_23 NS_83 0 -8.1673339757542799e-07
GC_23_84 ref NI_23 NS_84 0 9.7282625989888929e-03
GC_23_85 ref NI_23 NS_85 0 -1.3517679891913009e-01
GC_23_86 ref NI_23 NS_86 0 -2.9167240914479658e-01
GC_23_87 ref NI_23 NS_87 0 6.7674076555116269e-01
GC_23_88 ref NI_23 NS_88 0 -1.1838519499521070e-01
GC_23_89 ref NI_23 NS_89 0 -7.6567417106988272e-05
GC_23_90 ref NI_23 NS_90 0 -6.6549734758064678e-03
GC_23_91 ref NI_23 NS_91 0 -2.2857238193283780e-01
GC_23_92 ref NI_23 NS_92 0 5.3480274387602789e-01
GC_23_93 ref NI_23 NS_93 0 7.8659104121149559e-01
GC_23_94 ref NI_23 NS_94 0 -3.4098022811233103e-01
GC_23_95 ref NI_23 NS_95 0 -1.5294379396267875e-04
GC_23_96 ref NI_23 NS_96 0 -3.7032094111822178e-02
GC_23_97 ref NI_23 NS_97 0 1.0312692767274263e-02
GC_23_98 ref NI_23 NS_98 0 -3.9006053741738417e-01
GC_23_99 ref NI_23 NS_99 0 3.8279253238247390e-01
GC_23_100 ref NI_23 NS_100 0 8.5670674083387480e-02
GC_23_101 ref NI_23 NS_101 0 -3.6396218488290836e-05
GC_23_102 ref NI_23 NS_102 0 -1.8332983456284778e-02
GC_23_103 ref NI_23 NS_103 0 -4.6731360363990804e-01
GC_23_104 ref NI_23 NS_104 0 3.7979963065086392e-01
GC_23_105 ref NI_23 NS_105 0 -5.1515254304794933e-01
GC_23_106 ref NI_23 NS_106 0 2.9293007319066749e-01
GC_23_107 ref NI_23 NS_107 0 -7.2046277038639568e-05
GC_23_108 ref NI_23 NS_108 0 4.4345324468991303e-03
GC_23_109 ref NI_23 NS_109 0 -4.5472488422323404e-01
GC_23_110 ref NI_23 NS_110 0 3.7749666054006870e-01
GC_23_111 ref NI_23 NS_111 0 -5.0601781692643244e-01
GC_23_112 ref NI_23 NS_112 0 2.7938431358428861e-01
GC_23_113 ref NI_23 NS_113 0 -4.6856966876184036e-05
GC_23_114 ref NI_23 NS_114 0 7.7860792943481695e-03
GC_23_115 ref NI_23 NS_115 0 -4.4803513255461919e-01
GC_23_116 ref NI_23 NS_116 0 3.3893023009324164e-01
GC_23_117 ref NI_23 NS_117 0 -4.7862133241062033e-01
GC_23_118 ref NI_23 NS_118 0 2.9530585589168018e-01
GC_23_119 ref NI_23 NS_119 0 -6.4464579758328366e-05
GC_23_120 ref NI_23 NS_120 0 3.6546749985863204e-04
GC_23_121 ref NI_23 NS_121 0 1.1159407840078343e-02
GC_23_122 ref NI_23 NS_122 0 -2.5916526497704034e-01
GC_23_123 ref NI_23 NS_123 0 2.1754529609276918e-01
GC_23_124 ref NI_23 NS_124 0 1.1754123506931226e-01
GC_23_125 ref NI_23 NS_125 0 -4.9794504390911692e-05
GC_23_126 ref NI_23 NS_126 0 -1.2256191533225030e-02
GC_23_127 ref NI_23 NS_127 0 3.5596700107178086e-01
GC_23_128 ref NI_23 NS_128 0 6.7840227000729059e-02
GC_23_129 ref NI_23 NS_129 0 8.2108696768791012e-01
GC_23_130 ref NI_23 NS_130 0 -2.6497176386875826e-01
GC_23_131 ref NI_23 NS_131 0 -6.8730017653338021e-05
GC_23_132 ref NI_23 NS_132 0 -3.2065866951134982e-02
GC_23_133 ref NI_23 NS_133 0 1.2463251160301407e+00
GC_23_134 ref NI_23 NS_134 0 -6.6005669445730701e+00
GC_23_135 ref NI_23 NS_135 0 -3.4956043330830334e-05
GC_23_136 ref NI_23 NS_136 0 -5.2281087151177574e-01
GC_23_137 ref NI_23 NS_137 0 -3.5840698090505192e-04
GC_23_138 ref NI_23 NS_138 0 -4.9520362892027207e-02
GD_23_1 ref NI_23 NA_1 0 4.4076164541179977e-02
GD_23_2 ref NI_23 NA_2 0 4.4441747881328805e-02
GD_23_3 ref NI_23 NA_3 0 3.4280824703889427e-02
GD_23_4 ref NI_23 NA_4 0 5.9245283648228127e-02
GD_23_5 ref NI_23 NA_5 0 5.9209707371902502e-02
GD_23_6 ref NI_23 NA_6 0 5.8631501066239121e-02
GD_23_7 ref NI_23 NA_7 0 5.4656534146055549e-02
GD_23_8 ref NI_23 NA_8 0 3.1327546366697059e-02
GD_23_9 ref NI_23 NA_9 0 4.6051172397072329e-05
GD_23_10 ref NI_23 NA_10 0 -1.5932487066976386e-01
GD_23_11 ref NI_23 NA_11 0 2.0556237777363720e-02
GD_23_12 ref NI_23 NA_12 0 -1.4086133989071442e-01
GD_23_13 ref NI_23 NA_13 0 -2.7335479040232667e-02
GD_23_14 ref NI_23 NA_14 0 6.9699106985483372e-02
GD_23_15 ref NI_23 NA_15 0 2.0424374710594474e-02
GD_23_16 ref NI_23 NA_16 0 5.4857707973052505e-03
GD_23_17 ref NI_23 NA_17 0 1.9087225269622730e-02
GD_23_18 ref NI_23 NA_18 0 8.8108189855709479e-02
GD_23_19 ref NI_23 NA_19 0 8.4498873401470304e-02
GD_23_20 ref NI_23 NA_20 0 8.6742346757055916e-02
GD_23_21 ref NI_23 NA_21 0 1.5748495729154755e-02
GD_23_22 ref NI_23 NA_22 0 -7.0000853849524924e-02
GD_23_23 ref NI_23 NA_23 0 5.8791530758609785e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
* Impinging wave, port 16
RA_16 NA_16 0 1.5811388300841897e-01
FA_16 0 NA_16 VI_16 1.0
GA_16 0 NA_16 a_16 ref 1.0000000000000000e+01
*
* Impinging wave, port 17
RA_17 NA_17 0 1.5811388300841897e-01
FA_17 0 NA_17 VI_17 1.0
GA_17 0 NA_17 a_17 ref 1.0000000000000000e+01
*
* Impinging wave, port 18
RA_18 NA_18 0 1.5811388300841897e-01
FA_18 0 NA_18 VI_18 1.0
GA_18 0 NA_18 a_18 ref 1.0000000000000000e+01
*
* Impinging wave, port 19
RA_19 NA_19 0 1.5811388300841897e-01
FA_19 0 NA_19 VI_19 1.0
GA_19 0 NA_19 a_19 ref 1.0000000000000000e+01
*
* Impinging wave, port 20
RA_20 NA_20 0 1.5811388300841897e-01
FA_20 0 NA_20 VI_20 1.0
GA_20 0 NA_20 a_20 ref 1.0000000000000000e+01
*
* Impinging wave, port 21
RA_21 NA_21 0 1.5811388300841897e-01
FA_21 0 NA_21 VI_21 1.0
GA_21 0 NA_21 a_21 ref 1.0000000000000000e+01
*
* Impinging wave, port 22
RA_22 NA_22 0 1.5811388300841897e-01
FA_22 0 NA_22 VI_22 1.0
GA_22 0 NA_22 a_22 ref 1.0000000000000000e+01
*
* Impinging wave, port 23
RA_23 NA_23 0 1.5811388300841897e-01
FA_23 0 NA_23 VI_23 1.0
GA_23 0 NA_23 a_23 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 6.1207562511601477e-02
GS_1_1 0 NS_1 NA_1 0 7.0794352588161900e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 1.9632325895499253e-01
GS_2_1 0 NS_2 NA_1 0 7.0794352588161900e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 3.3040781630338162e-01
GS_3_1 0 NS_3 NA_1 0 7.0794352588161900e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 6.0983625470941272e-01
GS_4_1 0 NS_4 NA_1 0 7.0794352588161900e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 1.1378885011816509e+01
GS_5_1 0 NS_5 NA_1 0 7.0794352588161900e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 1.5532069375217969e+00
GS_6_1 0 NS_6 NA_1 0 7.0794352588161900e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 6.1207562511601477e-02
GS_7_2 0 NS_7 NA_2 0 7.0794352588161900e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 1.9632325895499253e-01
GS_8_2 0 NS_8 NA_2 0 7.0794352588161900e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 3.3040781630338162e-01
GS_9_2 0 NS_9 NA_2 0 7.0794352588161900e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 6.0983625470941272e-01
GS_10_2 0 NS_10 NA_2 0 7.0794352588161900e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 1.1378885011816509e+01
GS_11_2 0 NS_11 NA_2 0 7.0794352588161900e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 1.5532069375217969e+00
GS_12_2 0 NS_12 NA_2 0 7.0794352588161900e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 6.1207562511601477e-02
GS_13_3 0 NS_13 NA_3 0 7.0794352588161900e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 1.9632325895499253e-01
GS_14_3 0 NS_14 NA_3 0 7.0794352588161900e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 3.3040781630338162e-01
GS_15_3 0 NS_15 NA_3 0 7.0794352588161900e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 6.0983625470941272e-01
GS_16_3 0 NS_16 NA_3 0 7.0794352588161900e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 1.1378885011816509e+01
GS_17_3 0 NS_17 NA_3 0 7.0794352588161900e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 1.5532069375217969e+00
GS_18_3 0 NS_18 NA_3 0 7.0794352588161900e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 6.1207562511601477e-02
GS_19_4 0 NS_19 NA_4 0 7.0794352588161900e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 1.9632325895499253e-01
GS_20_4 0 NS_20 NA_4 0 7.0794352588161900e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 3.3040781630338162e-01
GS_21_4 0 NS_21 NA_4 0 7.0794352588161900e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 6.0983625470941272e-01
GS_22_4 0 NS_22 NA_4 0 7.0794352588161900e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 1.1378885011816509e+01
GS_23_4 0 NS_23 NA_4 0 7.0794352588161900e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 1.5532069375217969e+00
GS_24_4 0 NS_24 NA_4 0 7.0794352588161900e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 6.1207562511601477e-02
GS_25_5 0 NS_25 NA_5 0 7.0794352588161900e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 1.9632325895499253e-01
GS_26_5 0 NS_26 NA_5 0 7.0794352588161900e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 3.3040781630338162e-01
GS_27_5 0 NS_27 NA_5 0 7.0794352588161900e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 6.0983625470941272e-01
GS_28_5 0 NS_28 NA_5 0 7.0794352588161900e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 1.1378885011816509e+01
GS_29_5 0 NS_29 NA_5 0 7.0794352588161900e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 1.5532069375217969e+00
GS_30_5 0 NS_30 NA_5 0 7.0794352588161900e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 6.1207562511601477e-02
GS_31_6 0 NS_31 NA_6 0 7.0794352588161900e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 1.9632325895499253e-01
GS_32_6 0 NS_32 NA_6 0 7.0794352588161900e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 3.3040781630338162e-01
GS_33_6 0 NS_33 NA_6 0 7.0794352588161900e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 6.0983625470941272e-01
GS_34_6 0 NS_34 NA_6 0 7.0794352588161900e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 1.1378885011816509e+01
GS_35_6 0 NS_35 NA_6 0 7.0794352588161900e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 1.5532069375217969e+00
GS_36_6 0 NS_36 NA_6 0 7.0794352588161900e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 6.1207562511601477e-02
GS_37_7 0 NS_37 NA_7 0 7.0794352588161900e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 1.9632325895499253e-01
GS_38_7 0 NS_38 NA_7 0 7.0794352588161900e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 3.3040781630338162e-01
GS_39_7 0 NS_39 NA_7 0 7.0794352588161900e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 6.0983625470941272e-01
GS_40_7 0 NS_40 NA_7 0 7.0794352588161900e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 1.1378885011816509e+01
GS_41_7 0 NS_41 NA_7 0 7.0794352588161900e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 1.5532069375217969e+00
GS_42_7 0 NS_42 NA_7 0 7.0794352588161900e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 6.1207562511601477e-02
GS_43_8 0 NS_43 NA_8 0 7.0794352588161900e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 1.9632325895499253e-01
GS_44_8 0 NS_44 NA_8 0 7.0794352588161900e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 3.3040781630338162e-01
GS_45_8 0 NS_45 NA_8 0 7.0794352588161900e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 6.0983625470941272e-01
GS_46_8 0 NS_46 NA_8 0 7.0794352588161900e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 1.1378885011816509e+01
GS_47_8 0 NS_47 NA_8 0 7.0794352588161900e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 1.5532069375217969e+00
GS_48_8 0 NS_48 NA_8 0 7.0794352588161900e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 6.1207562511601477e-02
GS_49_9 0 NS_49 NA_9 0 7.0794352588161900e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 1.9632325895499253e-01
GS_50_9 0 NS_50 NA_9 0 7.0794352588161900e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 3.3040781630338162e-01
GS_51_9 0 NS_51 NA_9 0 7.0794352588161900e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 6.0983625470941272e-01
GS_52_9 0 NS_52 NA_9 0 7.0794352588161900e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 1.1378885011816509e+01
GS_53_9 0 NS_53 NA_9 0 7.0794352588161900e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 1.5532069375217969e+00
GS_54_9 0 NS_54 NA_9 0 7.0794352588161900e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 6.1207562511601477e-02
GS_55_10 0 NS_55 NA_10 0 7.0794352588161900e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 1.9632325895499253e-01
GS_56_10 0 NS_56 NA_10 0 7.0794352588161900e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 3.3040781630338162e-01
GS_57_10 0 NS_57 NA_10 0 7.0794352588161900e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 6.0983625470941272e-01
GS_58_10 0 NS_58 NA_10 0 7.0794352588161900e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 1.1378885011816509e+01
GS_59_10 0 NS_59 NA_10 0 7.0794352588161900e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 1.5532069375217969e+00
GS_60_10 0 NS_60 NA_10 0 7.0794352588161900e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 6.1207562511601477e-02
GS_61_11 0 NS_61 NA_11 0 7.0794352588161900e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 1.9632325895499253e-01
GS_62_11 0 NS_62 NA_11 0 7.0794352588161900e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 3.3040781630338162e-01
GS_63_11 0 NS_63 NA_11 0 7.0794352588161900e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 6.0983625470941272e-01
GS_64_11 0 NS_64 NA_11 0 7.0794352588161900e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 1.1378885011816509e+01
GS_65_11 0 NS_65 NA_11 0 7.0794352588161900e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 1.5532069375217969e+00
GS_66_11 0 NS_66 NA_11 0 7.0794352588161900e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 6.1207562511601477e-02
GS_67_12 0 NS_67 NA_12 0 7.0794352588161900e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 1.9632325895499253e-01
GS_68_12 0 NS_68 NA_12 0 7.0794352588161900e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 3.3040781630338162e-01
GS_69_12 0 NS_69 NA_12 0 7.0794352588161900e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 6.0983625470941272e-01
GS_70_12 0 NS_70 NA_12 0 7.0794352588161900e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 1.1378885011816509e+01
GS_71_12 0 NS_71 NA_12 0 7.0794352588161900e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 1.5532069375217969e+00
GS_72_12 0 NS_72 NA_12 0 7.0794352588161900e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 6.1207562511601477e-02
GS_73_13 0 NS_73 NA_13 0 7.0794352588161900e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 1.9632325895499253e-01
GS_74_13 0 NS_74 NA_13 0 7.0794352588161900e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 3.3040781630338162e-01
GS_75_13 0 NS_75 NA_13 0 7.0794352588161900e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 6.0983625470941272e-01
GS_76_13 0 NS_76 NA_13 0 7.0794352588161900e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 1.1378885011816509e+01
GS_77_13 0 NS_77 NA_13 0 7.0794352588161900e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 1.5532069375217969e+00
GS_78_13 0 NS_78 NA_13 0 7.0794352588161900e+00
*
* Real pole n. 79
CS_79 NS_79 0 1.0000000000000001e-09
RS_79 NS_79 0 6.1207562511601477e-02
GS_79_14 0 NS_79 NA_14 0 7.0794352588161900e+00
*
* Real pole n. 80
CS_80 NS_80 0 1.0000000000000001e-09
RS_80 NS_80 0 1.9632325895499253e-01
GS_80_14 0 NS_80 NA_14 0 7.0794352588161900e+00
*
* Real pole n. 81
CS_81 NS_81 0 1.0000000000000001e-09
RS_81 NS_81 0 3.3040781630338162e-01
GS_81_14 0 NS_81 NA_14 0 7.0794352588161900e+00
*
* Real pole n. 82
CS_82 NS_82 0 1.0000000000000001e-09
RS_82 NS_82 0 6.0983625470941272e-01
GS_82_14 0 NS_82 NA_14 0 7.0794352588161900e+00
*
* Real pole n. 83
CS_83 NS_83 0 1.0000000000000001e-09
RS_83 NS_83 0 1.1378885011816509e+01
GS_83_14 0 NS_83 NA_14 0 7.0794352588161900e+00
*
* Real pole n. 84
CS_84 NS_84 0 1.0000000000000001e-09
RS_84 NS_84 0 1.5532069375217969e+00
GS_84_14 0 NS_84 NA_14 0 7.0794352588161900e+00
*
* Real pole n. 85
CS_85 NS_85 0 1.0000000000000001e-09
RS_85 NS_85 0 6.1207562511601477e-02
GS_85_15 0 NS_85 NA_15 0 7.0794352588161900e+00
*
* Real pole n. 86
CS_86 NS_86 0 1.0000000000000001e-09
RS_86 NS_86 0 1.9632325895499253e-01
GS_86_15 0 NS_86 NA_15 0 7.0794352588161900e+00
*
* Real pole n. 87
CS_87 NS_87 0 1.0000000000000001e-09
RS_87 NS_87 0 3.3040781630338162e-01
GS_87_15 0 NS_87 NA_15 0 7.0794352588161900e+00
*
* Real pole n. 88
CS_88 NS_88 0 1.0000000000000001e-09
RS_88 NS_88 0 6.0983625470941272e-01
GS_88_15 0 NS_88 NA_15 0 7.0794352588161900e+00
*
* Real pole n. 89
CS_89 NS_89 0 1.0000000000000001e-09
RS_89 NS_89 0 1.1378885011816509e+01
GS_89_15 0 NS_89 NA_15 0 7.0794352588161900e+00
*
* Real pole n. 90
CS_90 NS_90 0 1.0000000000000001e-09
RS_90 NS_90 0 1.5532069375217969e+00
GS_90_15 0 NS_90 NA_15 0 7.0794352588161900e+00
*
* Real pole n. 91
CS_91 NS_91 0 1.0000000000000001e-09
RS_91 NS_91 0 6.1207562511601477e-02
GS_91_16 0 NS_91 NA_16 0 7.0794352588161900e+00
*
* Real pole n. 92
CS_92 NS_92 0 1.0000000000000001e-09
RS_92 NS_92 0 1.9632325895499253e-01
GS_92_16 0 NS_92 NA_16 0 7.0794352588161900e+00
*
* Real pole n. 93
CS_93 NS_93 0 1.0000000000000001e-09
RS_93 NS_93 0 3.3040781630338162e-01
GS_93_16 0 NS_93 NA_16 0 7.0794352588161900e+00
*
* Real pole n. 94
CS_94 NS_94 0 1.0000000000000001e-09
RS_94 NS_94 0 6.0983625470941272e-01
GS_94_16 0 NS_94 NA_16 0 7.0794352588161900e+00
*
* Real pole n. 95
CS_95 NS_95 0 1.0000000000000001e-09
RS_95 NS_95 0 1.1378885011816509e+01
GS_95_16 0 NS_95 NA_16 0 7.0794352588161900e+00
*
* Real pole n. 96
CS_96 NS_96 0 1.0000000000000001e-09
RS_96 NS_96 0 1.5532069375217969e+00
GS_96_16 0 NS_96 NA_16 0 7.0794352588161900e+00
*
* Real pole n. 97
CS_97 NS_97 0 1.0000000000000001e-09
RS_97 NS_97 0 6.1207562511601477e-02
GS_97_17 0 NS_97 NA_17 0 7.0794352588161900e+00
*
* Real pole n. 98
CS_98 NS_98 0 1.0000000000000001e-09
RS_98 NS_98 0 1.9632325895499253e-01
GS_98_17 0 NS_98 NA_17 0 7.0794352588161900e+00
*
* Real pole n. 99
CS_99 NS_99 0 1.0000000000000001e-09
RS_99 NS_99 0 3.3040781630338162e-01
GS_99_17 0 NS_99 NA_17 0 7.0794352588161900e+00
*
* Real pole n. 100
CS_100 NS_100 0 1.0000000000000001e-09
RS_100 NS_100 0 6.0983625470941272e-01
GS_100_17 0 NS_100 NA_17 0 7.0794352588161900e+00
*
* Real pole n. 101
CS_101 NS_101 0 1.0000000000000001e-09
RS_101 NS_101 0 1.1378885011816509e+01
GS_101_17 0 NS_101 NA_17 0 7.0794352588161900e+00
*
* Real pole n. 102
CS_102 NS_102 0 1.0000000000000001e-09
RS_102 NS_102 0 1.5532069375217969e+00
GS_102_17 0 NS_102 NA_17 0 7.0794352588161900e+00
*
* Real pole n. 103
CS_103 NS_103 0 1.0000000000000001e-09
RS_103 NS_103 0 6.1207562511601477e-02
GS_103_18 0 NS_103 NA_18 0 7.0794352588161900e+00
*
* Real pole n. 104
CS_104 NS_104 0 1.0000000000000001e-09
RS_104 NS_104 0 1.9632325895499253e-01
GS_104_18 0 NS_104 NA_18 0 7.0794352588161900e+00
*
* Real pole n. 105
CS_105 NS_105 0 1.0000000000000001e-09
RS_105 NS_105 0 3.3040781630338162e-01
GS_105_18 0 NS_105 NA_18 0 7.0794352588161900e+00
*
* Real pole n. 106
CS_106 NS_106 0 1.0000000000000001e-09
RS_106 NS_106 0 6.0983625470941272e-01
GS_106_18 0 NS_106 NA_18 0 7.0794352588161900e+00
*
* Real pole n. 107
CS_107 NS_107 0 1.0000000000000001e-09
RS_107 NS_107 0 1.1378885011816509e+01
GS_107_18 0 NS_107 NA_18 0 7.0794352588161900e+00
*
* Real pole n. 108
CS_108 NS_108 0 1.0000000000000001e-09
RS_108 NS_108 0 1.5532069375217969e+00
GS_108_18 0 NS_108 NA_18 0 7.0794352588161900e+00
*
* Real pole n. 109
CS_109 NS_109 0 1.0000000000000001e-09
RS_109 NS_109 0 6.1207562511601477e-02
GS_109_19 0 NS_109 NA_19 0 7.0794352588161900e+00
*
* Real pole n. 110
CS_110 NS_110 0 1.0000000000000001e-09
RS_110 NS_110 0 1.9632325895499253e-01
GS_110_19 0 NS_110 NA_19 0 7.0794352588161900e+00
*
* Real pole n. 111
CS_111 NS_111 0 1.0000000000000001e-09
RS_111 NS_111 0 3.3040781630338162e-01
GS_111_19 0 NS_111 NA_19 0 7.0794352588161900e+00
*
* Real pole n. 112
CS_112 NS_112 0 1.0000000000000001e-09
RS_112 NS_112 0 6.0983625470941272e-01
GS_112_19 0 NS_112 NA_19 0 7.0794352588161900e+00
*
* Real pole n. 113
CS_113 NS_113 0 1.0000000000000001e-09
RS_113 NS_113 0 1.1378885011816509e+01
GS_113_19 0 NS_113 NA_19 0 7.0794352588161900e+00
*
* Real pole n. 114
CS_114 NS_114 0 1.0000000000000001e-09
RS_114 NS_114 0 1.5532069375217969e+00
GS_114_19 0 NS_114 NA_19 0 7.0794352588161900e+00
*
* Real pole n. 115
CS_115 NS_115 0 1.0000000000000001e-09
RS_115 NS_115 0 6.1207562511601477e-02
GS_115_20 0 NS_115 NA_20 0 7.0794352588161900e+00
*
* Real pole n. 116
CS_116 NS_116 0 1.0000000000000001e-09
RS_116 NS_116 0 1.9632325895499253e-01
GS_116_20 0 NS_116 NA_20 0 7.0794352588161900e+00
*
* Real pole n. 117
CS_117 NS_117 0 1.0000000000000001e-09
RS_117 NS_117 0 3.3040781630338162e-01
GS_117_20 0 NS_117 NA_20 0 7.0794352588161900e+00
*
* Real pole n. 118
CS_118 NS_118 0 1.0000000000000001e-09
RS_118 NS_118 0 6.0983625470941272e-01
GS_118_20 0 NS_118 NA_20 0 7.0794352588161900e+00
*
* Real pole n. 119
CS_119 NS_119 0 1.0000000000000001e-09
RS_119 NS_119 0 1.1378885011816509e+01
GS_119_20 0 NS_119 NA_20 0 7.0794352588161900e+00
*
* Real pole n. 120
CS_120 NS_120 0 1.0000000000000001e-09
RS_120 NS_120 0 1.5532069375217969e+00
GS_120_20 0 NS_120 NA_20 0 7.0794352588161900e+00
*
* Real pole n. 121
CS_121 NS_121 0 1.0000000000000001e-09
RS_121 NS_121 0 6.1207562511601477e-02
GS_121_21 0 NS_121 NA_21 0 7.0794352588161900e+00
*
* Real pole n. 122
CS_122 NS_122 0 1.0000000000000001e-09
RS_122 NS_122 0 1.9632325895499253e-01
GS_122_21 0 NS_122 NA_21 0 7.0794352588161900e+00
*
* Real pole n. 123
CS_123 NS_123 0 1.0000000000000001e-09
RS_123 NS_123 0 3.3040781630338162e-01
GS_123_21 0 NS_123 NA_21 0 7.0794352588161900e+00
*
* Real pole n. 124
CS_124 NS_124 0 1.0000000000000001e-09
RS_124 NS_124 0 6.0983625470941272e-01
GS_124_21 0 NS_124 NA_21 0 7.0794352588161900e+00
*
* Real pole n. 125
CS_125 NS_125 0 1.0000000000000001e-09
RS_125 NS_125 0 1.1378885011816509e+01
GS_125_21 0 NS_125 NA_21 0 7.0794352588161900e+00
*
* Real pole n. 126
CS_126 NS_126 0 1.0000000000000001e-09
RS_126 NS_126 0 1.5532069375217969e+00
GS_126_21 0 NS_126 NA_21 0 7.0794352588161900e+00
*
* Real pole n. 127
CS_127 NS_127 0 1.0000000000000001e-09
RS_127 NS_127 0 6.1207562511601477e-02
GS_127_22 0 NS_127 NA_22 0 7.0794352588161900e+00
*
* Real pole n. 128
CS_128 NS_128 0 1.0000000000000001e-09
RS_128 NS_128 0 1.9632325895499253e-01
GS_128_22 0 NS_128 NA_22 0 7.0794352588161900e+00
*
* Real pole n. 129
CS_129 NS_129 0 1.0000000000000001e-09
RS_129 NS_129 0 3.3040781630338162e-01
GS_129_22 0 NS_129 NA_22 0 7.0794352588161900e+00
*
* Real pole n. 130
CS_130 NS_130 0 1.0000000000000001e-09
RS_130 NS_130 0 6.0983625470941272e-01
GS_130_22 0 NS_130 NA_22 0 7.0794352588161900e+00
*
* Real pole n. 131
CS_131 NS_131 0 1.0000000000000001e-09
RS_131 NS_131 0 1.1378885011816509e+01
GS_131_22 0 NS_131 NA_22 0 7.0794352588161900e+00
*
* Real pole n. 132
CS_132 NS_132 0 1.0000000000000001e-09
RS_132 NS_132 0 1.5532069375217969e+00
GS_132_22 0 NS_132 NA_22 0 7.0794352588161900e+00
*
* Real pole n. 133
CS_133 NS_133 0 1.0000000000000001e-09
RS_133 NS_133 0 6.1207562511601477e-02
GS_133_23 0 NS_133 NA_23 0 7.0794352588161900e+00
*
* Real pole n. 134
CS_134 NS_134 0 1.0000000000000001e-09
RS_134 NS_134 0 1.9632325895499253e-01
GS_134_23 0 NS_134 NA_23 0 7.0794352588161900e+00
*
* Real pole n. 135
CS_135 NS_135 0 1.0000000000000001e-09
RS_135 NS_135 0 3.3040781630338162e-01
GS_135_23 0 NS_135 NA_23 0 7.0794352588161900e+00
*
* Real pole n. 136
CS_136 NS_136 0 1.0000000000000001e-09
RS_136 NS_136 0 6.0983625470941272e-01
GS_136_23 0 NS_136 NA_23 0 7.0794352588161900e+00
*
* Real pole n. 137
CS_137 NS_137 0 1.0000000000000001e-09
RS_137 NS_137 0 1.1378885011816509e+01
GS_137_23 0 NS_137 NA_23 0 7.0794352588161900e+00
*
* Real pole n. 138
CS_138 NS_138 0 1.0000000000000001e-09
RS_138 NS_138 0 1.5532069375217969e+00
GS_138_23 0 NS_138 NA_23 0 7.0794352588161900e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
