**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 24-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0001_PSI_S-parameter_Sweep_w_IPD
**   Design: unknown
**  Creation time: Thu Apr 24 11:43:18 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Thu Apr 24 11:43:18 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_GRP_1_0_VDDCR_PCCX_DIE1_GRP_1_0_VSS
**  Port[2] = PORT_1_IPD1_VDDCR_PCCX_Group_IPD1_VSS_Group
**  Port[3] = PORT_2_BGA1_VDDCR_PCCX_Group_BGA1_VSS_Group
**  Port[4] = VDDCR_PCCX_B1_2
**  Port[5] = VDDCR_PCCX_B2_2
**  Port[6] = VDDCR_PCCX_B3_2
**  Port[7] = VDDCR_PCCX_B4_2
**  Port[8] = VDDCR_PCCX_C11_1
**  Port[9] = VDDCR_PCCX_C14_1
**  Port[10] = VDDCR_PCCX_C15_2
**  Port[11] = VDDCR_PCCX_C20_1
**  Port[12] = VDDCR_PCCX_C25_2
**  Port[13] = VDDCR_PCCX_C26_1
**  Port[14] = VDDCR_PCCX_C107_1
**  Port[15] = VDDCR_PCCX_C110_2
**  Port[16] = VDDCR_PCCX_C111_1
**  Port[17] = VDDCR_PCCX_C112_1
**  Port[18] = VDDCR_PCCX_C113_1
**  Port[19] = VDDCR_PCCX_C114_1
**  Port[20] = VDDCR_PCCX_C115_2
**  Port[21] = VDDCR_PCCX_C116_2
**  Port[22] = VDDCR_PCCX_C117_1
**  Port[23] = VDDCR_PCCX_C118_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 6]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_PCCX_s23p
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 a_16 a_17 a_18 a_19 a_20 a_21 a_22 a_23 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -1.2153398310799606e+01
GC_1_2 ref NI_1 NS_2 0 -3.6764811639013457e+00
GC_1_3 ref NI_1 NS_3 0 4.4403900865913326e-01
GC_1_4 ref NI_1 NS_4 0 -1.4439494826605359e-01
GC_1_5 ref NI_1 NS_5 0 -8.1185116970733547e-04
GC_1_6 ref NI_1 NS_6 0 -3.0862573128795843e-02
GC_1_7 ref NI_1 NS_7 0 1.0976695687251643e+01
GC_1_8 ref NI_1 NS_8 0 -3.3917894660338908e+00
GC_1_9 ref NI_1 NS_9 0 5.1176369580075587e-01
GC_1_10 ref NI_1 NS_10 0 -1.3350478096185769e-01
GC_1_11 ref NI_1 NS_11 0 -3.1058449828082711e-04
GC_1_12 ref NI_1 NS_12 0 -1.7095356417007528e-02
GC_1_13 ref NI_1 NS_13 0 1.0112989490529412e+01
GC_1_14 ref NI_1 NS_14 0 -2.7920403866497598e+00
GC_1_15 ref NI_1 NS_15 0 5.8373314327543624e-01
GC_1_16 ref NI_1 NS_16 0 -1.6084242355748402e-01
GC_1_17 ref NI_1 NS_17 0 -4.5074379961496824e-04
GC_1_18 ref NI_1 NS_18 0 -2.7599141916885315e-02
GC_1_19 ref NI_1 NS_19 0 3.6801648107339713e-01
GC_1_20 ref NI_1 NS_20 0 1.1683955880263368e+00
GC_1_21 ref NI_1 NS_21 0 -1.5085762454450435e-01
GC_1_22 ref NI_1 NS_22 0 -2.2595575277151909e-02
GC_1_23 ref NI_1 NS_23 0 -1.6254233269981423e-04
GC_1_24 ref NI_1 NS_24 0 -5.0353973479646971e-02
GC_1_25 ref NI_1 NS_25 0 -1.5282871245924079e-01
GC_1_26 ref NI_1 NS_26 0 8.8094824094301227e-01
GC_1_27 ref NI_1 NS_27 0 1.2084190863309857e-01
GC_1_28 ref NI_1 NS_28 0 -5.0146880395978581e-02
GC_1_29 ref NI_1 NS_29 0 -1.6944828327408379e-04
GC_1_30 ref NI_1 NS_30 0 -5.0251299826738212e-02
GC_1_31 ref NI_1 NS_31 0 -2.6848202972230961e-01
GC_1_32 ref NI_1 NS_32 0 8.2203664655150110e-01
GC_1_33 ref NI_1 NS_33 0 1.8626758751987857e-01
GC_1_34 ref NI_1 NS_34 0 -6.3643033066718271e-02
GC_1_35 ref NI_1 NS_35 0 -1.8170867409427532e-04
GC_1_36 ref NI_1 NS_36 0 -4.9538170215734693e-02
GC_1_37 ref NI_1 NS_37 0 3.2665636194005970e-01
GC_1_38 ref NI_1 NS_38 0 1.2952640339947470e+00
GC_1_39 ref NI_1 NS_39 0 -1.9766373549380123e-01
GC_1_40 ref NI_1 NS_40 0 -2.8930039128852170e-02
GC_1_41 ref NI_1 NS_41 0 -1.7174559948822220e-04
GC_1_42 ref NI_1 NS_42 0 -4.8609817386995199e-02
GC_1_43 ref NI_1 NS_43 0 -1.6507259570828586e-01
GC_1_44 ref NI_1 NS_44 0 8.4252937217797885e-01
GC_1_45 ref NI_1 NS_45 0 -2.5101935150285837e-01
GC_1_46 ref NI_1 NS_46 0 1.6386389737997494e-02
GC_1_47 ref NI_1 NS_47 0 1.0526736678390443e-04
GC_1_48 ref NI_1 NS_48 0 3.1282285261361343e-04
GC_1_49 ref NI_1 NS_49 0 -3.2589391472461759e-01
GC_1_50 ref NI_1 NS_50 0 8.7110387081158169e-01
GC_1_51 ref NI_1 NS_51 0 -1.8412587230316413e-01
GC_1_52 ref NI_1 NS_52 0 -2.8052449327528573e-03
GC_1_53 ref NI_1 NS_53 0 1.3844259563746829e-04
GC_1_54 ref NI_1 NS_54 0 -5.2922025248113699e-03
GC_1_55 ref NI_1 NS_55 0 -2.7131123218129610e-01
GC_1_56 ref NI_1 NS_56 0 6.7470931635179671e-02
GC_1_57 ref NI_1 NS_57 0 -9.3373826875092950e-02
GC_1_58 ref NI_1 NS_58 0 7.9552539232398717e-02
GC_1_59 ref NI_1 NS_59 0 1.6361781112679785e-04
GC_1_60 ref NI_1 NS_60 0 2.7941859362054386e-02
GC_1_61 ref NI_1 NS_61 0 -4.2769672167310807e-01
GC_1_62 ref NI_1 NS_62 0 3.5629304641310189e-01
GC_1_63 ref NI_1 NS_63 0 -1.5797604156317500e-02
GC_1_64 ref NI_1 NS_64 0 1.1194591705502455e-02
GC_1_65 ref NI_1 NS_65 0 1.2818056842217956e-04
GC_1_66 ref NI_1 NS_66 0 1.2311652689640034e-02
GC_1_67 ref NI_1 NS_67 0 -2.9149090450033716e-01
GC_1_68 ref NI_1 NS_68 0 3.9979033486795507e-01
GC_1_69 ref NI_1 NS_69 0 -6.4125149743057289e-02
GC_1_70 ref NI_1 NS_70 0 3.1124938179236228e-02
GC_1_71 ref NI_1 NS_71 0 2.1487533822799461e-04
GC_1_72 ref NI_1 NS_72 0 7.1023090474649766e-03
GC_1_73 ref NI_1 NS_73 0 -3.8177454792062543e-01
GC_1_74 ref NI_1 NS_74 0 4.7797613605233041e-01
GC_1_75 ref NI_1 NS_75 0 -6.3139474501326356e-02
GC_1_76 ref NI_1 NS_76 0 1.6326672504492226e-02
GC_1_77 ref NI_1 NS_77 0 1.8682358870554796e-04
GC_1_78 ref NI_1 NS_78 0 5.6630368928739447e-03
GC_1_79 ref NI_1 NS_79 0 -3.3280142733088636e-01
GC_1_80 ref NI_1 NS_80 0 6.1276681937212574e-01
GC_1_81 ref NI_1 NS_81 0 -1.4172607003921145e-01
GC_1_82 ref NI_1 NS_82 0 1.1356036626903630e-02
GC_1_83 ref NI_1 NS_83 0 1.2466573176274319e-04
GC_1_84 ref NI_1 NS_84 0 7.6774446809583004e-03
GC_1_85 ref NI_1 NS_85 0 -3.3436908936808551e-01
GC_1_86 ref NI_1 NS_86 0 5.7224053900412764e-01
GC_1_87 ref NI_1 NS_87 0 -2.7538304646290025e-02
GC_1_88 ref NI_1 NS_88 0 -1.3947171278030023e-03
GC_1_89 ref NI_1 NS_89 0 1.8675662219984948e-04
GC_1_90 ref NI_1 NS_90 0 -4.3933879789018748e-03
GC_1_91 ref NI_1 NS_91 0 -2.7772567151329985e-01
GC_1_92 ref NI_1 NS_92 0 9.3666780560679661e-02
GC_1_93 ref NI_1 NS_93 0 -9.1968056291757888e-02
GC_1_94 ref NI_1 NS_94 0 6.8161400202476005e-02
GC_1_95 ref NI_1 NS_95 0 1.3781036217619695e-04
GC_1_96 ref NI_1 NS_96 0 2.9148739339564040e-02
GC_1_97 ref NI_1 NS_97 0 -2.6619148510353896e-01
GC_1_98 ref NI_1 NS_98 0 1.0246832124159645e-01
GC_1_99 ref NI_1 NS_99 0 -1.1903996031411052e-01
GC_1_100 ref NI_1 NS_100 0 6.6074358354272819e-02
GC_1_101 ref NI_1 NS_101 0 1.0722003178170320e-04
GC_1_102 ref NI_1 NS_102 0 3.4364905819731437e-02
GC_1_103 ref NI_1 NS_103 0 -2.9043978085293948e-01
GC_1_104 ref NI_1 NS_104 0 7.1526999368959024e-02
GC_1_105 ref NI_1 NS_105 0 -2.9495046982202164e-02
GC_1_106 ref NI_1 NS_106 0 3.9257418421341721e-02
GC_1_107 ref NI_1 NS_107 0 9.8764038503530894e-05
GC_1_108 ref NI_1 NS_108 0 3.0845570270617243e-02
GC_1_109 ref NI_1 NS_109 0 -3.6900029521480937e-01
GC_1_110 ref NI_1 NS_110 0 1.4729006891320989e-01
GC_1_111 ref NI_1 NS_111 0 2.5205379957042459e-02
GC_1_112 ref NI_1 NS_112 0 1.9100499219459745e-02
GC_1_113 ref NI_1 NS_113 0 1.1545240981298280e-04
GC_1_114 ref NI_1 NS_114 0 2.1808348226121762e-02
GC_1_115 ref NI_1 NS_115 0 -2.6199988009713754e-01
GC_1_116 ref NI_1 NS_116 0 9.8542134337329973e-02
GC_1_117 ref NI_1 NS_117 0 -1.1792689685777996e-01
GC_1_118 ref NI_1 NS_118 0 5.7034974755088619e-02
GC_1_119 ref NI_1 NS_119 0 9.5699659811606142e-05
GC_1_120 ref NI_1 NS_120 0 3.7806940008938257e-02
GC_1_121 ref NI_1 NS_121 0 -2.9024786386795881e-01
GC_1_122 ref NI_1 NS_122 0 1.0534313324678247e-01
GC_1_123 ref NI_1 NS_123 0 -3.6588988351167973e-02
GC_1_124 ref NI_1 NS_124 0 4.4216633562027666e-02
GC_1_125 ref NI_1 NS_125 0 1.1920211711417066e-04
GC_1_126 ref NI_1 NS_126 0 2.7184481283544639e-02
GC_1_127 ref NI_1 NS_127 0 -2.9637744097394703e-01
GC_1_128 ref NI_1 NS_128 0 1.3234005590661960e-01
GC_1_129 ref NI_1 NS_129 0 -5.1449520867062726e-02
GC_1_130 ref NI_1 NS_130 0 5.5443760549487964e-02
GC_1_131 ref NI_1 NS_131 0 1.4552385517371233e-04
GC_1_132 ref NI_1 NS_132 0 2.3114750648225664e-02
GC_1_133 ref NI_1 NS_133 0 -3.4144237878671724e-01
GC_1_134 ref NI_1 NS_134 0 1.3878131381921641e-01
GC_1_135 ref NI_1 NS_135 0 -4.2729057555231653e-02
GC_1_136 ref NI_1 NS_136 0 5.7347917345854947e-02
GC_1_137 ref NI_1 NS_137 0 1.6373772884911638e-04
GC_1_138 ref NI_1 NS_138 0 2.0867528464838952e-02
GD_1_1 ref NI_1 NA_1 0 4.5390737690845224e+00
GD_1_2 ref NI_1 NA_2 0 5.3866834549483045e-01
GD_1_3 ref NI_1 NA_3 0 1.2395862128742674e-01
GD_1_4 ref NI_1 NA_4 0 -1.6561219477089323e-01
GD_1_5 ref NI_1 NA_5 0 -8.4711981934694189e-02
GD_1_6 ref NI_1 NA_6 0 -5.8614474185350263e-02
GD_1_7 ref NI_1 NA_7 0 -2.0611057406580074e-01
GD_1_8 ref NI_1 NA_8 0 -6.0416601100865983e-02
GD_1_9 ref NI_1 NA_9 0 -4.2394291981033977e-02
GD_1_10 ref NI_1 NA_10 0 5.7283318574847517e-02
GD_1_11 ref NI_1 NA_11 0 3.5323815493917617e-02
GD_1_12 ref NI_1 NA_12 0 6.5198027150017782e-03
GD_1_13 ref NI_1 NA_13 0 1.4757981564309887e-02
GD_1_14 ref NI_1 NA_14 0 -3.9147079768899543e-03
GD_1_15 ref NI_1 NA_15 0 -1.6194837170919071e-02
GD_1_16 ref NI_1 NA_16 0 5.6101233481845744e-02
GD_1_17 ref NI_1 NA_17 0 5.4607427242651378e-02
GD_1_18 ref NI_1 NA_18 0 5.6547183856840981e-02
GD_1_19 ref NI_1 NA_19 0 5.2718446449459458e-02
GD_1_20 ref NI_1 NA_20 0 5.5881752731440304e-02
GD_1_21 ref NI_1 NA_21 0 4.8650273928037911e-02
GD_1_22 ref NI_1 NA_22 0 4.6554635010473626e-02
GD_1_23 ref NI_1 NA_23 0 5.2970826851971867e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 1.0976695687251642e+01
GC_2_2 ref NI_2 NS_2 0 -3.3917894660338894e+00
GC_2_3 ref NI_2 NS_3 0 5.1176369580075332e-01
GC_2_4 ref NI_2 NS_4 0 -1.3350478096185625e-01
GC_2_5 ref NI_2 NS_5 0 -3.1058449828073891e-04
GC_2_6 ref NI_2 NS_6 0 -1.7095356417007917e-02
GC_2_7 ref NI_2 NS_7 0 -1.6614094428157557e+01
GC_2_8 ref NI_2 NS_8 0 -2.3546922409125974e+00
GC_2_9 ref NI_2 NS_9 0 2.6124158663913982e-01
GC_2_10 ref NI_2 NS_10 0 -1.0285653094971930e-01
GC_2_11 ref NI_2 NS_11 0 -5.4371761137600916e-04
GC_2_12 ref NI_2 NS_12 0 -1.8006078657503564e-02
GC_2_13 ref NI_2 NS_13 0 8.4710749232037976e+00
GC_2_14 ref NI_2 NS_14 0 -2.0936598092899437e+00
GC_2_15 ref NI_2 NS_15 0 4.0635143711403537e-01
GC_2_16 ref NI_2 NS_16 0 -1.1384201781867320e-01
GC_2_17 ref NI_2 NS_17 0 -2.5494828106913651e-04
GC_2_18 ref NI_2 NS_18 0 -2.0084047312401588e-02
GC_2_19 ref NI_2 NS_19 0 -2.4996379852809356e-01
GC_2_20 ref NI_2 NS_20 0 1.0139739391967710e+00
GC_2_21 ref NI_2 NS_21 0 -1.1740041029220688e-01
GC_2_22 ref NI_2 NS_22 0 1.1192759067720727e-03
GC_2_23 ref NI_2 NS_23 0 2.6832242881192439e-05
GC_2_24 ref NI_2 NS_24 0 -3.4897278377121151e-02
GC_2_25 ref NI_2 NS_25 0 -4.6850808617220391e-01
GC_2_26 ref NI_2 NS_26 0 7.2828216148420966e-01
GC_2_27 ref NI_2 NS_27 0 9.7929285824460255e-02
GC_2_28 ref NI_2 NS_28 0 -1.8139274231809846e-02
GC_2_29 ref NI_2 NS_29 0 1.1813969648118092e-05
GC_2_30 ref NI_2 NS_30 0 -3.5375932124037175e-02
GC_2_31 ref NI_2 NS_31 0 -4.9910667928751568e-01
GC_2_32 ref NI_2 NS_32 0 6.7826795870907541e-01
GC_2_33 ref NI_2 NS_33 0 1.4757666090918214e-01
GC_2_34 ref NI_2 NS_34 0 -2.9342951663465327e-02
GC_2_35 ref NI_2 NS_35 0 -6.9440131156085213e-06
GC_2_36 ref NI_2 NS_36 0 -3.5089307068792840e-02
GC_2_37 ref NI_2 NS_37 0 3.5764865461871950e-02
GC_2_38 ref NI_2 NS_38 0 1.0623877854475239e+00
GC_2_39 ref NI_2 NS_39 0 -1.5760113142798773e-01
GC_2_40 ref NI_2 NS_40 0 -7.3347406435465582e-03
GC_2_41 ref NI_2 NS_41 0 -1.8421801790105299e-05
GC_2_42 ref NI_2 NS_42 0 -3.4770355858117698e-02
GC_2_43 ref NI_2 NS_43 0 1.0650563330591669e+00
GC_2_44 ref NI_2 NS_44 0 5.5480184453804970e-01
GC_2_45 ref NI_2 NS_45 0 -2.3302993546050757e-01
GC_2_46 ref NI_2 NS_46 0 -1.4980722059864192e-02
GC_2_47 ref NI_2 NS_47 0 1.2126211206243665e-05
GC_2_48 ref NI_2 NS_48 0 -7.0181905329806053e-04
GC_2_49 ref NI_2 NS_49 0 8.5564522392039000e-01
GC_2_50 ref NI_2 NS_50 0 6.4750783095093933e-01
GC_2_51 ref NI_2 NS_51 0 -1.9836531502854671e-01
GC_2_52 ref NI_2 NS_52 0 -3.7066661963702896e-02
GC_2_53 ref NI_2 NS_53 0 4.7999103189596041e-05
GC_2_54 ref NI_2 NS_54 0 -4.7146067243106571e-03
GC_2_55 ref NI_2 NS_55 0 -2.0187175050797262e-01
GC_2_56 ref NI_2 NS_56 0 3.2518282148181234e-02
GC_2_57 ref NI_2 NS_57 0 -4.9635156159817236e-02
GC_2_58 ref NI_2 NS_58 0 8.2546860383919812e-02
GC_2_59 ref NI_2 NS_59 0 1.0759042433603882e-04
GC_2_60 ref NI_2 NS_60 0 2.0263891262043331e-02
GC_2_61 ref NI_2 NS_61 0 2.7993580828871489e-02
GC_2_62 ref NI_2 NS_62 0 3.2561676311237470e-01
GC_2_63 ref NI_2 NS_63 0 -1.8683374723044377e-02
GC_2_64 ref NI_2 NS_64 0 -8.2744489389942437e-03
GC_2_65 ref NI_2 NS_65 0 5.4319045907529988e-05
GC_2_66 ref NI_2 NS_66 0 8.5777945796531238e-03
GC_2_67 ref NI_2 NS_67 0 2.0028693493571489e-01
GC_2_68 ref NI_2 NS_68 0 3.0764292477106459e-01
GC_2_69 ref NI_2 NS_69 0 -4.1290787248353424e-02
GC_2_70 ref NI_2 NS_70 0 8.3394017293432886e-03
GC_2_71 ref NI_2 NS_71 0 1.4644776484741873e-04
GC_2_72 ref NI_2 NS_72 0 4.5883641512651958e-03
GC_2_73 ref NI_2 NS_73 0 1.6820099971077190e-01
GC_2_74 ref NI_2 NS_74 0 3.9858328648343366e-01
GC_2_75 ref NI_2 NS_75 0 -5.9955342482212244e-02
GC_2_76 ref NI_2 NS_76 0 -6.7814614303607045e-03
GC_2_77 ref NI_2 NS_77 0 1.1804970471843532e-04
GC_2_78 ref NI_2 NS_78 0 3.5419840062586505e-03
GC_2_79 ref NI_2 NS_79 0 6.7886855566627435e-01
GC_2_80 ref NI_2 NS_80 0 4.3688080996256340e-01
GC_2_81 ref NI_2 NS_81 0 -1.3665760520300949e-01
GC_2_82 ref NI_2 NS_82 0 -1.8515839985100632e-02
GC_2_83 ref NI_2 NS_83 0 2.6985916193886793e-05
GC_2_84 ref NI_2 NS_84 0 4.7742605266512649e-03
GC_2_85 ref NI_2 NS_85 0 5.1748929723012527e-01
GC_2_86 ref NI_2 NS_86 0 4.3947033419098430e-01
GC_2_87 ref NI_2 NS_87 0 -2.4202803010151350e-02
GC_2_88 ref NI_2 NS_88 0 -4.1340726082483931e-02
GC_2_89 ref NI_2 NS_89 0 9.6884680274770572e-05
GC_2_90 ref NI_2 NS_90 0 -3.9496690921628740e-03
GC_2_91 ref NI_2 NS_91 0 -1.8964646035127525e-01
GC_2_92 ref NI_2 NS_92 0 5.9003794652864136e-02
GC_2_93 ref NI_2 NS_93 0 -5.4986264783332080e-02
GC_2_94 ref NI_2 NS_94 0 7.2643079565227170e-02
GC_2_95 ref NI_2 NS_95 0 8.1829021548400222e-05
GC_2_96 ref NI_2 NS_96 0 2.1421892000837515e-02
GC_2_97 ref NI_2 NS_97 0 -1.8314747295574738e-01
GC_2_98 ref NI_2 NS_98 0 6.3046576722835271e-02
GC_2_99 ref NI_2 NS_99 0 -8.3580106797428361e-02
GC_2_100 ref NI_2 NS_100 0 7.7757620374349093e-02
GC_2_101 ref NI_2 NS_101 0 4.6230270672320450e-05
GC_2_102 ref NI_2 NS_102 0 2.5283714561768759e-02
GC_2_103 ref NI_2 NS_103 0 -1.6622026435627818e-01
GC_2_104 ref NI_2 NS_104 0 5.1949753838227683e-02
GC_2_105 ref NI_2 NS_105 0 6.5451554912468388e-03
GC_2_106 ref NI_2 NS_106 0 3.7912204960294647e-02
GC_2_107 ref NI_2 NS_107 0 2.5984750124128283e-05
GC_2_108 ref NI_2 NS_108 0 2.2801167081738037e-02
GC_2_109 ref NI_2 NS_109 0 -7.4403252048270127e-02
GC_2_110 ref NI_2 NS_110 0 1.4012805402728423e-01
GC_2_111 ref NI_2 NS_111 0 4.5739088142174936e-02
GC_2_112 ref NI_2 NS_112 0 2.4186994674940355e-03
GC_2_113 ref NI_2 NS_113 0 3.2042781683892957e-05
GC_2_114 ref NI_2 NS_114 0 1.5804726603697281e-02
GC_2_115 ref NI_2 NS_115 0 -1.8124267927716989e-01
GC_2_116 ref NI_2 NS_116 0 5.8206437569537688e-02
GC_2_117 ref NI_2 NS_117 0 -8.2733837888688253e-02
GC_2_118 ref NI_2 NS_118 0 7.1499237682024944e-02
GC_2_119 ref NI_2 NS_119 0 2.5681186170401686e-05
GC_2_120 ref NI_2 NS_120 0 2.8050196421632173e-02
GC_2_121 ref NI_2 NS_121 0 -1.4422110313875069e-01
GC_2_122 ref NI_2 NS_122 0 8.2387126135967464e-02
GC_2_123 ref NI_2 NS_123 0 -5.9414325190396073e-03
GC_2_124 ref NI_2 NS_124 0 4.2327400687045956e-02
GC_2_125 ref NI_2 NS_125 0 5.6651794614988680e-05
GC_2_126 ref NI_2 NS_126 0 1.9950280491631913e-02
GC_2_127 ref NI_2 NS_127 0 -1.3223354808956989e-01
GC_2_128 ref NI_2 NS_128 0 1.0049172880186137e-01
GC_2_129 ref NI_2 NS_129 0 -1.9289681109323678e-02
GC_2_130 ref NI_2 NS_130 0 5.1151199889184658e-02
GC_2_131 ref NI_2 NS_131 0 8.7479521066708126e-05
GC_2_132 ref NI_2 NS_132 0 1.6740488163302900e-02
GC_2_133 ref NI_2 NS_133 0 -1.7368674879697626e-01
GC_2_134 ref NI_2 NS_134 0 1.1461358732635513e-01
GC_2_135 ref NI_2 NS_135 0 -1.3265194790011887e-02
GC_2_136 ref NI_2 NS_136 0 5.0979455873508092e-02
GC_2_137 ref NI_2 NS_137 0 1.0532250363892171e-04
GC_2_138 ref NI_2 NS_138 0 1.4966681662308906e-02
GD_2_1 ref NI_2 NA_1 0 5.3866834549483045e-01
GD_2_2 ref NI_2 NA_2 0 4.5498864609325889e+00
GD_2_3 ref NI_2 NA_3 0 -9.8721248583438656e-02
GD_2_4 ref NI_2 NA_4 0 -9.2430756982094228e-02
GD_2_5 ref NI_2 NA_5 0 -2.9723648875659932e-02
GD_2_6 ref NI_2 NA_6 0 -1.6786622327383104e-02
GD_2_7 ref NI_2 NA_7 0 -1.3665564207963568e-01
GD_2_8 ref NI_2 NA_8 0 -2.5586833620136043e-02
GD_2_9 ref NI_2 NA_9 0 -5.9007575016146721e-03
GD_2_10 ref NI_2 NA_10 0 5.3974572203525660e-02
GD_2_11 ref NI_2 NA_11 0 4.4166933455496389e-02
GD_2_12 ref NI_2 NA_12 0 2.4891237881842172e-02
GD_2_13 ref NI_2 NA_13 0 3.7007398821947847e-02
GD_2_14 ref NI_2 NA_14 0 8.2197527233134858e-03
GD_2_15 ref NI_2 NA_15 0 8.9811373319797737e-03
GD_2_16 ref NI_2 NA_16 0 5.5354241408114652e-02
GD_2_17 ref NI_2 NA_17 0 4.9703400970007638e-02
GD_2_18 ref NI_2 NA_18 0 5.5317011349069717e-02
GD_2_19 ref NI_2 NA_19 0 5.1221117944690676e-02
GD_2_20 ref NI_2 NA_20 0 5.0038063747791031e-02
GD_2_21 ref NI_2 NA_21 0 4.8199446175572667e-02
GD_2_22 ref NI_2 NA_22 0 4.7914757563746968e-02
GD_2_23 ref NI_2 NA_23 0 5.2283382613129724e-02
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 1.0112989490529412e+01
GC_3_2 ref NI_3 NS_2 0 -2.7920403866497581e+00
GC_3_3 ref NI_3 NS_3 0 5.8373314327543468e-01
GC_3_4 ref NI_3 NS_4 0 -1.6084242355748307e-01
GC_3_5 ref NI_3 NS_5 0 -4.5074379961490899e-04
GC_3_6 ref NI_3 NS_6 0 -2.7599141916885579e-02
GC_3_7 ref NI_3 NS_7 0 8.4710749232037941e+00
GC_3_8 ref NI_3 NS_8 0 -2.0936598092899423e+00
GC_3_9 ref NI_3 NS_9 0 4.0635143711403360e-01
GC_3_10 ref NI_3 NS_10 0 -1.1384201781867224e-01
GC_3_11 ref NI_3 NS_11 0 -2.5494828106907108e-04
GC_3_12 ref NI_3 NS_12 0 -2.0084047312401876e-02
GC_3_13 ref NI_3 NS_13 0 -1.8503566503414785e+01
GC_3_14 ref NI_3 NS_14 0 -1.2928085350851481e+00
GC_3_15 ref NI_3 NS_15 0 2.7386640827431741e-01
GC_3_16 ref NI_3 NS_16 0 -1.2453683413572031e-01
GC_3_17 ref NI_3 NS_17 0 -6.0177654088526121e-04
GC_3_18 ref NI_3 NS_18 0 -3.7889648982498997e-02
GC_3_19 ref NI_3 NS_19 0 2.1716335662666864e+00
GC_3_20 ref NI_3 NS_20 0 4.8223751642487511e-01
GC_3_21 ref NI_3 NS_21 0 -4.4263572283648051e-02
GC_3_22 ref NI_3 NS_22 0 -6.3039837500347848e-02
GC_3_23 ref NI_3 NS_23 0 -1.2869677644086926e-04
GC_3_24 ref NI_3 NS_24 0 -5.6153935142396930e-02
GC_3_25 ref NI_3 NS_25 0 1.4888827094184587e+00
GC_3_26 ref NI_3 NS_26 0 4.3260740308274231e-01
GC_3_27 ref NI_3 NS_27 0 1.2063972043251361e-01
GC_3_28 ref NI_3 NS_28 0 -8.2841503766846500e-02
GC_3_29 ref NI_3 NS_29 0 -1.4019584162945381e-04
GC_3_30 ref NI_3 NS_30 0 -5.6529903292459237e-02
GC_3_31 ref NI_3 NS_31 0 1.2194427882132739e+00
GC_3_32 ref NI_3 NS_32 0 5.0251989597299906e-01
GC_3_33 ref NI_3 NS_33 0 1.4887018753735187e-01
GC_3_34 ref NI_3 NS_34 0 -9.2322840971164763e-02
GC_3_35 ref NI_3 NS_35 0 -1.5572388697445840e-04
GC_3_36 ref NI_3 NS_36 0 -5.6073868201818297e-02
GC_3_37 ref NI_3 NS_37 0 2.6168225993950740e+00
GC_3_38 ref NI_3 NS_38 0 4.4168344390148012e-01
GC_3_39 ref NI_3 NS_39 0 -6.4403079982720976e-02
GC_3_40 ref NI_3 NS_40 0 -7.5601285738351370e-02
GC_3_41 ref NI_3 NS_41 0 -1.7153784749280785e-04
GC_3_42 ref NI_3 NS_42 0 -5.3204149876853138e-02
GC_3_43 ref NI_3 NS_43 0 2.5397453590687363e-01
GC_3_44 ref NI_3 NS_44 0 4.1888383444509075e-01
GC_3_45 ref NI_3 NS_45 0 -8.1277173849700693e-02
GC_3_46 ref NI_3 NS_46 0 1.6488024853424248e-02
GC_3_47 ref NI_3 NS_47 0 6.6553950718059574e-05
GC_3_48 ref NI_3 NS_48 0 1.7173821116799747e-03
GC_3_49 ref NI_3 NS_49 0 2.7319568665001659e-01
GC_3_50 ref NI_3 NS_50 0 4.0898133965014727e-01
GC_3_51 ref NI_3 NS_51 0 -2.0229499096748517e-02
GC_3_52 ref NI_3 NS_52 0 2.4094653304797139e-03
GC_3_53 ref NI_3 NS_53 0 9.9356744366137890e-05
GC_3_54 ref NI_3 NS_54 0 -5.0425523350304110e-03
GC_3_55 ref NI_3 NS_55 0 -2.3329165641764102e-01
GC_3_56 ref NI_3 NS_56 0 9.7574055613768418e-02
GC_3_57 ref NI_3 NS_57 0 -1.1429924342481952e-01
GC_3_58 ref NI_3 NS_58 0 7.1443322264050951e-02
GC_3_59 ref NI_3 NS_59 0 1.3266719203844059e-04
GC_3_60 ref NI_3 NS_60 0 3.1422278073556395e-02
GC_3_61 ref NI_3 NS_61 0 -4.0891392691462004e-02
GC_3_62 ref NI_3 NS_62 0 1.6974309945004523e-01
GC_3_63 ref NI_3 NS_63 0 9.2025621705658211e-03
GC_3_64 ref NI_3 NS_64 0 2.2776228379253551e-02
GC_3_65 ref NI_3 NS_65 0 1.0000978073307975e-04
GC_3_66 ref NI_3 NS_66 0 1.3932307012108942e-02
GC_3_67 ref NI_3 NS_67 0 1.4900086136350046e-01
GC_3_68 ref NI_3 NS_68 0 1.8533535275877563e-01
GC_3_69 ref NI_3 NS_69 0 -2.1326500397972417e-02
GC_3_70 ref NI_3 NS_70 0 3.5677608114352950e-02
GC_3_71 ref NI_3 NS_71 0 1.7628936407247634e-04
GC_3_72 ref NI_3 NS_72 0 8.3552459283164331e-03
GC_3_73 ref NI_3 NS_73 0 1.2114795786238304e-01
GC_3_74 ref NI_3 NS_74 0 2.2165423939224863e-01
GC_3_75 ref NI_3 NS_75 0 -8.4280448613148033e-03
GC_3_76 ref NI_3 NS_76 0 2.3702001065996070e-02
GC_3_77 ref NI_3 NS_77 0 1.5050011279815038e-04
GC_3_78 ref NI_3 NS_78 0 6.6707679593223388e-03
GC_3_79 ref NI_3 NS_79 0 -1.1071928285633198e-01
GC_3_80 ref NI_3 NS_80 0 3.2566033051339921e-01
GC_3_81 ref NI_3 NS_81 0 -3.7102605274425472e-02
GC_3_82 ref NI_3 NS_82 0 2.2779220740334387e-02
GC_3_83 ref NI_3 NS_83 0 1.0967091135324059e-04
GC_3_84 ref NI_3 NS_84 0 9.4511913819726595e-03
GC_3_85 ref NI_3 NS_85 0 2.1153502174430969e-01
GC_3_86 ref NI_3 NS_86 0 2.4653991342477213e-01
GC_3_87 ref NI_3 NS_87 0 5.2419569573732845e-02
GC_3_88 ref NI_3 NS_88 0 1.3106523328279870e-02
GC_3_89 ref NI_3 NS_89 0 1.5297246425600319e-04
GC_3_90 ref NI_3 NS_90 0 -4.5049870827545855e-03
GC_3_91 ref NI_3 NS_91 0 -2.1562992710139037e-01
GC_3_92 ref NI_3 NS_92 0 1.0496030308922027e-01
GC_3_93 ref NI_3 NS_93 0 -1.0662680335226114e-01
GC_3_94 ref NI_3 NS_94 0 6.0239913793773602e-02
GC_3_95 ref NI_3 NS_95 0 1.0744644750587208e-04
GC_3_96 ref NI_3 NS_96 0 3.2718876828625044e-02
GC_3_97 ref NI_3 NS_97 0 -2.3506929451371117e-01
GC_3_98 ref NI_3 NS_98 0 1.2226135309655166e-01
GC_3_99 ref NI_3 NS_99 0 -1.3309901619685935e-01
GC_3_100 ref NI_3 NS_100 0 5.5407871210689151e-02
GC_3_101 ref NI_3 NS_101 0 7.9348079365451263e-05
GC_3_102 ref NI_3 NS_102 0 3.8788961506625690e-02
GC_3_103 ref NI_3 NS_103 0 -2.2720065864809719e-01
GC_3_104 ref NI_3 NS_104 0 7.8878098634121901e-02
GC_3_105 ref NI_3 NS_105 0 -6.2663713650365188e-02
GC_3_106 ref NI_3 NS_106 0 4.1913873079580312e-02
GC_3_107 ref NI_3 NS_107 0 8.0736062579850150e-05
GC_3_108 ref NI_3 NS_108 0 3.4724601324343213e-02
GC_3_109 ref NI_3 NS_109 0 -2.1438653872709257e-01
GC_3_110 ref NI_3 NS_110 0 8.5865880773736844e-02
GC_3_111 ref NI_3 NS_111 0 2.7109001825302544e-03
GC_3_112 ref NI_3 NS_112 0 3.3875815515647986e-02
GC_3_113 ref NI_3 NS_113 0 1.0393318401544140e-04
GC_3_114 ref NI_3 NS_114 0 2.4512325868222599e-02
GC_3_115 ref NI_3 NS_115 0 -2.5182014198046559e-01
GC_3_116 ref NI_3 NS_116 0 1.2396369930730629e-01
GC_3_117 ref NI_3 NS_117 0 -1.3566825833105828e-01
GC_3_118 ref NI_3 NS_118 0 4.6770566664818422e-02
GC_3_119 ref NI_3 NS_119 0 7.6104690303318632e-05
GC_3_120 ref NI_3 NS_120 0 4.2698482094502686e-02
GC_3_121 ref NI_3 NS_121 0 -1.6448271740260945e-01
GC_3_122 ref NI_3 NS_122 0 9.0677448488873574e-02
GC_3_123 ref NI_3 NS_123 0 -5.9300382843818722e-02
GC_3_124 ref NI_3 NS_124 0 4.4506727543036112e-02
GC_3_125 ref NI_3 NS_125 0 9.0856452011372300e-05
GC_3_126 ref NI_3 NS_126 0 3.0560064204622716e-02
GC_3_127 ref NI_3 NS_127 0 -1.3916727906212345e-01
GC_3_128 ref NI_3 NS_128 0 1.0426232155622796e-01
GC_3_129 ref NI_3 NS_129 0 -6.5568692954908400e-02
GC_3_130 ref NI_3 NS_130 0 5.3845254765610896e-02
GC_3_131 ref NI_3 NS_131 0 1.1210001989350054e-04
GC_3_132 ref NI_3 NS_132 0 2.5977914417868873e-02
GC_3_133 ref NI_3 NS_133 0 -1.6288696785121642e-01
GC_3_134 ref NI_3 NS_134 0 1.1017536420547003e-01
GC_3_135 ref NI_3 NS_135 0 -5.9693030739732762e-02
GC_3_136 ref NI_3 NS_136 0 5.7074151831597621e-02
GC_3_137 ref NI_3 NS_137 0 1.3240080738512313e-04
GC_3_138 ref NI_3 NS_138 0 2.3370057527144172e-02
GD_3_1 ref NI_3 NA_1 0 1.2395862128742674e-01
GD_3_2 ref NI_3 NA_2 0 -9.8721248583438656e-02
GD_3_3 ref NI_3 NA_3 0 4.1001444567503604e+00
GD_3_4 ref NI_3 NA_4 0 6.7710142476844704e-02
GD_3_5 ref NI_3 NA_5 0 1.0719064496306195e-01
GD_3_6 ref NI_3 NA_6 0 8.8198738279226252e-02
GD_3_7 ref NI_3 NA_7 0 2.1115479713981651e-02
GD_3_8 ref NI_3 NA_8 0 -5.5725541000884421e-02
GD_3_9 ref NI_3 NA_9 0 -5.2020877976302886e-02
GD_3_10 ref NI_3 NA_10 0 5.1656229778272687e-02
GD_3_11 ref NI_3 NA_11 0 1.3526524990949826e-02
GD_3_12 ref NI_3 NA_12 0 -2.8958087087038605e-03
GD_3_13 ref NI_3 NA_13 0 -2.1943661810703099e-04
GD_3_14 ref NI_3 NA_14 0 -1.3144469923693810e-02
GD_3_15 ref NI_3 NA_15 0 -3.1975802018750742e-02
GD_3_16 ref NI_3 NA_16 0 5.0065962698659996e-02
GD_3_17 ref NI_3 NA_17 0 5.0064768935266943e-02
GD_3_18 ref NI_3 NA_18 0 4.6982587611258682e-02
GD_3_19 ref NI_3 NA_19 0 3.4523904657329484e-02
GD_3_20 ref NI_3 NA_20 0 5.2733266224753050e-02
GD_3_21 ref NI_3 NA_21 0 3.7258745713271695e-02
GD_3_22 ref NI_3 NA_22 0 3.5713381339804895e-02
GD_3_23 ref NI_3 NA_23 0 3.9091564513816922e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 3.6801648107339707e-01
GC_4_2 ref NI_4 NS_2 0 1.1683955880263368e+00
GC_4_3 ref NI_4 NS_3 0 -1.5085762454450449e-01
GC_4_4 ref NI_4 NS_4 0 -2.2595575277151864e-02
GC_4_5 ref NI_4 NS_5 0 -1.6254233269981269e-04
GC_4_6 ref NI_4 NS_6 0 -5.0353973479646978e-02
GC_4_7 ref NI_4 NS_7 0 -2.4996379852809353e-01
GC_4_8 ref NI_4 NS_8 0 1.0139739391967706e+00
GC_4_9 ref NI_4 NS_9 0 -1.1740041029220653e-01
GC_4_10 ref NI_4 NS_10 0 1.1192759067718827e-03
GC_4_11 ref NI_4 NS_11 0 2.6832242881180520e-05
GC_4_12 ref NI_4 NS_12 0 -3.4897278377121109e-02
GC_4_13 ref NI_4 NS_13 0 2.1716335662666864e+00
GC_4_14 ref NI_4 NS_14 0 4.8223751642487511e-01
GC_4_15 ref NI_4 NS_15 0 -4.4263572283648016e-02
GC_4_16 ref NI_4 NS_16 0 -6.3039837500347889e-02
GC_4_17 ref NI_4 NS_17 0 -1.2869677644086934e-04
GC_4_18 ref NI_4 NS_18 0 -5.6153935142396930e-02
GC_4_19 ref NI_4 NS_19 0 5.1878367036804711e+00
GC_4_20 ref NI_4 NS_20 0 -5.5544078910884576e+00
GC_4_21 ref NI_4 NS_21 0 -7.0495831140093979e-01
GC_4_22 ref NI_4 NS_22 0 -2.9017382610322678e-01
GC_4_23 ref NI_4 NS_23 0 -2.1193986919586317e-03
GC_4_24 ref NI_4 NS_24 0 -1.1503783123521341e-01
GC_4_25 ref NI_4 NS_25 0 -1.3249087945473529e-03
GC_4_26 ref NI_4 NS_26 0 1.9138472436123890e+00
GC_4_27 ref NI_4 NS_27 0 -9.2284795455868943e-02
GC_4_28 ref NI_4 NS_28 0 -1.5592120098773740e-01
GC_4_29 ref NI_4 NS_29 0 -4.4298917876575130e-04
GC_4_30 ref NI_4 NS_30 0 -9.4808495470305468e-02
GC_4_31 ref NI_4 NS_31 0 -8.8747079364847103e-01
GC_4_32 ref NI_4 NS_32 0 3.2567433114676830e-01
GC_4_33 ref NI_4 NS_33 0 8.9420089257358071e-01
GC_4_34 ref NI_4 NS_34 0 -1.7483950199028547e-01
GC_4_35 ref NI_4 NS_35 0 -3.1031693410749306e-04
GC_4_36 ref NI_4 NS_36 0 -8.6405111319891578e-02
GC_4_37 ref NI_4 NS_37 0 -9.9994427165834643e-01
GC_4_38 ref NI_4 NS_38 0 1.3793416246993295e-01
GC_4_39 ref NI_4 NS_39 0 9.2952392490984936e-01
GC_4_40 ref NI_4 NS_40 0 -1.5344882976277319e-01
GC_4_41 ref NI_4 NS_41 0 -1.9717762352759551e-04
GC_4_42 ref NI_4 NS_42 0 -7.7544504738961045e-02
GC_4_43 ref NI_4 NS_43 0 -3.8487321891707432e-01
GC_4_44 ref NI_4 NS_44 0 -1.3407666622840547e-01
GC_4_45 ref NI_4 NS_45 0 1.8060317366792397e-01
GC_4_46 ref NI_4 NS_46 0 5.8110317636371478e-02
GC_4_47 ref NI_4 NS_47 0 1.6913487505498237e-04
GC_4_48 ref NI_4 NS_48 0 7.1079417393235360e-03
GC_4_49 ref NI_4 NS_49 0 -3.0724835623857899e-01
GC_4_50 ref NI_4 NS_50 0 -2.2840346228750338e-01
GC_4_51 ref NI_4 NS_51 0 2.4119752646075263e-01
GC_4_52 ref NI_4 NS_52 0 7.7195518097973634e-02
GC_4_53 ref NI_4 NS_53 0 2.2439034636724317e-04
GC_4_54 ref NI_4 NS_54 0 -3.4800342074678982e-03
GC_4_55 ref NI_4 NS_55 0 -3.8333018370885114e-01
GC_4_56 ref NI_4 NS_56 0 2.3386303498668023e-01
GC_4_57 ref NI_4 NS_57 0 -2.3861907010405814e-01
GC_4_58 ref NI_4 NS_58 0 5.0630949638478549e-02
GC_4_59 ref NI_4 NS_59 0 2.0605227937338849e-04
GC_4_60 ref NI_4 NS_60 0 5.0596678985511949e-02
GC_4_61 ref NI_4 NS_61 0 -2.0815719553357104e-01
GC_4_62 ref NI_4 NS_62 0 -6.9929461041447552e-02
GC_4_63 ref NI_4 NS_63 0 2.2521642879548900e-02
GC_4_64 ref NI_4 NS_64 0 6.8461552202656401e-02
GC_4_65 ref NI_4 NS_65 0 2.1497095227809531e-04
GC_4_66 ref NI_4 NS_66 0 2.2940619179899768e-02
GC_4_67 ref NI_4 NS_67 0 -3.1357399516713386e-01
GC_4_68 ref NI_4 NS_68 0 -6.1841567506650610e-03
GC_4_69 ref NI_4 NS_69 0 -1.1461354340155654e-02
GC_4_70 ref NI_4 NS_70 0 9.0059161543405833e-02
GC_4_71 ref NI_4 NS_71 0 2.8239880075965688e-04
GC_4_72 ref NI_4 NS_72 0 1.6521244927396803e-02
GC_4_73 ref NI_4 NS_73 0 -2.8164658666347792e-01
GC_4_74 ref NI_4 NS_74 0 -7.2032257241953099e-02
GC_4_75 ref NI_4 NS_75 0 5.2862072437015725e-02
GC_4_76 ref NI_4 NS_76 0 8.1953018159251587e-02
GC_4_77 ref NI_4 NS_77 0 2.6535354808915194e-04
GC_4_78 ref NI_4 NS_78 0 1.3347203988903631e-02
GC_4_79 ref NI_4 NS_79 0 -2.8298897819185337e-01
GC_4_80 ref NI_4 NS_80 0 -1.1787960016660184e-01
GC_4_81 ref NI_4 NS_81 0 9.4730552364377579e-02
GC_4_82 ref NI_4 NS_82 0 6.3544257208640542e-02
GC_4_83 ref NI_4 NS_83 0 2.0801224480014997e-04
GC_4_84 ref NI_4 NS_84 0 1.7401377219946175e-02
GC_4_85 ref NI_4 NS_85 0 -2.2863678230234979e-01
GC_4_86 ref NI_4 NS_86 0 -1.8170650022754858e-01
GC_4_87 ref NI_4 NS_87 0 1.2604158476667973e-01
GC_4_88 ref NI_4 NS_88 0 1.1674626627979004e-01
GC_4_89 ref NI_4 NS_89 0 2.8293960757170959e-04
GC_4_90 ref NI_4 NS_90 0 -2.8326798740774765e-03
GC_4_91 ref NI_4 NS_91 0 -3.5587924462861342e-01
GC_4_92 ref NI_4 NS_92 0 1.9675642280286820e-01
GC_4_93 ref NI_4 NS_93 0 -1.9393025882029299e-01
GC_4_94 ref NI_4 NS_94 0 3.4091771470155387e-02
GC_4_95 ref NI_4 NS_95 0 1.8565624146369160e-04
GC_4_96 ref NI_4 NS_96 0 5.1518038661064670e-02
GC_4_97 ref NI_4 NS_97 0 -3.4493978451190610e-01
GC_4_98 ref NI_4 NS_98 0 1.9834375478667610e-01
GC_4_99 ref NI_4 NS_99 0 -1.7424487172848288e-01
GC_4_100 ref NI_4 NS_100 0 2.6441670930470911e-03
GC_4_101 ref NI_4 NS_101 0 1.6136102986441788e-04
GC_4_102 ref NI_4 NS_102 0 5.9593329956634640e-02
GC_4_103 ref NI_4 NS_103 0 -2.6045195230161833e-01
GC_4_104 ref NI_4 NS_104 0 1.1830830363324153e-01
GC_4_105 ref NI_4 NS_105 0 -1.3357062161357666e-01
GC_4_106 ref NI_4 NS_106 0 1.8500128362766568e-02
GC_4_107 ref NI_4 NS_107 0 1.7443302262919530e-04
GC_4_108 ref NI_4 NS_108 0 5.2498957343114307e-02
GC_4_109 ref NI_4 NS_109 0 -1.9201098106828610e-01
GC_4_110 ref NI_4 NS_110 0 1.5520283139148414e-02
GC_4_111 ref NI_4 NS_111 0 -7.8272828674085790e-02
GC_4_112 ref NI_4 NS_112 0 5.5022984286397056e-02
GC_4_113 ref NI_4 NS_113 0 2.0600852142372054e-04
GC_4_114 ref NI_4 NS_114 0 3.7802311959109880e-02
GC_4_115 ref NI_4 NS_115 0 -3.2277842783208366e-01
GC_4_116 ref NI_4 NS_116 0 1.8144516326049739e-01
GC_4_117 ref NI_4 NS_117 0 -1.4687536380268015e-01
GC_4_118 ref NI_4 NS_118 0 -2.0076952881751813e-02
GC_4_119 ref NI_4 NS_119 0 1.6241801451379400e-04
GC_4_120 ref NI_4 NS_120 0 6.4206272230933156e-02
GC_4_121 ref NI_4 NS_121 0 -2.6598771677850624e-01
GC_4_122 ref NI_4 NS_122 0 1.0933544085870735e-01
GC_4_123 ref NI_4 NS_123 0 -1.2868933538062516e-01
GC_4_124 ref NI_4 NS_124 0 3.3488898892355096e-02
GC_4_125 ref NI_4 NS_125 0 1.8562059564815924e-04
GC_4_126 ref NI_4 NS_126 0 4.7208228126048378e-02
GC_4_127 ref NI_4 NS_127 0 -3.0913741177518311e-01
GC_4_128 ref NI_4 NS_128 0 1.3089894216552300e-01
GC_4_129 ref NI_4 NS_129 0 -1.5275247659677410e-01
GC_4_130 ref NI_4 NS_130 0 5.6207416241589342e-02
GC_4_131 ref NI_4 NS_131 0 2.0111089844384407e-04
GC_4_132 ref NI_4 NS_132 0 4.1775188569050679e-02
GC_4_133 ref NI_4 NS_133 0 -3.1805039283949388e-01
GC_4_134 ref NI_4 NS_134 0 1.2907851798839906e-01
GC_4_135 ref NI_4 NS_135 0 -1.6091330845099597e-01
GC_4_136 ref NI_4 NS_136 0 7.0023860553751885e-02
GC_4_137 ref NI_4 NS_137 0 2.2044398303839872e-04
GC_4_138 ref NI_4 NS_138 0 3.8401243789817914e-02
GD_4_1 ref NI_4 NA_1 0 -1.6561219477089323e-01
GD_4_2 ref NI_4 NA_2 0 -9.2430756982094228e-02
GD_4_3 ref NI_4 NA_3 0 6.7710142476844704e-02
GD_4_4 ref NI_4 NA_4 0 4.9068136321833364e+00
GD_4_5 ref NI_4 NA_5 0 -1.5093374801554446e-02
GD_4_6 ref NI_4 NA_6 0 1.3936312835967032e-01
GD_4_7 ref NI_4 NA_7 0 1.4154621253617544e-01
GD_4_8 ref NI_4 NA_8 0 7.1653805243172400e-02
GD_4_9 ref NI_4 NA_9 0 6.1395662102841045e-02
GD_4_10 ref NI_4 NA_10 0 7.6890763504165890e-02
GD_4_11 ref NI_4 NA_11 0 4.9741287318135055e-02
GD_4_12 ref NI_4 NA_12 0 6.3483947494355639e-02
GD_4_13 ref NI_4 NA_13 0 5.9939333450754542e-02
GD_4_14 ref NI_4 NA_14 0 6.1831551090805376e-02
GD_4_15 ref NI_4 NA_15 0 5.1079365684995916e-02
GD_4_16 ref NI_4 NA_16 0 7.2720612964282047e-02
GD_4_17 ref NI_4 NA_17 0 6.9441386399500579e-02
GD_4_18 ref NI_4 NA_18 0 5.8374534538908819e-02
GD_4_19 ref NI_4 NA_19 0 4.8901591676966026e-02
GD_4_20 ref NI_4 NA_20 0 6.6177087459519834e-02
GD_4_21 ref NI_4 NA_21 0 5.7692602303733076e-02
GD_4_22 ref NI_4 NA_22 0 6.4528200754980419e-02
GD_4_23 ref NI_4 NA_23 0 6.7102491228436784e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 -1.5282871245924098e-01
GC_5_2 ref NI_5 NS_2 0 8.8094824094301294e-01
GC_5_3 ref NI_5 NS_3 0 1.2084190863309766e-01
GC_5_4 ref NI_5 NS_4 0 -5.0146880395978088e-02
GC_5_5 ref NI_5 NS_5 0 -1.6944828327405210e-04
GC_5_6 ref NI_5 NS_6 0 -5.0251299826738351e-02
GC_5_7 ref NI_5 NS_7 0 -4.6850808617220391e-01
GC_5_8 ref NI_5 NS_8 0 7.2828216148420977e-01
GC_5_9 ref NI_5 NS_9 0 9.7929285824460116e-02
GC_5_10 ref NI_5 NS_10 0 -1.8139274231809759e-02
GC_5_11 ref NI_5 NS_11 0 1.1813969648124518e-05
GC_5_12 ref NI_5 NS_12 0 -3.5375932124037203e-02
GC_5_13 ref NI_5 NS_13 0 1.4888827094184587e+00
GC_5_14 ref NI_5 NS_14 0 4.3260740308274170e-01
GC_5_15 ref NI_5 NS_15 0 1.2063972043251443e-01
GC_5_16 ref NI_5 NS_16 0 -8.2841503766846944e-02
GC_5_17 ref NI_5 NS_17 0 -1.4019584162948271e-04
GC_5_18 ref NI_5 NS_18 0 -5.6529903292459105e-02
GC_5_19 ref NI_5 NS_19 0 -1.3249087945473978e-03
GC_5_20 ref NI_5 NS_20 0 1.9138472436123892e+00
GC_5_21 ref NI_5 NS_21 0 -9.2284795455869248e-02
GC_5_22 ref NI_5 NS_22 0 -1.5592120098773726e-01
GC_5_23 ref NI_5 NS_23 0 -4.4298917876574073e-04
GC_5_24 ref NI_5 NS_24 0 -9.4808495470305523e-02
GC_5_25 ref NI_5 NS_25 0 4.8376377919644558e+00
GC_5_26 ref NI_5 NS_26 0 -6.2997640403504089e+00
GC_5_27 ref NI_5 NS_27 0 -2.1754553733738080e-01
GC_5_28 ref NI_5 NS_28 0 -3.2234009091442828e-01
GC_5_29 ref NI_5 NS_29 0 -1.8376198507002886e-03
GC_5_30 ref NI_5 NS_30 0 -1.1304209844800471e-01
GC_5_31 ref NI_5 NS_31 0 1.4468308516217726e-01
GC_5_32 ref NI_5 NS_32 0 1.4026822696830612e+00
GC_5_33 ref NI_5 NS_33 0 2.0037309003909809e-01
GC_5_34 ref NI_5 NS_34 0 -1.6875605676072028e-01
GC_5_35 ref NI_5 NS_35 0 -3.7891389741985185e-04
GC_5_36 ref NI_5 NS_36 0 -9.4947284618460789e-02
GC_5_37 ref NI_5 NS_37 0 -9.6265187370684835e-01
GC_5_38 ref NI_5 NS_38 0 3.5900333554896707e-01
GC_5_39 ref NI_5 NS_39 0 8.8897050530869448e-01
GC_5_40 ref NI_5 NS_40 0 -1.8740087675080583e-01
GC_5_41 ref NI_5 NS_41 0 -3.0790431710676344e-04
GC_5_42 ref NI_5 NS_42 0 -8.1252800297752018e-02
GC_5_43 ref NI_5 NS_43 0 -2.4217986488523843e-01
GC_5_44 ref NI_5 NS_44 0 -1.9003111957295099e-01
GC_5_45 ref NI_5 NS_45 0 1.6443447974082556e-01
GC_5_46 ref NI_5 NS_46 0 7.6488517996403479e-02
GC_5_47 ref NI_5 NS_47 0 1.7109107653129105e-04
GC_5_48 ref NI_5 NS_48 0 6.4164839684571007e-03
GC_5_49 ref NI_5 NS_49 0 -1.5292188488724420e-01
GC_5_50 ref NI_5 NS_50 0 -2.8183945686795847e-01
GC_5_51 ref NI_5 NS_51 0 2.1401379624497052e-01
GC_5_52 ref NI_5 NS_52 0 1.0133516191479712e-01
GC_5_53 ref NI_5 NS_53 0 2.3409130013919010e-04
GC_5_54 ref NI_5 NS_54 0 -4.7555750052187332e-03
GC_5_55 ref NI_5 NS_55 0 -4.1768852671296558e-01
GC_5_56 ref NI_5 NS_56 0 2.6514166815997015e-01
GC_5_57 ref NI_5 NS_57 0 -2.5805958078071262e-01
GC_5_58 ref NI_5 NS_58 0 4.8539223485738588e-02
GC_5_59 ref NI_5 NS_59 0 1.9294536638324669e-04
GC_5_60 ref NI_5 NS_60 0 5.2437623526933271e-02
GC_5_61 ref NI_5 NS_61 0 -1.6376914038039800e-01
GC_5_62 ref NI_5 NS_62 0 -6.3488594713316471e-02
GC_5_63 ref NI_5 NS_63 0 -1.3349395538926964e-02
GC_5_64 ref NI_5 NS_64 0 8.2088226784562485e-02
GC_5_65 ref NI_5 NS_65 0 2.1365932005611564e-04
GC_5_66 ref NI_5 NS_66 0 2.3107897867387265e-02
GC_5_67 ref NI_5 NS_67 0 -2.6338255649325620e-01
GC_5_68 ref NI_5 NS_68 0 -9.2686179929592685e-03
GC_5_69 ref NI_5 NS_69 0 -4.3014478554798459e-02
GC_5_70 ref NI_5 NS_70 0 1.0403908378019797e-01
GC_5_71 ref NI_5 NS_71 0 2.8124856918324920e-04
GC_5_72 ref NI_5 NS_72 0 1.6590977883064371e-02
GC_5_73 ref NI_5 NS_73 0 -2.1264334131892951e-01
GC_5_74 ref NI_5 NS_74 0 -8.2410673974448206e-02
GC_5_75 ref NI_5 NS_75 0 2.0678103061381355e-02
GC_5_76 ref NI_5 NS_76 0 9.8111134540741510e-02
GC_5_77 ref NI_5 NS_77 0 2.6704934739317878e-04
GC_5_78 ref NI_5 NS_78 0 1.3134884995260054e-02
GC_5_79 ref NI_5 NS_79 0 -1.9020125784973463e-01
GC_5_80 ref NI_5 NS_80 0 -1.3519834493233152e-01
GC_5_81 ref NI_5 NS_81 0 6.3533969432684301e-02
GC_5_82 ref NI_5 NS_82 0 8.0108965524878006e-02
GC_5_83 ref NI_5 NS_83 0 2.0704273630170892e-04
GC_5_84 ref NI_5 NS_84 0 1.7174788391971320e-02
GC_5_85 ref NI_5 NS_85 0 -1.3292074354976208e-01
GC_5_86 ref NI_5 NS_86 0 -1.9446961111137392e-01
GC_5_87 ref NI_5 NS_87 0 7.9043370597460291e-02
GC_5_88 ref NI_5 NS_88 0 1.4182037225027952e-01
GC_5_89 ref NI_5 NS_89 0 3.0447817507956500e-04
GC_5_90 ref NI_5 NS_90 0 -3.9709352480704696e-03
GC_5_91 ref NI_5 NS_91 0 -3.8062053854487532e-01
GC_5_92 ref NI_5 NS_92 0 2.2173716621997142e-01
GC_5_93 ref NI_5 NS_93 0 -2.1036384952116974e-01
GC_5_94 ref NI_5 NS_94 0 3.1954566080590656e-02
GC_5_95 ref NI_5 NS_95 0 1.7337044194602297e-04
GC_5_96 ref NI_5 NS_96 0 5.3288076461371119e-02
GC_5_97 ref NI_5 NS_97 0 -3.6798346530792048e-01
GC_5_98 ref NI_5 NS_98 0 2.1739511910947287e-01
GC_5_99 ref NI_5 NS_99 0 -1.8228374031304437e-01
GC_5_100 ref NI_5 NS_100 0 -2.8447333732254474e-03
GC_5_101 ref NI_5 NS_101 0 1.4836768178580899e-04
GC_5_102 ref NI_5 NS_102 0 6.1619848615815730e-02
GC_5_103 ref NI_5 NS_103 0 -2.8091089677298903e-01
GC_5_104 ref NI_5 NS_104 0 1.4509384032035244e-01
GC_5_105 ref NI_5 NS_105 0 -1.5377909418025454e-01
GC_5_106 ref NI_5 NS_106 0 1.7969586271657914e-02
GC_5_107 ref NI_5 NS_107 0 1.6327812402303329e-04
GC_5_108 ref NI_5 NS_108 0 5.4120437710819355e-02
GC_5_109 ref NI_5 NS_109 0 -1.9339195724067509e-01
GC_5_110 ref NI_5 NS_110 0 4.5335157458182479e-02
GC_5_111 ref NI_5 NS_111 0 -1.1457659859741717e-01
GC_5_112 ref NI_5 NS_112 0 6.2730253563225813e-02
GC_5_113 ref NI_5 NS_113 0 1.9869188559805780e-04
GC_5_114 ref NI_5 NS_114 0 3.8710125594360309e-02
GC_5_115 ref NI_5 NS_115 0 -3.4353400660944727e-01
GC_5_116 ref NI_5 NS_116 0 1.9693837755241167e-01
GC_5_117 ref NI_5 NS_117 0 -1.5048964455748418e-01
GC_5_118 ref NI_5 NS_118 0 -2.7176464543563608e-02
GC_5_119 ref NI_5 NS_119 0 1.4941821933400309e-04
GC_5_120 ref NI_5 NS_120 0 6.6331590334392398e-02
GC_5_121 ref NI_5 NS_121 0 -2.7942722775357159e-01
GC_5_122 ref NI_5 NS_122 0 1.3350086157346269e-01
GC_5_123 ref NI_5 NS_123 0 -1.5098699476286986e-01
GC_5_124 ref NI_5 NS_124 0 3.4858685235336799e-02
GC_5_125 ref NI_5 NS_125 0 1.7556126968048698e-04
GC_5_126 ref NI_5 NS_126 0 4.8644665413874182e-02
GC_5_127 ref NI_5 NS_127 0 -3.2067169521091488e-01
GC_5_128 ref NI_5 NS_128 0 1.5529806058362858e-01
GC_5_129 ref NI_5 NS_129 0 -1.7791948772101293e-01
GC_5_130 ref NI_5 NS_130 0 5.9192162540020715e-02
GC_5_131 ref NI_5 NS_131 0 1.9142677469866984e-04
GC_5_132 ref NI_5 NS_132 0 4.3083080632322329e-02
GC_5_133 ref NI_5 NS_133 0 -3.2921709367552859e-01
GC_5_134 ref NI_5 NS_134 0 1.5623399216318357e-01
GC_5_135 ref NI_5 NS_135 0 -1.9001975356590253e-01
GC_5_136 ref NI_5 NS_136 0 7.4510897493076295e-02
GC_5_137 ref NI_5 NS_137 0 2.1142080008521580e-04
GC_5_138 ref NI_5 NS_138 0 3.9598462456054341e-02
GD_5_1 ref NI_5 NA_1 0 -8.4711981934694189e-02
GD_5_2 ref NI_5 NA_2 0 -2.9723648875659932e-02
GD_5_3 ref NI_5 NA_3 0 1.0719064496306195e-01
GD_5_4 ref NI_5 NA_4 0 -1.5093374801554446e-02
GD_5_5 ref NI_5 NA_5 0 5.0164974377897069e+00
GD_5_6 ref NI_5 NA_6 0 -1.2158320255593259e-02
GD_5_7 ref NI_5 NA_7 0 1.3138360915850394e-01
GD_5_8 ref NI_5 NA_8 0 5.3625226641437936e-02
GD_5_9 ref NI_5 NA_9 0 4.1408740144358025e-02
GD_5_10 ref NI_5 NA_10 0 8.1761668275479052e-02
GD_5_11 ref NI_5 NA_11 0 4.3601049275034512e-02
GD_5_12 ref NI_5 NA_12 0 5.7428146037133497e-02
GD_5_13 ref NI_5 NA_13 0 5.1067221736278486e-02
GD_5_14 ref NI_5 NA_14 0 4.9247853077766954e-02
GD_5_15 ref NI_5 NA_15 0 3.8682758816773223e-02
GD_5_16 ref NI_5 NA_16 0 7.6237273200230077e-02
GD_5_17 ref NI_5 NA_17 0 7.2763292841631425e-02
GD_5_18 ref NI_5 NA_18 0 6.0998262400140273e-02
GD_5_19 ref NI_5 NA_19 0 4.8603944829406540e-02
GD_5_20 ref NI_5 NA_20 0 6.9115194224660378e-02
GD_5_21 ref NI_5 NA_21 0 5.9532851376065843e-02
GD_5_22 ref NI_5 NA_22 0 6.6253170292442015e-02
GD_5_23 ref NI_5 NA_23 0 6.8667268365784642e-02
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 -2.6848202972230983e-01
GC_6_2 ref NI_6 NS_2 0 8.2203664655150166e-01
GC_6_3 ref NI_6 NS_3 0 1.8626758751987779e-01
GC_6_4 ref NI_6 NS_4 0 -6.3643033066717841e-02
GC_6_5 ref NI_6 NS_5 0 -1.8170867409424756e-04
GC_6_6 ref NI_6 NS_6 0 -4.9538170215734804e-02
GC_6_7 ref NI_6 NS_7 0 -4.9910667928751556e-01
GC_6_8 ref NI_6 NS_8 0 6.7826795870907497e-01
GC_6_9 ref NI_6 NS_9 0 1.4757666090918253e-01
GC_6_10 ref NI_6 NS_10 0 -2.9342951663465559e-02
GC_6_11 ref NI_6 NS_11 0 -6.9440131156230861e-06
GC_6_12 ref NI_6 NS_12 0 -3.5089307068792763e-02
GC_6_13 ref NI_6 NS_13 0 1.2194427882132739e+00
GC_6_14 ref NI_6 NS_14 0 5.0251989597299940e-01
GC_6_15 ref NI_6 NS_15 0 1.4887018753735146e-01
GC_6_16 ref NI_6 NS_16 0 -9.2322840971164541e-02
GC_6_17 ref NI_6 NS_17 0 -1.5572388697444270e-04
GC_6_18 ref NI_6 NS_18 0 -5.6073868201818373e-02
GC_6_19 ref NI_6 NS_19 0 -8.8747079364847081e-01
GC_6_20 ref NI_6 NS_20 0 3.2567433114676703e-01
GC_6_21 ref NI_6 NS_21 0 8.9420089257358226e-01
GC_6_22 ref NI_6 NS_22 0 -1.7483950199028636e-01
GC_6_23 ref NI_6 NS_23 0 -3.1031693410755334e-04
GC_6_24 ref NI_6 NS_24 0 -8.6405111319891315e-02
GC_6_25 ref NI_6 NS_25 0 1.4468308516217748e-01
GC_6_26 ref NI_6 NS_26 0 1.4026822696830603e+00
GC_6_27 ref NI_6 NS_27 0 2.0037309003909942e-01
GC_6_28 ref NI_6 NS_28 0 -1.6875605676072103e-01
GC_6_29 ref NI_6 NS_29 0 -3.7891389741990172e-04
GC_6_30 ref NI_6 NS_30 0 -9.4947284618460553e-02
GC_6_31 ref NI_6 NS_31 0 4.9352110111137701e+00
GC_6_32 ref NI_6 NS_32 0 -6.2144115496644456e+00
GC_6_33 ref NI_6 NS_33 0 -2.9174662060106998e-01
GC_6_34 ref NI_6 NS_34 0 -3.3106281962580852e-01
GC_6_35 ref NI_6 NS_35 0 -1.8954216323361791e-03
GC_6_36 ref NI_6 NS_36 0 -1.0938073516085352e-01
GC_6_37 ref NI_6 NS_37 0 -7.3842799632182193e-03
GC_6_38 ref NI_6 NS_38 0 1.9643218494708747e+00
GC_6_39 ref NI_6 NS_39 0 -1.3033562768002505e-01
GC_6_40 ref NI_6 NS_40 0 -1.7295425753754107e-01
GC_6_41 ref NI_6 NS_41 0 -4.2742247777317947e-04
GC_6_42 ref NI_6 NS_42 0 -8.6857356074428141e-02
GC_6_43 ref NI_6 NS_43 0 -2.0025481325971070e-01
GC_6_44 ref NI_6 NS_44 0 -2.1526181884738257e-01
GC_6_45 ref NI_6 NS_45 0 1.7584541728199446e-01
GC_6_46 ref NI_6 NS_46 0 7.7234026678722825e-02
GC_6_47 ref NI_6 NS_47 0 1.7412638168742909e-04
GC_6_48 ref NI_6 NS_48 0 5.9006563032613047e-03
GC_6_49 ref NI_6 NS_49 0 -1.0616808338515754e-01
GC_6_50 ref NI_6 NS_50 0 -3.0927417822799219e-01
GC_6_51 ref NI_6 NS_51 0 2.2599513838163934e-01
GC_6_52 ref NI_6 NS_52 0 1.0237868895838574e-01
GC_6_53 ref NI_6 NS_53 0 2.5822358482543891e-04
GC_6_54 ref NI_6 NS_54 0 -5.5038788994709355e-03
GC_6_55 ref NI_6 NS_55 0 -4.2470600573643430e-01
GC_6_56 ref NI_6 NS_56 0 2.7469192747969723e-01
GC_6_57 ref NI_6 NS_57 0 -2.6846515550780181e-01
GC_6_58 ref NI_6 NS_58 0 5.2712059218099419e-02
GC_6_59 ref NI_6 NS_59 0 1.9531426630183465e-04
GC_6_60 ref NI_6 NS_60 0 5.2011778018623042e-02
GC_6_61 ref NI_6 NS_61 0 -1.4336216881688987e-01
GC_6_62 ref NI_6 NS_62 0 -7.1419296385934167e-02
GC_6_63 ref NI_6 NS_63 0 -1.3602404148622980e-02
GC_6_64 ref NI_6 NS_64 0 8.4864031535261758e-02
GC_6_65 ref NI_6 NS_65 0 2.2954976654385620e-04
GC_6_66 ref NI_6 NS_66 0 2.2530256797187582e-02
GC_6_67 ref NI_6 NS_67 0 -2.4094062113542239e-01
GC_6_68 ref NI_6 NS_68 0 -2.0889123219380010e-02
GC_6_69 ref NI_6 NS_69 0 -4.0256412024685641e-02
GC_6_70 ref NI_6 NS_70 0 1.0643025440127338e-01
GC_6_71 ref NI_6 NS_71 0 2.8460321586717242e-04
GC_6_72 ref NI_6 NS_72 0 1.6026214616446231e-02
GC_6_73 ref NI_6 NS_73 0 -1.8678542393410619e-01
GC_6_74 ref NI_6 NS_74 0 -9.5658390480142935e-02
GC_6_75 ref NI_6 NS_75 0 2.4112154868772266e-02
GC_6_76 ref NI_6 NS_76 0 1.0034941461071806e-01
GC_6_77 ref NI_6 NS_77 0 2.8672996503361205e-04
GC_6_78 ref NI_6 NS_78 0 1.2484164013725985e-02
GC_6_79 ref NI_6 NS_79 0 -1.5765884301177033e-01
GC_6_80 ref NI_6 NS_80 0 -1.5041374795803955e-01
GC_6_81 ref NI_6 NS_81 0 6.7372994415426657e-02
GC_6_82 ref NI_6 NS_82 0 8.2387863258094690e-02
GC_6_83 ref NI_6 NS_83 0 2.0869855676747091e-04
GC_6_84 ref NI_6 NS_84 0 1.6661078009723447e-02
GC_6_85 ref NI_6 NS_85 0 -9.1110655066839422e-02
GC_6_86 ref NI_6 NS_86 0 -2.1787113356445320e-01
GC_6_87 ref NI_6 NS_87 0 8.8319960068444447e-02
GC_6_88 ref NI_6 NS_88 0 1.4364299122259341e-01
GC_6_89 ref NI_6 NS_89 0 3.0201439784388113e-04
GC_6_90 ref NI_6 NS_90 0 -4.6175551781782367e-03
GC_6_91 ref NI_6 NS_91 0 -3.8656366553534494e-01
GC_6_92 ref NI_6 NS_92 0 2.3012864019940868e-01
GC_6_93 ref NI_6 NS_93 0 -2.1976007334385625e-01
GC_6_94 ref NI_6 NS_94 0 3.5817723337170246e-02
GC_6_95 ref NI_6 NS_95 0 1.7601089549305895e-04
GC_6_96 ref NI_6 NS_96 0 5.2884596850450424e-02
GC_6_97 ref NI_6 NS_97 0 -3.7736695775930562e-01
GC_6_98 ref NI_6 NS_98 0 2.2750983412737127e-01
GC_6_99 ref NI_6 NS_99 0 -1.9226420948125975e-01
GC_6_100 ref NI_6 NS_100 0 8.1632631563076179e-04
GC_6_101 ref NI_6 NS_101 0 1.5043165448719566e-04
GC_6_102 ref NI_6 NS_102 0 6.1284306382734813e-02
GC_6_103 ref NI_6 NS_103 0 -2.8493668196437333e-01
GC_6_104 ref NI_6 NS_104 0 1.5277907794270415e-01
GC_6_105 ref NI_6 NS_105 0 -1.6277437204274456e-01
GC_6_106 ref NI_6 NS_106 0 2.1660309794178861e-02
GC_6_107 ref NI_6 NS_107 0 1.6516213093611297e-04
GC_6_108 ref NI_6 NS_108 0 5.3753933250263619e-02
GC_6_109 ref NI_6 NS_109 0 -1.8584113248384607e-01
GC_6_110 ref NI_6 NS_110 0 4.6998981429573955e-02
GC_6_111 ref NI_6 NS_111 0 -1.2080171308004398e-01
GC_6_112 ref NI_6 NS_112 0 6.6401545462857828e-02
GC_6_113 ref NI_6 NS_113 0 2.0214609144227313e-04
GC_6_114 ref NI_6 NS_114 0 3.8248569340065493e-02
GC_6_115 ref NI_6 NS_115 0 -3.5433793270499370e-01
GC_6_116 ref NI_6 NS_116 0 2.0769426943571445e-01
GC_6_117 ref NI_6 NS_117 0 -1.6054174755699513e-01
GC_6_118 ref NI_6 NS_118 0 -2.3722598872129484e-02
GC_6_119 ref NI_6 NS_119 0 1.5019564159941953e-04
GC_6_120 ref NI_6 NS_120 0 6.6053660032480296e-02
GC_6_121 ref NI_6 NS_121 0 -2.8032931536747047e-01
GC_6_122 ref NI_6 NS_122 0 1.3888293330759985e-01
GC_6_123 ref NI_6 NS_123 0 -1.5865635349795093e-01
GC_6_124 ref NI_6 NS_124 0 3.8489446305251175e-02
GC_6_125 ref NI_6 NS_125 0 1.7983910738400452e-04
GC_6_126 ref NI_6 NS_126 0 4.8217086338447450e-02
GC_6_127 ref NI_6 NS_127 0 -3.1922919705083019e-01
GC_6_128 ref NI_6 NS_128 0 1.5910560706057472e-01
GC_6_129 ref NI_6 NS_129 0 -1.8482112738179421e-01
GC_6_130 ref NI_6 NS_130 0 6.2887303135599898e-02
GC_6_131 ref NI_6 NS_131 0 1.9575183739316355e-04
GC_6_132 ref NI_6 NS_132 0 4.2609721112389927e-02
GC_6_133 ref NI_6 NS_133 0 -3.2567909348352414e-01
GC_6_134 ref NI_6 NS_134 0 1.5900331394643979e-01
GC_6_135 ref NI_6 NS_135 0 -1.9654801246876649e-01
GC_6_136 ref NI_6 NS_136 0 7.8298668154572496e-02
GC_6_137 ref NI_6 NS_137 0 2.1458663638236145e-04
GC_6_138 ref NI_6 NS_138 0 3.9103345824505760e-02
GD_6_1 ref NI_6 NA_1 0 -5.8614474185350263e-02
GD_6_2 ref NI_6 NA_2 0 -1.6786622327383104e-02
GD_6_3 ref NI_6 NA_3 0 8.8198738279226252e-02
GD_6_4 ref NI_6 NA_4 0 1.3936312835967032e-01
GD_6_5 ref NI_6 NA_5 0 -1.2158320255593259e-02
GD_6_6 ref NI_6 NA_6 0 5.0341477060436253e+00
GD_6_7 ref NI_6 NA_7 0 -1.0868189833102787e-02
GD_6_8 ref NI_6 NA_8 0 4.7261503542874610e-02
GD_6_9 ref NI_6 NA_9 0 3.4309274847371014e-02
GD_6_10 ref NI_6 NA_10 0 8.2428501453221864e-02
GD_6_11 ref NI_6 NA_11 0 4.0139011733976500e-02
GD_6_12 ref NI_6 NA_12 0 5.3777002643417282e-02
GD_6_13 ref NI_6 NA_13 0 4.6941927101859390e-02
GD_6_14 ref NI_6 NA_14 0 4.3980678728572392e-02
GD_6_15 ref NI_6 NA_15 0 3.2045521856517281e-02
GD_6_16 ref NI_6 NA_16 0 7.6780134919381349e-02
GD_6_17 ref NI_6 NA_17 0 7.3877919356006946e-02
GD_6_18 ref NI_6 NA_18 0 6.1203916176805810e-02
GD_6_19 ref NI_6 NA_19 0 4.6933380508022107e-02
GD_6_20 ref NI_6 NA_20 0 7.0469745171022807e-02
GD_6_21 ref NI_6 NA_21 0 5.9281017862542508e-02
GD_6_22 ref NI_6 NA_22 0 6.5645496592765334e-02
GD_6_23 ref NI_6 NA_23 0 6.7709551201972695e-02
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 3.2665636194005959e-01
GC_7_2 ref NI_7 NS_2 0 1.2952640339947477e+00
GC_7_3 ref NI_7 NS_3 0 -1.9766373549380170e-01
GC_7_4 ref NI_7 NS_4 0 -2.8930039128851889e-02
GC_7_5 ref NI_7 NS_5 0 -1.7174559948820490e-04
GC_7_6 ref NI_7 NS_6 0 -4.8609817386995269e-02
GC_7_7 ref NI_7 NS_7 0 3.5764865461872089e-02
GC_7_8 ref NI_7 NS_8 0 1.0623877854475232e+00
GC_7_9 ref NI_7 NS_9 0 -1.5760113142798715e-01
GC_7_10 ref NI_7 NS_10 0 -7.3347406435468887e-03
GC_7_11 ref NI_7 NS_11 0 -1.8421801790126434e-05
GC_7_12 ref NI_7 NS_12 0 -3.4770355858117601e-02
GC_7_13 ref NI_7 NS_13 0 2.6168225993950740e+00
GC_7_14 ref NI_7 NS_14 0 4.4168344390148012e-01
GC_7_15 ref NI_7 NS_15 0 -6.4403079982720962e-02
GC_7_16 ref NI_7 NS_16 0 -7.5601285738351370e-02
GC_7_17 ref NI_7 NS_17 0 -1.7153784749280657e-04
GC_7_18 ref NI_7 NS_18 0 -5.3204149876853138e-02
GC_7_19 ref NI_7 NS_19 0 -9.9994427165834621e-01
GC_7_20 ref NI_7 NS_20 0 1.3793416246993179e-01
GC_7_21 ref NI_7 NS_21 0 9.2952392490985092e-01
GC_7_22 ref NI_7 NS_22 0 -1.5344882976277410e-01
GC_7_23 ref NI_7 NS_23 0 -1.9717762352765584e-04
GC_7_24 ref NI_7 NS_24 0 -7.7544504738960782e-02
GC_7_25 ref NI_7 NS_25 0 -9.6265187370684835e-01
GC_7_26 ref NI_7 NS_26 0 3.5900333554896668e-01
GC_7_27 ref NI_7 NS_27 0 8.8897050530869526e-01
GC_7_28 ref NI_7 NS_28 0 -1.8740087675080616e-01
GC_7_29 ref NI_7 NS_29 0 -3.0790431710678453e-04
GC_7_30 ref NI_7 NS_30 0 -8.1252800297751934e-02
GC_7_31 ref NI_7 NS_31 0 -7.3842799632181204e-03
GC_7_32 ref NI_7 NS_32 0 1.9643218494708743e+00
GC_7_33 ref NI_7 NS_33 0 -1.3033562768002452e-01
GC_7_34 ref NI_7 NS_34 0 -1.7295425753754140e-01
GC_7_35 ref NI_7 NS_35 0 -4.2742247777319926e-04
GC_7_36 ref NI_7 NS_36 0 -8.6857356074428058e-02
GC_7_37 ref NI_7 NS_37 0 4.4772354505124161e+00
GC_7_38 ref NI_7 NS_38 0 -5.7451678146449678e+00
GC_7_39 ref NI_7 NS_39 0 -6.9260104149187185e-01
GC_7_40 ref NI_7 NS_40 0 -2.6544406012229155e-01
GC_7_41 ref NI_7 NS_41 0 -1.8103843019572699e-03
GC_7_42 ref NI_7 NS_42 0 -9.8958077769502120e-02
GC_7_43 ref NI_7 NS_43 0 -3.8931864414446848e-01
GC_7_44 ref NI_7 NS_44 0 -1.2371666577941336e-01
GC_7_45 ref NI_7 NS_45 0 2.0333189615909053e-01
GC_7_46 ref NI_7 NS_46 0 4.8079181544538843e-02
GC_7_47 ref NI_7 NS_47 0 1.4357273052563479e-04
GC_7_48 ref NI_7 NS_48 0 5.9618691456432230e-03
GC_7_49 ref NI_7 NS_49 0 -3.1479986977874796e-01
GC_7_50 ref NI_7 NS_50 0 -2.1858604128350634e-01
GC_7_51 ref NI_7 NS_51 0 2.7213723015127400e-01
GC_7_52 ref NI_7 NS_52 0 6.2725068360621514e-02
GC_7_53 ref NI_7 NS_53 0 2.3021036941344174e-04
GC_7_54 ref NI_7 NS_54 0 -4.6481827825060225e-03
GC_7_55 ref NI_7 NS_55 0 -3.7293142542699798e-01
GC_7_56 ref NI_7 NS_56 0 2.3051283013232196e-01
GC_7_57 ref NI_7 NS_57 0 -2.4534535408526231e-01
GC_7_58 ref NI_7 NS_58 0 6.2596688894192301e-02
GC_7_59 ref NI_7 NS_59 0 1.8918377546111873e-04
GC_7_60 ref NI_7 NS_60 0 4.7728830876628693e-02
GC_7_61 ref NI_7 NS_61 0 -2.0026256813575810e-01
GC_7_62 ref NI_7 NS_62 0 -7.5929501916483483e-02
GC_7_63 ref NI_7 NS_63 0 4.1152406656144912e-02
GC_7_64 ref NI_7 NS_64 0 6.5785704449020363e-02
GC_7_65 ref NI_7 NS_65 0 2.0985438140048521e-04
GC_7_66 ref NI_7 NS_66 0 2.1052958995256447e-02
GC_7_67 ref NI_7 NS_67 0 -2.9990695773464526e-01
GC_7_68 ref NI_7 NS_68 0 -9.3396019598617295e-03
GC_7_69 ref NI_7 NS_69 0 8.4080879521390966e-03
GC_7_70 ref NI_7 NS_70 0 8.5841463287216493e-02
GC_7_71 ref NI_7 NS_71 0 2.6961670108722265e-04
GC_7_72 ref NI_7 NS_72 0 1.4652534900859658e-02
GC_7_73 ref NI_7 NS_73 0 -2.7535983941780051e-01
GC_7_74 ref NI_7 NS_74 0 -7.1661277173220919e-02
GC_7_75 ref NI_7 NS_75 0 7.4104125082562047e-02
GC_7_76 ref NI_7 NS_76 0 7.5804329004114032e-02
GC_7_77 ref NI_7 NS_77 0 2.6575418035754578e-04
GC_7_78 ref NI_7 NS_78 0 1.1603605757368369e-02
GC_7_79 ref NI_7 NS_79 0 -2.8181484438066706e-01
GC_7_80 ref NI_7 NS_80 0 -1.2432665329240256e-01
GC_7_81 ref NI_7 NS_81 0 1.1857329752900735e-01
GC_7_82 ref NI_7 NS_82 0 5.8191500523077630e-02
GC_7_83 ref NI_7 NS_83 0 1.8466416526203154e-04
GC_7_84 ref NI_7 NS_84 0 1.5883617268609762e-02
GC_7_85 ref NI_7 NS_85 0 -2.1312542763583348e-01
GC_7_86 ref NI_7 NS_86 0 -1.9345956252172469e-01
GC_7_87 ref NI_7 NS_87 0 1.6706717169040844e-01
GC_7_88 ref NI_7 NS_88 0 1.0273466770583756e-01
GC_7_89 ref NI_7 NS_89 0 2.7058068511535060e-04
GC_7_90 ref NI_7 NS_90 0 -4.1237558572928884e-03
GC_7_91 ref NI_7 NS_91 0 -3.5046952728176445e-01
GC_7_92 ref NI_7 NS_92 0 1.9749173551786856e-01
GC_7_93 ref NI_7 NS_93 0 -2.0235676699881025e-01
GC_7_94 ref NI_7 NS_94 0 4.5697239526181092e-02
GC_7_95 ref NI_7 NS_95 0 1.6777242229717402e-04
GC_7_96 ref NI_7 NS_96 0 4.8773986921836238e-02
GC_7_97 ref NI_7 NS_97 0 -3.4921790646915157e-01
GC_7_98 ref NI_7 NS_98 0 2.0798427875033645e-01
GC_7_99 ref NI_7 NS_99 0 -1.9208694388010650e-01
GC_7_100 ref NI_7 NS_100 0 1.7132143892263703e-02
GC_7_101 ref NI_7 NS_101 0 1.4173063833985291e-04
GC_7_102 ref NI_7 NS_102 0 5.6802428934267249e-02
GC_7_103 ref NI_7 NS_103 0 -2.5774914056830850e-01
GC_7_104 ref NI_7 NS_104 0 1.1889565897542755e-01
GC_7_105 ref NI_7 NS_105 0 -1.4105746807419658e-01
GC_7_106 ref NI_7 NS_106 0 2.9268729199142179e-02
GC_7_107 ref NI_7 NS_107 0 1.5617544729663239e-04
GC_7_108 ref NI_7 NS_108 0 4.9958551980894869e-02
GC_7_109 ref NI_7 NS_109 0 -1.7874170407711285e-01
GC_7_110 ref NI_7 NS_110 0 3.2610232185818779e-03
GC_7_111 ref NI_7 NS_111 0 -6.8169030008751769e-02
GC_7_112 ref NI_7 NS_112 0 5.9003301606159506e-02
GC_7_113 ref NI_7 NS_113 0 1.9544889189782011e-04
GC_7_114 ref NI_7 NS_114 0 3.5604766286122913e-02
GC_7_115 ref NI_7 NS_115 0 -3.3333216404488542e-01
GC_7_116 ref NI_7 NS_116 0 1.9620324364887107e-01
GC_7_117 ref NI_7 NS_117 0 -1.6975569413530534e-01
GC_7_118 ref NI_7 NS_118 0 -4.2900097568059261e-03
GC_7_119 ref NI_7 NS_119 0 1.4150170439840325e-04
GC_7_120 ref NI_7 NS_120 0 6.1462642634737802e-02
GC_7_121 ref NI_7 NS_121 0 -2.6045240581852758e-01
GC_7_122 ref NI_7 NS_122 0 1.0810764097599866e-01
GC_7_123 ref NI_7 NS_123 0 -1.3133900173054666e-01
GC_7_124 ref NI_7 NS_124 0 4.2126593103078168e-02
GC_7_125 ref NI_7 NS_125 0 1.6793460585573606e-04
GC_7_126 ref NI_7 NS_126 0 4.4699343216026373e-02
GC_7_127 ref NI_7 NS_127 0 -2.9856277771114181e-01
GC_7_128 ref NI_7 NS_128 0 1.2614983002974783e-01
GC_7_129 ref NI_7 NS_129 0 -1.5058243911159203e-01
GC_7_130 ref NI_7 NS_130 0 6.3203604885423995e-02
GC_7_131 ref NI_7 NS_131 0 1.8430180609691713e-04
GC_7_132 ref NI_7 NS_132 0 3.9247237839769772e-02
GC_7_133 ref NI_7 NS_133 0 -3.0513668819967094e-01
GC_7_134 ref NI_7 NS_134 0 1.2084545066061460e-01
GC_7_135 ref NI_7 NS_135 0 -1.5460910700367878e-01
GC_7_136 ref NI_7 NS_136 0 7.5742501920556357e-02
GC_7_137 ref NI_7 NS_137 0 2.0395548637892430e-04
GC_7_138 ref NI_7 NS_138 0 3.5893624368540322e-02
GD_7_1 ref NI_7 NA_1 0 -2.0611057406580074e-01
GD_7_2 ref NI_7 NA_2 0 -1.3665564207963568e-01
GD_7_3 ref NI_7 NA_3 0 2.1115479713981651e-02
GD_7_4 ref NI_7 NA_4 0 1.4154621253617544e-01
GD_7_5 ref NI_7 NA_5 0 1.3138360915850394e-01
GD_7_6 ref NI_7 NA_6 0 -1.0868189833102787e-02
GD_7_7 ref NI_7 NA_7 0 5.1031164178514796e+00
GD_7_8 ref NI_7 NA_8 0 6.5862274143313831e-02
GD_7_9 ref NI_7 NA_9 0 5.5665187728583261e-02
GD_7_10 ref NI_7 NA_10 0 7.4111236930106211e-02
GD_7_11 ref NI_7 NA_11 0 4.5000624396683730e-02
GD_7_12 ref NI_7 NA_12 0 5.6999013841705186e-02
GD_7_13 ref NI_7 NA_13 0 5.4357311915508980e-02
GD_7_14 ref NI_7 NA_14 0 5.7372117714786008e-02
GD_7_15 ref NI_7 NA_15 0 4.2932899574206519e-02
GD_7_16 ref NI_7 NA_16 0 7.0609166111625918e-02
GD_7_17 ref NI_7 NA_17 0 6.8989174325820579e-02
GD_7_18 ref NI_7 NA_18 0 5.6778505818121217e-02
GD_7_19 ref NI_7 NA_19 0 4.4989979591264800e-02
GD_7_20 ref NI_7 NA_20 0 6.6871918960774962e-02
GD_7_21 ref NI_7 NA_21 0 5.5151675084219795e-02
GD_7_22 ref NI_7 NA_22 0 6.0913542065426207e-02
GD_7_23 ref NI_7 NA_23 0 6.3066632189287319e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 -1.6507259570828603e-01
GC_8_2 ref NI_8 NS_2 0 8.4252937217797941e-01
GC_8_3 ref NI_8 NS_3 0 -2.5101935150285892e-01
GC_8_4 ref NI_8 NS_4 0 1.6386389737997834e-02
GC_8_5 ref NI_8 NS_5 0 1.0526736678392567e-04
GC_8_6 ref NI_8 NS_6 0 3.1282285261351628e-04
GC_8_7 ref NI_8 NS_7 0 1.0650563330591669e+00
GC_8_8 ref NI_8 NS_8 0 5.5480184453804993e-01
GC_8_9 ref NI_8 NS_9 0 -2.3302993546050793e-01
GC_8_10 ref NI_8 NS_10 0 -1.4980722059863970e-02
GC_8_11 ref NI_8 NS_11 0 1.2126211206259274e-05
GC_8_12 ref NI_8 NS_12 0 -7.0181905329812732e-04
GC_8_13 ref NI_8 NS_13 0 2.5397453590687386e-01
GC_8_14 ref NI_8 NS_14 0 4.1888383444508998e-01
GC_8_15 ref NI_8 NS_15 0 -8.1277173849699721e-02
GC_8_16 ref NI_8 NS_16 0 1.6488024853423711e-02
GC_8_17 ref NI_8 NS_17 0 6.6553950718024120e-05
GC_8_18 ref NI_8 NS_18 0 1.7173821116801314e-03
GC_8_19 ref NI_8 NS_19 0 -3.8487321891707416e-01
GC_8_20 ref NI_8 NS_20 0 -1.3407666622840578e-01
GC_8_21 ref NI_8 NS_21 0 1.8060317366792442e-01
GC_8_22 ref NI_8 NS_22 0 5.8110317636371249e-02
GC_8_23 ref NI_8 NS_23 0 1.6913487505496662e-04
GC_8_24 ref NI_8 NS_24 0 7.1079417393236062e-03
GC_8_25 ref NI_8 NS_25 0 -2.4217986488523821e-01
GC_8_26 ref NI_8 NS_26 0 -1.9003111957295166e-01
GC_8_27 ref NI_8 NS_27 0 1.6443447974082651e-01
GC_8_28 ref NI_8 NS_28 0 7.6488517996402952e-02
GC_8_29 ref NI_8 NS_29 0 1.7109107653125565e-04
GC_8_30 ref NI_8 NS_30 0 6.4164839684572568e-03
GC_8_31 ref NI_8 NS_31 0 -2.0025481325971065e-01
GC_8_32 ref NI_8 NS_32 0 -2.1526181884738277e-01
GC_8_33 ref NI_8 NS_33 0 1.7584541728199465e-01
GC_8_34 ref NI_8 NS_34 0 7.7234026678722686e-02
GC_8_35 ref NI_8 NS_35 0 1.7412638168741993e-04
GC_8_36 ref NI_8 NS_36 0 5.9006563032613455e-03
GC_8_37 ref NI_8 NS_37 0 -3.8931864414446826e-01
GC_8_38 ref NI_8 NS_38 0 -1.2371666577941402e-01
GC_8_39 ref NI_8 NS_39 0 2.0333189615909145e-01
GC_8_40 ref NI_8 NS_40 0 4.8079181544538323e-02
GC_8_41 ref NI_8 NS_41 0 1.4357273052559945e-04
GC_8_42 ref NI_8 NS_42 0 5.9618691456433774e-03
GC_8_43 ref NI_8 NS_43 0 3.4255378092561979e+00
GC_8_44 ref NI_8 NS_44 0 -5.2704690763372808e+00
GC_8_45 ref NI_8 NS_45 0 -1.5595800047820385e+00
GC_8_46 ref NI_8 NS_46 0 -1.6834435363419398e-01
GC_8_47 ref NI_8 NS_47 0 -7.1444029214606493e-04
GC_8_48 ref NI_8 NS_48 0 -2.4313508652918168e-02
GC_8_49 ref NI_8 NS_49 0 -5.1405901826286815e-01
GC_8_50 ref NI_8 NS_50 0 7.8017048084326390e-01
GC_8_51 ref NI_8 NS_51 0 1.0544713822998776e-01
GC_8_52 ref NI_8 NS_52 0 -1.4882700526300260e-01
GC_8_53 ref NI_8 NS_53 0 -6.2851069895659829e-05
GC_8_54 ref NI_8 NS_54 0 2.1628268673780254e-03
GC_8_55 ref NI_8 NS_55 0 -7.7919256721859689e-02
GC_8_56 ref NI_8 NS_56 0 -5.3951663491514402e-02
GC_8_57 ref NI_8 NS_57 0 -8.2112335719920271e-02
GC_8_58 ref NI_8 NS_58 0 1.6424378743647816e-01
GC_8_59 ref NI_8 NS_59 0 1.3756242721074740e-05
GC_8_60 ref NI_8 NS_60 0 3.4720640225805021e-03
GC_8_61 ref NI_8 NS_61 0 -5.4215628344490008e-02
GC_8_62 ref NI_8 NS_62 0 1.9838823802495640e+00
GC_8_63 ref NI_8 NS_63 0 -6.5390408957576318e-01
GC_8_64 ref NI_8 NS_64 0 -1.2153146632873946e-01
GC_8_65 ref NI_8 NS_65 0 -1.2946787075990090e-04
GC_8_66 ref NI_8 NS_66 0 -3.4524916265863486e-03
GC_8_67 ref NI_8 NS_67 0 -1.9896393748978453e-01
GC_8_68 ref NI_8 NS_68 0 7.3367491829749346e-02
GC_8_69 ref NI_8 NS_69 0 1.7952824097474029e-01
GC_8_70 ref NI_8 NS_70 0 3.3444271894816362e-03
GC_8_71 ref NI_8 NS_71 0 3.3520305564279924e-05
GC_8_72 ref NI_8 NS_72 0 2.1963678991141762e-03
GC_8_73 ref NI_8 NS_73 0 -4.3664787351234902e-01
GC_8_74 ref NI_8 NS_74 0 5.8164458959078813e-01
GC_8_75 ref NI_8 NS_75 0 6.5743651696845665e-02
GC_8_76 ref NI_8 NS_76 0 -7.5983049515126105e-02
GC_8_77 ref NI_8 NS_77 0 -1.9699364756928579e-05
GC_8_78 ref NI_8 NS_78 0 1.9230790969859723e-03
GC_8_79 ref NI_8 NS_79 0 -5.8226700724039571e-01
GC_8_80 ref NI_8 NS_80 0 1.1945140398122689e+00
GC_8_81 ref NI_8 NS_81 0 -3.3479110021042917e-02
GC_8_82 ref NI_8 NS_82 0 -1.9093460856637001e-01
GC_8_83 ref NI_8 NS_83 0 -2.8677014399335013e-05
GC_8_84 ref NI_8 NS_84 0 -2.8860128935720231e-03
GC_8_85 ref NI_8 NS_85 0 -1.5104433962354480e-01
GC_8_86 ref NI_8 NS_86 0 -4.6475701115528859e-02
GC_8_87 ref NI_8 NS_87 0 4.0307397545066298e-01
GC_8_88 ref NI_8 NS_88 0 -7.5145804296671795e-02
GC_8_89 ref NI_8 NS_89 0 4.9407836499307194e-06
GC_8_90 ref NI_8 NS_90 0 1.2382461792532582e-03
GC_8_91 ref NI_8 NS_91 0 -1.3919733017119301e-01
GC_8_92 ref NI_8 NS_92 0 -3.2795303640728288e-02
GC_8_93 ref NI_8 NS_93 0 -7.4231506874167597e-03
GC_8_94 ref NI_8 NS_94 0 1.2261295562633635e-01
GC_8_95 ref NI_8 NS_95 0 2.8760068485538333e-06
GC_8_96 ref NI_8 NS_96 0 3.0211701703325047e-03
GC_8_97 ref NI_8 NS_97 0 1.8079485830685152e-02
GC_8_98 ref NI_8 NS_98 0 -1.7166126980065760e-01
GC_8_99 ref NI_8 NS_99 0 1.1754505882275153e-01
GC_8_100 ref NI_8 NS_100 0 1.0501035605305076e-01
GC_8_101 ref NI_8 NS_101 0 8.6742743997248884e-06
GC_8_102 ref NI_8 NS_102 0 -1.8668946858084203e-03
GC_8_103 ref NI_8 NS_103 0 -8.6005871394079475e-02
GC_8_104 ref NI_8 NS_104 0 -1.9241611552332283e-01
GC_8_105 ref NI_8 NS_105 0 3.7612800255753265e-01
GC_8_106 ref NI_8 NS_106 0 -1.3945646509511328e-02
GC_8_107 ref NI_8 NS_107 0 2.0360057921672417e-05
GC_8_108 ref NI_8 NS_108 0 -4.5398826930992953e-03
GC_8_109 ref NI_8 NS_109 0 -3.5510538353720023e-01
GC_8_110 ref NI_8 NS_110 0 2.1969010597364552e-01
GC_8_111 ref NI_8 NS_111 0 3.9035846897236559e-01
GC_8_112 ref NI_8 NS_112 0 -1.3099835658846623e-01
GC_8_113 ref NI_8 NS_113 0 -3.0939126499946105e-07
GC_8_114 ref NI_8 NS_114 0 -3.6793547283741203e-03
GC_8_115 ref NI_8 NS_115 0 1.4447970421372988e-01
GC_8_116 ref NI_8 NS_116 0 -2.8632333729297410e-01
GC_8_117 ref NI_8 NS_117 0 1.7966479262568588e-01
GC_8_118 ref NI_8 NS_118 0 1.0840739491135795e-01
GC_8_119 ref NI_8 NS_119 0 4.4661617497865820e-05
GC_8_120 ref NI_8 NS_120 0 -5.9726094415105723e-03
GC_8_121 ref NI_8 NS_121 0 -2.9965732271615980e-01
GC_8_122 ref NI_8 NS_122 0 1.0205627159071499e-01
GC_8_123 ref NI_8 NS_123 0 2.2520523541176235e-01
GC_8_124 ref NI_8 NS_124 0 -1.6971097369025384e-02
GC_8_125 ref NI_8 NS_125 0 -1.5149337689403265e-05
GC_8_126 ref NI_8 NS_126 0 -3.3780514723193888e-04
GC_8_127 ref NI_8 NS_127 0 -2.1381500416857299e-01
GC_8_128 ref NI_8 NS_128 0 3.2517640133962661e-02
GC_8_129 ref NI_8 NS_129 0 8.5620689045703025e-02
GC_8_130 ref NI_8 NS_130 0 6.1370165539535906e-02
GC_8_131 ref NI_8 NS_131 0 5.8461667242433407e-06
GC_8_132 ref NI_8 NS_132 0 2.7748946471746125e-03
GC_8_133 ref NI_8 NS_133 0 -1.2887211360067233e-01
GC_8_134 ref NI_8 NS_134 0 -4.7729060443068891e-02
GC_8_135 ref NI_8 NS_135 0 4.3308766551399501e-02
GC_8_136 ref NI_8 NS_136 0 1.0160998222811575e-01
GC_8_137 ref NI_8 NS_137 0 1.3816329279797122e-05
GC_8_138 ref NI_8 NS_138 0 3.3114236080144855e-03
GD_8_1 ref NI_8 NA_1 0 -6.0416601100865983e-02
GD_8_2 ref NI_8 NA_2 0 -2.5586833620136043e-02
GD_8_3 ref NI_8 NA_3 0 -5.5725541000884421e-02
GD_8_4 ref NI_8 NA_4 0 7.1653805243172400e-02
GD_8_5 ref NI_8 NA_5 0 5.3625226641437936e-02
GD_8_6 ref NI_8 NA_6 0 4.7261503542874610e-02
GD_8_7 ref NI_8 NA_7 0 6.5862274143313831e-02
GD_8_8 ref NI_8 NA_8 0 5.4923552587642064e+00
GD_8_9 ref NI_8 NA_9 0 6.4988910981815917e-02
GD_8_10 ref NI_8 NA_10 0 3.1413283971037480e-02
GD_8_11 ref NI_8 NA_11 0 -1.5572442442475447e-02
GD_8_12 ref NI_8 NA_12 0 3.5233771314848963e-02
GD_8_13 ref NI_8 NA_13 0 6.8316470528488618e-02
GD_8_14 ref NI_8 NA_14 0 9.4368391784269950e-02
GD_8_15 ref NI_8 NA_15 0 2.0949229486885046e-02
GD_8_16 ref NI_8 NA_16 0 4.2468995092140492e-02
GD_8_17 ref NI_8 NA_17 0 1.4552988870465638e-02
GD_8_18 ref NI_8 NA_18 0 3.7808994197792170e-02
GD_8_19 ref NI_8 NA_19 0 7.0147020546726793e-02
GD_8_20 ref NI_8 NA_20 0 4.0588371779502215e-04
GD_8_21 ref NI_8 NA_21 0 5.1713406746292510e-02
GD_8_22 ref NI_8 NA_22 0 4.7211237317154639e-02
GD_8_23 ref NI_8 NA_23 0 3.4063777157298546e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 -3.2589391472461771e-01
GC_9_2 ref NI_9 NS_2 0 8.7110387081158203e-01
GC_9_3 ref NI_9 NS_3 0 -1.8412587230316457e-01
GC_9_4 ref NI_9 NS_4 0 -2.8052449327525997e-03
GC_9_5 ref NI_9 NS_5 0 1.3844259563748423e-04
GC_9_6 ref NI_9 NS_6 0 -5.2922025248114428e-03
GC_9_7 ref NI_9 NS_7 0 8.5564522392039000e-01
GC_9_8 ref NI_9 NS_8 0 6.4750783095093922e-01
GC_9_9 ref NI_9 NS_9 0 -1.9836531502854676e-01
GC_9_10 ref NI_9 NS_10 0 -3.7066661963702854e-02
GC_9_11 ref NI_9 NS_11 0 4.7999103189599795e-05
GC_9_12 ref NI_9 NS_12 0 -4.7146067243106710e-03
GC_9_13 ref NI_9 NS_13 0 2.7319568665001681e-01
GC_9_14 ref NI_9 NS_14 0 4.0898133965014649e-01
GC_9_15 ref NI_9 NS_15 0 -2.0229499096747407e-02
GC_9_16 ref NI_9 NS_16 0 2.4094653304790941e-03
GC_9_17 ref NI_9 NS_17 0 9.9356744366097137e-05
GC_9_18 ref NI_9 NS_18 0 -5.0425523350302297e-03
GC_9_19 ref NI_9 NS_19 0 -3.0724835623857905e-01
GC_9_20 ref NI_9 NS_20 0 -2.2840346228750313e-01
GC_9_21 ref NI_9 NS_21 0 2.4119752646075218e-01
GC_9_22 ref NI_9 NS_22 0 7.7195518097973814e-02
GC_9_23 ref NI_9 NS_23 0 2.2439034636725623e-04
GC_9_24 ref NI_9 NS_24 0 -3.4800342074679555e-03
GC_9_25 ref NI_9 NS_25 0 -1.5292188488724401e-01
GC_9_26 ref NI_9 NS_26 0 -2.8183945686795925e-01
GC_9_27 ref NI_9 NS_27 0 2.1401379624497158e-01
GC_9_28 ref NI_9 NS_28 0 1.0133516191479650e-01
GC_9_29 ref NI_9 NS_29 0 2.3409130013914815e-04
GC_9_30 ref NI_9 NS_30 0 -4.7555750052185467e-03
GC_9_31 ref NI_9 NS_31 0 -1.0616808338515768e-01
GC_9_32 ref NI_9 NS_32 0 -3.0927417822799180e-01
GC_9_33 ref NI_9 NS_33 0 2.2599513838163879e-01
GC_9_34 ref NI_9 NS_34 0 1.0237868895838607e-01
GC_9_35 ref NI_9 NS_35 0 2.5822358482546114e-04
GC_9_36 ref NI_9 NS_36 0 -5.5038788994710335e-03
GC_9_37 ref NI_9 NS_37 0 -3.1479986977874796e-01
GC_9_38 ref NI_9 NS_38 0 -2.1858604128350648e-01
GC_9_39 ref NI_9 NS_39 0 2.7213723015127428e-01
GC_9_40 ref NI_9 NS_40 0 6.2725068360621403e-02
GC_9_41 ref NI_9 NS_41 0 2.3021036941343523e-04
GC_9_42 ref NI_9 NS_42 0 -4.6481827825059921e-03
GC_9_43 ref NI_9 NS_43 0 -5.1405901826286826e-01
GC_9_44 ref NI_9 NS_44 0 7.8017048084326390e-01
GC_9_45 ref NI_9 NS_45 0 1.0544713822998771e-01
GC_9_46 ref NI_9 NS_46 0 -1.4882700526300252e-01
GC_9_47 ref NI_9 NS_47 0 -6.2851069895657267e-05
GC_9_48 ref NI_9 NS_48 0 2.1628268673780154e-03
GC_9_49 ref NI_9 NS_49 0 2.7958391699929699e+00
GC_9_50 ref NI_9 NS_50 0 -2.6635841279320864e+00
GC_9_51 ref NI_9 NS_51 0 -2.9394649664651351e+00
GC_9_52 ref NI_9 NS_52 0 -2.2465229058530928e-01
GC_9_53 ref NI_9 NS_53 0 -7.6442396661485789e-04
GC_9_54 ref NI_9 NS_54 0 -2.2235033118523102e-02
GC_9_55 ref NI_9 NS_55 0 2.5117123151770426e-01
GC_9_56 ref NI_9 NS_56 0 -3.5026340448983134e-01
GC_9_57 ref NI_9 NS_57 0 1.8677304716677218e-01
GC_9_58 ref NI_9 NS_58 0 1.1005754768712946e-01
GC_9_59 ref NI_9 NS_59 0 2.5528044962467648e-05
GC_9_60 ref NI_9 NS_60 0 -1.7746621611511326e-03
GC_9_61 ref NI_9 NS_61 0 -3.8328723663670949e-01
GC_9_62 ref NI_9 NS_62 0 2.3405163963352413e-01
GC_9_63 ref NI_9 NS_63 0 2.8747909332343885e-01
GC_9_64 ref NI_9 NS_64 0 -9.5700727168081826e-02
GC_9_65 ref NI_9 NS_65 0 -4.2743339951709422e-05
GC_9_66 ref NI_9 NS_66 0 4.5218870487412728e-03
GC_9_67 ref NI_9 NS_67 0 -1.2926613142685792e-01
GC_9_68 ref NI_9 NS_68 0 1.9333748125997391e-01
GC_9_69 ref NI_9 NS_69 0 4.0524483175143622e-01
GC_9_70 ref NI_9 NS_70 0 -1.3720135604126660e-01
GC_9_71 ref NI_9 NS_71 0 -4.2431222069891272e-05
GC_9_72 ref NI_9 NS_72 0 -2.4782427446713396e-03
GC_9_73 ref NI_9 NS_73 0 -5.6214016638226250e-01
GC_9_74 ref NI_9 NS_74 0 1.4097650182734163e+00
GC_9_75 ref NI_9 NS_75 0 -1.5340589037994093e-01
GC_9_76 ref NI_9 NS_76 0 -1.9221369911874667e-01
GC_9_77 ref NI_9 NS_77 0 -1.1794907877926868e-04
GC_9_78 ref NI_9 NS_78 0 -2.5178072003934245e-04
GC_9_79 ref NI_9 NS_79 0 -2.9989482549107338e-01
GC_9_80 ref NI_9 NS_80 0 -3.6580202150081724e-02
GC_9_81 ref NI_9 NS_81 0 3.3043051677278512e-01
GC_9_82 ref NI_9 NS_82 0 -4.4653352897884760e-02
GC_9_83 ref NI_9 NS_83 0 2.2120667565393245e-05
GC_9_84 ref NI_9 NS_84 0 4.6466406075517698e-03
GC_9_85 ref NI_9 NS_85 0 -1.9830094508386006e-01
GC_9_86 ref NI_9 NS_86 0 2.1145685180011792e-01
GC_9_87 ref NI_9 NS_87 0 6.7633917198155202e-01
GC_9_88 ref NI_9 NS_88 0 -2.7564082808884932e-01
GC_9_89 ref NI_9 NS_89 0 -1.3471413242619707e-04
GC_9_90 ref NI_9 NS_90 0 -2.4668916520318670e-03
GC_9_91 ref NI_9 NS_91 0 7.8855798121428108e-02
GC_9_92 ref NI_9 NS_92 0 -1.9647156154114320e-01
GC_9_93 ref NI_9 NS_93 0 1.1677747582203005e-01
GC_9_94 ref NI_9 NS_94 0 9.9103749504959066e-02
GC_9_95 ref NI_9 NS_95 0 -2.9669301427197660e-06
GC_9_96 ref NI_9 NS_96 0 2.2822043202754016e-03
GC_9_97 ref NI_9 NS_97 0 -8.6052475791694935e-02
GC_9_98 ref NI_9 NS_98 0 -6.1594208874963348e-03
GC_9_99 ref NI_9 NS_99 0 -1.1033197128164125e-01
GC_9_100 ref NI_9 NS_100 0 1.5362852826999052e-01
GC_9_101 ref NI_9 NS_101 0 -2.1145523965179121e-05
GC_9_102 ref NI_9 NS_102 0 8.4962743962904066e-03
GC_9_103 ref NI_9 NS_103 0 -1.4241670709802992e-01
GC_9_104 ref NI_9 NS_104 0 -2.1027303837174823e-02
GC_9_105 ref NI_9 NS_105 0 -6.3993702181395315e-02
GC_9_106 ref NI_9 NS_106 0 1.2763919731780946e-01
GC_9_107 ref NI_9 NS_107 0 -6.0291174223579835e-06
GC_9_108 ref NI_9 NS_108 0 1.1396651742958501e-02
GC_9_109 ref NI_9 NS_109 0 -8.9243413951890740e-02
GC_9_110 ref NI_9 NS_110 0 -1.5913223784907252e-01
GC_9_111 ref NI_9 NS_111 0 1.6494479511414076e-01
GC_9_112 ref NI_9 NS_112 0 5.6441480370493111e-02
GC_9_113 ref NI_9 NS_113 0 1.9847653126156763e-05
GC_9_114 ref NI_9 NS_114 0 7.8962683009742695e-03
GC_9_115 ref NI_9 NS_115 0 -2.5420723588188965e-01
GC_9_116 ref NI_9 NS_116 0 1.5469339054697195e-01
GC_9_117 ref NI_9 NS_117 0 -2.7657279474767593e-01
GC_9_118 ref NI_9 NS_118 0 1.8492204784617314e-01
GC_9_119 ref NI_9 NS_119 0 -2.2999884337961771e-05
GC_9_120 ref NI_9 NS_120 0 1.4309304866573756e-02
GC_9_121 ref NI_9 NS_121 0 -1.1073936147910560e-01
GC_9_122 ref NI_9 NS_122 0 -5.6676597851282692e-02
GC_9_123 ref NI_9 NS_123 0 1.0377642756171879e-01
GC_9_124 ref NI_9 NS_124 0 6.3134879704574459e-02
GC_9_125 ref NI_9 NS_125 0 -2.1751581095817565e-05
GC_9_126 ref NI_9 NS_126 0 7.1178354678792279e-03
GC_9_127 ref NI_9 NS_127 0 -4.6711323267955247e-02
GC_9_128 ref NI_9 NS_128 0 -1.1971307603313326e-01
GC_9_129 ref NI_9 NS_129 0 2.6343391051937165e-01
GC_9_130 ref NI_9 NS_130 0 1.2337249427282659e-02
GC_9_131 ref NI_9 NS_131 0 -3.0535507301885753e-05
GC_9_132 ref NI_9 NS_132 0 1.3933889915736836e-03
GC_9_133 ref NI_9 NS_133 0 6.0705718991701546e-02
GC_9_134 ref NI_9 NS_134 0 -2.4464885022882923e-01
GC_9_135 ref NI_9 NS_135 0 3.4992828753361360e-01
GC_9_136 ref NI_9 NS_136 0 6.6611995844584170e-03
GC_9_137 ref NI_9 NS_137 0 -7.9066166581324183e-06
GC_9_138 ref NI_9 NS_138 0 -1.8988904974724182e-03
GD_9_1 ref NI_9 NA_1 0 -4.2394291981033977e-02
GD_9_2 ref NI_9 NA_2 0 -5.9007575016146721e-03
GD_9_3 ref NI_9 NA_3 0 -5.2020877976302886e-02
GD_9_4 ref NI_9 NA_4 0 6.1395662102841045e-02
GD_9_5 ref NI_9 NA_5 0 4.1408740144358025e-02
GD_9_6 ref NI_9 NA_6 0 3.4309274847371014e-02
GD_9_7 ref NI_9 NA_7 0 5.5665187728583261e-02
GD_9_8 ref NI_9 NA_8 0 6.4988910981815917e-02
GD_9_9 ref NI_9 NA_9 0 5.6478729135557817e+00
GD_9_10 ref NI_9 NA_10 0 -2.2033170581129660e-02
GD_9_11 ref NI_9 NA_11 0 5.8507660745457345e-02
GD_9_12 ref NI_9 NA_12 0 1.0024447695677011e-02
GD_9_13 ref NI_9 NA_13 0 6.6088097245729366e-02
GD_9_14 ref NI_9 NA_14 0 5.3328004809824636e-02
GD_9_15 ref NI_9 NA_15 0 8.5203651798890934e-03
GD_9_16 ref NI_9 NA_16 0 4.3126482387935089e-03
GD_9_17 ref NI_9 NA_17 0 2.8251689686371467e-02
GD_9_18 ref NI_9 NA_18 0 4.1582562537040686e-02
GD_9_19 ref NI_9 NA_19 0 3.1307601018928731e-02
GD_9_20 ref NI_9 NA_20 0 5.6449735173501790e-02
GD_9_21 ref NI_9 NA_21 0 2.8314947952201689e-02
GD_9_22 ref NI_9 NA_22 0 1.2976473734177056e-02
GD_9_23 ref NI_9 NA_23 0 -2.2208139890077748e-03
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 -2.7131123218129621e-01
GC_10_2 ref NI_10 NS_2 0 6.7470931635179907e-02
GC_10_3 ref NI_10 NS_3 0 -9.3373826875093213e-02
GC_10_4 ref NI_10 NS_4 0 7.9552539232398828e-02
GC_10_5 ref NI_10 NS_5 0 1.6361781112680596e-04
GC_10_6 ref NI_10 NS_6 0 2.7941859362054348e-02
GC_10_7 ref NI_10 NS_7 0 -2.0187175050797251e-01
GC_10_8 ref NI_10 NS_8 0 3.2518282148180887e-02
GC_10_9 ref NI_10 NS_9 0 -4.9635156159816785e-02
GC_10_10 ref NI_10 NS_10 0 8.2546860383919549e-02
GC_10_11 ref NI_10 NS_11 0 1.0759042433602296e-04
GC_10_12 ref NI_10 NS_12 0 2.0263891262043403e-02
GC_10_13 ref NI_10 NS_13 0 -2.3329165641764085e-01
GC_10_14 ref NI_10 NS_14 0 9.7574055613768113e-02
GC_10_15 ref NI_10 NS_15 0 -1.1429924342481911e-01
GC_10_16 ref NI_10 NS_16 0 7.1443322264050729e-02
GC_10_17 ref NI_10 NS_17 0 1.3266719203842609e-04
GC_10_18 ref NI_10 NS_18 0 3.1422278073556464e-02
GC_10_19 ref NI_10 NS_19 0 -3.8333018370885130e-01
GC_10_20 ref NI_10 NS_20 0 2.3386303498668096e-01
GC_10_21 ref NI_10 NS_21 0 -2.3861907010405919e-01
GC_10_22 ref NI_10 NS_22 0 5.0630949638479139e-02
GC_10_23 ref NI_10 NS_23 0 2.0605227937342785e-04
GC_10_24 ref NI_10 NS_24 0 5.0596678985511775e-02
GC_10_25 ref NI_10 NS_25 0 -4.1768852671296591e-01
GC_10_26 ref NI_10 NS_26 0 2.6514166815997131e-01
GC_10_27 ref NI_10 NS_27 0 -2.5805958078071423e-01
GC_10_28 ref NI_10 NS_28 0 4.8539223485739483e-02
GC_10_29 ref NI_10 NS_29 0 1.9294536638330702e-04
GC_10_30 ref NI_10 NS_30 0 5.2437623526933007e-02
GC_10_31 ref NI_10 NS_31 0 -4.2470600573643447e-01
GC_10_32 ref NI_10 NS_32 0 2.7469192747969828e-01
GC_10_33 ref NI_10 NS_33 0 -2.6846515550780314e-01
GC_10_34 ref NI_10 NS_34 0 5.2712059218100196e-02
GC_10_35 ref NI_10 NS_35 0 1.9531426630188710e-04
GC_10_36 ref NI_10 NS_36 0 5.2011778018622813e-02
GC_10_37 ref NI_10 NS_37 0 -3.7293142542699814e-01
GC_10_38 ref NI_10 NS_38 0 2.3051283013232235e-01
GC_10_39 ref NI_10 NS_39 0 -2.4534535408526292e-01
GC_10_40 ref NI_10 NS_40 0 6.2596688894192648e-02
GC_10_41 ref NI_10 NS_41 0 1.8918377546114101e-04
GC_10_42 ref NI_10 NS_42 0 4.7728830876628582e-02
GC_10_43 ref NI_10 NS_43 0 -7.7919256721859384e-02
GC_10_44 ref NI_10 NS_44 0 -5.3951663491515638e-02
GC_10_45 ref NI_10 NS_45 0 -8.2112335719918578e-02
GC_10_46 ref NI_10 NS_46 0 1.6424378743647719e-01
GC_10_47 ref NI_10 NS_47 0 1.3756242721010479e-05
GC_10_48 ref NI_10 NS_48 0 3.4720640225807853e-03
GC_10_49 ref NI_10 NS_49 0 2.5117123151770460e-01
GC_10_50 ref NI_10 NS_50 0 -3.5026340448983279e-01
GC_10_51 ref NI_10 NS_51 0 1.8677304716677418e-01
GC_10_52 ref NI_10 NS_52 0 1.1005754768712832e-01
GC_10_53 ref NI_10 NS_53 0 2.5528044962391646e-05
GC_10_54 ref NI_10 NS_54 0 -1.7746621611507986e-03
GC_10_55 ref NI_10 NS_55 0 2.9383720285627164e+00
GC_10_56 ref NI_10 NS_56 0 -4.5708862096770284e+00
GC_10_57 ref NI_10 NS_57 0 -7.9821770602554420e-01
GC_10_58 ref NI_10 NS_58 0 -6.3691990471354987e-01
GC_10_59 ref NI_10 NS_59 0 -4.4344421719551253e-04
GC_10_60 ref NI_10 NS_60 0 -6.8405250287684502e-02
GC_10_61 ref NI_10 NS_61 0 -2.2615339558888534e-02
GC_10_62 ref NI_10 NS_62 0 -1.5421590578211058e-01
GC_10_63 ref NI_10 NS_63 0 4.8743851159899085e-02
GC_10_64 ref NI_10 NS_64 0 1.4714704276759719e-01
GC_10_65 ref NI_10 NS_65 0 -2.5645887556704126e-05
GC_10_66 ref NI_10 NS_66 0 -5.5798615769128909e-03
GC_10_67 ref NI_10 NS_67 0 -6.7524870789229208e-01
GC_10_68 ref NI_10 NS_68 0 -1.7189521118640752e-01
GC_10_69 ref NI_10 NS_69 0 9.9505752497379885e-01
GC_10_70 ref NI_10 NS_70 0 -2.6504767535412621e-01
GC_10_71 ref NI_10 NS_71 0 -1.4971402506572679e-04
GC_10_72 ref NI_10 NS_72 0 -1.9216147662307771e-02
GC_10_73 ref NI_10 NS_73 0 2.5025357363000056e-01
GC_10_74 ref NI_10 NS_74 0 -4.9200242465140454e-01
GC_10_75 ref NI_10 NS_75 0 6.3254812910023206e-01
GC_10_76 ref NI_10 NS_76 0 -4.7002765372056783e-02
GC_10_77 ref NI_10 NS_77 0 -6.3887513157917492e-05
GC_10_78 ref NI_10 NS_78 0 -1.3284146499632360e-02
GC_10_79 ref NI_10 NS_79 0 -4.6590524145225709e-01
GC_10_80 ref NI_10 NS_80 0 3.3124887233959605e-01
GC_10_81 ref NI_10 NS_81 0 -4.5450665811615154e-01
GC_10_82 ref NI_10 NS_82 0 2.4670386921222215e-01
GC_10_83 ref NI_10 NS_83 0 -2.8218001990685296e-05
GC_10_84 ref NI_10 NS_84 0 9.9918496903463397e-03
GC_10_85 ref NI_10 NS_85 0 5.0623523895274591e-01
GC_10_86 ref NI_10 NS_86 0 -6.3852440908509178e-01
GC_10_87 ref NI_10 NS_87 0 4.4335806795128929e-01
GC_10_88 ref NI_10 NS_88 0 6.7455395797929335e-02
GC_10_89 ref NI_10 NS_89 0 -1.1337560088717752e-05
GC_10_90 ref NI_10 NS_90 0 -8.8254017408220149e-03
GC_10_91 ref NI_10 NS_91 0 7.0212573381674304e-01
GC_10_92 ref NI_10 NS_92 0 1.9039606566740173e+00
GC_10_93 ref NI_10 NS_93 0 1.8461794843183558e-02
GC_10_94 ref NI_10 NS_94 0 -3.6263835393322225e-01
GC_10_95 ref NI_10 NS_95 0 -7.4882273109736329e-05
GC_10_96 ref NI_10 NS_96 0 -5.0439678904903133e-02
GC_10_97 ref NI_10 NS_97 0 -1.8013014594677740e-01
GC_10_98 ref NI_10 NS_98 0 -2.4946280591562570e-01
GC_10_99 ref NI_10 NS_99 0 4.8469232020414893e-01
GC_10_100 ref NI_10 NS_100 0 8.9646881887338725e-03
GC_10_101 ref NI_10 NS_101 0 7.0688754611150102e-06
GC_10_102 ref NI_10 NS_102 0 -2.5691032010937555e-02
GC_10_103 ref NI_10 NS_103 0 -5.3517312226894498e-01
GC_10_104 ref NI_10 NS_104 0 3.2985439530952787e-01
GC_10_105 ref NI_10 NS_105 0 -4.3707504602666780e-01
GC_10_106 ref NI_10 NS_106 0 2.6833670200930015e-01
GC_10_107 ref NI_10 NS_107 0 -8.4491283285232323e-05
GC_10_108 ref NI_10 NS_108 0 -4.6966619369916889e-04
GC_10_109 ref NI_10 NS_109 0 -5.6669761854503986e-01
GC_10_110 ref NI_10 NS_110 0 4.0121537235069199e-01
GC_10_111 ref NI_10 NS_111 0 -5.1598681688633208e-01
GC_10_112 ref NI_10 NS_112 0 2.7476722045319479e-01
GC_10_113 ref NI_10 NS_113 0 -6.9360332496526107e-05
GC_10_114 ref NI_10 NS_114 0 5.4812796465925377e-03
GC_10_115 ref NI_10 NS_115 0 -4.8224480507537520e-01
GC_10_116 ref NI_10 NS_116 0 2.3662661860099662e-01
GC_10_117 ref NI_10 NS_117 0 -3.2491160505946987e-01
GC_10_118 ref NI_10 NS_118 0 2.5034832424150888e-01
GC_10_119 ref NI_10 NS_119 0 -5.2595948163324148e-05
GC_10_120 ref NI_10 NS_120 0 -6.8426677922874442e-03
GC_10_121 ref NI_10 NS_121 0 -5.4116912334998074e-02
GC_10_122 ref NI_10 NS_122 0 -2.6851215134699763e-01
GC_10_123 ref NI_10 NS_123 0 2.8986216571905521e-01
GC_10_124 ref NI_10 NS_124 0 9.0520664233673276e-02
GC_10_125 ref NI_10 NS_125 0 -4.3903588178128865e-05
GC_10_126 ref NI_10 NS_126 0 -1.8171973519591652e-02
GC_10_127 ref NI_10 NS_127 0 -1.9745801175374295e-01
GC_10_128 ref NI_10 NS_128 0 -9.7684573451040119e-02
GC_10_129 ref NI_10 NS_129 0 1.0907886765057755e+00
GC_10_130 ref NI_10 NS_130 0 -3.1623957842738420e-01
GC_10_131 ref NI_10 NS_131 0 -5.3542491744309677e-05
GC_10_132 ref NI_10 NS_132 0 -3.5140513454239047e-02
GC_10_133 ref NI_10 NS_133 0 9.9430713536266280e-01
GC_10_134 ref NI_10 NS_134 0 2.6436626998506125e+00
GC_10_135 ref NI_10 NS_135 0 -3.1844521509826951e-01
GC_10_136 ref NI_10 NS_136 0 -4.4458749986600288e-01
GC_10_137 ref NI_10 NS_137 0 -1.1177477632791260e-04
GC_10_138 ref NI_10 NS_138 0 -4.7526096606701262e-02
GD_10_1 ref NI_10 NA_1 0 5.7283318574847517e-02
GD_10_2 ref NI_10 NA_2 0 5.3974572203525660e-02
GD_10_3 ref NI_10 NA_3 0 5.1656229778272687e-02
GD_10_4 ref NI_10 NA_4 0 7.6890763504165890e-02
GD_10_5 ref NI_10 NA_5 0 8.1761668275479052e-02
GD_10_6 ref NI_10 NA_6 0 8.2428501453221864e-02
GD_10_7 ref NI_10 NA_7 0 7.4111236930106211e-02
GD_10_8 ref NI_10 NA_8 0 3.1413283971037480e-02
GD_10_9 ref NI_10 NA_9 0 -2.2033170581129660e-02
GD_10_10 ref NI_10 NA_10 0 5.5620467395893041e+00
GD_10_11 ref NI_10 NA_11 0 2.3592670575341989e-02
GD_10_12 ref NI_10 NA_12 0 9.8318858775167217e-02
GD_10_13 ref NI_10 NA_13 0 -2.7780911497535508e-02
GD_10_14 ref NI_10 NA_14 0 9.1733756266360184e-02
GD_10_15 ref NI_10 NA_15 0 -5.7920332820261267e-02
GD_10_16 ref NI_10 NA_16 0 -1.3993348861453156e-01
GD_10_17 ref NI_10 NA_17 0 4.8062787418304741e-02
GD_10_18 ref NI_10 NA_18 0 1.0705655802521269e-01
GD_10_19 ref NI_10 NA_19 0 1.0914211236836471e-01
GD_10_20 ref NI_10 NA_20 0 1.0181792353633866e-01
GD_10_21 ref NI_10 NA_21 0 2.9384308973254326e-02
GD_10_22 ref NI_10 NA_22 0 1.5894105610075680e-02
GD_10_23 ref NI_10 NA_23 0 -1.5758686398053545e-01
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 -4.2769672167310829e-01
GC_11_2 ref NI_11 NS_2 0 3.5629304641310217e-01
GC_11_3 ref NI_11 NS_3 0 -1.5797604156317948e-02
GC_11_4 ref NI_11 NS_4 0 1.1194591705502693e-02
GC_11_5 ref NI_11 NS_5 0 1.2818056842219417e-04
GC_11_6 ref NI_11 NS_6 0 1.2311652689639966e-02
GC_11_7 ref NI_11 NS_7 0 2.7993580828871510e-02
GC_11_8 ref NI_11 NS_8 0 3.2561676311237475e-01
GC_11_9 ref NI_11 NS_9 0 -1.8683374723044429e-02
GC_11_10 ref NI_11 NS_10 0 -8.2744489389942021e-03
GC_11_11 ref NI_11 NS_11 0 5.4319045907533755e-05
GC_11_12 ref NI_11 NS_12 0 8.5777945796531117e-03
GC_11_13 ref NI_11 NS_13 0 -4.0891392691461838e-02
GC_11_14 ref NI_11 NS_14 0 1.6974309945004470e-01
GC_11_15 ref NI_11 NS_15 0 9.2025621705665202e-03
GC_11_16 ref NI_11 NS_16 0 2.2776228379253163e-02
GC_11_17 ref NI_11 NS_17 0 1.0000978073305473e-04
GC_11_18 ref NI_11 NS_18 0 1.3932307012109056e-02
GC_11_19 ref NI_11 NS_19 0 -2.0815719553357087e-01
GC_11_20 ref NI_11 NS_20 0 -6.9929461041448190e-02
GC_11_21 ref NI_11 NS_21 0 2.2521642879549761e-02
GC_11_22 ref NI_11 NS_22 0 6.8461552202655887e-02
GC_11_23 ref NI_11 NS_23 0 2.1497095227806251e-04
GC_11_24 ref NI_11 NS_24 0 2.2940619179899910e-02
GC_11_25 ref NI_11 NS_25 0 -1.6376914038039786e-01
GC_11_26 ref NI_11 NS_26 0 -6.3488594713316832e-02
GC_11_27 ref NI_11 NS_27 0 -1.3349395538926475e-02
GC_11_28 ref NI_11 NS_28 0 8.2088226784562193e-02
GC_11_29 ref NI_11 NS_29 0 2.1365932005609723e-04
GC_11_30 ref NI_11 NS_30 0 2.3107897867387355e-02
GC_11_31 ref NI_11 NS_31 0 -1.4336216881688976e-01
GC_11_32 ref NI_11 NS_32 0 -7.1419296385934652e-02
GC_11_33 ref NI_11 NS_33 0 -1.3602404148622325e-02
GC_11_34 ref NI_11 NS_34 0 8.4864031535261383e-02
GC_11_35 ref NI_11 NS_35 0 2.2954976654383127e-04
GC_11_36 ref NI_11 NS_36 0 2.2530256797187693e-02
GC_11_37 ref NI_11 NS_37 0 -2.0026256813575788e-01
GC_11_38 ref NI_11 NS_38 0 -7.5929501916484274e-02
GC_11_39 ref NI_11 NS_39 0 4.1152406656145973e-02
GC_11_40 ref NI_11 NS_40 0 6.5785704449019766e-02
GC_11_41 ref NI_11 NS_41 0 2.0985438140044455e-04
GC_11_42 ref NI_11 NS_42 0 2.1052958995256624e-02
GC_11_43 ref NI_11 NS_43 0 -5.4215628344489911e-02
GC_11_44 ref NI_11 NS_44 0 1.9838823802495635e+00
GC_11_45 ref NI_11 NS_45 0 -6.5390408957576285e-01
GC_11_46 ref NI_11 NS_46 0 -1.2153146632873975e-01
GC_11_47 ref NI_11 NS_47 0 -1.2946787075991930e-04
GC_11_48 ref NI_11 NS_48 0 -3.4524916265862662e-03
GC_11_49 ref NI_11 NS_49 0 -3.8328723663670949e-01
GC_11_50 ref NI_11 NS_50 0 2.3405163963352413e-01
GC_11_51 ref NI_11 NS_51 0 2.8747909332343885e-01
GC_11_52 ref NI_11 NS_52 0 -9.5700727168081826e-02
GC_11_53 ref NI_11 NS_53 0 -4.2743339951709416e-05
GC_11_54 ref NI_11 NS_54 0 4.5218870487412719e-03
GC_11_55 ref NI_11 NS_55 0 -2.2615339558888749e-02
GC_11_56 ref NI_11 NS_56 0 -1.5421590578210970e-01
GC_11_57 ref NI_11 NS_57 0 4.8743851159897898e-02
GC_11_58 ref NI_11 NS_58 0 1.4714704276759788e-01
GC_11_59 ref NI_11 NS_59 0 -2.5645887556658265e-05
GC_11_60 ref NI_11 NS_60 0 -5.5798615769130904e-03
GC_11_61 ref NI_11 NS_61 0 3.3100602101177867e+00
GC_11_62 ref NI_11 NS_62 0 -4.5089278335227032e+00
GC_11_63 ref NI_11 NS_63 0 -2.1651279952244078e+00
GC_11_64 ref NI_11 NS_64 0 -8.4689634488281790e-02
GC_11_65 ref NI_11 NS_65 0 -5.5047977464241324e-04
GC_11_66 ref NI_11 NS_66 0 -2.6453973301553503e-02
GC_11_67 ref NI_11 NS_67 0 -9.0380839242265226e-02
GC_11_68 ref NI_11 NS_68 0 -9.5654196914913472e-03
GC_11_69 ref NI_11 NS_69 0 1.5588252219573409e-01
GC_11_70 ref NI_11 NS_70 0 3.9376224783352891e-02
GC_11_71 ref NI_11 NS_71 0 7.3994205798784444e-06
GC_11_72 ref NI_11 NS_72 0 1.6158844037464734e-04
GC_11_73 ref NI_11 NS_73 0 -3.5115336247344153e-01
GC_11_74 ref NI_11 NS_74 0 5.8766322618618128e-01
GC_11_75 ref NI_11 NS_75 0 2.4307062240003275e-02
GC_11_76 ref NI_11 NS_76 0 -5.6332837395987871e-02
GC_11_77 ref NI_11 NS_77 0 -6.0317752772850136e-05
GC_11_78 ref NI_11 NS_78 0 3.6369658044540961e-04
GC_11_79 ref NI_11 NS_79 0 -4.5732178049058492e-01
GC_11_80 ref NI_11 NS_80 0 2.7829475768627954e-01
GC_11_81 ref NI_11 NS_81 0 4.1464928096561904e-01
GC_11_82 ref NI_11 NS_82 0 -1.4989174493333879e-01
GC_11_83 ref NI_11 NS_83 0 -3.1895958522737973e-05
GC_11_84 ref NI_11 NS_84 0 -5.5238677288129657e-03
GC_11_85 ref NI_11 NS_85 0 -2.6677057989966634e-02
GC_11_86 ref NI_11 NS_86 0 -1.6126982263799028e-01
GC_11_87 ref NI_11 NS_87 0 3.0789784479753607e-01
GC_11_88 ref NI_11 NS_88 0 -4.8254419436368039e-03
GC_11_89 ref NI_11 NS_89 0 6.5713944323495371e-06
GC_11_90 ref NI_11 NS_90 0 3.1549007916348987e-03
GC_11_91 ref NI_11 NS_91 0 -1.8200284567999117e-01
GC_11_92 ref NI_11 NS_92 0 3.7353816193673554e-02
GC_11_93 ref NI_11 NS_93 0 9.1297947673339583e-02
GC_11_94 ref NI_11 NS_94 0 7.7287165718882000e-02
GC_11_95 ref NI_11 NS_95 0 -3.9889967937470109e-05
GC_11_96 ref NI_11 NS_96 0 -6.3299975252646794e-03
GC_11_97 ref NI_11 NS_97 0 -5.7516174322772763e-02
GC_11_98 ref NI_11 NS_98 0 -7.5134320518223455e-02
GC_11_99 ref NI_11 NS_99 0 3.5735353448129903e-01
GC_11_100 ref NI_11 NS_100 0 -8.7028254518225576e-03
GC_11_101 ref NI_11 NS_101 0 -8.0079807224545728e-05
GC_11_102 ref NI_11 NS_102 0 -1.3674227203433248e-02
GC_11_103 ref NI_11 NS_103 0 -3.8777101351318531e-02
GC_11_104 ref NI_11 NS_104 0 -4.3964456053780743e-02
GC_11_105 ref NI_11 NS_105 0 4.1100502918026682e-01
GC_11_106 ref NI_11 NS_106 0 -4.4932076538187427e-02
GC_11_107 ref NI_11 NS_107 0 1.3604033864864074e-05
GC_11_108 ref NI_11 NS_108 0 -1.7351562464304179e-02
GC_11_109 ref NI_11 NS_109 0 -1.6975709405756334e-01
GC_11_110 ref NI_11 NS_110 0 2.0742314084528976e-01
GC_11_111 ref NI_11 NS_111 0 3.8611032160686248e-01
GC_11_112 ref NI_11 NS_112 0 -1.0960941942986803e-01
GC_11_113 ref NI_11 NS_113 0 -3.8502852232264260e-06
GC_11_114 ref NI_11 NS_114 0 -1.3525369738969872e-02
GC_11_115 ref NI_11 NS_115 0 2.1343810646660982e-01
GC_11_116 ref NI_11 NS_116 0 -3.9857022454408692e-01
GC_11_117 ref NI_11 NS_117 0 4.4496666709066596e-01
GC_11_118 ref NI_11 NS_118 0 4.0234308076808015e-02
GC_11_119 ref NI_11 NS_119 0 2.7279961466674455e-05
GC_11_120 ref NI_11 NS_120 0 -2.1144545411373825e-02
GC_11_121 ref NI_11 NS_121 0 -2.8639325951845266e-02
GC_11_122 ref NI_11 NS_122 0 1.3027259433202574e+00
GC_11_123 ref NI_11 NS_123 0 -2.7563387051426108e-01
GC_11_124 ref NI_11 NS_124 0 -8.8676145498184783e-02
GC_11_125 ref NI_11 NS_125 0 -1.7568258863534858e-04
GC_11_126 ref NI_11 NS_126 0 -1.2001337677566944e-02
GC_11_127 ref NI_11 NS_127 0 -2.8138870310101438e-01
GC_11_128 ref NI_11 NS_128 0 2.6644274109824639e-01
GC_11_129 ref NI_11 NS_129 0 5.7575582777644838e-02
GC_11_130 ref NI_11 NS_130 0 2.8427700408687386e-02
GC_11_131 ref NI_11 NS_131 0 -2.4039753168084376e-05
GC_11_132 ref NI_11 NS_132 0 -4.5503942731601821e-03
GC_11_133 ref NI_11 NS_133 0 -4.0295227344070220e-02
GC_11_134 ref NI_11 NS_134 0 -1.1618598547691861e-01
GC_11_135 ref NI_11 NS_135 0 9.5691067889483422e-02
GC_11_136 ref NI_11 NS_136 0 1.0731574076255340e-01
GC_11_137 ref NI_11 NS_137 0 -2.1263057582020487e-05
GC_11_138 ref NI_11 NS_138 0 -3.1789491245050928e-03
GD_11_1 ref NI_11 NA_1 0 3.5323815493917617e-02
GD_11_2 ref NI_11 NA_2 0 4.4166933455496389e-02
GD_11_3 ref NI_11 NA_3 0 1.3526524990949826e-02
GD_11_4 ref NI_11 NA_4 0 4.9741287318135055e-02
GD_11_5 ref NI_11 NA_5 0 4.3601049275034512e-02
GD_11_6 ref NI_11 NA_6 0 4.0139011733976500e-02
GD_11_7 ref NI_11 NA_7 0 4.5000624396683730e-02
GD_11_8 ref NI_11 NA_8 0 -1.5572442442475447e-02
GD_11_9 ref NI_11 NA_9 0 5.8507660745457345e-02
GD_11_10 ref NI_11 NA_10 0 2.3592670575341989e-02
GD_11_11 ref NI_11 NA_11 0 5.5616689209219583e+00
GD_11_12 ref NI_11 NA_12 0 2.2810833662859294e-02
GD_11_13 ref NI_11 NA_13 0 5.5632736875820397e-02
GD_11_14 ref NI_11 NA_14 0 8.3278895375622414e-02
GD_11_15 ref NI_11 NA_15 0 1.1471482098534566e-02
GD_11_16 ref NI_11 NA_16 0 4.8780914861192834e-02
GD_11_17 ref NI_11 NA_17 0 1.2051864146514706e-02
GD_11_18 ref NI_11 NA_18 0 2.6096639501019640e-02
GD_11_19 ref NI_11 NA_19 0 4.2256444281873799e-02
GD_11_20 ref NI_11 NA_20 0 -1.1261412117334077e-02
GD_11_21 ref NI_11 NA_21 0 -2.9848964892351344e-02
GD_11_22 ref NI_11 NA_22 0 5.7863309376803417e-02
GD_11_23 ref NI_11 NA_23 0 2.1271547443523348e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 -2.9149090450033727e-01
GC_12_2 ref NI_12 NS_2 0 3.9979033486795523e-01
GC_12_3 ref NI_12 NS_3 0 -6.4125149743057414e-02
GC_12_4 ref NI_12 NS_4 0 3.1124938179236269e-02
GC_12_5 ref NI_12 NS_5 0 2.1487533822799610e-04
GC_12_6 ref NI_12 NS_6 0 7.1023090474649653e-03
GC_12_7 ref NI_12 NS_7 0 2.0028693493571506e-01
GC_12_8 ref NI_12 NS_8 0 3.0764292477106414e-01
GC_12_9 ref NI_12 NS_9 0 -4.1290787248352792e-02
GC_12_10 ref NI_12 NS_10 0 8.3394017293429365e-03
GC_12_11 ref NI_12 NS_11 0 1.4644776484739629e-04
GC_12_12 ref NI_12 NS_12 0 4.5883641512652947e-03
GC_12_13 ref NI_12 NS_13 0 1.4900086136350071e-01
GC_12_14 ref NI_12 NS_14 0 1.8533535275877497e-01
GC_12_15 ref NI_12 NS_15 0 -2.1326500397971581e-02
GC_12_16 ref NI_12 NS_16 0 3.5677608114352478e-02
GC_12_17 ref NI_12 NS_17 0 1.7628936407244607e-04
GC_12_18 ref NI_12 NS_18 0 8.3552459283165650e-03
GC_12_19 ref NI_12 NS_19 0 -3.1357399516713408e-01
GC_12_20 ref NI_12 NS_20 0 -6.1841567506644565e-03
GC_12_21 ref NI_12 NS_21 0 -1.1461354340156471e-02
GC_12_22 ref NI_12 NS_22 0 9.0059161543406305e-02
GC_12_23 ref NI_12 NS_23 0 2.8239880075968838e-04
GC_12_24 ref NI_12 NS_24 0 1.6521244927396664e-02
GC_12_25 ref NI_12 NS_25 0 -2.6338255649325593e-01
GC_12_26 ref NI_12 NS_26 0 -9.2686179929604082e-03
GC_12_27 ref NI_12 NS_27 0 -4.3014478554796919e-02
GC_12_28 ref NI_12 NS_28 0 1.0403908378019709e-01
GC_12_29 ref NI_12 NS_29 0 2.8124856918319011e-04
GC_12_30 ref NI_12 NS_30 0 1.6590977883064632e-02
GC_12_31 ref NI_12 NS_31 0 -2.4094062113542239e-01
GC_12_32 ref NI_12 NS_32 0 -2.0889123219380041e-02
GC_12_33 ref NI_12 NS_33 0 -4.0256412024685599e-02
GC_12_34 ref NI_12 NS_34 0 1.0643025440127336e-01
GC_12_35 ref NI_12 NS_35 0 2.8460321586717106e-04
GC_12_36 ref NI_12 NS_36 0 1.6026214616446238e-02
GC_12_37 ref NI_12 NS_37 0 -2.9990695773464554e-01
GC_12_38 ref NI_12 NS_38 0 -9.3396019598609419e-03
GC_12_39 ref NI_12 NS_39 0 8.4080879521380297e-03
GC_12_40 ref NI_12 NS_40 0 8.5841463287217118e-02
GC_12_41 ref NI_12 NS_41 0 2.6961670108726331e-04
GC_12_42 ref NI_12 NS_42 0 1.4652534900859479e-02
GC_12_43 ref NI_12 NS_43 0 -1.9896393748978439e-01
GC_12_44 ref NI_12 NS_44 0 7.3367491829748818e-02
GC_12_45 ref NI_12 NS_45 0 1.7952824097474096e-01
GC_12_46 ref NI_12 NS_46 0 3.3444271894812433e-03
GC_12_47 ref NI_12 NS_47 0 3.3520305564253659e-05
GC_12_48 ref NI_12 NS_48 0 2.1963678991142929e-03
GC_12_49 ref NI_12 NS_49 0 -1.2926613142685775e-01
GC_12_50 ref NI_12 NS_50 0 1.9333748125997319e-01
GC_12_51 ref NI_12 NS_51 0 4.0524483175143711e-01
GC_12_52 ref NI_12 NS_52 0 -1.3720135604126715e-01
GC_12_53 ref NI_12 NS_53 0 -4.2431222069927979e-05
GC_12_54 ref NI_12 NS_54 0 -2.4782427446711779e-03
GC_12_55 ref NI_12 NS_55 0 -6.7524870789229230e-01
GC_12_56 ref NI_12 NS_56 0 -1.7189521118640672e-01
GC_12_57 ref NI_12 NS_57 0 9.9505752497379762e-01
GC_12_58 ref NI_12 NS_58 0 -2.6504767535412560e-01
GC_12_59 ref NI_12 NS_59 0 -1.4971402506568351e-04
GC_12_60 ref NI_12 NS_60 0 -1.9216147662307961e-02
GC_12_61 ref NI_12 NS_61 0 -9.0380839242265171e-02
GC_12_62 ref NI_12 NS_62 0 -9.5654196914915172e-03
GC_12_63 ref NI_12 NS_63 0 1.5588252219573434e-01
GC_12_64 ref NI_12 NS_64 0 3.9376224783352759e-02
GC_12_65 ref NI_12 NS_65 0 7.3994205798692786e-06
GC_12_66 ref NI_12 NS_66 0 1.6158844037468748e-04
GC_12_67 ref NI_12 NS_67 0 3.0150422165353108e+00
GC_12_68 ref NI_12 NS_68 0 -5.0613160393162628e+00
GC_12_69 ref NI_12 NS_69 0 -1.4804813990294197e+00
GC_12_70 ref NI_12 NS_70 0 -2.4584060708739217e-01
GC_12_71 ref NI_12 NS_71 0 -7.5175965171350018e-04
GC_12_72 ref NI_12 NS_72 0 -3.1324585612764716e-02
GC_12_73 ref NI_12 NS_73 0 5.8165326503002556e-03
GC_12_74 ref NI_12 NS_74 0 5.0115819238515913e-01
GC_12_75 ref NI_12 NS_75 0 2.5974105758875105e-01
GC_12_76 ref NI_12 NS_76 0 -1.4355352104757191e-01
GC_12_77 ref NI_12 NS_77 0 -6.5870737087088554e-05
GC_12_78 ref NI_12 NS_78 0 -8.5478230258268419e-03
GC_12_79 ref NI_12 NS_79 0 -3.0383133889859304e-01
GC_12_80 ref NI_12 NS_80 0 6.1418439413353142e-02
GC_12_81 ref NI_12 NS_81 0 -4.6579848019471952e-02
GC_12_82 ref NI_12 NS_82 0 1.1211315579864306e-01
GC_12_83 ref NI_12 NS_83 0 5.0442705601015187e-05
GC_12_84 ref NI_12 NS_84 0 8.1854324639649995e-03
GC_12_85 ref NI_12 NS_85 0 -4.2670508265371038e-01
GC_12_86 ref NI_12 NS_86 0 1.4780520769763488e+00
GC_12_87 ref NI_12 NS_87 0 4.7660785115098574e-02
GC_12_88 ref NI_12 NS_88 0 -3.1332148148501465e-01
GC_12_89 ref NI_12 NS_89 0 -1.9482303855441341e-04
GC_12_90 ref NI_12 NS_90 0 -5.2966184134957536e-03
GC_12_91 ref NI_12 NS_91 0 1.0923130578863789e-01
GC_12_92 ref NI_12 NS_92 0 -4.5043629649157879e-01
GC_12_93 ref NI_12 NS_93 0 7.4458635727216393e-01
GC_12_94 ref NI_12 NS_94 0 -1.0523698541311707e-01
GC_12_95 ref NI_12 NS_95 0 -7.4988890402519925e-05
GC_12_96 ref NI_12 NS_96 0 -1.6001856963816046e-02
GC_12_97 ref NI_12 NS_97 0 4.4084366815278574e-02
GC_12_98 ref NI_12 NS_98 0 -1.8100064022579634e-01
GC_12_99 ref NI_12 NS_99 0 3.7713212141727112e-02
GC_12_100 ref NI_12 NS_100 0 1.5193380642671125e-01
GC_12_101 ref NI_12 NS_101 0 -3.2563652457046242e-05
GC_12_102 ref NI_12 NS_102 0 -3.4802813476093510e-03
GC_12_103 ref NI_12 NS_103 0 -4.2859450369213664e-01
GC_12_104 ref NI_12 NS_104 0 2.7104154341669978e-01
GC_12_105 ref NI_12 NS_105 0 -3.6480311643255620e-01
GC_12_106 ref NI_12 NS_106 0 2.1204114493369916e-01
GC_12_107 ref NI_12 NS_107 0 -4.2793258302810071e-05
GC_12_108 ref NI_12 NS_108 0 1.1661720363902029e-02
GC_12_109 ref NI_12 NS_109 0 -3.5095182535615610e-01
GC_12_110 ref NI_12 NS_110 0 1.7225260851880894e-01
GC_12_111 ref NI_12 NS_111 0 -2.4650495538847084e-01
GC_12_112 ref NI_12 NS_112 0 1.7893428426548139e-01
GC_12_113 ref NI_12 NS_113 0 -1.8828954538498342e-06
GC_12_114 ref NI_12 NS_114 0 1.0576330378399293e-02
GC_12_115 ref NI_12 NS_115 0 -4.8483669686792352e-01
GC_12_116 ref NI_12 NS_116 0 3.4098978369109184e-01
GC_12_117 ref NI_12 NS_117 0 -4.4563810982300944e-01
GC_12_118 ref NI_12 NS_118 0 2.3600559346402405e-01
GC_12_119 ref NI_12 NS_119 0 -5.4664026766437140e-05
GC_12_120 ref NI_12 NS_120 0 1.1753210930956598e-02
GC_12_121 ref NI_12 NS_121 0 -1.9374510106296896e-02
GC_12_122 ref NI_12 NS_122 0 -1.0587606913088582e-01
GC_12_123 ref NI_12 NS_123 0 5.8367210921727974e-02
GC_12_124 ref NI_12 NS_124 0 1.1873859268264085e-01
GC_12_125 ref NI_12 NS_125 0 -3.5564549162053092e-05
GC_12_126 ref NI_12 NS_126 0 -1.6106379919272309e-03
GC_12_127 ref NI_12 NS_127 0 2.0624805759772927e-01
GC_12_128 ref NI_12 NS_128 0 -1.3096222830648596e-01
GC_12_129 ref NI_12 NS_129 0 5.7390344726719178e-01
GC_12_130 ref NI_12 NS_130 0 -1.1207615835556334e-01
GC_12_131 ref NI_12 NS_131 0 -1.1310286002249902e-04
GC_12_132 ref NI_12 NS_132 0 -1.5615735255171351e-02
GC_12_133 ref NI_12 NS_133 0 1.0308564040153207e+00
GC_12_134 ref NI_12 NS_134 0 2.1719083603008258e+00
GC_12_135 ref NI_12 NS_135 0 -6.6223177361228480e-01
GC_12_136 ref NI_12 NS_136 0 -1.8928909419673959e-01
GC_12_137 ref NI_12 NS_137 0 -1.6163047506723158e-04
GC_12_138 ref NI_12 NS_138 0 -2.5067697441532692e-02
GD_12_1 ref NI_12 NA_1 0 6.5198027150017782e-03
GD_12_2 ref NI_12 NA_2 0 2.4891237881842172e-02
GD_12_3 ref NI_12 NA_3 0 -2.8958087087038605e-03
GD_12_4 ref NI_12 NA_4 0 6.3483947494355639e-02
GD_12_5 ref NI_12 NA_5 0 5.7428146037133497e-02
GD_12_6 ref NI_12 NA_6 0 5.3777002643417282e-02
GD_12_7 ref NI_12 NA_7 0 5.6999013841705186e-02
GD_12_8 ref NI_12 NA_8 0 3.5233771314848963e-02
GD_12_9 ref NI_12 NA_9 0 1.0024447695677011e-02
GD_12_10 ref NI_12 NA_10 0 9.8318858775167217e-02
GD_12_11 ref NI_12 NA_11 0 2.2810833662859294e-02
GD_12_12 ref NI_12 NA_12 0 5.5935612432747206e+00
GD_12_13 ref NI_12 NA_13 0 -1.7134689212360055e-02
GD_12_14 ref NI_12 NA_14 0 6.1263258447193256e-02
GD_12_15 ref NI_12 NA_15 0 5.2897067502761512e-02
GD_12_16 ref NI_12 NA_16 0 -3.2001676018982199e-03
GD_12_17 ref NI_12 NA_17 0 1.2869054530862189e-02
GD_12_18 ref NI_12 NA_18 0 8.5625871292558733e-02
GD_12_19 ref NI_12 NA_19 0 7.2217555870722178e-02
GD_12_20 ref NI_12 NA_20 0 9.4142691153528912e-02
GD_12_21 ref NI_12 NA_21 0 1.7755682278219876e-02
GD_12_22 ref NI_12 NA_22 0 -3.7954939867483460e-02
GD_12_23 ref NI_12 NA_23 0 -1.3935985519929833e-01
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 -3.8177454792062560e-01
GC_13_2 ref NI_13 NS_2 0 4.7797613605233097e-01
GC_13_3 ref NI_13 NS_3 0 -6.3139474501326953e-02
GC_13_4 ref NI_13 NS_4 0 1.6326672504492545e-02
GC_13_5 ref NI_13 NS_5 0 1.8682358870556785e-04
GC_13_6 ref NI_13 NS_6 0 5.6630368928738545e-03
GC_13_7 ref NI_13 NS_7 0 1.6820099971077213e-01
GC_13_8 ref NI_13 NS_8 0 3.9858328648343316e-01
GC_13_9 ref NI_13 NS_9 0 -5.9955342482211578e-02
GC_13_10 ref NI_13 NS_10 0 -6.7814614303610748e-03
GC_13_11 ref NI_13 NS_11 0 1.1804970471841156e-04
GC_13_12 ref NI_13 NS_12 0 3.5419840062587567e-03
GC_13_13 ref NI_13 NS_13 0 1.2114795786238317e-01
GC_13_14 ref NI_13 NS_14 0 2.2165423939224799e-01
GC_13_15 ref NI_13 NS_15 0 -8.4280448613140088e-03
GC_13_16 ref NI_13 NS_16 0 2.3702001065995626e-02
GC_13_17 ref NI_13 NS_17 0 1.5050011279812146e-04
GC_13_18 ref NI_13 NS_18 0 6.6707679593224689e-03
GC_13_19 ref NI_13 NS_19 0 -2.8164658666347792e-01
GC_13_20 ref NI_13 NS_20 0 -7.2032257241953168e-02
GC_13_21 ref NI_13 NS_21 0 5.2862072437015802e-02
GC_13_22 ref NI_13 NS_22 0 8.1953018159251531e-02
GC_13_23 ref NI_13 NS_23 0 2.6535354808914928e-04
GC_13_24 ref NI_13 NS_24 0 1.3347203988903643e-02
GC_13_25 ref NI_13 NS_25 0 -2.1264334131892954e-01
GC_13_26 ref NI_13 NS_26 0 -8.2410673974448151e-02
GC_13_27 ref NI_13 NS_27 0 2.0678103061381289e-02
GC_13_28 ref NI_13 NS_28 0 9.8111134540741524e-02
GC_13_29 ref NI_13 NS_29 0 2.6704934739318138e-04
GC_13_30 ref NI_13 NS_30 0 1.3134884995260046e-02
GC_13_31 ref NI_13 NS_31 0 -1.8678542393410622e-01
GC_13_32 ref NI_13 NS_32 0 -9.5658390480142755e-02
GC_13_33 ref NI_13 NS_33 0 2.4112154868772030e-02
GC_13_34 ref NI_13 NS_34 0 1.0034941461071820e-01
GC_13_35 ref NI_13 NS_35 0 2.8672996503362121e-04
GC_13_36 ref NI_13 NS_36 0 1.2484164013725946e-02
GC_13_37 ref NI_13 NS_37 0 -2.7535983941780035e-01
GC_13_38 ref NI_13 NS_38 0 -7.1661277173221530e-02
GC_13_39 ref NI_13 NS_39 0 7.4104125082562852e-02
GC_13_40 ref NI_13 NS_40 0 7.5804329004113588e-02
GC_13_41 ref NI_13 NS_41 0 2.6575418035751434e-04
GC_13_42 ref NI_13 NS_42 0 1.1603605757368509e-02
GC_13_43 ref NI_13 NS_43 0 -4.3664787351234874e-01
GC_13_44 ref NI_13 NS_44 0 5.8164458959078713e-01
GC_13_45 ref NI_13 NS_45 0 6.5743651696846941e-02
GC_13_46 ref NI_13 NS_46 0 -7.5983049515126799e-02
GC_13_47 ref NI_13 NS_47 0 -1.9699364756977107e-05
GC_13_48 ref NI_13 NS_48 0 1.9230790969861859e-03
GC_13_49 ref NI_13 NS_49 0 -5.6214016638226239e-01
GC_13_50 ref NI_13 NS_50 0 1.4097650182734158e+00
GC_13_51 ref NI_13 NS_51 0 -1.5340589037994024e-01
GC_13_52 ref NI_13 NS_52 0 -1.9221369911874703e-01
GC_13_53 ref NI_13 NS_53 0 -1.1794907877929356e-04
GC_13_54 ref NI_13 NS_54 0 -2.5178072003923310e-04
GC_13_55 ref NI_13 NS_55 0 2.5025357363000045e-01
GC_13_56 ref NI_13 NS_56 0 -4.9200242465140420e-01
GC_13_57 ref NI_13 NS_57 0 6.3254812910023162e-01
GC_13_58 ref NI_13 NS_58 0 -4.7002765372056554e-02
GC_13_59 ref NI_13 NS_59 0 -6.3887513157903086e-05
GC_13_60 ref NI_13 NS_60 0 -1.3284146499632426e-02
GC_13_61 ref NI_13 NS_61 0 -3.5115336247344131e-01
GC_13_62 ref NI_13 NS_62 0 5.8766322618618050e-01
GC_13_63 ref NI_13 NS_63 0 2.4307062240004229e-02
GC_13_64 ref NI_13 NS_64 0 -5.6332837395988419e-02
GC_13_65 ref NI_13 NS_65 0 -6.0317752772886830e-05
GC_13_66 ref NI_13 NS_66 0 3.6369658044557094e-04
GC_13_67 ref NI_13 NS_67 0 5.8165326502999833e-03
GC_13_68 ref NI_13 NS_68 0 5.0115819238516024e-01
GC_13_69 ref NI_13 NS_69 0 2.5974105758874955e-01
GC_13_70 ref NI_13 NS_70 0 -1.4355352104757108e-01
GC_13_71 ref NI_13 NS_71 0 -6.5870737087032162e-05
GC_13_72 ref NI_13 NS_72 0 -8.5478230258270917e-03
GC_13_73 ref NI_13 NS_73 0 3.4571727239480099e+00
GC_13_74 ref NI_13 NS_74 0 -4.2803360014846614e+00
GC_13_75 ref NI_13 NS_75 0 -2.3711165196096453e+00
GC_13_76 ref NI_13 NS_76 0 -5.7318997886553140e-02
GC_13_77 ref NI_13 NS_77 0 -5.5660355039719497e-04
GC_13_78 ref NI_13 NS_78 0 -2.8834692644287348e-02
GC_13_79 ref NI_13 NS_79 0 -2.7192515187207755e-01
GC_13_80 ref NI_13 NS_80 0 -6.8420614081285927e-02
GC_13_81 ref NI_13 NS_81 0 2.0011687178009768e-01
GC_13_82 ref NI_13 NS_82 0 3.0298536019573406e-02
GC_13_83 ref NI_13 NS_83 0 3.0733832179483491e-05
GC_13_84 ref NI_13 NS_84 0 4.1529842445877175e-03
GC_13_85 ref NI_13 NS_85 0 -1.0358279853906674e-01
GC_13_86 ref NI_13 NS_86 0 4.7103335882807192e-02
GC_13_87 ref NI_13 NS_87 0 5.8098053430286534e-01
GC_13_88 ref NI_13 NS_88 0 -1.8360228413871066e-01
GC_13_89 ref NI_13 NS_89 0 -6.5561820215730748e-05
GC_13_90 ref NI_13 NS_90 0 -3.6218903976422299e-03
GC_13_91 ref NI_13 NS_91 0 2.5967535163249521e-02
GC_13_92 ref NI_13 NS_92 0 -7.9682308695436327e-02
GC_13_93 ref NI_13 NS_93 0 3.5859786344816835e-01
GC_13_94 ref NI_13 NS_94 0 -3.0927056246307334e-02
GC_13_95 ref NI_13 NS_95 0 -9.7169387597588632e-05
GC_13_96 ref NI_13 NS_96 0 -7.3164082274191078e-03
GC_13_97 ref NI_13 NS_97 0 -8.9324474887964481e-02
GC_13_98 ref NI_13 NS_98 0 -8.7932400732237029e-02
GC_13_99 ref NI_13 NS_99 0 1.1872763285520846e-01
GC_13_100 ref NI_13 NS_100 0 8.6419540359798680e-02
GC_13_101 ref NI_13 NS_101 0 -6.5335870641904705e-05
GC_13_102 ref NI_13 NS_102 0 -2.0272621564860023e-03
GC_13_103 ref NI_13 NS_103 0 -2.1127639234437029e-01
GC_13_104 ref NI_13 NS_104 0 1.7301796590896944e-02
GC_13_105 ref NI_13 NS_105 0 -8.4323950692736349e-02
GC_13_106 ref NI_13 NS_106 0 1.4713749286885808e-01
GC_13_107 ref NI_13 NS_107 0 -3.8654432685911046e-05
GC_13_108 ref NI_13 NS_108 0 4.7608943237263616e-03
GC_13_109 ref NI_13 NS_109 0 -1.7695436714104856e-01
GC_13_110 ref NI_13 NS_110 0 -6.4940177501314103e-02
GC_13_111 ref NI_13 NS_111 0 4.7792333049963019e-02
GC_13_112 ref NI_13 NS_112 0 1.0259237906311588e-01
GC_13_113 ref NI_13 NS_113 0 -4.6446188866376376e-06
GC_13_114 ref NI_13 NS_114 0 4.2494037772976972e-03
GC_13_115 ref NI_13 NS_115 0 -2.3777499106714195e-01
GC_13_116 ref NI_13 NS_116 0 8.4828105393619652e-02
GC_13_117 ref NI_13 NS_117 0 -1.9382195471643565e-01
GC_13_118 ref NI_13 NS_118 0 1.8585767684962329e-01
GC_13_119 ref NI_13 NS_119 0 -4.4510361375149781e-05
GC_13_120 ref NI_13 NS_120 0 4.6769126899779143e-03
GC_13_121 ref NI_13 NS_121 0 -2.1966480731925014e-01
GC_13_122 ref NI_13 NS_122 0 2.0057521834905689e-01
GC_13_123 ref NI_13 NS_123 0 7.6385592201208261e-02
GC_13_124 ref NI_13 NS_124 0 2.7927768784993302e-02
GC_13_125 ref NI_13 NS_125 0 -7.7993591132388438e-05
GC_13_126 ref NI_13 NS_126 0 -9.2706989509850084e-04
GC_13_127 ref NI_13 NS_127 0 6.3899355864672047e-02
GC_13_128 ref NI_13 NS_128 0 8.6334215641821299e-01
GC_13_129 ref NI_13 NS_129 0 -5.2879849582905369e-02
GC_13_130 ref NI_13 NS_130 0 -8.6743335223408505e-02
GC_13_131 ref NI_13 NS_131 0 -1.8735383544830962e-04
GC_13_132 ref NI_13 NS_132 0 -9.5052748141366949e-03
GC_13_133 ref NI_13 NS_133 0 1.6443669204165900e-01
GC_13_134 ref NI_13 NS_134 0 2.7776985377441763e-03
GC_13_135 ref NI_13 NS_135 0 4.5105220402214091e-01
GC_13_136 ref NI_13 NS_136 0 -9.4513691423197724e-02
GC_13_137 ref NI_13 NS_137 0 -8.4227894506277106e-05
GC_13_138 ref NI_13 NS_138 0 -1.2442270984911203e-02
GD_13_1 ref NI_13 NA_1 0 1.4757981564309887e-02
GD_13_2 ref NI_13 NA_2 0 3.7007398821947847e-02
GD_13_3 ref NI_13 NA_3 0 -2.1943661810703099e-04
GD_13_4 ref NI_13 NA_4 0 5.9939333450754542e-02
GD_13_5 ref NI_13 NA_5 0 5.1067221736278486e-02
GD_13_6 ref NI_13 NA_6 0 4.6941927101859390e-02
GD_13_7 ref NI_13 NA_7 0 5.4357311915508980e-02
GD_13_8 ref NI_13 NA_8 0 6.8316470528488618e-02
GD_13_9 ref NI_13 NA_9 0 6.6088097245729366e-02
GD_13_10 ref NI_13 NA_10 0 -2.7780911497535508e-02
GD_13_11 ref NI_13 NA_11 0 5.5632736875820397e-02
GD_13_12 ref NI_13 NA_12 0 -1.7134689212360055e-02
GD_13_13 ref NI_13 NA_13 0 5.5625481049209915e+00
GD_13_14 ref NI_13 NA_14 0 5.8990881670332861e-02
GD_13_15 ref NI_13 NA_15 0 8.7763159712504358e-03
GD_13_16 ref NI_13 NA_16 0 5.5134296584197972e-03
GD_13_17 ref NI_13 NA_17 0 2.9919069074477236e-02
GD_13_18 ref NI_13 NA_18 0 5.5241778179761364e-02
GD_13_19 ref NI_13 NA_19 0 4.8768490196299717e-02
GD_13_20 ref NI_13 NA_20 0 5.8301376735767609e-02
GD_13_21 ref NI_13 NA_21 0 4.1450036887302262e-02
GD_13_22 ref NI_13 NA_22 0 -3.5997212864396250e-02
GD_13_23 ref NI_13 NA_23 0 -3.0998801130799929e-02
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 -3.3280142733088647e-01
GC_14_2 ref NI_14 NS_2 0 6.1276681937212585e-01
GC_14_3 ref NI_14 NS_3 0 -1.4172607003921164e-01
GC_14_4 ref NI_14 NS_4 0 1.1356036626903713e-02
GC_14_5 ref NI_14 NS_5 0 1.2466573176274728e-04
GC_14_6 ref NI_14 NS_6 0 7.6774446809582788e-03
GC_14_7 ref NI_14 NS_7 0 6.7886855566627435e-01
GC_14_8 ref NI_14 NS_8 0 4.3688080996256329e-01
GC_14_9 ref NI_14 NS_9 0 -1.3665760520300935e-01
GC_14_10 ref NI_14 NS_10 0 -1.8515839985100709e-02
GC_14_11 ref NI_14 NS_11 0 2.6985916193882690e-05
GC_14_12 ref NI_14 NS_12 0 4.7742605266512857e-03
GC_14_13 ref NI_14 NS_13 0 -1.1071928285633179e-01
GC_14_14 ref NI_14 NS_14 0 3.2566033051339860e-01
GC_14_15 ref NI_14 NS_15 0 -3.7102605274424633e-02
GC_14_16 ref NI_14 NS_16 0 2.2779220740333918e-02
GC_14_17 ref NI_14 NS_17 0 1.0967091135321033e-04
GC_14_18 ref NI_14 NS_18 0 9.4511913819727948e-03
GC_14_19 ref NI_14 NS_19 0 -2.8298897819185320e-01
GC_14_20 ref NI_14 NS_20 0 -1.1787960016660286e-01
GC_14_21 ref NI_14 NS_21 0 9.4730552364378912e-02
GC_14_22 ref NI_14 NS_22 0 6.3544257208639765e-02
GC_14_23 ref NI_14 NS_23 0 2.0801224480009883e-04
GC_14_24 ref NI_14 NS_24 0 1.7401377219946404e-02
GC_14_25 ref NI_14 NS_25 0 -1.9020125784973441e-01
GC_14_26 ref NI_14 NS_26 0 -1.3519834493233243e-01
GC_14_27 ref NI_14 NS_27 0 6.3533969432685508e-02
GC_14_28 ref NI_14 NS_28 0 8.0108965524877326e-02
GC_14_29 ref NI_14 NS_29 0 2.0704273630166298e-04
GC_14_30 ref NI_14 NS_30 0 1.7174788391971518e-02
GC_14_31 ref NI_14 NS_31 0 -1.5765884301177011e-01
GC_14_32 ref NI_14 NS_32 0 -1.5041374795804041e-01
GC_14_33 ref NI_14 NS_33 0 6.7372994415427906e-02
GC_14_34 ref NI_14 NS_34 0 8.2387863258093996e-02
GC_14_35 ref NI_14 NS_35 0 2.0869855676742372e-04
GC_14_36 ref NI_14 NS_36 0 1.6661078009723655e-02
GC_14_37 ref NI_14 NS_37 0 -2.8181484438066695e-01
GC_14_38 ref NI_14 NS_38 0 -1.2432665329240308e-01
GC_14_39 ref NI_14 NS_39 0 1.1857329752900807e-01
GC_14_40 ref NI_14 NS_40 0 5.8191500523077221e-02
GC_14_41 ref NI_14 NS_41 0 1.8466416526200403e-04
GC_14_42 ref NI_14 NS_42 0 1.5883617268609887e-02
GC_14_43 ref NI_14 NS_43 0 -5.8226700724039582e-01
GC_14_44 ref NI_14 NS_44 0 1.1945140398122691e+00
GC_14_45 ref NI_14 NS_45 0 -3.3479110021042979e-02
GC_14_46 ref NI_14 NS_46 0 -1.9093460856636998e-01
GC_14_47 ref NI_14 NS_47 0 -2.8677014399332448e-05
GC_14_48 ref NI_14 NS_48 0 -2.8860128935720335e-03
GC_14_49 ref NI_14 NS_49 0 -2.9989482549107349e-01
GC_14_50 ref NI_14 NS_50 0 -3.6580202150081079e-02
GC_14_51 ref NI_14 NS_51 0 3.3043051677278429e-01
GC_14_52 ref NI_14 NS_52 0 -4.4653352897884274e-02
GC_14_53 ref NI_14 NS_53 0 2.2120667565426039e-05
GC_14_54 ref NI_14 NS_54 0 4.6466406075516267e-03
GC_14_55 ref NI_14 NS_55 0 -4.6590524145225709e-01
GC_14_56 ref NI_14 NS_56 0 3.3124887233959599e-01
GC_14_57 ref NI_14 NS_57 0 -4.5450665811615154e-01
GC_14_58 ref NI_14 NS_58 0 2.4670386921222207e-01
GC_14_59 ref NI_14 NS_59 0 -2.8218001990689253e-05
GC_14_60 ref NI_14 NS_60 0 9.9918496903463570e-03
GC_14_61 ref NI_14 NS_61 0 -4.5732178049058492e-01
GC_14_62 ref NI_14 NS_62 0 2.7829475768627981e-01
GC_14_63 ref NI_14 NS_63 0 4.1464928096561876e-01
GC_14_64 ref NI_14 NS_64 0 -1.4989174493333862e-01
GC_14_65 ref NI_14 NS_65 0 -3.1895958522726169e-05
GC_14_66 ref NI_14 NS_66 0 -5.5238677288130178e-03
GC_14_67 ref NI_14 NS_67 0 -3.0383133889859310e-01
GC_14_68 ref NI_14 NS_68 0 6.1418439413353593e-02
GC_14_69 ref NI_14 NS_69 0 -4.6579848019472569e-02
GC_14_70 ref NI_14 NS_70 0 1.1211315579864341e-01
GC_14_71 ref NI_14 NS_71 0 5.0442705601038768e-05
GC_14_72 ref NI_14 NS_72 0 8.1854324639648972e-03
GC_14_73 ref NI_14 NS_73 0 -2.7192515187207755e-01
GC_14_74 ref NI_14 NS_74 0 -6.8420614081285760e-02
GC_14_75 ref NI_14 NS_75 0 2.0011687178009746e-01
GC_14_76 ref NI_14 NS_76 0 3.0298536019573528e-02
GC_14_77 ref NI_14 NS_77 0 3.0733832179491338e-05
GC_14_78 ref NI_14 NS_78 0 4.1529842445876836e-03
GC_14_79 ref NI_14 NS_79 0 3.4176278542547367e+00
GC_14_80 ref NI_14 NS_80 0 -2.9874367407279729e+00
GC_14_81 ref NI_14 NS_81 0 -2.4082578632550424e+00
GC_14_82 ref NI_14 NS_82 0 -3.8969279497727205e-01
GC_14_83 ref NI_14 NS_83 0 -7.3433172038808053e-04
GC_14_84 ref NI_14 NS_84 0 -3.3357148806476403e-02
GC_14_85 ref NI_14 NS_85 0 -1.4590812830050029e-01
GC_14_86 ref NI_14 NS_86 0 -1.1707583644126694e-01
GC_14_87 ref NI_14 NS_87 0 1.7210328279657477e-01
GC_14_88 ref NI_14 NS_88 0 4.8423065552432559e-02
GC_14_89 ref NI_14 NS_89 0 6.4125299378282541e-05
GC_14_90 ref NI_14 NS_90 0 6.5718180858323309e-03
GC_14_91 ref NI_14 NS_91 0 -2.8739985500574883e-01
GC_14_92 ref NI_14 NS_92 0 1.1816055088401554e-01
GC_14_93 ref NI_14 NS_93 0 -2.2786798222828394e-01
GC_14_94 ref NI_14 NS_94 0 1.9774334144446415e-01
GC_14_95 ref NI_14 NS_95 0 -1.6761586224843307e-05
GC_14_96 ref NI_14 NS_96 0 3.5632529811844859e-03
GC_14_97 ref NI_14 NS_97 0 2.5863982039179556e-01
GC_14_98 ref NI_14 NS_98 0 -3.5746570514698367e-01
GC_14_99 ref NI_14 NS_99 0 2.0702516269569032e-01
GC_14_100 ref NI_14 NS_100 0 1.3536634972934544e-01
GC_14_101 ref NI_14 NS_101 0 6.5691735964127753e-06
GC_14_102 ref NI_14 NS_102 0 -1.5152734906064723e-02
GC_14_103 ref NI_14 NS_103 0 2.1706052862521689e-02
GC_14_104 ref NI_14 NS_104 0 -1.5975034471144681e-01
GC_14_105 ref NI_14 NS_105 0 8.7425753010924256e-01
GC_14_106 ref NI_14 NS_106 0 -2.3146556123865361e-01
GC_14_107 ref NI_14 NS_107 0 -8.4342176825321366e-05
GC_14_108 ref NI_14 NS_108 0 -2.2993451725540286e-02
GC_14_109 ref NI_14 NS_109 0 -1.6638111381127718e-01
GC_14_110 ref NI_14 NS_110 0 1.7261485758341348e+00
GC_14_111 ref NI_14 NS_111 0 2.0686440975104753e-01
GC_14_112 ref NI_14 NS_112 0 -4.3307008668515989e-01
GC_14_113 ref NI_14 NS_113 0 -3.1590113129483031e-04
GC_14_114 ref NI_14 NS_114 0 -1.8877861512664892e-02
GC_14_115 ref NI_14 NS_115 0 6.9629824945409857e-01
GC_14_116 ref NI_14 NS_116 0 -7.7384990225024786e-01
GC_14_117 ref NI_14 NS_117 0 7.2440876387289976e-01
GC_14_118 ref NI_14 NS_118 0 9.3778259997166491e-03
GC_14_119 ref NI_14 NS_119 0 -1.5141532595732681e-05
GC_14_120 ref NI_14 NS_120 0 -2.9664123708676472e-02
GC_14_121 ref NI_14 NS_121 0 6.0256874188984011e-02
GC_14_122 ref NI_14 NS_122 0 -2.9684261955295527e-01
GC_14_123 ref NI_14 NS_123 0 4.2604367039581476e-01
GC_14_124 ref NI_14 NS_124 0 2.8514571451558873e-03
GC_14_125 ref NI_14 NS_125 0 2.9136557599011069e-05
GC_14_126 ref NI_14 NS_126 0 -1.1526648242089836e-02
GC_14_127 ref NI_14 NS_127 0 -2.4262731151762001e-01
GC_14_128 ref NI_14 NS_128 0 3.8408285605866857e-02
GC_14_129 ref NI_14 NS_129 0 -1.1109040353707172e-01
GC_14_130 ref NI_14 NS_130 0 1.5842699138227906e-01
GC_14_131 ref NI_14 NS_131 0 1.4444345058302370e-05
GC_14_132 ref NI_14 NS_132 0 3.7773358578199693e-03
GC_14_133 ref NI_14 NS_133 0 -3.9297612839417878e-01
GC_14_134 ref NI_14 NS_134 0 2.1973243430769604e-01
GC_14_135 ref NI_14 NS_135 0 -3.0829746524793444e-01
GC_14_136 ref NI_14 NS_136 0 2.0077062666808410e-01
GC_14_137 ref NI_14 NS_137 0 -1.2951477876641296e-05
GC_14_138 ref NI_14 NS_138 0 9.8995908335789938e-03
GD_14_1 ref NI_14 NA_1 0 -3.9147079768899543e-03
GD_14_2 ref NI_14 NA_2 0 8.2197527233134858e-03
GD_14_3 ref NI_14 NA_3 0 -1.3144469923693810e-02
GD_14_4 ref NI_14 NA_4 0 6.1831551090805376e-02
GD_14_5 ref NI_14 NA_5 0 4.9247853077766954e-02
GD_14_6 ref NI_14 NA_6 0 4.3980678728572392e-02
GD_14_7 ref NI_14 NA_7 0 5.7372117714786008e-02
GD_14_8 ref NI_14 NA_8 0 9.4368391784269950e-02
GD_14_9 ref NI_14 NA_9 0 5.3328004809824636e-02
GD_14_10 ref NI_14 NA_10 0 9.1733756266360184e-02
GD_14_11 ref NI_14 NA_11 0 8.3278895375622414e-02
GD_14_12 ref NI_14 NA_12 0 6.1263258447193256e-02
GD_14_13 ref NI_14 NA_13 0 5.8990881670332861e-02
GD_14_14 ref NI_14 NA_14 0 5.4921320782720597e+00
GD_14_15 ref NI_14 NA_15 0 3.2470144123753285e-02
GD_14_16 ref NI_14 NA_16 0 6.8324623649557895e-02
GD_14_17 ref NI_14 NA_17 0 -2.0012935073297454e-02
GD_14_18 ref NI_14 NA_18 0 -2.1399040017651468e-03
GD_14_19 ref NI_14 NA_19 0 -3.6359382552236794e-02
GD_14_20 ref NI_14 NA_20 0 -9.5856362797663797e-02
GD_14_21 ref NI_14 NA_21 0 1.2472217345448643e-02
GD_14_22 ref NI_14 NA_22 0 5.9875615170944273e-02
GD_14_23 ref NI_14 NA_23 0 7.8936260148507992e-02
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 -3.3436908936808540e-01
GC_15_2 ref NI_15 NS_2 0 5.7224053900412686e-01
GC_15_3 ref NI_15 NS_3 0 -2.7538304646289084e-02
GC_15_4 ref NI_15 NS_4 0 -1.3947171278035487e-03
GC_15_5 ref NI_15 NS_5 0 1.8675662219981161e-04
GC_15_6 ref NI_15 NS_6 0 -4.3933879789017109e-03
GC_15_7 ref NI_15 NS_7 0 5.1748929723012560e-01
GC_15_8 ref NI_15 NS_8 0 4.3947033419098297e-01
GC_15_9 ref NI_15 NS_9 0 -2.4202803010149519e-02
GC_15_10 ref NI_15 NS_10 0 -4.1340726082484965e-02
GC_15_11 ref NI_15 NS_11 0 9.6884680274702227e-05
GC_15_12 ref NI_15 NS_12 0 -3.9496690921625704e-03
GC_15_13 ref NI_15 NS_13 0 2.1153502174430988e-01
GC_15_14 ref NI_15 NS_14 0 2.4653991342477127e-01
GC_15_15 ref NI_15 NS_15 0 5.2419569573733872e-02
GC_15_16 ref NI_15 NS_16 0 1.3106523328279289e-02
GC_15_17 ref NI_15 NS_17 0 1.5297246425596508e-04
GC_15_18 ref NI_15 NS_18 0 -4.5049870827544173e-03
GC_15_19 ref NI_15 NS_19 0 -2.2863678230234979e-01
GC_15_20 ref NI_15 NS_20 0 -1.8170650022754856e-01
GC_15_21 ref NI_15 NS_21 0 1.2604158476667970e-01
GC_15_22 ref NI_15 NS_22 0 1.1674626627979005e-01
GC_15_23 ref NI_15 NS_23 0 2.8293960757171089e-04
GC_15_24 ref NI_15 NS_24 0 -2.8326798740774821e-03
GC_15_25 ref NI_15 NS_25 0 -1.3292074354976216e-01
GC_15_26 ref NI_15 NS_26 0 -1.9446961111137356e-01
GC_15_27 ref NI_15 NS_27 0 7.9043370597459819e-02
GC_15_28 ref NI_15 NS_28 0 1.4182037225027977e-01
GC_15_29 ref NI_15 NS_29 0 3.0447817507958333e-04
GC_15_30 ref NI_15 NS_30 0 -3.9709352480705494e-03
GC_15_31 ref NI_15 NS_31 0 -9.1110655066839477e-02
GC_15_32 ref NI_15 NS_32 0 -2.1787113356445298e-01
GC_15_33 ref NI_15 NS_33 0 8.8319960068444142e-02
GC_15_34 ref NI_15 NS_34 0 1.4364299122259361e-01
GC_15_35 ref NI_15 NS_35 0 3.0201439784389289e-04
GC_15_36 ref NI_15 NS_36 0 -4.6175551781782904e-03
GC_15_37 ref NI_15 NS_37 0 -2.1312542763583348e-01
GC_15_38 ref NI_15 NS_38 0 -1.9345956252172469e-01
GC_15_39 ref NI_15 NS_39 0 1.6706717169040844e-01
GC_15_40 ref NI_15 NS_40 0 1.0273466770583756e-01
GC_15_41 ref NI_15 NS_41 0 2.7058068511535049e-04
GC_15_42 ref NI_15 NS_42 0 -4.1237558572928875e-03
GC_15_43 ref NI_15 NS_43 0 -1.5104433962354449e-01
GC_15_44 ref NI_15 NS_44 0 -4.6475701115529858e-02
GC_15_45 ref NI_15 NS_45 0 4.0307397545066420e-01
GC_15_46 ref NI_15 NS_46 0 -7.5145804296672572e-02
GC_15_47 ref NI_15 NS_47 0 4.9407836498795349e-06
GC_15_48 ref NI_15 NS_48 0 1.2382461792534848e-03
GC_15_49 ref NI_15 NS_49 0 -1.9830094508386031e-01
GC_15_50 ref NI_15 NS_50 0 2.1145685180011903e-01
GC_15_51 ref NI_15 NS_51 0 6.7633917198155069e-01
GC_15_52 ref NI_15 NS_52 0 -2.7564082808884854e-01
GC_15_53 ref NI_15 NS_53 0 -1.3471413242614069e-04
GC_15_54 ref NI_15 NS_54 0 -2.4668916520321155e-03
GC_15_55 ref NI_15 NS_55 0 5.0623523895274580e-01
GC_15_56 ref NI_15 NS_56 0 -6.3852440908509100e-01
GC_15_57 ref NI_15 NS_57 0 4.4335806795128846e-01
GC_15_58 ref NI_15 NS_58 0 6.7455395797929876e-02
GC_15_59 ref NI_15 NS_59 0 -1.1337560088679754e-05
GC_15_60 ref NI_15 NS_60 0 -8.8254017408221797e-03
GC_15_61 ref NI_15 NS_61 0 -2.6677057989966661e-02
GC_15_62 ref NI_15 NS_62 0 -1.6126982263799017e-01
GC_15_63 ref NI_15 NS_63 0 3.0789784479753590e-01
GC_15_64 ref NI_15 NS_64 0 -4.8254419436367085e-03
GC_15_65 ref NI_15 NS_65 0 6.5713944323560846e-06
GC_15_66 ref NI_15 NS_66 0 3.1549007916348705e-03
GC_15_67 ref NI_15 NS_67 0 -4.2670508265371065e-01
GC_15_68 ref NI_15 NS_68 0 1.4780520769763499e+00
GC_15_69 ref NI_15 NS_69 0 4.7660785115096964e-02
GC_15_70 ref NI_15 NS_70 0 -3.1332148148501371e-01
GC_15_71 ref NI_15 NS_71 0 -1.9482303855435182e-04
GC_15_72 ref NI_15 NS_72 0 -5.2966184134960242e-03
GC_15_73 ref NI_15 NS_73 0 -1.0358279853906661e-01
GC_15_74 ref NI_15 NS_74 0 4.7103335882806768e-02
GC_15_75 ref NI_15 NS_75 0 5.8098053430286578e-01
GC_15_76 ref NI_15 NS_76 0 -1.8360228413871099e-01
GC_15_77 ref NI_15 NS_77 0 -6.5561820215753042e-05
GC_15_78 ref NI_15 NS_78 0 -3.6218903976421310e-03
GC_15_79 ref NI_15 NS_79 0 -1.4590812830050012e-01
GC_15_80 ref NI_15 NS_80 0 -1.1707583644126766e-01
GC_15_81 ref NI_15 NS_81 0 1.7210328279657575e-01
GC_15_82 ref NI_15 NS_82 0 4.8423065552432032e-02
GC_15_83 ref NI_15 NS_83 0 6.4125299378247128e-05
GC_15_84 ref NI_15 NS_84 0 6.5718180858324871e-03
GC_15_85 ref NI_15 NS_85 0 1.9207116242294378e+00
GC_15_86 ref NI_15 NS_86 0 -9.5520895724781640e-01
GC_15_87 ref NI_15 NS_87 0 -3.1159917172584621e+00
GC_15_88 ref NI_15 NS_88 0 -6.0139492603818279e-01
GC_15_89 ref NI_15 NS_89 0 -1.0330130302701373e-03
GC_15_90 ref NI_15 NS_90 0 -2.2260672466947559e-02
GC_15_91 ref NI_15 NS_91 0 3.0988764586864548e-01
GC_15_92 ref NI_15 NS_92 0 -3.6442250994409159e-01
GC_15_93 ref NI_15 NS_93 0 2.0821544253409530e-01
GC_15_94 ref NI_15 NS_94 0 1.0117168549296465e-01
GC_15_95 ref NI_15 NS_95 0 6.1913922696282328e-06
GC_15_96 ref NI_15 NS_96 0 -2.2230375962647977e-03
GC_15_97 ref NI_15 NS_97 0 -1.6798440246009150e-01
GC_15_98 ref NI_15 NS_98 0 1.1155582484617259e-01
GC_15_99 ref NI_15 NS_99 0 -2.5548824922720187e-01
GC_15_100 ref NI_15 NS_100 0 1.9404251206173628e-01
GC_15_101 ref NI_15 NS_101 0 -3.2309219092486427e-05
GC_15_102 ref NI_15 NS_102 0 1.0417583710678616e-02
GC_15_103 ref NI_15 NS_103 0 -3.5640282740132867e-01
GC_15_104 ref NI_15 NS_104 0 2.1754962554738017e-01
GC_15_105 ref NI_15 NS_105 0 -3.0391280652595387e-01
GC_15_106 ref NI_15 NS_106 0 1.7610533268942435e-01
GC_15_107 ref NI_15 NS_107 0 -2.8459577030154551e-05
GC_15_108 ref NI_15 NS_108 0 1.8281715827484023e-02
GC_15_109 ref NI_15 NS_109 0 -1.8588845979545532e-01
GC_15_110 ref NI_15 NS_110 0 2.1578617369223636e-02
GC_15_111 ref NI_15 NS_111 0 -9.9654280085664668e-02
GC_15_112 ref NI_15 NS_112 0 1.3327886807597059e-01
GC_15_113 ref NI_15 NS_113 0 2.0826605467562074e-05
GC_15_114 ref NI_15 NS_114 0 1.2912482593682512e-02
GC_15_115 ref NI_15 NS_115 0 -5.2329878937935403e-01
GC_15_116 ref NI_15 NS_116 0 3.9264146361777741e-01
GC_15_117 ref NI_15 NS_117 0 -4.6607513422336633e-01
GC_15_118 ref NI_15 NS_118 0 2.0689133827523445e-01
GC_15_119 ref NI_15 NS_119 0 -5.7585647167560479e-05
GC_15_120 ref NI_15 NS_120 0 2.2454029988104775e-02
GC_15_121 ref NI_15 NS_121 0 -7.2805271974143840e-02
GC_15_122 ref NI_15 NS_122 0 -2.7490044931403446e-02
GC_15_123 ref NI_15 NS_123 0 -4.6414527969308297e-02
GC_15_124 ref NI_15 NS_124 0 1.2856968597094090e-01
GC_15_125 ref NI_15 NS_125 0 -1.8784242075571294e-05
GC_15_126 ref NI_15 NS_126 0 7.9860743924330818e-03
GC_15_127 ref NI_15 NS_127 0 2.6041104943662535e-01
GC_15_128 ref NI_15 NS_128 0 -3.4663167875722922e-01
GC_15_129 ref NI_15 NS_129 0 3.6026273992547636e-01
GC_15_130 ref NI_15 NS_130 0 2.7881831762390320e-02
GC_15_131 ref NI_15 NS_131 0 -3.0412441905828966e-05
GC_15_132 ref NI_15 NS_132 0 -4.1791634403216746e-03
GC_15_133 ref NI_15 NS_133 0 -1.2385374564135190e-01
GC_15_134 ref NI_15 NS_134 0 -2.8477168742947767e-01
GC_15_135 ref NI_15 NS_135 0 6.2737111277978941e-01
GC_15_136 ref NI_15 NS_136 0 -1.0368759403511700e-01
GC_15_137 ref NI_15 NS_137 0 -7.1591488894269333e-05
GC_15_138 ref NI_15 NS_138 0 -6.0544607871492384e-03
GD_15_1 ref NI_15 NA_1 0 -1.6194837170919071e-02
GD_15_2 ref NI_15 NA_2 0 8.9811373319797737e-03
GD_15_3 ref NI_15 NA_3 0 -3.1975802018750742e-02
GD_15_4 ref NI_15 NA_4 0 5.1079365684995916e-02
GD_15_5 ref NI_15 NA_5 0 3.8682758816773223e-02
GD_15_6 ref NI_15 NA_6 0 3.2045521856517281e-02
GD_15_7 ref NI_15 NA_7 0 4.2932899574206519e-02
GD_15_8 ref NI_15 NA_8 0 2.0949229486885046e-02
GD_15_9 ref NI_15 NA_9 0 8.5203651798890934e-03
GD_15_10 ref NI_15 NA_10 0 -5.7920332820261267e-02
GD_15_11 ref NI_15 NA_11 0 1.1471482098534566e-02
GD_15_12 ref NI_15 NA_12 0 5.2897067502761512e-02
GD_15_13 ref NI_15 NA_13 0 8.7763159712504358e-03
GD_15_14 ref NI_15 NA_14 0 3.2470144123753285e-02
GD_15_15 ref NI_15 NA_15 0 5.7705178127626429e+00
GD_15_16 ref NI_15 NA_16 0 -3.1591673647390163e-02
GD_15_17 ref NI_15 NA_17 0 3.9631647556036161e-02
GD_15_18 ref NI_15 NA_18 0 7.1937507293816622e-02
GD_15_19 ref NI_15 NA_19 0 4.4421645888906236e-02
GD_15_20 ref NI_15 NA_20 0 9.6384721044458235e-02
GD_15_21 ref NI_15 NA_21 0 2.3184197609070659e-02
GD_15_22 ref NI_15 NA_22 0 -3.3493207254521561e-02
GD_15_23 ref NI_15 NA_23 0 2.1009200369250351e-02
*
* Port 16
VI_16 a_16 NI_16 0
RI_16 NI_16 ref 1.0000000000000001e-01
GC_16_1 ref NI_16 NS_1 0 -2.7772567151330008e-01
GC_16_2 ref NI_16 NS_2 0 9.3666780560680243e-02
GC_16_3 ref NI_16 NS_3 0 -9.1968056291758637e-02
GC_16_4 ref NI_16 NS_4 0 6.8161400202476408e-02
GC_16_5 ref NI_16 NS_5 0 1.3781036217622210e-04
GC_16_6 ref NI_16 NS_6 0 2.9148739339563929e-02
GC_16_7 ref NI_16 NS_7 0 -1.8964646035127525e-01
GC_16_8 ref NI_16 NS_8 0 5.9003794652864136e-02
GC_16_9 ref NI_16 NS_9 0 -5.4986264783332114e-02
GC_16_10 ref NI_16 NS_10 0 7.2643079565227212e-02
GC_16_11 ref NI_16 NS_11 0 8.1829021548402730e-05
GC_16_12 ref NI_16 NS_12 0 2.1421892000837502e-02
GC_16_13 ref NI_16 NS_13 0 -2.1562992710139037e-01
GC_16_14 ref NI_16 NS_14 0 1.0496030308922026e-01
GC_16_15 ref NI_16 NS_15 0 -1.0662680335226114e-01
GC_16_16 ref NI_16 NS_16 0 6.0239913793773615e-02
GC_16_17 ref NI_16 NS_17 0 1.0744644750587333e-04
GC_16_18 ref NI_16 NS_18 0 3.2718876828625038e-02
GC_16_19 ref NI_16 NS_19 0 -3.5587924462861359e-01
GC_16_20 ref NI_16 NS_20 0 1.9675642280286912e-01
GC_16_21 ref NI_16 NS_21 0 -1.9393025882029419e-01
GC_16_22 ref NI_16 NS_22 0 3.4091771470156067e-02
GC_16_23 ref NI_16 NS_23 0 1.8565624146373751e-04
GC_16_24 ref NI_16 NS_24 0 5.1518038661064476e-02
GC_16_25 ref NI_16 NS_25 0 -3.8062053854487571e-01
GC_16_26 ref NI_16 NS_26 0 2.2173716621997291e-01
GC_16_27 ref NI_16 NS_27 0 -2.1036384952117174e-01
GC_16_28 ref NI_16 NS_28 0 3.1954566080591815e-02
GC_16_29 ref NI_16 NS_29 0 1.7337044194610032e-04
GC_16_30 ref NI_16 NS_30 0 5.3288076461370779e-02
GC_16_31 ref NI_16 NS_31 0 -3.8656366553534521e-01
GC_16_32 ref NI_16 NS_32 0 2.3012864019940985e-01
GC_16_33 ref NI_16 NS_33 0 -2.1976007334385778e-01
GC_16_34 ref NI_16 NS_34 0 3.5817723337171113e-02
GC_16_35 ref NI_16 NS_35 0 1.7601089549311666e-04
GC_16_36 ref NI_16 NS_36 0 5.2884596850450175e-02
GC_16_37 ref NI_16 NS_37 0 -3.5046952728176461e-01
GC_16_38 ref NI_16 NS_38 0 1.9749173551786922e-01
GC_16_39 ref NI_16 NS_39 0 -2.0235676699881111e-01
GC_16_40 ref NI_16 NS_40 0 4.5697239526181585e-02
GC_16_41 ref NI_16 NS_41 0 1.6777242229720684e-04
GC_16_42 ref NI_16 NS_42 0 4.8773986921836085e-02
GC_16_43 ref NI_16 NS_43 0 -1.3919733017119279e-01
GC_16_44 ref NI_16 NS_44 0 -3.2795303640729100e-02
GC_16_45 ref NI_16 NS_45 0 -7.4231506874156659e-03
GC_16_46 ref NI_16 NS_46 0 1.2261295562633574e-01
GC_16_47 ref NI_16 NS_47 0 2.8760068485118878e-06
GC_16_48 ref NI_16 NS_48 0 3.0211701703326895e-03
GC_16_49 ref NI_16 NS_49 0 7.8855798121428192e-02
GC_16_50 ref NI_16 NS_50 0 -1.9647156154114365e-01
GC_16_51 ref NI_16 NS_51 0 1.1677747582203063e-01
GC_16_52 ref NI_16 NS_52 0 9.9103749504958719e-02
GC_16_53 ref NI_16 NS_53 0 -2.9669301427433097e-06
GC_16_54 ref NI_16 NS_54 0 2.2822043202755048e-03
GC_16_55 ref NI_16 NS_55 0 7.0212573381674315e-01
GC_16_56 ref NI_16 NS_56 0 1.9039606566740161e+00
GC_16_57 ref NI_16 NS_57 0 1.8461794843185265e-02
GC_16_58 ref NI_16 NS_58 0 -3.6263835393322330e-01
GC_16_59 ref NI_16 NS_59 0 -7.4882273109801842e-05
GC_16_60 ref NI_16 NS_60 0 -5.0439678904902842e-02
GC_16_61 ref NI_16 NS_61 0 -1.8200284567999112e-01
GC_16_62 ref NI_16 NS_62 0 3.7353816193673117e-02
GC_16_63 ref NI_16 NS_63 0 9.1297947673340193e-02
GC_16_64 ref NI_16 NS_64 0 7.7287165718881640e-02
GC_16_65 ref NI_16 NS_65 0 -3.9889967937493649e-05
GC_16_66 ref NI_16 NS_66 0 -6.3299975252645770e-03
GC_16_67 ref NI_16 NS_67 0 1.0923130578863820e-01
GC_16_68 ref NI_16 NS_68 0 -4.5043629649158012e-01
GC_16_69 ref NI_16 NS_69 0 7.4458635727216571e-01
GC_16_70 ref NI_16 NS_70 0 -1.0523698541311806e-01
GC_16_71 ref NI_16 NS_71 0 -7.4988890402586739e-05
GC_16_72 ref NI_16 NS_72 0 -1.6001856963815751e-02
GC_16_73 ref NI_16 NS_73 0 2.5967535163249615e-02
GC_16_74 ref NI_16 NS_74 0 -7.9682308695436715e-02
GC_16_75 ref NI_16 NS_75 0 3.5859786344816885e-01
GC_16_76 ref NI_16 NS_76 0 -3.0927056246307646e-02
GC_16_77 ref NI_16 NS_77 0 -9.7169387597609571e-05
GC_16_78 ref NI_16 NS_78 0 -7.3164082274190159e-03
GC_16_79 ref NI_16 NS_79 0 -2.8739985500574883e-01
GC_16_80 ref NI_16 NS_80 0 1.1816055088401557e-01
GC_16_81 ref NI_16 NS_81 0 -2.2786798222828394e-01
GC_16_82 ref NI_16 NS_82 0 1.9774334144446415e-01
GC_16_83 ref NI_16 NS_83 0 -1.6761586224843257e-05
GC_16_84 ref NI_16 NS_84 0 3.5632529811844850e-03
GC_16_85 ref NI_16 NS_85 0 3.0988764586864542e-01
GC_16_86 ref NI_16 NS_86 0 -3.6442250994409126e-01
GC_16_87 ref NI_16 NS_87 0 2.0821544253409494e-01
GC_16_88 ref NI_16 NS_88 0 1.0117168549296489e-01
GC_16_89 ref NI_16 NS_89 0 6.1913922696440308e-06
GC_16_90 ref NI_16 NS_90 0 -2.2230375962648684e-03
GC_16_91 ref NI_16 NS_91 0 3.4344307365174909e+00
GC_16_92 ref NI_16 NS_92 0 -6.1372062943881325e+00
GC_16_93 ref NI_16 NS_93 0 -5.9601517870579557e-01
GC_16_94 ref NI_16 NS_94 0 -2.9980895679236452e-01
GC_16_95 ref NI_16 NS_95 0 -4.2987414168357379e-04
GC_16_96 ref NI_16 NS_96 0 -6.1292077749180128e-02
GC_16_97 ref NI_16 NS_97 0 -3.3578587165709212e-01
GC_16_98 ref NI_16 NS_98 0 1.1649908237668976e+00
GC_16_99 ref NI_16 NS_99 0 -9.0374923834524917e-02
GC_16_100 ref NI_16 NS_100 0 -9.6562502496179606e-02
GC_16_101 ref NI_16 NS_101 0 -2.4749306244247175e-06
GC_16_102 ref NI_16 NS_102 0 -3.0434556586895777e-02
GC_16_103 ref NI_16 NS_103 0 -3.8422770206121654e-01
GC_16_104 ref NI_16 NS_104 0 1.0432105044483224e-01
GC_16_105 ref NI_16 NS_105 0 -7.2862429933351472e-02
GC_16_106 ref NI_16 NS_106 0 1.6398895079247069e-01
GC_16_107 ref NI_16 NS_107 0 -5.0051005393570856e-05
GC_16_108 ref NI_16 NS_108 0 -1.1587999042582080e-02
GC_16_109 ref NI_16 NS_109 0 -3.4363736674618911e-01
GC_16_110 ref NI_16 NS_110 0 1.2076694134613701e-01
GC_16_111 ref NI_16 NS_111 0 -1.9000902835299124e-01
GC_16_112 ref NI_16 NS_112 0 1.9980868995502163e-01
GC_16_113 ref NI_16 NS_113 0 -3.6876562349053714e-05
GC_16_114 ref NI_16 NS_114 0 -4.3340853337513361e-03
GC_16_115 ref NI_16 NS_115 0 -4.1225381760550761e-01
GC_16_116 ref NI_16 NS_116 0 1.2063265592546142e-01
GC_16_117 ref NI_16 NS_117 0 4.1929241239280768e-02
GC_16_118 ref NI_16 NS_118 0 1.1653611772295057e-01
GC_16_119 ref NI_16 NS_119 0 -6.6672190824270747e-06
GC_16_120 ref NI_16 NS_120 0 -1.8395761375183017e-02
GC_16_121 ref NI_16 NS_121 0 -3.5316404580647831e-01
GC_16_122 ref NI_16 NS_122 0 4.6753817906556855e-01
GC_16_123 ref NI_16 NS_123 0 1.2110279516959054e-01
GC_16_124 ref NI_16 NS_124 0 -1.9850966136662748e-02
GC_16_125 ref NI_16 NS_125 0 -4.5993393128422914e-05
GC_16_126 ref NI_16 NS_126 0 -2.0954864393869874e-02
GC_16_127 ref NI_16 NS_127 0 2.8900455270160225e-01
GC_16_128 ref NI_16 NS_128 0 1.6446067979489301e+00
GC_16_129 ref NI_16 NS_129 0 -2.0777603092494881e-01
GC_16_130 ref NI_16 NS_130 0 -1.9519515789896280e-01
GC_16_131 ref NI_16 NS_131 0 -3.5414171646278933e-05
GC_16_132 ref NI_16 NS_132 0 -3.4346932709967685e-02
GC_16_133 ref NI_16 NS_133 0 -2.5717941745815071e-01
GC_16_134 ref NI_16 NS_134 0 4.7511224734838786e-01
GC_16_135 ref NI_16 NS_135 0 7.6278385160047457e-01
GC_16_136 ref NI_16 NS_136 0 -3.1260530311057749e-01
GC_16_137 ref NI_16 NS_137 0 -1.0144554145712579e-04
GC_16_138 ref NI_16 NS_138 0 -3.5024203336751901e-02
GD_16_1 ref NI_16 NA_1 0 5.6101233481845744e-02
GD_16_2 ref NI_16 NA_2 0 5.5354241408114652e-02
GD_16_3 ref NI_16 NA_3 0 5.0065962698659996e-02
GD_16_4 ref NI_16 NA_4 0 7.2720612964282047e-02
GD_16_5 ref NI_16 NA_5 0 7.6237273200230077e-02
GD_16_6 ref NI_16 NA_6 0 7.6780134919381349e-02
GD_16_7 ref NI_16 NA_7 0 7.0609166111625918e-02
GD_16_8 ref NI_16 NA_8 0 4.2468995092140492e-02
GD_16_9 ref NI_16 NA_9 0 4.3126482387935089e-03
GD_16_10 ref NI_16 NA_10 0 -1.3993348861453156e-01
GD_16_11 ref NI_16 NA_11 0 4.8780914861192834e-02
GD_16_12 ref NI_16 NA_12 0 -3.2001676018982199e-03
GD_16_13 ref NI_16 NA_13 0 5.5134296584197972e-03
GD_16_14 ref NI_16 NA_14 0 6.8324623649557895e-02
GD_16_15 ref NI_16 NA_15 0 -3.1591673647390163e-02
GD_16_16 ref NI_16 NA_16 0 5.4569252785663789e+00
GD_16_17 ref NI_16 NA_17 0 6.8109888119208734e-02
GD_16_18 ref NI_16 NA_18 0 9.0047242816459996e-02
GD_16_19 ref NI_16 NA_19 0 8.0723783494809062e-02
GD_16_20 ref NI_16 NA_20 0 9.8702953905297611e-02
GD_16_21 ref NI_16 NA_21 0 7.1335662506357103e-02
GD_16_22 ref NI_16 NA_22 0 -4.4864711425156731e-02
GD_16_23 ref NI_16 NA_23 0 1.1623791034970896e-02
*
* Port 17
VI_17 a_17 NI_17 0
RI_17 NI_17 ref 1.0000000000000001e-01
GC_17_1 ref NI_17 NS_1 0 -2.6619148510353924e-01
GC_17_2 ref NI_17 NS_2 0 1.0246832124159738e-01
GC_17_3 ref NI_17 NS_3 0 -1.1903996031411172e-01
GC_17_4 ref NI_17 NS_4 0 6.6074358354273485e-02
GC_17_5 ref NI_17 NS_5 0 1.0722003178174667e-04
GC_17_6 ref NI_17 NS_6 0 3.4364905819731228e-02
GC_17_7 ref NI_17 NS_7 0 -1.8314747295574738e-01
GC_17_8 ref NI_17 NS_8 0 6.3046576722835451e-02
GC_17_9 ref NI_17 NS_9 0 -8.3580106797428624e-02
GC_17_10 ref NI_17 NS_10 0 7.7757620374349259e-02
GC_17_11 ref NI_17 NS_11 0 4.6230270672332105e-05
GC_17_12 ref NI_17 NS_12 0 2.5283714561768710e-02
GC_17_13 ref NI_17 NS_13 0 -2.3506929451371103e-01
GC_17_14 ref NI_17 NS_14 0 1.2226135309655135e-01
GC_17_15 ref NI_17 NS_15 0 -1.3309901619685899e-01
GC_17_16 ref NI_17 NS_16 0 5.5407871210688943e-02
GC_17_17 ref NI_17 NS_17 0 7.9348079365438063e-05
GC_17_18 ref NI_17 NS_18 0 3.8788961506625738e-02
GC_17_19 ref NI_17 NS_19 0 -3.4493978451190604e-01
GC_17_20 ref NI_17 NS_20 0 1.9834375478667604e-01
GC_17_21 ref NI_17 NS_21 0 -1.7424487172848280e-01
GC_17_22 ref NI_17 NS_22 0 2.6441670930470304e-03
GC_17_23 ref NI_17 NS_23 0 1.6136102986441398e-04
GC_17_24 ref NI_17 NS_24 0 5.9593329956634654e-02
GC_17_25 ref NI_17 NS_25 0 -3.6798346530792053e-01
GC_17_26 ref NI_17 NS_26 0 2.1739511910947310e-01
GC_17_27 ref NI_17 NS_27 0 -1.8228374031304462e-01
GC_17_28 ref NI_17 NS_28 0 -2.8447333732252934e-03
GC_17_29 ref NI_17 NS_29 0 1.4836768178581942e-04
GC_17_30 ref NI_17 NS_30 0 6.1619848615815681e-02
GC_17_31 ref NI_17 NS_31 0 -3.7736695775930573e-01
GC_17_32 ref NI_17 NS_32 0 2.2750983412737150e-01
GC_17_33 ref NI_17 NS_33 0 -1.9226420948126000e-01
GC_17_34 ref NI_17 NS_34 0 8.1632631563091922e-04
GC_17_35 ref NI_17 NS_35 0 1.5043165448720613e-04
GC_17_36 ref NI_17 NS_36 0 6.1284306382734778e-02
GC_17_37 ref NI_17 NS_37 0 -3.4921790646915163e-01
GC_17_38 ref NI_17 NS_38 0 2.0798427875033684e-01
GC_17_39 ref NI_17 NS_39 0 -1.9208694388010705e-01
GC_17_40 ref NI_17 NS_40 0 1.7132143892264032e-02
GC_17_41 ref NI_17 NS_41 0 1.4173063833987522e-04
GC_17_42 ref NI_17 NS_42 0 5.6802428934267159e-02
GC_17_43 ref NI_17 NS_43 0 1.8079485830685169e-02
GC_17_44 ref NI_17 NS_44 0 -1.7166126980065766e-01
GC_17_45 ref NI_17 NS_45 0 1.1754505882275164e-01
GC_17_46 ref NI_17 NS_46 0 1.0501035605305070e-01
GC_17_47 ref NI_17 NS_47 0 8.6742743997222354e-06
GC_17_48 ref NI_17 NS_48 0 -1.8668946858084079e-03
GC_17_49 ref NI_17 NS_49 0 -8.6052475791695018e-02
GC_17_50 ref NI_17 NS_50 0 -6.1594208874960190e-03
GC_17_51 ref NI_17 NS_51 0 -1.1033197128164167e-01
GC_17_52 ref NI_17 NS_52 0 1.5362852826999074e-01
GC_17_53 ref NI_17 NS_53 0 -2.1145523965163363e-05
GC_17_54 ref NI_17 NS_54 0 8.4962743962903337e-03
GC_17_55 ref NI_17 NS_55 0 -1.8013014594677715e-01
GC_17_56 ref NI_17 NS_56 0 -2.4946280591562672e-01
GC_17_57 ref NI_17 NS_57 0 4.8469232020415026e-01
GC_17_58 ref NI_17 NS_58 0 8.9646881887331092e-03
GC_17_59 ref NI_17 NS_59 0 7.0688754610638722e-06
GC_17_60 ref NI_17 NS_60 0 -2.5691032010937330e-02
GC_17_61 ref NI_17 NS_61 0 -5.7516174322772722e-02
GC_17_62 ref NI_17 NS_62 0 -7.5134320518223621e-02
GC_17_63 ref NI_17 NS_63 0 3.5735353448129931e-01
GC_17_64 ref NI_17 NS_64 0 -8.7028254518226947e-03
GC_17_65 ref NI_17 NS_65 0 -8.0079807224554903e-05
GC_17_66 ref NI_17 NS_66 0 -1.3674227203433207e-02
GC_17_67 ref NI_17 NS_67 0 4.4084366815278692e-02
GC_17_68 ref NI_17 NS_68 0 -1.8100064022579687e-01
GC_17_69 ref NI_17 NS_69 0 3.7713212141727799e-02
GC_17_70 ref NI_17 NS_70 0 1.5193380642671084e-01
GC_17_71 ref NI_17 NS_71 0 -3.2563652457072460e-05
GC_17_72 ref NI_17 NS_72 0 -3.4802813476092357e-03
GC_17_73 ref NI_17 NS_73 0 -8.9324474887964272e-02
GC_17_74 ref NI_17 NS_74 0 -8.7932400732237792e-02
GC_17_75 ref NI_17 NS_75 0 1.1872763285520950e-01
GC_17_76 ref NI_17 NS_76 0 8.6419540359798111e-02
GC_17_77 ref NI_17 NS_77 0 -6.5335870641944048e-05
GC_17_78 ref NI_17 NS_78 0 -2.0272621564858292e-03
GC_17_79 ref NI_17 NS_79 0 2.5863982039179539e-01
GC_17_80 ref NI_17 NS_80 0 -3.5746570514698284e-01
GC_17_81 ref NI_17 NS_81 0 2.0702516269568932e-01
GC_17_82 ref NI_17 NS_82 0 1.3536634972934602e-01
GC_17_83 ref NI_17 NS_83 0 6.5691735964521285e-06
GC_17_84 ref NI_17 NS_84 0 -1.5152734906064894e-02
GC_17_85 ref NI_17 NS_85 0 -1.6798440246009130e-01
GC_17_86 ref NI_17 NS_86 0 1.1155582484617173e-01
GC_17_87 ref NI_17 NS_87 0 -2.5548824922720076e-01
GC_17_88 ref NI_17 NS_88 0 1.9404251206173562e-01
GC_17_89 ref NI_17 NS_89 0 -3.2309219092530988e-05
GC_17_90 ref NI_17 NS_90 0 1.0417583710678814e-02
GC_17_91 ref NI_17 NS_91 0 -3.3578587165709195e-01
GC_17_92 ref NI_17 NS_92 0 1.1649908237668967e+00
GC_17_93 ref NI_17 NS_93 0 -9.0374923834523724e-02
GC_17_94 ref NI_17 NS_94 0 -9.6562502496180300e-02
GC_17_95 ref NI_17 NS_95 0 -2.4749306244706385e-06
GC_17_96 ref NI_17 NS_96 0 -3.0434556586895579e-02
GC_17_97 ref NI_17 NS_97 0 3.1761977858557588e+00
GC_17_98 ref NI_17 NS_98 0 -2.2382461416105790e+00
GC_17_99 ref NI_17 NS_99 0 -2.7560312872211576e+00
GC_17_100 ref NI_17 NS_100 0 -3.4390865267528875e-01
GC_17_101 ref NI_17 NS_101 0 -5.1072480814998589e-04
GC_17_102 ref NI_17 NS_102 0 -6.5193800346452169e-02
GC_17_103 ref NI_17 NS_103 0 1.6102834440234570e-01
GC_17_104 ref NI_17 NS_104 0 -2.3396190470285094e-01
GC_17_105 ref NI_17 NS_105 0 7.5527041539403372e-01
GC_17_106 ref NI_17 NS_106 0 -1.0337939119876596e-01
GC_17_107 ref NI_17 NS_107 0 3.9051158388792631e-05
GC_17_108 ref NI_17 NS_108 0 -4.4540635387486198e-02
GC_17_109 ref NI_17 NS_109 0 3.2267997711510665e-01
GC_17_110 ref NI_17 NS_110 0 -5.0091662771028145e-01
GC_17_111 ref NI_17 NS_111 0 5.4706738323290638e-01
GC_17_112 ref NI_17 NS_112 0 4.1654487814220667e-02
GC_17_113 ref NI_17 NS_113 0 4.4688508909360043e-05
GC_17_114 ref NI_17 NS_114 0 -3.2135118372698709e-02
GC_17_115 ref NI_17 NS_115 0 -1.3104137058356025e-01
GC_17_116 ref NI_17 NS_116 0 3.4827502849367065e-01
GC_17_117 ref NI_17 NS_117 0 8.3050932499207442e-01
GC_17_118 ref NI_17 NS_118 0 -2.7782594123358550e-01
GC_17_119 ref NI_17 NS_119 0 6.0881093156416102e-05
GC_17_120 ref NI_17 NS_120 0 -5.3362892020313149e-02
GC_17_121 ref NI_17 NS_121 0 -2.3244300832953685e-01
GC_17_122 ref NI_17 NS_122 0 1.4375868897502806e+00
GC_17_123 ref NI_17 NS_123 0 1.3373137313639108e-01
GC_17_124 ref NI_17 NS_124 0 -2.7169555438509363e-01
GC_17_125 ref NI_17 NS_125 0 -2.0858672081099303e-04
GC_17_126 ref NI_17 NS_126 0 -3.1905247138812036e-02
GC_17_127 ref NI_17 NS_127 0 -5.4812047525093233e-01
GC_17_128 ref NI_17 NS_128 0 2.8133448847709275e-01
GC_17_129 ref NI_17 NS_129 0 3.3209454220524365e-01
GC_17_130 ref NI_17 NS_130 0 -6.9497245510185254e-02
GC_17_131 ref NI_17 NS_131 0 -4.1530996215892100e-06
GC_17_132 ref NI_17 NS_132 0 -1.9339148253073323e-02
GC_17_133 ref NI_17 NS_133 0 4.3659191087772956e-02
GC_17_134 ref NI_17 NS_134 0 -3.7656378806415530e-01
GC_17_135 ref NI_17 NS_135 0 3.5660367078989935e-01
GC_17_136 ref NI_17 NS_136 0 8.1494674290742031e-02
GC_17_137 ref NI_17 NS_137 0 -2.3253479335263060e-05
GC_17_138 ref NI_17 NS_138 0 -1.7799993547595171e-02
GD_17_1 ref NI_17 NA_1 0 5.4607427242651378e-02
GD_17_2 ref NI_17 NA_2 0 4.9703400970007638e-02
GD_17_3 ref NI_17 NA_3 0 5.0064768935266943e-02
GD_17_4 ref NI_17 NA_4 0 6.9441386399500579e-02
GD_17_5 ref NI_17 NA_5 0 7.2763292841631425e-02
GD_17_6 ref NI_17 NA_6 0 7.3877919356006946e-02
GD_17_7 ref NI_17 NA_7 0 6.8989174325820579e-02
GD_17_8 ref NI_17 NA_8 0 1.4552988870465638e-02
GD_17_9 ref NI_17 NA_9 0 2.8251689686371467e-02
GD_17_10 ref NI_17 NA_10 0 4.8062787418304741e-02
GD_17_11 ref NI_17 NA_11 0 1.2051864146514706e-02
GD_17_12 ref NI_17 NA_12 0 1.2869054530862189e-02
GD_17_13 ref NI_17 NA_13 0 2.9919069074477236e-02
GD_17_14 ref NI_17 NA_14 0 -2.0012935073297454e-02
GD_17_15 ref NI_17 NA_15 0 3.9631647556036161e-02
GD_17_16 ref NI_17 NA_16 0 6.8109888119208734e-02
GD_17_17 ref NI_17 NA_17 0 5.5421626943121893e+00
GD_17_18 ref NI_17 NA_18 0 -1.4515018347775585e-02
GD_17_19 ref NI_17 NA_19 0 -2.9978171349808326e-02
GD_17_20 ref NI_17 NA_20 0 2.3816776663999357e-02
GD_17_21 ref NI_17 NA_21 0 -2.2919267940688930e-02
GD_17_22 ref NI_17 NA_22 0 1.0798811009402147e-01
GD_17_23 ref NI_17 NA_23 0 1.4727734428656622e-02
*
* Port 18
VI_18 a_18 NI_18 0
RI_18 NI_18 ref 1.0000000000000001e-01
GC_18_1 ref NI_18 NS_1 0 -2.9043978085293987e-01
GC_18_2 ref NI_18 NS_2 0 7.1526999368960148e-02
GC_18_3 ref NI_18 NS_3 0 -2.9495046982203638e-02
GC_18_4 ref NI_18 NS_4 0 3.9257418421342546e-02
GC_18_5 ref NI_18 NS_5 0 9.8764038503584861e-05
GC_18_6 ref NI_18 NS_6 0 3.0845570270617004e-02
GC_18_7 ref NI_18 NS_7 0 -1.6622026435627804e-01
GC_18_8 ref NI_18 NS_8 0 5.1949753838227378e-02
GC_18_9 ref NI_18 NS_9 0 6.5451554912472265e-03
GC_18_10 ref NI_18 NS_10 0 3.7912204960294439e-02
GC_18_11 ref NI_18 NS_11 0 2.5984750124115012e-05
GC_18_12 ref NI_18 NS_12 0 2.2801167081738100e-02
GC_18_13 ref NI_18 NS_13 0 -2.2720065864809705e-01
GC_18_14 ref NI_18 NS_14 0 7.8878098634121666e-02
GC_18_15 ref NI_18 NS_15 0 -6.2663713650364869e-02
GC_18_16 ref NI_18 NS_16 0 4.1913873079580145e-02
GC_18_17 ref NI_18 NS_17 0 8.0736062579839539e-05
GC_18_18 ref NI_18 NS_18 0 3.4724601324343254e-02
GC_18_19 ref NI_18 NS_19 0 -2.6045195230161816e-01
GC_18_20 ref NI_18 NS_20 0 1.1830830363324084e-01
GC_18_21 ref NI_18 NS_21 0 -1.3357062161357566e-01
GC_18_22 ref NI_18 NS_22 0 1.8500128362766016e-02
GC_18_23 ref NI_18 NS_23 0 1.7443302262915857e-04
GC_18_24 ref NI_18 NS_24 0 5.2498957343114452e-02
GC_18_25 ref NI_18 NS_25 0 -2.8091089677298886e-01
GC_18_26 ref NI_18 NS_26 0 1.4509384032035194e-01
GC_18_27 ref NI_18 NS_27 0 -1.5377909418025384e-01
GC_18_28 ref NI_18 NS_28 0 1.7969586271657522e-02
GC_18_29 ref NI_18 NS_29 0 1.6327812402300702e-04
GC_18_30 ref NI_18 NS_30 0 5.4120437710819466e-02
GC_18_31 ref NI_18 NS_31 0 -2.8493668196437327e-01
GC_18_32 ref NI_18 NS_32 0 1.5277907794270404e-01
GC_18_33 ref NI_18 NS_33 0 -1.6277437204274439e-01
GC_18_34 ref NI_18 NS_34 0 2.1660309794178764e-02
GC_18_35 ref NI_18 NS_35 0 1.6516213093610641e-04
GC_18_36 ref NI_18 NS_36 0 5.3753933250263654e-02
GC_18_37 ref NI_18 NS_37 0 -2.5774914056830839e-01
GC_18_38 ref NI_18 NS_38 0 1.1889565897542728e-01
GC_18_39 ref NI_18 NS_39 0 -1.4105746807419625e-01
GC_18_40 ref NI_18 NS_40 0 2.9268729199141981e-02
GC_18_41 ref NI_18 NS_41 0 1.5617544729661927e-04
GC_18_42 ref NI_18 NS_42 0 4.9958551980894925e-02
GC_18_43 ref NI_18 NS_43 0 -8.6005871394079794e-02
GC_18_44 ref NI_18 NS_44 0 -1.9241611552332155e-01
GC_18_45 ref NI_18 NS_45 0 3.7612800255753093e-01
GC_18_46 ref NI_18 NS_46 0 -1.3945646509510351e-02
GC_18_47 ref NI_18 NS_47 0 2.0360057921737940e-05
GC_18_48 ref NI_18 NS_48 0 -4.5398826930995832e-03
GC_18_49 ref NI_18 NS_49 0 -1.4241670709803006e-01
GC_18_50 ref NI_18 NS_50 0 -2.1027303837174258e-02
GC_18_51 ref NI_18 NS_51 0 -6.3993702181396078e-02
GC_18_52 ref NI_18 NS_52 0 1.2763919731780990e-01
GC_18_53 ref NI_18 NS_53 0 -6.0291174223291234e-06
GC_18_54 ref NI_18 NS_54 0 1.1396651742958374e-02
GC_18_55 ref NI_18 NS_55 0 -5.3517312226894465e-01
GC_18_56 ref NI_18 NS_56 0 3.2985439530952654e-01
GC_18_57 ref NI_18 NS_57 0 -4.3707504602666603e-01
GC_18_58 ref NI_18 NS_58 0 2.6833670200929916e-01
GC_18_59 ref NI_18 NS_59 0 -8.4491283285300519e-05
GC_18_60 ref NI_18 NS_60 0 -4.6966619369886840e-04
GC_18_61 ref NI_18 NS_61 0 -3.8777101351318871e-02
GC_18_62 ref NI_18 NS_62 0 -4.3964456053779390e-02
GC_18_63 ref NI_18 NS_63 0 4.1100502918026499e-01
GC_18_64 ref NI_18 NS_64 0 -4.4932076538186407e-02
GC_18_65 ref NI_18 NS_65 0 1.3604033864933571e-05
GC_18_66 ref NI_18 NS_66 0 -1.7351562464304488e-02
GC_18_67 ref NI_18 NS_67 0 -4.2859450369213686e-01
GC_18_68 ref NI_18 NS_68 0 2.7104154341670061e-01
GC_18_69 ref NI_18 NS_69 0 -3.6480311643255731e-01
GC_18_70 ref NI_18 NS_70 0 2.1204114493369983e-01
GC_18_71 ref NI_18 NS_71 0 -4.2793258302768106e-05
GC_18_72 ref NI_18 NS_72 0 1.1661720363901843e-02
GC_18_73 ref NI_18 NS_73 0 -2.1127639234437046e-01
GC_18_74 ref NI_18 NS_74 0 1.7301796590897780e-02
GC_18_75 ref NI_18 NS_75 0 -8.4323950692737473e-02
GC_18_76 ref NI_18 NS_76 0 1.4713749286885874e-01
GC_18_77 ref NI_18 NS_77 0 -3.8654432685867773e-05
GC_18_78 ref NI_18 NS_78 0 4.7608943237261716e-03
GC_18_79 ref NI_18 NS_79 0 2.1706052862521433e-02
GC_18_80 ref NI_18 NS_80 0 -1.5975034471144575e-01
GC_18_81 ref NI_18 NS_81 0 8.7425753010924112e-01
GC_18_82 ref NI_18 NS_82 0 -2.3146556123865281e-01
GC_18_83 ref NI_18 NS_83 0 -8.4342176825267604e-05
GC_18_84 ref NI_18 NS_84 0 -2.2993451725540525e-02
GC_18_85 ref NI_18 NS_85 0 -3.5640282740132889e-01
GC_18_86 ref NI_18 NS_86 0 2.1754962554738089e-01
GC_18_87 ref NI_18 NS_87 0 -3.0391280652595482e-01
GC_18_88 ref NI_18 NS_88 0 1.7610533268942488e-01
GC_18_89 ref NI_18 NS_89 0 -2.8459577030117837e-05
GC_18_90 ref NI_18 NS_90 0 1.8281715827483860e-02
GC_18_91 ref NI_18 NS_91 0 -3.8422770206121620e-01
GC_18_92 ref NI_18 NS_92 0 1.0432105044483113e-01
GC_18_93 ref NI_18 NS_93 0 -7.2862429933349959e-02
GC_18_94 ref NI_18 NS_94 0 1.6398895079246983e-01
GC_18_95 ref NI_18 NS_95 0 -5.0051005393628590e-05
GC_18_96 ref NI_18 NS_96 0 -1.1587999042581827e-02
GC_18_97 ref NI_18 NS_97 0 1.6102834440234592e-01
GC_18_98 ref NI_18 NS_98 0 -2.3396190470285183e-01
GC_18_99 ref NI_18 NS_99 0 7.5527041539403483e-01
GC_18_100 ref NI_18 NS_100 0 -1.0337939119876664e-01
GC_18_101 ref NI_18 NS_101 0 3.9051158388748050e-05
GC_18_102 ref NI_18 NS_102 0 -4.4540635387485997e-02
GC_18_103 ref NI_18 NS_103 0 4.1250383409358244e+00
GC_18_104 ref NI_18 NS_104 0 -4.1646596621486971e+00
GC_18_105 ref NI_18 NS_105 0 -1.5943978173761026e+00
GC_18_106 ref NI_18 NS_106 0 -3.6099228889933643e-01
GC_18_107 ref NI_18 NS_107 0 -3.1766368396445466e-04
GC_18_108 ref NI_18 NS_108 0 -8.8872178231910987e-02
GC_18_109 ref NI_18 NS_109 0 1.2893408671565104e-01
GC_18_110 ref NI_18 NS_110 0 1.6327656242084734e+00
GC_18_111 ref NI_18 NS_111 0 2.5553830986991583e-01
GC_18_112 ref NI_18 NS_112 0 -3.7971905951209994e-01
GC_18_113 ref NI_18 NS_113 0 -6.5250427585088932e-05
GC_18_114 ref NI_18 NS_114 0 -4.7188784419228698e-02
GC_18_115 ref NI_18 NS_115 0 4.5879277593446854e-01
GC_18_116 ref NI_18 NS_116 0 9.0031595943264020e-01
GC_18_117 ref NI_18 NS_117 0 9.9382347496981926e-01
GC_18_118 ref NI_18 NS_118 0 -4.9144514771141923e-01
GC_18_119 ref NI_18 NS_119 0 -1.5705791242039512e-04
GC_18_120 ref NI_18 NS_120 0 -6.9453529584785942e-02
GC_18_121 ref NI_18 NS_121 0 -3.5194705590202408e-02
GC_18_122 ref NI_18 NS_122 0 2.1438310677756844e-01
GC_18_123 ref NI_18 NS_123 0 4.6587432137735557e-01
GC_18_124 ref NI_18 NS_124 0 -1.0267490148473138e-01
GC_18_125 ref NI_18 NS_125 0 7.2916997669378281e-05
GC_18_126 ref NI_18 NS_126 0 -3.6197317087555671e-02
GC_18_127 ref NI_18 NS_127 0 -3.2582817418535320e-01
GC_18_128 ref NI_18 NS_128 0 5.6630155595334845e-02
GC_18_129 ref NI_18 NS_129 0 -8.9828480756463755e-02
GC_18_130 ref NI_18 NS_130 0 1.7096348980669943e-01
GC_18_131 ref NI_18 NS_131 0 -2.8542113703761232e-05
GC_18_132 ref NI_18 NS_132 0 -6.4457144628560937e-03
GC_18_133 ref NI_18 NS_133 0 -5.0468172999144556e-01
GC_18_134 ref NI_18 NS_134 0 3.3549648821900863e-01
GC_18_135 ref NI_18 NS_135 0 -4.5113661778825981e-01
GC_18_136 ref NI_18 NS_136 0 2.5937888390292602e-01
GC_18_137 ref NI_18 NS_137 0 -8.5759778010071355e-05
GC_18_138 ref NI_18 NS_138 0 4.8337694306735219e-03
GD_18_1 ref NI_18 NA_1 0 5.6547183856840981e-02
GD_18_2 ref NI_18 NA_2 0 5.5317011349069717e-02
GD_18_3 ref NI_18 NA_3 0 4.6982587611258682e-02
GD_18_4 ref NI_18 NA_4 0 5.8374534538908819e-02
GD_18_5 ref NI_18 NA_5 0 6.0998262400140273e-02
GD_18_6 ref NI_18 NA_6 0 6.1203916176805810e-02
GD_18_7 ref NI_18 NA_7 0 5.6778505818121217e-02
GD_18_8 ref NI_18 NA_8 0 3.7808994197792170e-02
GD_18_9 ref NI_18 NA_9 0 4.1582562537040686e-02
GD_18_10 ref NI_18 NA_10 0 1.0705655802521269e-01
GD_18_11 ref NI_18 NA_11 0 2.6096639501019640e-02
GD_18_12 ref NI_18 NA_12 0 8.5625871292558733e-02
GD_18_13 ref NI_18 NA_13 0 5.5241778179761364e-02
GD_18_14 ref NI_18 NA_14 0 -2.1399040017651468e-03
GD_18_15 ref NI_18 NA_15 0 7.1937507293816622e-02
GD_18_16 ref NI_18 NA_16 0 9.0047242816459996e-02
GD_18_17 ref NI_18 NA_17 0 -1.4515018347775585e-02
GD_18_18 ref NI_18 NA_18 0 5.4029856460600127e+00
GD_18_19 ref NI_18 NA_19 0 -6.3808089049810182e-02
GD_18_20 ref NI_18 NA_20 0 -1.4825825523673786e-01
GD_18_21 ref NI_18 NA_21 0 2.4172292710592330e-02
GD_18_22 ref NI_18 NA_22 0 8.0554678816317365e-02
GD_18_23 ref NI_18 NA_23 0 9.9365983874322841e-02
*
* Port 19
VI_19 a_19 NI_19 0
RI_19 NI_19 ref 1.0000000000000001e-01
GC_19_1 ref NI_19 NS_1 0 -3.6900029521480959e-01
GC_19_2 ref NI_19 NS_2 0 1.4729006891321081e-01
GC_19_3 ref NI_19 NS_3 0 2.5205379957041269e-02
GC_19_4 ref NI_19 NS_4 0 1.9100499219460412e-02
GC_19_5 ref NI_19 NS_5 0 1.1545240981302628e-04
GC_19_6 ref NI_19 NS_6 0 2.1808348226121568e-02
GC_19_7 ref NI_19 NS_7 0 -7.4403252048270058e-02
GC_19_8 ref NI_19 NS_8 0 1.4012805402728401e-01
GC_19_9 ref NI_19 NS_9 0 4.5739088142175172e-02
GC_19_10 ref NI_19 NS_10 0 2.4186994674939011e-03
GC_19_11 ref NI_19 NS_11 0 3.2042781683884941e-05
GC_19_12 ref NI_19 NS_12 0 1.5804726603697323e-02
GC_19_13 ref NI_19 NS_13 0 -2.1438653872709248e-01
GC_19_14 ref NI_19 NS_14 0 8.5865880773736455e-02
GC_19_15 ref NI_19 NS_15 0 2.7109001825307713e-03
GC_19_16 ref NI_19 NS_16 0 3.3875815515647695e-02
GC_19_17 ref NI_19 NS_17 0 1.0393318401542297e-04
GC_19_18 ref NI_19 NS_18 0 2.4512325868222683e-02
GC_19_19 ref NI_19 NS_19 0 -1.9201098106828590e-01
GC_19_20 ref NI_19 NS_20 0 1.5520283139147575e-02
GC_19_21 ref NI_19 NS_21 0 -7.8272828674084652e-02
GC_19_22 ref NI_19 NS_22 0 5.5022984286396417e-02
GC_19_23 ref NI_19 NS_23 0 2.0600852142367730e-04
GC_19_24 ref NI_19 NS_24 0 3.7802311959110074e-02
GC_19_25 ref NI_19 NS_25 0 -1.9339195724067493e-01
GC_19_26 ref NI_19 NS_26 0 4.5335157458181792e-02
GC_19_27 ref NI_19 NS_27 0 -1.1457659859741624e-01
GC_19_28 ref NI_19 NS_28 0 6.2730253563225286e-02
GC_19_29 ref NI_19 NS_29 0 1.9869188559802235e-04
GC_19_30 ref NI_19 NS_30 0 3.8710125594360476e-02
GC_19_31 ref NI_19 NS_31 0 -1.8584113248384571e-01
GC_19_32 ref NI_19 NS_32 0 4.6998981429572567e-02
GC_19_33 ref NI_19 NS_33 0 -1.2080171308004208e-01
GC_19_34 ref NI_19 NS_34 0 6.6401545462856731e-02
GC_19_35 ref NI_19 NS_35 0 2.0214609144220101e-04
GC_19_36 ref NI_19 NS_36 0 3.8248569340065812e-02
GC_19_37 ref NI_19 NS_37 0 -1.7874170407711268e-01
GC_19_38 ref NI_19 NS_38 0 3.2610232185810461e-03
GC_19_39 ref NI_19 NS_39 0 -6.8169030008750631e-02
GC_19_40 ref NI_19 NS_40 0 5.9003301606158867e-02
GC_19_41 ref NI_19 NS_41 0 1.9544889189777688e-04
GC_19_42 ref NI_19 NS_42 0 3.5604766286123093e-02
GC_19_43 ref NI_19 NS_43 0 -3.5510538353720034e-01
GC_19_44 ref NI_19 NS_44 0 2.1969010597364641e-01
GC_19_45 ref NI_19 NS_45 0 3.9035846897236454e-01
GC_19_46 ref NI_19 NS_46 0 -1.3099835658846559e-01
GC_19_47 ref NI_19 NS_47 0 -3.0939126495491585e-07
GC_19_48 ref NI_19 NS_48 0 -3.6793547283743159e-03
GC_19_49 ref NI_19 NS_49 0 -8.9243413951891046e-02
GC_19_50 ref NI_19 NS_50 0 -1.5913223784907143e-01
GC_19_51 ref NI_19 NS_51 0 1.6494479511413931e-01
GC_19_52 ref NI_19 NS_52 0 5.6441480370493943e-02
GC_19_53 ref NI_19 NS_53 0 1.9847653126211861e-05
GC_19_54 ref NI_19 NS_54 0 7.8962683009740266e-03
GC_19_55 ref NI_19 NS_55 0 -5.6669761854503986e-01
GC_19_56 ref NI_19 NS_56 0 4.0121537235069199e-01
GC_19_57 ref NI_19 NS_57 0 -5.1598681688633208e-01
GC_19_58 ref NI_19 NS_58 0 2.7476722045319479e-01
GC_19_59 ref NI_19 NS_59 0 -6.9360332496527408e-05
GC_19_60 ref NI_19 NS_60 0 5.4812796465925438e-03
GC_19_61 ref NI_19 NS_61 0 -1.6975709405756348e-01
GC_19_62 ref NI_19 NS_62 0 2.0742314084529040e-01
GC_19_63 ref NI_19 NS_63 0 3.8611032160686154e-01
GC_19_64 ref NI_19 NS_64 0 -1.0960941942986752e-01
GC_19_65 ref NI_19 NS_65 0 -3.8502852231936356e-06
GC_19_66 ref NI_19 NS_66 0 -1.3525369738970018e-02
GC_19_67 ref NI_19 NS_67 0 -3.5095182535615627e-01
GC_19_68 ref NI_19 NS_68 0 1.7225260851880955e-01
GC_19_69 ref NI_19 NS_69 0 -2.4650495538847161e-01
GC_19_70 ref NI_19 NS_70 0 1.7893428426548180e-01
GC_19_71 ref NI_19 NS_71 0 -1.8828954538183513e-06
GC_19_72 ref NI_19 NS_72 0 1.0576330378399154e-02
GC_19_73 ref NI_19 NS_73 0 -1.7695436714104867e-01
GC_19_74 ref NI_19 NS_74 0 -6.4940177501313673e-02
GC_19_75 ref NI_19 NS_75 0 4.7792333049962443e-02
GC_19_76 ref NI_19 NS_76 0 1.0259237906311622e-01
GC_19_77 ref NI_19 NS_77 0 -4.6446188866153572e-06
GC_19_78 ref NI_19 NS_78 0 4.2494037772975984e-03
GC_19_79 ref NI_19 NS_79 0 -1.6638111381127743e-01
GC_19_80 ref NI_19 NS_80 0 1.7261485758341355e+00
GC_19_81 ref NI_19 NS_81 0 2.0686440975104631e-01
GC_19_82 ref NI_19 NS_82 0 -4.3307008668515923e-01
GC_19_83 ref NI_19 NS_83 0 -3.1590113129478179e-04
GC_19_84 ref NI_19 NS_84 0 -1.8877861512665108e-02
GC_19_85 ref NI_19 NS_85 0 -1.8588845979545549e-01
GC_19_86 ref NI_19 NS_86 0 2.1578617369224382e-02
GC_19_87 ref NI_19 NS_87 0 -9.9654280085665681e-02
GC_19_88 ref NI_19 NS_88 0 1.3327886807597114e-01
GC_19_89 ref NI_19 NS_89 0 2.0826605467600112e-05
GC_19_90 ref NI_19 NS_90 0 1.2912482593682342e-02
GC_19_91 ref NI_19 NS_91 0 -3.4363736674618900e-01
GC_19_92 ref NI_19 NS_92 0 1.2076694134613640e-01
GC_19_93 ref NI_19 NS_93 0 -1.9000902835299038e-01
GC_19_94 ref NI_19 NS_94 0 1.9980868995502116e-01
GC_19_95 ref NI_19 NS_95 0 -3.6876562349086524e-05
GC_19_96 ref NI_19 NS_96 0 -4.3340853337511913e-03
GC_19_97 ref NI_19 NS_97 0 3.2267997711510671e-01
GC_19_98 ref NI_19 NS_98 0 -5.0091662771028156e-01
GC_19_99 ref NI_19 NS_99 0 5.4706738323290671e-01
GC_19_100 ref NI_19 NS_100 0 4.1654487814220494e-02
GC_19_101 ref NI_19 NS_101 0 4.4688508909348246e-05
GC_19_102 ref NI_19 NS_102 0 -3.2135118372698661e-02
GC_19_103 ref NI_19 NS_103 0 1.2893408671565115e-01
GC_19_104 ref NI_19 NS_104 0 1.6327656242084734e+00
GC_19_105 ref NI_19 NS_105 0 2.5553830986991632e-01
GC_19_106 ref NI_19 NS_106 0 -3.7971905951210022e-01
GC_19_107 ref NI_19 NS_107 0 -6.5250427585111212e-05
GC_19_108 ref NI_19 NS_108 0 -4.7188784419228594e-02
GC_19_109 ref NI_19 NS_109 0 3.6196832882498944e+00
GC_19_110 ref NI_19 NS_110 0 -3.8558257786604946e+00
GC_19_111 ref NI_19 NS_111 0 -1.8050561406894747e+00
GC_19_112 ref NI_19 NS_112 0 -3.9094751635607672e-01
GC_19_113 ref NI_19 NS_113 0 -5.9527868450502067e-04
GC_19_114 ref NI_19 NS_114 0 -6.0868842060130129e-02
GC_19_115 ref NI_19 NS_115 0 6.1336198151468013e-01
GC_19_116 ref NI_19 NS_116 0 -7.2206749097857559e-01
GC_19_117 ref NI_19 NS_117 0 1.2650737277104276e+00
GC_19_118 ref NI_19 NS_118 0 -2.1646691748109545e-01
GC_19_119 ref NI_19 NS_119 0 -1.4996695841632231e-05
GC_19_120 ref NI_19 NS_120 0 -5.3353646099430024e-02
GC_19_121 ref NI_19 NS_121 0 2.9671348525551968e-03
GC_19_122 ref NI_19 NS_122 0 -8.9967144694578963e-02
GC_19_123 ref NI_19 NS_123 0 4.8725448135773547e-01
GC_19_124 ref NI_19 NS_124 0 -5.0459942245909439e-02
GC_19_125 ref NI_19 NS_125 0 6.2869438007854091e-05
GC_19_126 ref NI_19 NS_126 0 -2.6271780177992820e-02
GC_19_127 ref NI_19 NS_127 0 -2.9148189155228249e-01
GC_19_128 ref NI_19 NS_128 0 7.2551399819657608e-02
GC_19_129 ref NI_19 NS_129 0 -1.4433427462756596e-01
GC_19_130 ref NI_19 NS_130 0 1.8104621275732910e-01
GC_19_131 ref NI_19 NS_131 0 -1.2811408569661603e-05
GC_19_132 ref NI_19 NS_132 0 -1.5726164720039667e-03
GC_19_133 ref NI_19 NS_133 0 -4.9411374632431454e-01
GC_19_134 ref NI_19 NS_134 0 3.3619693760858671e-01
GC_19_135 ref NI_19 NS_135 0 -4.4502585226048802e-01
GC_19_136 ref NI_19 NS_136 0 2.4715621025810686e-01
GC_19_137 ref NI_19 NS_137 0 -5.9815044892520693e-05
GC_19_138 ref NI_19 NS_138 0 8.1220789676941779e-03
GD_19_1 ref NI_19 NA_1 0 5.2718446449459458e-02
GD_19_2 ref NI_19 NA_2 0 5.1221117944690676e-02
GD_19_3 ref NI_19 NA_3 0 3.4523904657329484e-02
GD_19_4 ref NI_19 NA_4 0 4.8901591676966026e-02
GD_19_5 ref NI_19 NA_5 0 4.8603944829406540e-02
GD_19_6 ref NI_19 NA_6 0 4.6933380508022107e-02
GD_19_7 ref NI_19 NA_7 0 4.4989979591264800e-02
GD_19_8 ref NI_19 NA_8 0 7.0147020546726793e-02
GD_19_9 ref NI_19 NA_9 0 3.1307601018928731e-02
GD_19_10 ref NI_19 NA_10 0 1.0914211236836471e-01
GD_19_11 ref NI_19 NA_11 0 4.2256444281873799e-02
GD_19_12 ref NI_19 NA_12 0 7.2217555870722178e-02
GD_19_13 ref NI_19 NA_13 0 4.8768490196299717e-02
GD_19_14 ref NI_19 NA_14 0 -3.6359382552236794e-02
GD_19_15 ref NI_19 NA_15 0 4.4421645888906236e-02
GD_19_16 ref NI_19 NA_16 0 8.0723783494809062e-02
GD_19_17 ref NI_19 NA_17 0 -2.9978171349808326e-02
GD_19_18 ref NI_19 NA_18 0 -6.3808089049810182e-02
GD_19_19 ref NI_19 NA_19 0 5.4954387108611442e+00
GD_19_20 ref NI_19 NA_20 0 -1.0033655088304586e-01
GD_19_21 ref NI_19 NA_21 0 2.0066052902747128e-02
GD_19_22 ref NI_19 NA_22 0 7.1490371801158373e-02
GD_19_23 ref NI_19 NA_23 0 9.5916897802969414e-02
*
* Port 20
VI_20 a_20 NI_20 0
RI_20 NI_20 ref 1.0000000000000001e-01
GC_20_1 ref NI_20 NS_1 0 -2.6199988009713787e-01
GC_20_2 ref NI_20 NS_2 0 9.8542134337331042e-02
GC_20_3 ref NI_20 NS_3 0 -1.1792689685778135e-01
GC_20_4 ref NI_20 NS_4 0 5.7034974755089410e-02
GC_20_5 ref NI_20 NS_5 0 9.5699659811657520e-05
GC_20_6 ref NI_20 NS_6 0 3.7806940008938035e-02
GC_20_7 ref NI_20 NS_7 0 -1.8124267927716997e-01
GC_20_8 ref NI_20 NS_8 0 5.8206437569537917e-02
GC_20_9 ref NI_20 NS_9 0 -8.2733837888688586e-02
GC_20_10 ref NI_20 NS_10 0 7.1499237682025152e-02
GC_20_11 ref NI_20 NS_11 0 2.5681186170415984e-05
GC_20_12 ref NI_20 NS_12 0 2.8050196421632107e-02
GC_20_13 ref NI_20 NS_13 0 -2.5182014198046565e-01
GC_20_14 ref NI_20 NS_14 0 1.2396369930730637e-01
GC_20_15 ref NI_20 NS_15 0 -1.3566825833105836e-01
GC_20_16 ref NI_20 NS_16 0 4.6770566664818498e-02
GC_20_17 ref NI_20 NS_17 0 7.6104690303323809e-05
GC_20_18 ref NI_20 NS_18 0 4.2698482094502666e-02
GC_20_19 ref NI_20 NS_19 0 -3.2277842783208360e-01
GC_20_20 ref NI_20 NS_20 0 1.8144516326049684e-01
GC_20_21 ref NI_20 NS_21 0 -1.4687536380267943e-01
GC_20_22 ref NI_20 NS_22 0 -2.0076952881752218e-02
GC_20_23 ref NI_20 NS_23 0 1.6241801451376652e-04
GC_20_24 ref NI_20 NS_24 0 6.4206272230933281e-02
GC_20_25 ref NI_20 NS_25 0 -3.4353400660944727e-01
GC_20_26 ref NI_20 NS_26 0 1.9693837755241175e-01
GC_20_27 ref NI_20 NS_27 0 -1.5048964455748429e-01
GC_20_28 ref NI_20 NS_28 0 -2.7176464543563546e-02
GC_20_29 ref NI_20 NS_29 0 1.4941821933400705e-04
GC_20_30 ref NI_20 NS_30 0 6.6331590334392371e-02
GC_20_31 ref NI_20 NS_31 0 -3.5433793270499342e-01
GC_20_32 ref NI_20 NS_32 0 2.0769426943571345e-01
GC_20_33 ref NI_20 NS_33 0 -1.6054174755699371e-01
GC_20_34 ref NI_20 NS_34 0 -2.3722598872130286e-02
GC_20_35 ref NI_20 NS_35 0 1.5019564159936575e-04
GC_20_36 ref NI_20 NS_36 0 6.6053660032480518e-02
GC_20_37 ref NI_20 NS_37 0 -3.3333216404488536e-01
GC_20_38 ref NI_20 NS_38 0 1.9620324364887035e-01
GC_20_39 ref NI_20 NS_39 0 -1.6975569413530431e-01
GC_20_40 ref NI_20 NS_40 0 -4.2900097568064907e-03
GC_20_41 ref NI_20 NS_41 0 1.4150170439836525e-04
GC_20_42 ref NI_20 NS_42 0 6.1462642634737968e-02
GC_20_43 ref NI_20 NS_43 0 1.4447970421372966e-01
GC_20_44 ref NI_20 NS_44 0 -2.8632333729297321e-01
GC_20_45 ref NI_20 NS_45 0 1.7966479262568463e-01
GC_20_46 ref NI_20 NS_46 0 1.0840739491135865e-01
GC_20_47 ref NI_20 NS_47 0 4.4661617497913017e-05
GC_20_48 ref NI_20 NS_48 0 -5.9726094415107804e-03
GC_20_49 ref NI_20 NS_49 0 -2.5420723588188981e-01
GC_20_50 ref NI_20 NS_50 0 1.5469339054697268e-01
GC_20_51 ref NI_20 NS_51 0 -2.7657279474767688e-01
GC_20_52 ref NI_20 NS_52 0 1.8492204784617364e-01
GC_20_53 ref NI_20 NS_53 0 -2.2999884337925000e-05
GC_20_54 ref NI_20 NS_54 0 1.4309304866573589e-02
GC_20_55 ref NI_20 NS_55 0 -4.8224480507537498e-01
GC_20_56 ref NI_20 NS_56 0 2.3662661860099565e-01
GC_20_57 ref NI_20 NS_57 0 -3.2491160505946853e-01
GC_20_58 ref NI_20 NS_58 0 2.5034832424150810e-01
GC_20_59 ref NI_20 NS_59 0 -5.2595948163373967e-05
GC_20_60 ref NI_20 NS_60 0 -6.8426677922872247e-03
GC_20_61 ref NI_20 NS_61 0 2.1343810646660960e-01
GC_20_62 ref NI_20 NS_62 0 -3.9857022454408625e-01
GC_20_63 ref NI_20 NS_63 0 4.4496666709066496e-01
GC_20_64 ref NI_20 NS_64 0 4.0234308076808570e-02
GC_20_65 ref NI_20 NS_65 0 2.7279961466711217e-05
GC_20_66 ref NI_20 NS_66 0 -2.1144545411373988e-02
GC_20_67 ref NI_20 NS_67 0 -4.8483669686792386e-01
GC_20_68 ref NI_20 NS_68 0 3.4098978369109245e-01
GC_20_69 ref NI_20 NS_69 0 -4.4563810982301028e-01
GC_20_70 ref NI_20 NS_70 0 2.3600559346402444e-01
GC_20_71 ref NI_20 NS_71 0 -5.4664026766405644e-05
GC_20_72 ref NI_20 NS_72 0 1.1753210930956460e-02
GC_20_73 ref NI_20 NS_73 0 -2.3777499106714203e-01
GC_20_74 ref NI_20 NS_74 0 8.4828105393620165e-02
GC_20_75 ref NI_20 NS_75 0 -1.9382195471643637e-01
GC_20_76 ref NI_20 NS_76 0 1.8585767684962370e-01
GC_20_77 ref NI_20 NS_77 0 -4.4510361375122222e-05
GC_20_78 ref NI_20 NS_78 0 4.6769126899777920e-03
GC_20_79 ref NI_20 NS_79 0 6.9629824945409824e-01
GC_20_80 ref NI_20 NS_80 0 -7.7384990225024619e-01
GC_20_81 ref NI_20 NS_81 0 7.2440876387289754e-01
GC_20_82 ref NI_20 NS_82 0 9.3778259997180004e-03
GC_20_83 ref NI_20 NS_83 0 -1.5141532595642176e-05
GC_20_84 ref NI_20 NS_84 0 -2.9664123708676871e-02
GC_20_85 ref NI_20 NS_85 0 -5.2329878937935437e-01
GC_20_86 ref NI_20 NS_86 0 3.9264146361777830e-01
GC_20_87 ref NI_20 NS_87 0 -4.6607513422336760e-01
GC_20_88 ref NI_20 NS_88 0 2.0689133827523518e-01
GC_20_89 ref NI_20 NS_89 0 -5.7585647167509298e-05
GC_20_90 ref NI_20 NS_90 0 2.2454029988104546e-02
GC_20_91 ref NI_20 NS_91 0 -4.1225381760550711e-01
GC_20_92 ref NI_20 NS_92 0 1.2063265592545955e-01
GC_20_93 ref NI_20 NS_93 0 4.1929241239283266e-02
GC_20_94 ref NI_20 NS_94 0 1.1653611772294913e-01
GC_20_95 ref NI_20 NS_95 0 -6.6672190825227971e-06
GC_20_96 ref NI_20 NS_96 0 -1.8395761375182593e-02
GC_20_97 ref NI_20 NS_97 0 -1.3104137058356002e-01
GC_20_98 ref NI_20 NS_98 0 3.4827502849366959e-01
GC_20_99 ref NI_20 NS_99 0 8.3050932499207586e-01
GC_20_100 ref NI_20 NS_100 0 -2.7782594123358628e-01
GC_20_101 ref NI_20 NS_101 0 6.0881093156361079e-05
GC_20_102 ref NI_20 NS_102 0 -5.3362892020312920e-02
GC_20_103 ref NI_20 NS_103 0 4.5879277593446821e-01
GC_20_104 ref NI_20 NS_104 0 9.0031595943264098e-01
GC_20_105 ref NI_20 NS_105 0 9.9382347496981815e-01
GC_20_106 ref NI_20 NS_106 0 -4.9144514771141873e-01
GC_20_107 ref NI_20 NS_107 0 -1.5705791242035707e-04
GC_20_108 ref NI_20 NS_108 0 -6.9453529584786122e-02
GC_20_109 ref NI_20 NS_109 0 6.1336198151467958e-01
GC_20_110 ref NI_20 NS_110 0 -7.2206749097857359e-01
GC_20_111 ref NI_20 NS_111 0 1.2650737277104249e+00
GC_20_112 ref NI_20 NS_112 0 -2.1646691748109395e-01
GC_20_113 ref NI_20 NS_113 0 -1.4996695841532562e-05
GC_20_114 ref NI_20 NS_114 0 -5.3353646099430468e-02
GC_20_115 ref NI_20 NS_115 0 3.2659049202292669e+00
GC_20_116 ref NI_20 NS_116 0 -1.5892041161775214e+00
GC_20_117 ref NI_20 NS_117 0 -2.2091649851274555e+00
GC_20_118 ref NI_20 NS_118 0 -7.0848567684164410e-01
GC_20_119 ref NI_20 NS_119 0 -4.9232230486583614e-04
GC_20_120 ref NI_20 NS_120 0 -1.0857339687620624e-01
GC_20_121 ref NI_20 NS_121 0 3.6711860073549415e-02
GC_20_122 ref NI_20 NS_122 0 -1.5083776114889685e-01
GC_20_123 ref NI_20 NS_123 0 8.0707922670021681e-01
GC_20_124 ref NI_20 NS_124 0 -1.5859739932379549e-01
GC_20_125 ref NI_20 NS_125 0 9.2426220419684714e-05
GC_20_126 ref NI_20 NS_126 0 -4.2407991905233387e-02
GC_20_127 ref NI_20 NS_127 0 -3.0386164575160796e-01
GC_20_128 ref NI_20 NS_128 0 -1.2554558438331701e-02
GC_20_129 ref NI_20 NS_129 0 -1.3859400624197154e-03
GC_20_130 ref NI_20 NS_130 0 1.5613030045421558e-01
GC_20_131 ref NI_20 NS_131 0 -1.3685759716995158e-05
GC_20_132 ref NI_20 NS_132 0 -1.1368470728892513e-02
GC_20_133 ref NI_20 NS_133 0 -4.8027191739006958e-01
GC_20_134 ref NI_20 NS_134 0 2.9563946168524075e-01
GC_20_135 ref NI_20 NS_135 0 -4.1659622897188336e-01
GC_20_136 ref NI_20 NS_136 0 2.6181523572265836e-01
GC_20_137 ref NI_20 NS_137 0 -7.3315263106069374e-05
GC_20_138 ref NI_20 NS_138 0 8.2595366773309845e-04
GD_20_1 ref NI_20 NA_1 0 5.5881752731440304e-02
GD_20_2 ref NI_20 NA_2 0 5.0038063747791031e-02
GD_20_3 ref NI_20 NA_3 0 5.2733266224753050e-02
GD_20_4 ref NI_20 NA_4 0 6.6177087459519834e-02
GD_20_5 ref NI_20 NA_5 0 6.9115194224660378e-02
GD_20_6 ref NI_20 NA_6 0 7.0469745171022807e-02
GD_20_7 ref NI_20 NA_7 0 6.6871918960774962e-02
GD_20_8 ref NI_20 NA_8 0 4.0588371779502215e-04
GD_20_9 ref NI_20 NA_9 0 5.6449735173501790e-02
GD_20_10 ref NI_20 NA_10 0 1.0181792353633866e-01
GD_20_11 ref NI_20 NA_11 0 -1.1261412117334077e-02
GD_20_12 ref NI_20 NA_12 0 9.4142691153528912e-02
GD_20_13 ref NI_20 NA_13 0 5.8301376735767609e-02
GD_20_14 ref NI_20 NA_14 0 -9.5856362797663797e-02
GD_20_15 ref NI_20 NA_15 0 9.6384721044458235e-02
GD_20_16 ref NI_20 NA_16 0 9.8702953905297611e-02
GD_20_17 ref NI_20 NA_17 0 2.3816776663999357e-02
GD_20_18 ref NI_20 NA_18 0 -1.4825825523673786e-01
GD_20_19 ref NI_20 NA_19 0 -1.0033655088304586e-01
GD_20_20 ref NI_20 NA_20 0 5.4980197953820547e+00
GD_20_21 ref NI_20 NA_21 0 1.4462662809752287e-02
GD_20_22 ref NI_20 NA_22 0 8.0718559379034979e-02
GD_20_23 ref NI_20 NA_23 0 9.7100194973598689e-02
*
* Port 21
VI_21 a_21 NI_21 0
RI_21 NI_21 ref 1.0000000000000001e-01
GC_21_1 ref NI_21 NS_1 0 -2.9024786386795903e-01
GC_21_2 ref NI_21 NS_2 0 1.0534313324678315e-01
GC_21_3 ref NI_21 NS_3 0 -3.6588988351168833e-02
GC_21_4 ref NI_21 NS_4 0 4.4216633562028131e-02
GC_21_5 ref NI_21 NS_5 0 1.1920211711420104e-04
GC_21_6 ref NI_21 NS_6 0 2.7184481283544504e-02
GC_21_7 ref NI_21 NS_7 0 -1.4422110313875075e-01
GC_21_8 ref NI_21 NS_8 0 8.2387126135967881e-02
GC_21_9 ref NI_21 NS_9 0 -5.9414325190401789e-03
GC_21_10 ref NI_21 NS_10 0 4.2327400687046303e-02
GC_21_11 ref NI_21 NS_11 0 5.6651794615012140e-05
GC_21_12 ref NI_21 NS_12 0 1.9950280491631812e-02
GC_21_13 ref NI_21 NS_13 0 -1.6448271740260931e-01
GC_21_14 ref NI_21 NS_14 0 9.0677448488873047e-02
GC_21_15 ref NI_21 NS_15 0 -5.9300382843818035e-02
GC_21_16 ref NI_21 NS_16 0 4.4506727543035730e-02
GC_21_17 ref NI_21 NS_17 0 9.0856452011347323e-05
GC_21_18 ref NI_21 NS_18 0 3.0560064204622824e-02
GC_21_19 ref NI_21 NS_19 0 -2.6598771677850624e-01
GC_21_20 ref NI_21 NS_20 0 1.0933544085870713e-01
GC_21_21 ref NI_21 NS_21 0 -1.2868933538062485e-01
GC_21_22 ref NI_21 NS_22 0 3.3488898892354908e-02
GC_21_23 ref NI_21 NS_23 0 1.8562059564814745e-04
GC_21_24 ref NI_21 NS_24 0 4.7208228126048427e-02
GC_21_25 ref NI_21 NS_25 0 -2.7942722775357154e-01
GC_21_26 ref NI_21 NS_26 0 1.3350086157346258e-01
GC_21_27 ref NI_21 NS_27 0 -1.5098699476286973e-01
GC_21_28 ref NI_21 NS_28 0 3.4858685235336709e-02
GC_21_29 ref NI_21 NS_29 0 1.7556126968048042e-04
GC_21_30 ref NI_21 NS_30 0 4.8644665413874209e-02
GC_21_31 ref NI_21 NS_31 0 -2.8032931536747030e-01
GC_21_32 ref NI_21 NS_32 0 1.3888293330759946e-01
GC_21_33 ref NI_21 NS_33 0 -1.5865635349795040e-01
GC_21_34 ref NI_21 NS_34 0 3.8489446305250856e-02
GC_21_35 ref NI_21 NS_35 0 1.7983910738398357e-04
GC_21_36 ref NI_21 NS_36 0 4.8217086338447533e-02
GC_21_37 ref NI_21 NS_37 0 -2.6045240581852758e-01
GC_21_38 ref NI_21 NS_38 0 1.0810764097599862e-01
GC_21_39 ref NI_21 NS_39 0 -1.3133900173054666e-01
GC_21_40 ref NI_21 NS_40 0 4.2126593103078154e-02
GC_21_41 ref NI_21 NS_41 0 1.6793460585573468e-04
GC_21_42 ref NI_21 NS_42 0 4.4699343216026380e-02
GC_21_43 ref NI_21 NS_43 0 -2.9965732271615986e-01
GC_21_44 ref NI_21 NS_44 0 1.0205627159071556e-01
GC_21_45 ref NI_21 NS_45 0 2.2520523541176157e-01
GC_21_46 ref NI_21 NS_46 0 -1.6971097369024930e-02
GC_21_47 ref NI_21 NS_47 0 -1.5149337689373111e-05
GC_21_48 ref NI_21 NS_48 0 -3.3780514723207169e-04
GC_21_49 ref NI_21 NS_49 0 -1.1073936147910553e-01
GC_21_50 ref NI_21 NS_50 0 -5.6676597851282942e-02
GC_21_51 ref NI_21 NS_51 0 1.0377642756171911e-01
GC_21_52 ref NI_21 NS_52 0 6.3134879704574265e-02
GC_21_53 ref NI_21 NS_53 0 -2.1751581095830636e-05
GC_21_54 ref NI_21 NS_54 0 7.1178354678792851e-03
GC_21_55 ref NI_21 NS_55 0 -5.4116912334998137e-02
GC_21_56 ref NI_21 NS_56 0 -2.6851215134699730e-01
GC_21_57 ref NI_21 NS_57 0 2.8986216571905488e-01
GC_21_58 ref NI_21 NS_58 0 9.0520664233673442e-02
GC_21_59 ref NI_21 NS_59 0 -4.3903588178117054e-05
GC_21_60 ref NI_21 NS_60 0 -1.8171973519591701e-02
GC_21_61 ref NI_21 NS_61 0 -2.8639325951845391e-02
GC_21_62 ref NI_21 NS_62 0 1.3027259433202580e+00
GC_21_63 ref NI_21 NS_63 0 -2.7563387051426169e-01
GC_21_64 ref NI_21 NS_64 0 -8.8676145498184394e-02
GC_21_65 ref NI_21 NS_65 0 -1.7568258863532362e-04
GC_21_66 ref NI_21 NS_66 0 -1.2001337677567055e-02
GC_21_67 ref NI_21 NS_67 0 -1.9374510106296962e-02
GC_21_68 ref NI_21 NS_68 0 -1.0587606913088557e-01
GC_21_69 ref NI_21 NS_69 0 5.8367210921727648e-02
GC_21_70 ref NI_21 NS_70 0 1.1873859268264107e-01
GC_21_71 ref NI_21 NS_71 0 -3.5564549162039946e-05
GC_21_72 ref NI_21 NS_72 0 -1.6106379919272897e-03
GC_21_73 ref NI_21 NS_73 0 -2.1966480731925006e-01
GC_21_74 ref NI_21 NS_74 0 2.0057521834905664e-01
GC_21_75 ref NI_21 NS_75 0 7.6385592201208607e-02
GC_21_76 ref NI_21 NS_76 0 2.7927768784993104e-02
GC_21_77 ref NI_21 NS_77 0 -7.7993591132401529e-05
GC_21_78 ref NI_21 NS_78 0 -9.2706989509844370e-04
GC_21_79 ref NI_21 NS_79 0 6.0256874188983969e-02
GC_21_80 ref NI_21 NS_80 0 -2.9684261955295521e-01
GC_21_81 ref NI_21 NS_81 0 4.2604367039581459e-01
GC_21_82 ref NI_21 NS_82 0 2.8514571451559471e-03
GC_21_83 ref NI_21 NS_83 0 2.9136557599015040e-05
GC_21_84 ref NI_21 NS_84 0 -1.1526648242089856e-02
GC_21_85 ref NI_21 NS_85 0 -7.2805271974143881e-02
GC_21_86 ref NI_21 NS_86 0 -2.7490044931403262e-02
GC_21_87 ref NI_21 NS_87 0 -4.6414527969308547e-02
GC_21_88 ref NI_21 NS_88 0 1.2856968597094104e-01
GC_21_89 ref NI_21 NS_89 0 -1.8784242075562065e-05
GC_21_90 ref NI_21 NS_90 0 7.9860743924330402e-03
GC_21_91 ref NI_21 NS_91 0 -3.5316404580647820e-01
GC_21_92 ref NI_21 NS_92 0 4.6753817906556827e-01
GC_21_93 ref NI_21 NS_93 0 1.2110279516959095e-01
GC_21_94 ref NI_21 NS_94 0 -1.9850966136663005e-02
GC_21_95 ref NI_21 NS_95 0 -4.5993393128439956e-05
GC_21_96 ref NI_21 NS_96 0 -2.0954864393869801e-02
GC_21_97 ref NI_21 NS_97 0 -2.3244300832953679e-01
GC_21_98 ref NI_21 NS_98 0 1.4375868897502804e+00
GC_21_99 ref NI_21 NS_99 0 1.3373137313639127e-01
GC_21_100 ref NI_21 NS_100 0 -2.7169555438509368e-01
GC_21_101 ref NI_21 NS_101 0 -2.0858672081099959e-04
GC_21_102 ref NI_21 NS_102 0 -3.1905247138812008e-02
GC_21_103 ref NI_21 NS_103 0 -3.5194705590202442e-02
GC_21_104 ref NI_21 NS_104 0 2.1438310677756858e-01
GC_21_105 ref NI_21 NS_105 0 4.6587432137735529e-01
GC_21_106 ref NI_21 NS_106 0 -1.0267490148473128e-01
GC_21_107 ref NI_21 NS_107 0 7.2916997669384868e-05
GC_21_108 ref NI_21 NS_108 0 -3.6197317087555698e-02
GC_21_109 ref NI_21 NS_109 0 2.9671348525550875e-03
GC_21_110 ref NI_21 NS_110 0 -8.9967144694578532e-02
GC_21_111 ref NI_21 NS_111 0 4.8725448135773486e-01
GC_21_112 ref NI_21 NS_112 0 -5.0459942245909099e-02
GC_21_113 ref NI_21 NS_113 0 6.2869438007876385e-05
GC_21_114 ref NI_21 NS_114 0 -2.6271780177992914e-02
GC_21_115 ref NI_21 NS_115 0 3.6711860073549395e-02
GC_21_116 ref NI_21 NS_116 0 -1.5083776114889674e-01
GC_21_117 ref NI_21 NS_117 0 8.0707922670021659e-01
GC_21_118 ref NI_21 NS_118 0 -1.5859739932379541e-01
GC_21_119 ref NI_21 NS_119 0 9.2426220419689973e-05
GC_21_120 ref NI_21 NS_120 0 -4.2407991905233408e-02
GC_21_121 ref NI_21 NS_121 0 3.5345481256981395e+00
GC_21_122 ref NI_21 NS_122 0 -3.8377523501868209e+00
GC_21_123 ref NI_21 NS_123 0 -2.4366374120406182e+00
GC_21_124 ref NI_21 NS_124 0 -9.1544496974615641e-02
GC_21_125 ref NI_21 NS_125 0 -4.8528125494506674e-04
GC_21_126 ref NI_21 NS_126 0 -5.2454820531975935e-02
GC_21_127 ref NI_21 NS_127 0 -4.5080626911990435e-01
GC_21_128 ref NI_21 NS_128 0 5.8501939001387238e-01
GC_21_129 ref NI_21 NS_129 0 3.2409610953158183e-02
GC_21_130 ref NI_21 NS_130 0 -2.0551256925051133e-02
GC_21_131 ref NI_21 NS_131 0 -2.5994709256083286e-05
GC_21_132 ref NI_21 NS_132 0 -1.4632529568503872e-02
GC_21_133 ref NI_21 NS_133 0 2.3370263373098898e-02
GC_21_134 ref NI_21 NS_134 0 -2.4282021647626176e-01
GC_21_135 ref NI_21 NS_135 0 1.9673760397774245e-01
GC_21_136 ref NI_21 NS_136 0 1.1256821218995844e-01
GC_21_137 ref NI_21 NS_137 0 -5.8084571397702138e-05
GC_21_138 ref NI_21 NS_138 0 -1.2172736033419687e-02
GD_21_1 ref NI_21 NA_1 0 4.8650273928037911e-02
GD_21_2 ref NI_21 NA_2 0 4.8199446175572667e-02
GD_21_3 ref NI_21 NA_3 0 3.7258745713271695e-02
GD_21_4 ref NI_21 NA_4 0 5.7692602303733076e-02
GD_21_5 ref NI_21 NA_5 0 5.9532851376065843e-02
GD_21_6 ref NI_21 NA_6 0 5.9281017862542508e-02
GD_21_7 ref NI_21 NA_7 0 5.5151675084219795e-02
GD_21_8 ref NI_21 NA_8 0 5.1713406746292510e-02
GD_21_9 ref NI_21 NA_9 0 2.8314947952201689e-02
GD_21_10 ref NI_21 NA_10 0 2.9384308973254326e-02
GD_21_11 ref NI_21 NA_11 0 -2.9848964892351344e-02
GD_21_12 ref NI_21 NA_12 0 1.7755682278219876e-02
GD_21_13 ref NI_21 NA_13 0 4.1450036887302262e-02
GD_21_14 ref NI_21 NA_14 0 1.2472217345448643e-02
GD_21_15 ref NI_21 NA_15 0 2.3184197609070659e-02
GD_21_16 ref NI_21 NA_16 0 7.1335662506357103e-02
GD_21_17 ref NI_21 NA_17 0 -2.2919267940688930e-02
GD_21_18 ref NI_21 NA_18 0 2.4172292710592330e-02
GD_21_19 ref NI_21 NA_19 0 2.0066052902747128e-02
GD_21_20 ref NI_21 NA_20 0 1.4462662809752287e-02
GD_21_21 ref NI_21 NA_21 0 5.5324758425847520e+00
GD_21_22 ref NI_21 NA_22 0 8.7644457382634003e-02
GD_21_23 ref NI_21 NA_23 0 1.4456034479604168e-02
*
* Port 22
VI_22 a_22 NI_22 0
RI_22 NI_22 ref 1.0000000000000001e-01
GC_22_1 ref NI_22 NS_1 0 -2.9637744097394725e-01
GC_22_2 ref NI_22 NS_2 0 1.3234005590662004e-01
GC_22_3 ref NI_22 NS_3 0 -5.1449520867063302e-02
GC_22_4 ref NI_22 NS_4 0 5.5443760549488276e-02
GC_22_5 ref NI_22 NS_5 0 1.4552385517373223e-04
GC_22_6 ref NI_22 NS_6 0 2.3114750648225567e-02
GC_22_7 ref NI_22 NS_7 0 -1.3223354808956986e-01
GC_22_8 ref NI_22 NS_8 0 1.0049172880186118e-01
GC_22_9 ref NI_22 NS_9 0 -1.9289681109323425e-02
GC_22_10 ref NI_22 NS_10 0 5.1151199889184519e-02
GC_22_11 ref NI_22 NS_11 0 8.7479521066700117e-05
GC_22_12 ref NI_22 NS_12 0 1.6740488163302942e-02
GC_22_13 ref NI_22 NS_13 0 -1.3916727906212339e-01
GC_22_14 ref NI_22 NS_14 0 1.0426232155622776e-01
GC_22_15 ref NI_22 NS_15 0 -6.5568692954908192e-02
GC_22_16 ref NI_22 NS_16 0 5.3845254765610764e-02
GC_22_17 ref NI_22 NS_17 0 1.1210001989349262e-04
GC_22_18 ref NI_22 NS_18 0 2.5977914417868907e-02
GC_22_19 ref NI_22 NS_19 0 -3.0913741177518322e-01
GC_22_20 ref NI_22 NS_20 0 1.3089894216552364e-01
GC_22_21 ref NI_22 NS_21 0 -1.5275247659677496e-01
GC_22_22 ref NI_22 NS_22 0 5.6207416241589835e-02
GC_22_23 ref NI_22 NS_23 0 2.0111089844387684e-04
GC_22_24 ref NI_22 NS_24 0 4.1775188569050541e-02
GC_22_25 ref NI_22 NS_25 0 -3.2067169521091493e-01
GC_22_26 ref NI_22 NS_26 0 1.5529806058362894e-01
GC_22_27 ref NI_22 NS_27 0 -1.7791948772101340e-01
GC_22_28 ref NI_22 NS_28 0 5.9192162540021014e-02
GC_22_29 ref NI_22 NS_29 0 1.9142677469868950e-04
GC_22_30 ref NI_22 NS_30 0 4.3083080632322239e-02
GC_22_31 ref NI_22 NS_31 0 -3.1922919705083019e-01
GC_22_32 ref NI_22 NS_32 0 1.5910560706057514e-01
GC_22_33 ref NI_22 NS_33 0 -1.8482112738179476e-01
GC_22_34 ref NI_22 NS_34 0 6.2887303135600231e-02
GC_22_35 ref NI_22 NS_35 0 1.9575183739318586e-04
GC_22_36 ref NI_22 NS_36 0 4.2609721112389830e-02
GC_22_37 ref NI_22 NS_37 0 -2.9856277771114204e-01
GC_22_38 ref NI_22 NS_38 0 1.2614983002974861e-01
GC_22_39 ref NI_22 NS_39 0 -1.5058243911159308e-01
GC_22_40 ref NI_22 NS_40 0 6.3203604885424591e-02
GC_22_41 ref NI_22 NS_41 0 1.8430180609695773e-04
GC_22_42 ref NI_22 NS_42 0 3.9247237839769591e-02
GC_22_43 ref NI_22 NS_43 0 -2.1381500416857277e-01
GC_22_44 ref NI_22 NS_44 0 3.2517640133961898e-02
GC_22_45 ref NI_22 NS_45 0 8.5620689045704065e-02
GC_22_46 ref NI_22 NS_46 0 6.1370165539535303e-02
GC_22_47 ref NI_22 NS_47 0 5.8461667242039944e-06
GC_22_48 ref NI_22 NS_48 0 2.7748946471747868e-03
GC_22_49 ref NI_22 NS_49 0 -4.6711323267954949e-02
GC_22_50 ref NI_22 NS_50 0 -1.1971307603313451e-01
GC_22_51 ref NI_22 NS_51 0 2.6343391051937326e-01
GC_22_52 ref NI_22 NS_52 0 1.2337249427281689e-02
GC_22_53 ref NI_22 NS_53 0 -3.0535507301951266e-05
GC_22_54 ref NI_22 NS_54 0 1.3933889915739718e-03
GC_22_55 ref NI_22 NS_55 0 -1.9745801175374303e-01
GC_22_56 ref NI_22 NS_56 0 -9.7684573451039841e-02
GC_22_57 ref NI_22 NS_57 0 1.0907886765057753e+00
GC_22_58 ref NI_22 NS_58 0 -3.1623957842738398e-01
GC_22_59 ref NI_22 NS_59 0 -5.3542491744295243e-05
GC_22_60 ref NI_22 NS_60 0 -3.5140513454239117e-02
GC_22_61 ref NI_22 NS_61 0 -2.8138870310101438e-01
GC_22_62 ref NI_22 NS_62 0 2.6644274109824623e-01
GC_22_63 ref NI_22 NS_63 0 5.7575582777644956e-02
GC_22_64 ref NI_22 NS_64 0 2.8427700408687310e-02
GC_22_65 ref NI_22 NS_65 0 -2.4039753168089580e-05
GC_22_66 ref NI_22 NS_66 0 -4.5503942731601604e-03
GC_22_67 ref NI_22 NS_67 0 2.0624805759772941e-01
GC_22_68 ref NI_22 NS_68 0 -1.3096222830648643e-01
GC_22_69 ref NI_22 NS_69 0 5.7390344726719245e-01
GC_22_70 ref NI_22 NS_70 0 -1.1207615835556371e-01
GC_22_71 ref NI_22 NS_71 0 -1.1310286002252390e-04
GC_22_72 ref NI_22 NS_72 0 -1.5615735255171244e-02
GC_22_73 ref NI_22 NS_73 0 6.3899355864672144e-02
GC_22_74 ref NI_22 NS_74 0 8.6334215641821255e-01
GC_22_75 ref NI_22 NS_75 0 -5.2879849582904717e-02
GC_22_76 ref NI_22 NS_76 0 -8.6743335223408866e-02
GC_22_77 ref NI_22 NS_77 0 -1.8735383544833448e-04
GC_22_78 ref NI_22 NS_78 0 -9.5052748141365873e-03
GC_22_79 ref NI_22 NS_79 0 -2.4262731151761985e-01
GC_22_80 ref NI_22 NS_80 0 3.8408285605866281e-02
GC_22_81 ref NI_22 NS_81 0 -1.1109040353707096e-01
GC_22_82 ref NI_22 NS_82 0 1.5842699138227864e-01
GC_22_83 ref NI_22 NS_83 0 1.4444345058272243e-05
GC_22_84 ref NI_22 NS_84 0 3.7773358578201007e-03
GC_22_85 ref NI_22 NS_85 0 2.6041104943662535e-01
GC_22_86 ref NI_22 NS_86 0 -3.4663167875722922e-01
GC_22_87 ref NI_22 NS_87 0 3.6026273992547631e-01
GC_22_88 ref NI_22 NS_88 0 2.7881831762390341e-02
GC_22_89 ref NI_22 NS_89 0 -3.0412441905827611e-05
GC_22_90 ref NI_22 NS_90 0 -4.1791634403216815e-03
GC_22_91 ref NI_22 NS_91 0 2.8900455270160225e-01
GC_22_92 ref NI_22 NS_92 0 1.6446067979489305e+00
GC_22_93 ref NI_22 NS_93 0 -2.0777603092494912e-01
GC_22_94 ref NI_22 NS_94 0 -1.9519515789896261e-01
GC_22_95 ref NI_22 NS_95 0 -3.5414171646269772e-05
GC_22_96 ref NI_22 NS_96 0 -3.4346932709967720e-02
GC_22_97 ref NI_22 NS_97 0 -5.4812047525093244e-01
GC_22_98 ref NI_22 NS_98 0 2.8133448847709353e-01
GC_22_99 ref NI_22 NS_99 0 3.3209454220524265e-01
GC_22_100 ref NI_22 NS_100 0 -6.9497245510184671e-02
GC_22_101 ref NI_22 NS_101 0 -4.1530996215498653e-06
GC_22_102 ref NI_22 NS_102 0 -1.9339148253073493e-02
GC_22_103 ref NI_22 NS_103 0 -3.2582817418535320e-01
GC_22_104 ref NI_22 NS_104 0 5.6630155595334859e-02
GC_22_105 ref NI_22 NS_105 0 -8.9828480756463755e-02
GC_22_106 ref NI_22 NS_106 0 1.7096348980669943e-01
GC_22_107 ref NI_22 NS_107 0 -2.8542113703761205e-05
GC_22_108 ref NI_22 NS_108 0 -6.4457144628560937e-03
GC_22_109 ref NI_22 NS_109 0 -2.9148189155228249e-01
GC_22_110 ref NI_22 NS_110 0 7.2551399819657372e-02
GC_22_111 ref NI_22 NS_111 0 -1.4433427462756562e-01
GC_22_112 ref NI_22 NS_112 0 1.8104621275732893e-01
GC_22_113 ref NI_22 NS_113 0 -1.2811408569673389e-05
GC_22_114 ref NI_22 NS_114 0 -1.5726164720039147e-03
GC_22_115 ref NI_22 NS_115 0 -3.0386164575160801e-01
GC_22_116 ref NI_22 NS_116 0 -1.2554558438330938e-02
GC_22_117 ref NI_22 NS_117 0 -1.3859400624207431e-03
GC_22_118 ref NI_22 NS_118 0 1.5613030045421619e-01
GC_22_119 ref NI_22 NS_119 0 -1.3685759716955830e-05
GC_22_120 ref NI_22 NS_120 0 -1.1368470728892686e-02
GC_22_121 ref NI_22 NS_121 0 -4.5080626911990440e-01
GC_22_122 ref NI_22 NS_122 0 5.8501939001387315e-01
GC_22_123 ref NI_22 NS_123 0 3.2409610953157100e-02
GC_22_124 ref NI_22 NS_124 0 -2.0551256925050502e-02
GC_22_125 ref NI_22 NS_125 0 -2.5994709256041334e-05
GC_22_126 ref NI_22 NS_126 0 -1.4632529568504058e-02
GC_22_127 ref NI_22 NS_127 0 3.6233942182916201e+00
GC_22_128 ref NI_22 NS_128 0 -4.0994137649813336e+00
GC_22_129 ref NI_22 NS_129 0 -2.1645859491023440e+00
GC_22_130 ref NI_22 NS_130 0 -1.5626226056831805e-01
GC_22_131 ref NI_22 NS_131 0 -5.1716838801283522e-04
GC_22_132 ref NI_22 NS_132 0 -5.3304972066272285e-02
GC_22_133 ref NI_22 NS_133 0 3.8098359965795475e-01
GC_22_134 ref NI_22 NS_134 0 5.9133171676580706e-02
GC_22_135 ref NI_22 NS_135 0 7.7196500835388759e-01
GC_22_136 ref NI_22 NS_136 0 -2.3851156408723528e-01
GC_22_137 ref NI_22 NS_137 0 -4.0946723925819922e-05
GC_22_138 ref NI_22 NS_138 0 -3.0538944908631967e-02
GD_22_1 ref NI_22 NA_1 0 4.6554635010473626e-02
GD_22_2 ref NI_22 NA_2 0 4.7914757563746968e-02
GD_22_3 ref NI_22 NA_3 0 3.5713381339804895e-02
GD_22_4 ref NI_22 NA_4 0 6.4528200754980419e-02
GD_22_5 ref NI_22 NA_5 0 6.6253170292442015e-02
GD_22_6 ref NI_22 NA_6 0 6.5645496592765334e-02
GD_22_7 ref NI_22 NA_7 0 6.0913542065426207e-02
GD_22_8 ref NI_22 NA_8 0 4.7211237317154639e-02
GD_22_9 ref NI_22 NA_9 0 1.2976473734177056e-02
GD_22_10 ref NI_22 NA_10 0 1.5894105610075680e-02
GD_22_11 ref NI_22 NA_11 0 5.7863309376803417e-02
GD_22_12 ref NI_22 NA_12 0 -3.7954939867483460e-02
GD_22_13 ref NI_22 NA_13 0 -3.5997212864396250e-02
GD_22_14 ref NI_22 NA_14 0 5.9875615170944273e-02
GD_22_15 ref NI_22 NA_15 0 -3.3493207254521561e-02
GD_22_16 ref NI_22 NA_16 0 -4.4864711425156731e-02
GD_22_17 ref NI_22 NA_17 0 1.0798811009402147e-01
GD_22_18 ref NI_22 NA_18 0 8.0554678816317365e-02
GD_22_19 ref NI_22 NA_19 0 7.1490371801158373e-02
GD_22_20 ref NI_22 NA_20 0 8.0718559379034979e-02
GD_22_21 ref NI_22 NA_21 0 8.7644457382634003e-02
GD_22_22 ref NI_22 NA_22 0 5.4984150283044748e+00
GD_22_23 ref NI_22 NA_23 0 -7.9037127277866534e-02
*
* Port 23
VI_23 a_23 NI_23 0
RI_23 NI_23 ref 1.0000000000000001e-01
GC_23_1 ref NI_23 NS_1 0 -3.4144237878671740e-01
GC_23_2 ref NI_23 NS_2 0 1.3878131381921652e-01
GC_23_3 ref NI_23 NS_3 0 -4.2729057555231750e-02
GC_23_4 ref NI_23 NS_4 0 5.7347917345854989e-02
GC_23_5 ref NI_23 NS_5 0 1.6373772884911792e-04
GC_23_6 ref NI_23 NS_6 0 2.0867528464838938e-02
GC_23_7 ref NI_23 NS_7 0 -1.7368674879697618e-01
GC_23_8 ref NI_23 NS_8 0 1.1461358732635481e-01
GC_23_9 ref NI_23 NS_9 0 -1.3265194790011498e-02
GC_23_10 ref NI_23 NS_10 0 5.0979455873507884e-02
GC_23_11 ref NI_23 NS_11 0 1.0532250363890847e-04
GC_23_12 ref NI_23 NS_12 0 1.4966681662308964e-02
GC_23_13 ref NI_23 NS_13 0 -1.6288696785121623e-01
GC_23_14 ref NI_23 NS_14 0 1.1017536420546938e-01
GC_23_15 ref NI_23 NS_15 0 -5.9693030739731895e-02
GC_23_16 ref NI_23 NS_16 0 5.7074151831597142e-02
GC_23_17 ref NI_23 NS_17 0 1.3240080738509161e-04
GC_23_18 ref NI_23 NS_18 0 2.3370057527144310e-02
GC_23_19 ref NI_23 NS_19 0 -3.1805039283949399e-01
GC_23_20 ref NI_23 NS_20 0 1.2907851798839931e-01
GC_23_21 ref NI_23 NS_21 0 -1.6091330845099633e-01
GC_23_22 ref NI_23 NS_22 0 7.0023860553752079e-02
GC_23_23 ref NI_23 NS_23 0 2.2044398303841184e-04
GC_23_24 ref NI_23 NS_24 0 3.8401243789817865e-02
GC_23_25 ref NI_23 NS_25 0 -3.2921709367552882e-01
GC_23_26 ref NI_23 NS_26 0 1.5623399216318457e-01
GC_23_27 ref NI_23 NS_27 0 -1.9001975356590381e-01
GC_23_28 ref NI_23 NS_28 0 7.4510897493077030e-02
GC_23_29 ref NI_23 NS_29 0 2.1142080008526560e-04
GC_23_30 ref NI_23 NS_30 0 3.9598462456054112e-02
GC_23_31 ref NI_23 NS_31 0 -3.2567909348352447e-01
GC_23_32 ref NI_23 NS_32 0 1.5900331394644096e-01
GC_23_33 ref NI_23 NS_33 0 -1.9654801246876802e-01
GC_23_34 ref NI_23 NS_34 0 7.8298668154573370e-02
GC_23_35 ref NI_23 NS_35 0 2.1458663638242043e-04
GC_23_36 ref NI_23 NS_36 0 3.9103345824505503e-02
GC_23_37 ref NI_23 NS_37 0 -3.0513668819967099e-01
GC_23_38 ref NI_23 NS_38 0 1.2084545066061474e-01
GC_23_39 ref NI_23 NS_39 0 -1.5460910700367897e-01
GC_23_40 ref NI_23 NS_40 0 7.5742501920556440e-02
GC_23_41 ref NI_23 NS_41 0 2.0395548637893086e-04
GC_23_42 ref NI_23 NS_42 0 3.5893624368540294e-02
GC_23_43 ref NI_23 NS_43 0 -1.2887211360067227e-01
GC_23_44 ref NI_23 NS_44 0 -4.7729060443069120e-02
GC_23_45 ref NI_23 NS_45 0 4.3308766551399806e-02
GC_23_46 ref NI_23 NS_46 0 1.0160998222811557e-01
GC_23_47 ref NI_23 NS_47 0 1.3816329279785312e-05
GC_23_48 ref NI_23 NS_48 0 3.3114236080145371e-03
GC_23_49 ref NI_23 NS_49 0 6.0705718991701761e-02
GC_23_50 ref NI_23 NS_50 0 -2.4464885022883021e-01
GC_23_51 ref NI_23 NS_51 0 3.4992828753361499e-01
GC_23_52 ref NI_23 NS_52 0 6.6611995844576789e-03
GC_23_53 ref NI_23 NS_53 0 -7.9066166581821950e-06
GC_23_54 ref NI_23 NS_54 0 -1.8988904974722000e-03
GC_23_55 ref NI_23 NS_55 0 9.9430713536266224e-01
GC_23_56 ref NI_23 NS_56 0 2.6436626998506139e+00
GC_23_57 ref NI_23 NS_57 0 -3.1844521509827106e-01
GC_23_58 ref NI_23 NS_58 0 -4.4458749986600199e-01
GC_23_59 ref NI_23 NS_59 0 -1.1177477632785358e-04
GC_23_60 ref NI_23 NS_60 0 -4.7526096606701519e-02
GC_23_61 ref NI_23 NS_61 0 -4.0295227344070192e-02
GC_23_62 ref NI_23 NS_62 0 -1.1618598547691872e-01
GC_23_63 ref NI_23 NS_63 0 9.5691067889483575e-02
GC_23_64 ref NI_23 NS_64 0 1.0731574076255332e-01
GC_23_65 ref NI_23 NS_65 0 -2.1263057582027006e-05
GC_23_66 ref NI_23 NS_66 0 -3.1789491245050646e-03
GC_23_67 ref NI_23 NS_67 0 1.0308564040153205e+00
GC_23_68 ref NI_23 NS_68 0 2.1719083603008262e+00
GC_23_69 ref NI_23 NS_69 0 -6.6223177361228591e-01
GC_23_70 ref NI_23 NS_70 0 -1.8928909419673906e-01
GC_23_71 ref NI_23 NS_71 0 -1.6163047506719485e-04
GC_23_72 ref NI_23 NS_72 0 -2.5067697441532859e-02
GC_23_73 ref NI_23 NS_73 0 1.6443669204165931e-01
GC_23_74 ref NI_23 NS_74 0 2.7776985377430149e-03
GC_23_75 ref NI_23 NS_75 0 4.5105220402214258e-01
GC_23_76 ref NI_23 NS_76 0 -9.4513691423198626e-02
GC_23_77 ref NI_23 NS_77 0 -8.4227894506337387e-05
GC_23_78 ref NI_23 NS_78 0 -1.2442270984910936e-02
GC_23_79 ref NI_23 NS_79 0 -3.9297612839417867e-01
GC_23_80 ref NI_23 NS_80 0 2.1973243430769546e-01
GC_23_81 ref NI_23 NS_81 0 -3.0829746524793367e-01
GC_23_82 ref NI_23 NS_82 0 2.0077062666808368e-01
GC_23_83 ref NI_23 NS_83 0 -1.2951477876671413e-05
GC_23_84 ref NI_23 NS_84 0 9.8995908335791308e-03
GC_23_85 ref NI_23 NS_85 0 -1.2385374564135163e-01
GC_23_86 ref NI_23 NS_86 0 -2.8477168742947895e-01
GC_23_87 ref NI_23 NS_87 0 6.2737111277979118e-01
GC_23_88 ref NI_23 NS_88 0 -1.0368759403511794e-01
GC_23_89 ref NI_23 NS_89 0 -7.1591488894332244e-05
GC_23_90 ref NI_23 NS_90 0 -6.0544607871489626e-03
GC_23_91 ref NI_23 NS_91 0 -2.5717941745815093e-01
GC_23_92 ref NI_23 NS_92 0 4.7511224734838886e-01
GC_23_93 ref NI_23 NS_93 0 7.6278385160047335e-01
GC_23_94 ref NI_23 NS_94 0 -3.1260530311057683e-01
GC_23_95 ref NI_23 NS_95 0 -1.0144554145708127e-04
GC_23_96 ref NI_23 NS_96 0 -3.5024203336752088e-02
GC_23_97 ref NI_23 NS_97 0 4.3659191087772796e-02
GC_23_98 ref NI_23 NS_98 0 -3.7656378806415464e-01
GC_23_99 ref NI_23 NS_99 0 3.5660367078989852e-01
GC_23_100 ref NI_23 NS_100 0 8.1494674290742489e-02
GC_23_101 ref NI_23 NS_101 0 -2.3253479335231581e-05
GC_23_102 ref NI_23 NS_102 0 -1.7799993547595306e-02
GC_23_103 ref NI_23 NS_103 0 -5.0468172999144578e-01
GC_23_104 ref NI_23 NS_104 0 3.3549648821900951e-01
GC_23_105 ref NI_23 NS_105 0 -4.5113661778826103e-01
GC_23_106 ref NI_23 NS_106 0 2.5937888390292668e-01
GC_23_107 ref NI_23 NS_107 0 -8.5759778010026768e-05
GC_23_108 ref NI_23 NS_108 0 4.8337694306733259e-03
GC_23_109 ref NI_23 NS_109 0 -4.9411374632431443e-01
GC_23_110 ref NI_23 NS_110 0 3.3619693760858621e-01
GC_23_111 ref NI_23 NS_111 0 -4.4502585226048741e-01
GC_23_112 ref NI_23 NS_112 0 2.4715621025810652e-01
GC_23_113 ref NI_23 NS_113 0 -5.9815044892544274e-05
GC_23_114 ref NI_23 NS_114 0 8.1220789676942819e-03
GC_23_115 ref NI_23 NS_115 0 -4.8027191739006975e-01
GC_23_116 ref NI_23 NS_116 0 2.9563946168524174e-01
GC_23_117 ref NI_23 NS_117 0 -4.1659622897188475e-01
GC_23_118 ref NI_23 NS_118 0 2.6181523572265913e-01
GC_23_119 ref NI_23 NS_119 0 -7.3315263106016939e-05
GC_23_120 ref NI_23 NS_120 0 8.2595366773286763e-04
GC_23_121 ref NI_23 NS_121 0 2.3370263373098873e-02
GC_23_122 ref NI_23 NS_122 0 -2.4282021647626173e-01
GC_23_123 ref NI_23 NS_123 0 1.9673760397774237e-01
GC_23_124 ref NI_23 NS_124 0 1.1256821218995854e-01
GC_23_125 ref NI_23 NS_125 0 -5.8084571397698222e-05
GC_23_126 ref NI_23 NS_126 0 -1.2172736033419704e-02
GC_23_127 ref NI_23 NS_127 0 3.8098359965795475e-01
GC_23_128 ref NI_23 NS_128 0 5.9133171676580970e-02
GC_23_129 ref NI_23 NS_129 0 7.7196500835388748e-01
GC_23_130 ref NI_23 NS_130 0 -2.3851156408723515e-01
GC_23_131 ref NI_23 NS_131 0 -4.0946723925806823e-05
GC_23_132 ref NI_23 NS_132 0 -3.0538944908632015e-02
GC_23_133 ref NI_23 NS_133 0 1.7887443228432371e+00
GC_23_134 ref NI_23 NS_134 0 -6.1545714401725924e+00
GC_23_135 ref NI_23 NS_135 0 -2.4133106347566508e-01
GC_23_136 ref NI_23 NS_136 0 -4.5620068558158922e-01
GC_23_137 ref NI_23 NS_137 0 -3.3180343007921858e-04
GC_23_138 ref NI_23 NS_138 0 -4.7548503010810539e-02
GD_23_1 ref NI_23 NA_1 0 5.2970826851971867e-02
GD_23_2 ref NI_23 NA_2 0 5.2283382613129724e-02
GD_23_3 ref NI_23 NA_3 0 3.9091564513816922e-02
GD_23_4 ref NI_23 NA_4 0 6.7102491228436784e-02
GD_23_5 ref NI_23 NA_5 0 6.8667268365784642e-02
GD_23_6 ref NI_23 NA_6 0 6.7709551201972695e-02
GD_23_7 ref NI_23 NA_7 0 6.3066632189287319e-02
GD_23_8 ref NI_23 NA_8 0 3.4063777157298546e-02
GD_23_9 ref NI_23 NA_9 0 -2.2208139890077748e-03
GD_23_10 ref NI_23 NA_10 0 -1.5758686398053545e-01
GD_23_11 ref NI_23 NA_11 0 2.1271547443523348e-02
GD_23_12 ref NI_23 NA_12 0 -1.3935985519929833e-01
GD_23_13 ref NI_23 NA_13 0 -3.0998801130799929e-02
GD_23_14 ref NI_23 NA_14 0 7.8936260148507992e-02
GD_23_15 ref NI_23 NA_15 0 2.1009200369250351e-02
GD_23_16 ref NI_23 NA_16 0 1.1623791034970896e-02
GD_23_17 ref NI_23 NA_17 0 1.4727734428656622e-02
GD_23_18 ref NI_23 NA_18 0 9.9365983874322841e-02
GD_23_19 ref NI_23 NA_19 0 9.5916897802969414e-02
GD_23_20 ref NI_23 NA_20 0 9.7100194973598689e-02
GD_23_21 ref NI_23 NA_21 0 1.4456034479604168e-02
GD_23_22 ref NI_23 NA_22 0 -7.9037127277866534e-02
GD_23_23 ref NI_23 NA_23 0 5.7849810507510693e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
* Impinging wave, port 16
RA_16 NA_16 0 1.5811388300841897e-01
FA_16 0 NA_16 VI_16 1.0
GA_16 0 NA_16 a_16 ref 1.0000000000000000e+01
*
* Impinging wave, port 17
RA_17 NA_17 0 1.5811388300841897e-01
FA_17 0 NA_17 VI_17 1.0
GA_17 0 NA_17 a_17 ref 1.0000000000000000e+01
*
* Impinging wave, port 18
RA_18 NA_18 0 1.5811388300841897e-01
FA_18 0 NA_18 VI_18 1.0
GA_18 0 NA_18 a_18 ref 1.0000000000000000e+01
*
* Impinging wave, port 19
RA_19 NA_19 0 1.5811388300841897e-01
FA_19 0 NA_19 VI_19 1.0
GA_19 0 NA_19 a_19 ref 1.0000000000000000e+01
*
* Impinging wave, port 20
RA_20 NA_20 0 1.5811388300841897e-01
FA_20 0 NA_20 VI_20 1.0
GA_20 0 NA_20 a_20 ref 1.0000000000000000e+01
*
* Impinging wave, port 21
RA_21 NA_21 0 1.5811388300841897e-01
FA_21 0 NA_21 VI_21 1.0
GA_21 0 NA_21 a_21 ref 1.0000000000000000e+01
*
* Impinging wave, port 22
RA_22 NA_22 0 1.5811388300841897e-01
FA_22 0 NA_22 VI_22 1.0
GA_22 0 NA_22 a_22 ref 1.0000000000000000e+01
*
* Impinging wave, port 23
RA_23 NA_23 0 1.5811388300841897e-01
FA_23 0 NA_23 VI_23 1.0
GA_23 0 NA_23 a_23 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 1.0000000000000001e-09
RS_1 NS_1 0 5.4399432312366956e-02
GS_1_1 0 NS_1 NA_1 0 7.5244519323275991e+00
*
* Real pole n. 2
CS_2 NS_2 0 1.0000000000000001e-09
RS_2 NS_2 0 1.9024914358812270e-01
GS_2_1 0 NS_2 NA_1 0 7.5244519323275991e+00
*
* Real pole n. 3
CS_3 NS_3 0 1.0000000000000001e-09
RS_3 NS_3 0 3.2712574667710409e-01
GS_3_1 0 NS_3 NA_1 0 7.5244519323275991e+00
*
* Real pole n. 4
CS_4 NS_4 0 1.0000000000000001e-09
RS_4 NS_4 0 6.1744050867248901e-01
GS_4_1 0 NS_4 NA_1 0 7.5244519323275991e+00
*
* Real pole n. 5
CS_5 NS_5 0 1.0000000000000001e-09
RS_5 NS_5 0 1.1579863532076049e+01
GS_5_1 0 NS_5 NA_1 0 7.5244519323275991e+00
*
* Real pole n. 6
CS_6 NS_6 0 1.0000000000000001e-09
RS_6 NS_6 0 1.5362958698707145e+00
GS_6_1 0 NS_6 NA_1 0 7.5244519323275991e+00
*
* Real pole n. 7
CS_7 NS_7 0 1.0000000000000001e-09
RS_7 NS_7 0 5.4399432312366956e-02
GS_7_2 0 NS_7 NA_2 0 7.5244519323275991e+00
*
* Real pole n. 8
CS_8 NS_8 0 1.0000000000000001e-09
RS_8 NS_8 0 1.9024914358812270e-01
GS_8_2 0 NS_8 NA_2 0 7.5244519323275991e+00
*
* Real pole n. 9
CS_9 NS_9 0 1.0000000000000001e-09
RS_9 NS_9 0 3.2712574667710409e-01
GS_9_2 0 NS_9 NA_2 0 7.5244519323275991e+00
*
* Real pole n. 10
CS_10 NS_10 0 1.0000000000000001e-09
RS_10 NS_10 0 6.1744050867248901e-01
GS_10_2 0 NS_10 NA_2 0 7.5244519323275991e+00
*
* Real pole n. 11
CS_11 NS_11 0 1.0000000000000001e-09
RS_11 NS_11 0 1.1579863532076049e+01
GS_11_2 0 NS_11 NA_2 0 7.5244519323275991e+00
*
* Real pole n. 12
CS_12 NS_12 0 1.0000000000000001e-09
RS_12 NS_12 0 1.5362958698707145e+00
GS_12_2 0 NS_12 NA_2 0 7.5244519323275991e+00
*
* Real pole n. 13
CS_13 NS_13 0 1.0000000000000001e-09
RS_13 NS_13 0 5.4399432312366956e-02
GS_13_3 0 NS_13 NA_3 0 7.5244519323275991e+00
*
* Real pole n. 14
CS_14 NS_14 0 1.0000000000000001e-09
RS_14 NS_14 0 1.9024914358812270e-01
GS_14_3 0 NS_14 NA_3 0 7.5244519323275991e+00
*
* Real pole n. 15
CS_15 NS_15 0 1.0000000000000001e-09
RS_15 NS_15 0 3.2712574667710409e-01
GS_15_3 0 NS_15 NA_3 0 7.5244519323275991e+00
*
* Real pole n. 16
CS_16 NS_16 0 1.0000000000000001e-09
RS_16 NS_16 0 6.1744050867248901e-01
GS_16_3 0 NS_16 NA_3 0 7.5244519323275991e+00
*
* Real pole n. 17
CS_17 NS_17 0 1.0000000000000001e-09
RS_17 NS_17 0 1.1579863532076049e+01
GS_17_3 0 NS_17 NA_3 0 7.5244519323275991e+00
*
* Real pole n. 18
CS_18 NS_18 0 1.0000000000000001e-09
RS_18 NS_18 0 1.5362958698707145e+00
GS_18_3 0 NS_18 NA_3 0 7.5244519323275991e+00
*
* Real pole n. 19
CS_19 NS_19 0 1.0000000000000001e-09
RS_19 NS_19 0 5.4399432312366956e-02
GS_19_4 0 NS_19 NA_4 0 7.5244519323275991e+00
*
* Real pole n. 20
CS_20 NS_20 0 1.0000000000000001e-09
RS_20 NS_20 0 1.9024914358812270e-01
GS_20_4 0 NS_20 NA_4 0 7.5244519323275991e+00
*
* Real pole n. 21
CS_21 NS_21 0 1.0000000000000001e-09
RS_21 NS_21 0 3.2712574667710409e-01
GS_21_4 0 NS_21 NA_4 0 7.5244519323275991e+00
*
* Real pole n. 22
CS_22 NS_22 0 1.0000000000000001e-09
RS_22 NS_22 0 6.1744050867248901e-01
GS_22_4 0 NS_22 NA_4 0 7.5244519323275991e+00
*
* Real pole n. 23
CS_23 NS_23 0 1.0000000000000001e-09
RS_23 NS_23 0 1.1579863532076049e+01
GS_23_4 0 NS_23 NA_4 0 7.5244519323275991e+00
*
* Real pole n. 24
CS_24 NS_24 0 1.0000000000000001e-09
RS_24 NS_24 0 1.5362958698707145e+00
GS_24_4 0 NS_24 NA_4 0 7.5244519323275991e+00
*
* Real pole n. 25
CS_25 NS_25 0 1.0000000000000001e-09
RS_25 NS_25 0 5.4399432312366956e-02
GS_25_5 0 NS_25 NA_5 0 7.5244519323275991e+00
*
* Real pole n. 26
CS_26 NS_26 0 1.0000000000000001e-09
RS_26 NS_26 0 1.9024914358812270e-01
GS_26_5 0 NS_26 NA_5 0 7.5244519323275991e+00
*
* Real pole n. 27
CS_27 NS_27 0 1.0000000000000001e-09
RS_27 NS_27 0 3.2712574667710409e-01
GS_27_5 0 NS_27 NA_5 0 7.5244519323275991e+00
*
* Real pole n. 28
CS_28 NS_28 0 1.0000000000000001e-09
RS_28 NS_28 0 6.1744050867248901e-01
GS_28_5 0 NS_28 NA_5 0 7.5244519323275991e+00
*
* Real pole n. 29
CS_29 NS_29 0 1.0000000000000001e-09
RS_29 NS_29 0 1.1579863532076049e+01
GS_29_5 0 NS_29 NA_5 0 7.5244519323275991e+00
*
* Real pole n. 30
CS_30 NS_30 0 1.0000000000000001e-09
RS_30 NS_30 0 1.5362958698707145e+00
GS_30_5 0 NS_30 NA_5 0 7.5244519323275991e+00
*
* Real pole n. 31
CS_31 NS_31 0 1.0000000000000001e-09
RS_31 NS_31 0 5.4399432312366956e-02
GS_31_6 0 NS_31 NA_6 0 7.5244519323275991e+00
*
* Real pole n. 32
CS_32 NS_32 0 1.0000000000000001e-09
RS_32 NS_32 0 1.9024914358812270e-01
GS_32_6 0 NS_32 NA_6 0 7.5244519323275991e+00
*
* Real pole n. 33
CS_33 NS_33 0 1.0000000000000001e-09
RS_33 NS_33 0 3.2712574667710409e-01
GS_33_6 0 NS_33 NA_6 0 7.5244519323275991e+00
*
* Real pole n. 34
CS_34 NS_34 0 1.0000000000000001e-09
RS_34 NS_34 0 6.1744050867248901e-01
GS_34_6 0 NS_34 NA_6 0 7.5244519323275991e+00
*
* Real pole n. 35
CS_35 NS_35 0 1.0000000000000001e-09
RS_35 NS_35 0 1.1579863532076049e+01
GS_35_6 0 NS_35 NA_6 0 7.5244519323275991e+00
*
* Real pole n. 36
CS_36 NS_36 0 1.0000000000000001e-09
RS_36 NS_36 0 1.5362958698707145e+00
GS_36_6 0 NS_36 NA_6 0 7.5244519323275991e+00
*
* Real pole n. 37
CS_37 NS_37 0 1.0000000000000001e-09
RS_37 NS_37 0 5.4399432312366956e-02
GS_37_7 0 NS_37 NA_7 0 7.5244519323275991e+00
*
* Real pole n. 38
CS_38 NS_38 0 1.0000000000000001e-09
RS_38 NS_38 0 1.9024914358812270e-01
GS_38_7 0 NS_38 NA_7 0 7.5244519323275991e+00
*
* Real pole n. 39
CS_39 NS_39 0 1.0000000000000001e-09
RS_39 NS_39 0 3.2712574667710409e-01
GS_39_7 0 NS_39 NA_7 0 7.5244519323275991e+00
*
* Real pole n. 40
CS_40 NS_40 0 1.0000000000000001e-09
RS_40 NS_40 0 6.1744050867248901e-01
GS_40_7 0 NS_40 NA_7 0 7.5244519323275991e+00
*
* Real pole n. 41
CS_41 NS_41 0 1.0000000000000001e-09
RS_41 NS_41 0 1.1579863532076049e+01
GS_41_7 0 NS_41 NA_7 0 7.5244519323275991e+00
*
* Real pole n. 42
CS_42 NS_42 0 1.0000000000000001e-09
RS_42 NS_42 0 1.5362958698707145e+00
GS_42_7 0 NS_42 NA_7 0 7.5244519323275991e+00
*
* Real pole n. 43
CS_43 NS_43 0 1.0000000000000001e-09
RS_43 NS_43 0 5.4399432312366956e-02
GS_43_8 0 NS_43 NA_8 0 7.5244519323275991e+00
*
* Real pole n. 44
CS_44 NS_44 0 1.0000000000000001e-09
RS_44 NS_44 0 1.9024914358812270e-01
GS_44_8 0 NS_44 NA_8 0 7.5244519323275991e+00
*
* Real pole n. 45
CS_45 NS_45 0 1.0000000000000001e-09
RS_45 NS_45 0 3.2712574667710409e-01
GS_45_8 0 NS_45 NA_8 0 7.5244519323275991e+00
*
* Real pole n. 46
CS_46 NS_46 0 1.0000000000000001e-09
RS_46 NS_46 0 6.1744050867248901e-01
GS_46_8 0 NS_46 NA_8 0 7.5244519323275991e+00
*
* Real pole n. 47
CS_47 NS_47 0 1.0000000000000001e-09
RS_47 NS_47 0 1.1579863532076049e+01
GS_47_8 0 NS_47 NA_8 0 7.5244519323275991e+00
*
* Real pole n. 48
CS_48 NS_48 0 1.0000000000000001e-09
RS_48 NS_48 0 1.5362958698707145e+00
GS_48_8 0 NS_48 NA_8 0 7.5244519323275991e+00
*
* Real pole n. 49
CS_49 NS_49 0 1.0000000000000001e-09
RS_49 NS_49 0 5.4399432312366956e-02
GS_49_9 0 NS_49 NA_9 0 7.5244519323275991e+00
*
* Real pole n. 50
CS_50 NS_50 0 1.0000000000000001e-09
RS_50 NS_50 0 1.9024914358812270e-01
GS_50_9 0 NS_50 NA_9 0 7.5244519323275991e+00
*
* Real pole n. 51
CS_51 NS_51 0 1.0000000000000001e-09
RS_51 NS_51 0 3.2712574667710409e-01
GS_51_9 0 NS_51 NA_9 0 7.5244519323275991e+00
*
* Real pole n. 52
CS_52 NS_52 0 1.0000000000000001e-09
RS_52 NS_52 0 6.1744050867248901e-01
GS_52_9 0 NS_52 NA_9 0 7.5244519323275991e+00
*
* Real pole n. 53
CS_53 NS_53 0 1.0000000000000001e-09
RS_53 NS_53 0 1.1579863532076049e+01
GS_53_9 0 NS_53 NA_9 0 7.5244519323275991e+00
*
* Real pole n. 54
CS_54 NS_54 0 1.0000000000000001e-09
RS_54 NS_54 0 1.5362958698707145e+00
GS_54_9 0 NS_54 NA_9 0 7.5244519323275991e+00
*
* Real pole n. 55
CS_55 NS_55 0 1.0000000000000001e-09
RS_55 NS_55 0 5.4399432312366956e-02
GS_55_10 0 NS_55 NA_10 0 7.5244519323275991e+00
*
* Real pole n. 56
CS_56 NS_56 0 1.0000000000000001e-09
RS_56 NS_56 0 1.9024914358812270e-01
GS_56_10 0 NS_56 NA_10 0 7.5244519323275991e+00
*
* Real pole n. 57
CS_57 NS_57 0 1.0000000000000001e-09
RS_57 NS_57 0 3.2712574667710409e-01
GS_57_10 0 NS_57 NA_10 0 7.5244519323275991e+00
*
* Real pole n. 58
CS_58 NS_58 0 1.0000000000000001e-09
RS_58 NS_58 0 6.1744050867248901e-01
GS_58_10 0 NS_58 NA_10 0 7.5244519323275991e+00
*
* Real pole n. 59
CS_59 NS_59 0 1.0000000000000001e-09
RS_59 NS_59 0 1.1579863532076049e+01
GS_59_10 0 NS_59 NA_10 0 7.5244519323275991e+00
*
* Real pole n. 60
CS_60 NS_60 0 1.0000000000000001e-09
RS_60 NS_60 0 1.5362958698707145e+00
GS_60_10 0 NS_60 NA_10 0 7.5244519323275991e+00
*
* Real pole n. 61
CS_61 NS_61 0 1.0000000000000001e-09
RS_61 NS_61 0 5.4399432312366956e-02
GS_61_11 0 NS_61 NA_11 0 7.5244519323275991e+00
*
* Real pole n. 62
CS_62 NS_62 0 1.0000000000000001e-09
RS_62 NS_62 0 1.9024914358812270e-01
GS_62_11 0 NS_62 NA_11 0 7.5244519323275991e+00
*
* Real pole n. 63
CS_63 NS_63 0 1.0000000000000001e-09
RS_63 NS_63 0 3.2712574667710409e-01
GS_63_11 0 NS_63 NA_11 0 7.5244519323275991e+00
*
* Real pole n. 64
CS_64 NS_64 0 1.0000000000000001e-09
RS_64 NS_64 0 6.1744050867248901e-01
GS_64_11 0 NS_64 NA_11 0 7.5244519323275991e+00
*
* Real pole n. 65
CS_65 NS_65 0 1.0000000000000001e-09
RS_65 NS_65 0 1.1579863532076049e+01
GS_65_11 0 NS_65 NA_11 0 7.5244519323275991e+00
*
* Real pole n. 66
CS_66 NS_66 0 1.0000000000000001e-09
RS_66 NS_66 0 1.5362958698707145e+00
GS_66_11 0 NS_66 NA_11 0 7.5244519323275991e+00
*
* Real pole n. 67
CS_67 NS_67 0 1.0000000000000001e-09
RS_67 NS_67 0 5.4399432312366956e-02
GS_67_12 0 NS_67 NA_12 0 7.5244519323275991e+00
*
* Real pole n. 68
CS_68 NS_68 0 1.0000000000000001e-09
RS_68 NS_68 0 1.9024914358812270e-01
GS_68_12 0 NS_68 NA_12 0 7.5244519323275991e+00
*
* Real pole n. 69
CS_69 NS_69 0 1.0000000000000001e-09
RS_69 NS_69 0 3.2712574667710409e-01
GS_69_12 0 NS_69 NA_12 0 7.5244519323275991e+00
*
* Real pole n. 70
CS_70 NS_70 0 1.0000000000000001e-09
RS_70 NS_70 0 6.1744050867248901e-01
GS_70_12 0 NS_70 NA_12 0 7.5244519323275991e+00
*
* Real pole n. 71
CS_71 NS_71 0 1.0000000000000001e-09
RS_71 NS_71 0 1.1579863532076049e+01
GS_71_12 0 NS_71 NA_12 0 7.5244519323275991e+00
*
* Real pole n. 72
CS_72 NS_72 0 1.0000000000000001e-09
RS_72 NS_72 0 1.5362958698707145e+00
GS_72_12 0 NS_72 NA_12 0 7.5244519323275991e+00
*
* Real pole n. 73
CS_73 NS_73 0 1.0000000000000001e-09
RS_73 NS_73 0 5.4399432312366956e-02
GS_73_13 0 NS_73 NA_13 0 7.5244519323275991e+00
*
* Real pole n. 74
CS_74 NS_74 0 1.0000000000000001e-09
RS_74 NS_74 0 1.9024914358812270e-01
GS_74_13 0 NS_74 NA_13 0 7.5244519323275991e+00
*
* Real pole n. 75
CS_75 NS_75 0 1.0000000000000001e-09
RS_75 NS_75 0 3.2712574667710409e-01
GS_75_13 0 NS_75 NA_13 0 7.5244519323275991e+00
*
* Real pole n. 76
CS_76 NS_76 0 1.0000000000000001e-09
RS_76 NS_76 0 6.1744050867248901e-01
GS_76_13 0 NS_76 NA_13 0 7.5244519323275991e+00
*
* Real pole n. 77
CS_77 NS_77 0 1.0000000000000001e-09
RS_77 NS_77 0 1.1579863532076049e+01
GS_77_13 0 NS_77 NA_13 0 7.5244519323275991e+00
*
* Real pole n. 78
CS_78 NS_78 0 1.0000000000000001e-09
RS_78 NS_78 0 1.5362958698707145e+00
GS_78_13 0 NS_78 NA_13 0 7.5244519323275991e+00
*
* Real pole n. 79
CS_79 NS_79 0 1.0000000000000001e-09
RS_79 NS_79 0 5.4399432312366956e-02
GS_79_14 0 NS_79 NA_14 0 7.5244519323275991e+00
*
* Real pole n. 80
CS_80 NS_80 0 1.0000000000000001e-09
RS_80 NS_80 0 1.9024914358812270e-01
GS_80_14 0 NS_80 NA_14 0 7.5244519323275991e+00
*
* Real pole n. 81
CS_81 NS_81 0 1.0000000000000001e-09
RS_81 NS_81 0 3.2712574667710409e-01
GS_81_14 0 NS_81 NA_14 0 7.5244519323275991e+00
*
* Real pole n. 82
CS_82 NS_82 0 1.0000000000000001e-09
RS_82 NS_82 0 6.1744050867248901e-01
GS_82_14 0 NS_82 NA_14 0 7.5244519323275991e+00
*
* Real pole n. 83
CS_83 NS_83 0 1.0000000000000001e-09
RS_83 NS_83 0 1.1579863532076049e+01
GS_83_14 0 NS_83 NA_14 0 7.5244519323275991e+00
*
* Real pole n. 84
CS_84 NS_84 0 1.0000000000000001e-09
RS_84 NS_84 0 1.5362958698707145e+00
GS_84_14 0 NS_84 NA_14 0 7.5244519323275991e+00
*
* Real pole n. 85
CS_85 NS_85 0 1.0000000000000001e-09
RS_85 NS_85 0 5.4399432312366956e-02
GS_85_15 0 NS_85 NA_15 0 7.5244519323275991e+00
*
* Real pole n. 86
CS_86 NS_86 0 1.0000000000000001e-09
RS_86 NS_86 0 1.9024914358812270e-01
GS_86_15 0 NS_86 NA_15 0 7.5244519323275991e+00
*
* Real pole n. 87
CS_87 NS_87 0 1.0000000000000001e-09
RS_87 NS_87 0 3.2712574667710409e-01
GS_87_15 0 NS_87 NA_15 0 7.5244519323275991e+00
*
* Real pole n. 88
CS_88 NS_88 0 1.0000000000000001e-09
RS_88 NS_88 0 6.1744050867248901e-01
GS_88_15 0 NS_88 NA_15 0 7.5244519323275991e+00
*
* Real pole n. 89
CS_89 NS_89 0 1.0000000000000001e-09
RS_89 NS_89 0 1.1579863532076049e+01
GS_89_15 0 NS_89 NA_15 0 7.5244519323275991e+00
*
* Real pole n. 90
CS_90 NS_90 0 1.0000000000000001e-09
RS_90 NS_90 0 1.5362958698707145e+00
GS_90_15 0 NS_90 NA_15 0 7.5244519323275991e+00
*
* Real pole n. 91
CS_91 NS_91 0 1.0000000000000001e-09
RS_91 NS_91 0 5.4399432312366956e-02
GS_91_16 0 NS_91 NA_16 0 7.5244519323275991e+00
*
* Real pole n. 92
CS_92 NS_92 0 1.0000000000000001e-09
RS_92 NS_92 0 1.9024914358812270e-01
GS_92_16 0 NS_92 NA_16 0 7.5244519323275991e+00
*
* Real pole n. 93
CS_93 NS_93 0 1.0000000000000001e-09
RS_93 NS_93 0 3.2712574667710409e-01
GS_93_16 0 NS_93 NA_16 0 7.5244519323275991e+00
*
* Real pole n. 94
CS_94 NS_94 0 1.0000000000000001e-09
RS_94 NS_94 0 6.1744050867248901e-01
GS_94_16 0 NS_94 NA_16 0 7.5244519323275991e+00
*
* Real pole n. 95
CS_95 NS_95 0 1.0000000000000001e-09
RS_95 NS_95 0 1.1579863532076049e+01
GS_95_16 0 NS_95 NA_16 0 7.5244519323275991e+00
*
* Real pole n. 96
CS_96 NS_96 0 1.0000000000000001e-09
RS_96 NS_96 0 1.5362958698707145e+00
GS_96_16 0 NS_96 NA_16 0 7.5244519323275991e+00
*
* Real pole n. 97
CS_97 NS_97 0 1.0000000000000001e-09
RS_97 NS_97 0 5.4399432312366956e-02
GS_97_17 0 NS_97 NA_17 0 7.5244519323275991e+00
*
* Real pole n. 98
CS_98 NS_98 0 1.0000000000000001e-09
RS_98 NS_98 0 1.9024914358812270e-01
GS_98_17 0 NS_98 NA_17 0 7.5244519323275991e+00
*
* Real pole n. 99
CS_99 NS_99 0 1.0000000000000001e-09
RS_99 NS_99 0 3.2712574667710409e-01
GS_99_17 0 NS_99 NA_17 0 7.5244519323275991e+00
*
* Real pole n. 100
CS_100 NS_100 0 1.0000000000000001e-09
RS_100 NS_100 0 6.1744050867248901e-01
GS_100_17 0 NS_100 NA_17 0 7.5244519323275991e+00
*
* Real pole n. 101
CS_101 NS_101 0 1.0000000000000001e-09
RS_101 NS_101 0 1.1579863532076049e+01
GS_101_17 0 NS_101 NA_17 0 7.5244519323275991e+00
*
* Real pole n. 102
CS_102 NS_102 0 1.0000000000000001e-09
RS_102 NS_102 0 1.5362958698707145e+00
GS_102_17 0 NS_102 NA_17 0 7.5244519323275991e+00
*
* Real pole n. 103
CS_103 NS_103 0 1.0000000000000001e-09
RS_103 NS_103 0 5.4399432312366956e-02
GS_103_18 0 NS_103 NA_18 0 7.5244519323275991e+00
*
* Real pole n. 104
CS_104 NS_104 0 1.0000000000000001e-09
RS_104 NS_104 0 1.9024914358812270e-01
GS_104_18 0 NS_104 NA_18 0 7.5244519323275991e+00
*
* Real pole n. 105
CS_105 NS_105 0 1.0000000000000001e-09
RS_105 NS_105 0 3.2712574667710409e-01
GS_105_18 0 NS_105 NA_18 0 7.5244519323275991e+00
*
* Real pole n. 106
CS_106 NS_106 0 1.0000000000000001e-09
RS_106 NS_106 0 6.1744050867248901e-01
GS_106_18 0 NS_106 NA_18 0 7.5244519323275991e+00
*
* Real pole n. 107
CS_107 NS_107 0 1.0000000000000001e-09
RS_107 NS_107 0 1.1579863532076049e+01
GS_107_18 0 NS_107 NA_18 0 7.5244519323275991e+00
*
* Real pole n. 108
CS_108 NS_108 0 1.0000000000000001e-09
RS_108 NS_108 0 1.5362958698707145e+00
GS_108_18 0 NS_108 NA_18 0 7.5244519323275991e+00
*
* Real pole n. 109
CS_109 NS_109 0 1.0000000000000001e-09
RS_109 NS_109 0 5.4399432312366956e-02
GS_109_19 0 NS_109 NA_19 0 7.5244519323275991e+00
*
* Real pole n. 110
CS_110 NS_110 0 1.0000000000000001e-09
RS_110 NS_110 0 1.9024914358812270e-01
GS_110_19 0 NS_110 NA_19 0 7.5244519323275991e+00
*
* Real pole n. 111
CS_111 NS_111 0 1.0000000000000001e-09
RS_111 NS_111 0 3.2712574667710409e-01
GS_111_19 0 NS_111 NA_19 0 7.5244519323275991e+00
*
* Real pole n. 112
CS_112 NS_112 0 1.0000000000000001e-09
RS_112 NS_112 0 6.1744050867248901e-01
GS_112_19 0 NS_112 NA_19 0 7.5244519323275991e+00
*
* Real pole n. 113
CS_113 NS_113 0 1.0000000000000001e-09
RS_113 NS_113 0 1.1579863532076049e+01
GS_113_19 0 NS_113 NA_19 0 7.5244519323275991e+00
*
* Real pole n. 114
CS_114 NS_114 0 1.0000000000000001e-09
RS_114 NS_114 0 1.5362958698707145e+00
GS_114_19 0 NS_114 NA_19 0 7.5244519323275991e+00
*
* Real pole n. 115
CS_115 NS_115 0 1.0000000000000001e-09
RS_115 NS_115 0 5.4399432312366956e-02
GS_115_20 0 NS_115 NA_20 0 7.5244519323275991e+00
*
* Real pole n. 116
CS_116 NS_116 0 1.0000000000000001e-09
RS_116 NS_116 0 1.9024914358812270e-01
GS_116_20 0 NS_116 NA_20 0 7.5244519323275991e+00
*
* Real pole n. 117
CS_117 NS_117 0 1.0000000000000001e-09
RS_117 NS_117 0 3.2712574667710409e-01
GS_117_20 0 NS_117 NA_20 0 7.5244519323275991e+00
*
* Real pole n. 118
CS_118 NS_118 0 1.0000000000000001e-09
RS_118 NS_118 0 6.1744050867248901e-01
GS_118_20 0 NS_118 NA_20 0 7.5244519323275991e+00
*
* Real pole n. 119
CS_119 NS_119 0 1.0000000000000001e-09
RS_119 NS_119 0 1.1579863532076049e+01
GS_119_20 0 NS_119 NA_20 0 7.5244519323275991e+00
*
* Real pole n. 120
CS_120 NS_120 0 1.0000000000000001e-09
RS_120 NS_120 0 1.5362958698707145e+00
GS_120_20 0 NS_120 NA_20 0 7.5244519323275991e+00
*
* Real pole n. 121
CS_121 NS_121 0 1.0000000000000001e-09
RS_121 NS_121 0 5.4399432312366956e-02
GS_121_21 0 NS_121 NA_21 0 7.5244519323275991e+00
*
* Real pole n. 122
CS_122 NS_122 0 1.0000000000000001e-09
RS_122 NS_122 0 1.9024914358812270e-01
GS_122_21 0 NS_122 NA_21 0 7.5244519323275991e+00
*
* Real pole n. 123
CS_123 NS_123 0 1.0000000000000001e-09
RS_123 NS_123 0 3.2712574667710409e-01
GS_123_21 0 NS_123 NA_21 0 7.5244519323275991e+00
*
* Real pole n. 124
CS_124 NS_124 0 1.0000000000000001e-09
RS_124 NS_124 0 6.1744050867248901e-01
GS_124_21 0 NS_124 NA_21 0 7.5244519323275991e+00
*
* Real pole n. 125
CS_125 NS_125 0 1.0000000000000001e-09
RS_125 NS_125 0 1.1579863532076049e+01
GS_125_21 0 NS_125 NA_21 0 7.5244519323275991e+00
*
* Real pole n. 126
CS_126 NS_126 0 1.0000000000000001e-09
RS_126 NS_126 0 1.5362958698707145e+00
GS_126_21 0 NS_126 NA_21 0 7.5244519323275991e+00
*
* Real pole n. 127
CS_127 NS_127 0 1.0000000000000001e-09
RS_127 NS_127 0 5.4399432312366956e-02
GS_127_22 0 NS_127 NA_22 0 7.5244519323275991e+00
*
* Real pole n. 128
CS_128 NS_128 0 1.0000000000000001e-09
RS_128 NS_128 0 1.9024914358812270e-01
GS_128_22 0 NS_128 NA_22 0 7.5244519323275991e+00
*
* Real pole n. 129
CS_129 NS_129 0 1.0000000000000001e-09
RS_129 NS_129 0 3.2712574667710409e-01
GS_129_22 0 NS_129 NA_22 0 7.5244519323275991e+00
*
* Real pole n. 130
CS_130 NS_130 0 1.0000000000000001e-09
RS_130 NS_130 0 6.1744050867248901e-01
GS_130_22 0 NS_130 NA_22 0 7.5244519323275991e+00
*
* Real pole n. 131
CS_131 NS_131 0 1.0000000000000001e-09
RS_131 NS_131 0 1.1579863532076049e+01
GS_131_22 0 NS_131 NA_22 0 7.5244519323275991e+00
*
* Real pole n. 132
CS_132 NS_132 0 1.0000000000000001e-09
RS_132 NS_132 0 1.5362958698707145e+00
GS_132_22 0 NS_132 NA_22 0 7.5244519323275991e+00
*
* Real pole n. 133
CS_133 NS_133 0 1.0000000000000001e-09
RS_133 NS_133 0 5.4399432312366956e-02
GS_133_23 0 NS_133 NA_23 0 7.5244519323275991e+00
*
* Real pole n. 134
CS_134 NS_134 0 1.0000000000000001e-09
RS_134 NS_134 0 1.9024914358812270e-01
GS_134_23 0 NS_134 NA_23 0 7.5244519323275991e+00
*
* Real pole n. 135
CS_135 NS_135 0 1.0000000000000001e-09
RS_135 NS_135 0 3.2712574667710409e-01
GS_135_23 0 NS_135 NA_23 0 7.5244519323275991e+00
*
* Real pole n. 136
CS_136 NS_136 0 1.0000000000000001e-09
RS_136 NS_136 0 6.1744050867248901e-01
GS_136_23 0 NS_136 NA_23 0 7.5244519323275991e+00
*
* Real pole n. 137
CS_137 NS_137 0 1.0000000000000001e-09
RS_137 NS_137 0 1.1579863532076049e+01
GS_137_23 0 NS_137 NA_23 0 7.5244519323275991e+00
*
* Real pole n. 138
CS_138 NS_138 0 1.0000000000000001e-09
RS_138 NS_138 0 1.5362958698707145e+00
GS_138_23 0 NS_138 NA_23 0 7.5244519323275991e+00
*
******************************

.ends
*******************
* End of subcircuit
*******************
