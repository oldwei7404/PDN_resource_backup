**********************************************************
** STATE-SPACE REALIZATION
** IN SPICE LANGUAGE
** This file is automatically generated
**********************************************************
** Created: 18-Apr-2025 by IdEM 2023 (2023.0.0)
**********************************************************
**
**********************************************************
** COMMENTS
**********************************************************
**
**  Touchstone file exported from Ansys Full-Wave Spice
**  Project: 0001_PSI_S-parameter_Sweep
**   Design: unknown
**  Creation time: Thu Apr 17 18:21:19 2025
**  Notes: ! Touchstone(R) file created by SIwave 2025 R1
**       : ! Touchstone(R) file created on Thu Apr 17 18:21:19 2025
**
**  Modal data exported
**  Port[1] = PORT_1_DIE1_VDDCR_SOC_Group_DIE1_VSS_Group
**  Port[2] = PORT_2_BGA1_VDDCR_SOC_Group_BGA1_GRP_1_1_VSS
**  Port[3] = VDDCR_SOC_C6_1
**  Port[4] = VDDCR_SOC_C13_1
**  Port[5] = VDDCR_SOC_C28_2
**  Port[6] = VDDCR_SOC_C30_2
**  Port[7] = VDDCR_SOC_C31_2
**  Port[8] = VDDCR_SOC_C33_1
**  Port[9] = VDDCR_SOC_C77_2
**  Port[10] = VDDCR_SOC_C81_2
**  Port[11] = VDDCR_SOC_C82_2
**  Port[12] = VDDCR_SOC_C93_1
**  Port[13] = VDDCR_SOC_C94_1
**  Port[14] = VDDCR_SOC_C97_2
**  Port[15] = VDDCR_SOC_C105_2
**  Port[16] = VDDCR_SOC_C106_1
**  Port[17] = VDDCR_SOC_C122_2
**  Port[18] = VDDCR_SOC_C123_2
**  Port[19] = VDDCR_SOC_C124_2
**  Port[20] = VDDCR_SOC_C125_2
**
**********************************************************
**
**
**---------------------------
** Options Used in IdEM Flow
**---------------------------
**
** Fitting Options **
**
** Bandwidth: 1.0000e+09 Hz
** Order: [2 2 4]
** SplitType: none
** tol: 1.0000e-03
** DC Point: enforced
**
**---------------------------
**
** Passivity Options **
**
** Alg: SOC+HAM
**    Max SOC it: 200
**    Max HAM it: 50
** Freq sampling: adaptive
** DC Point: enforced
** Optimization method: Model based
**
**---------------------------
**
** Netlist Options **
**
** Netlist format: SPICE standard
** Port reference: common
** Resistor synthesis: standard
**
**---------------------------
**
**********************************************************
* NOTE:
* a_i  --> input node associated to the port i
* ref  --> reference node, common for all the input nodes
**********************************************************

***********************************
* Interface (ports specification) *
***********************************
.subckt swv_ff5_250126_master-2_072e_lp5_cut_SOC
+  a_1 a_2 a_3 a_4 a_5 a_6 a_7 a_8 a_9 a_10 a_11 a_12 a_13 a_14 a_15 a_16 a_17 a_18 a_19 a_20 ref
***********************************

******************************************
* Main circuit connected to output nodes *
******************************************

* Port 1
VI_1 a_1 NI_1 0
RI_1 NI_1 ref 1.0000000000000001e-01
GC_1_1 ref NI_1 NS_1 0 -3.9617660159608548e-01
GC_1_2 ref NI_1 NS_2 0 4.0776071596818834e-02
GC_1_3 ref NI_1 NS_3 0 -6.6079334856915181e-03
GC_1_4 ref NI_1 NS_4 0 -1.8117964117356772e-04
GC_1_5 ref NI_1 NS_5 0 2.2732988260675691e-01
GC_1_6 ref NI_1 NS_6 0 -1.5461214233121442e-01
GC_1_7 ref NI_1 NS_7 0 1.6888823639681617e-02
GC_1_8 ref NI_1 NS_8 0 -1.2167602264951559e-03
GC_1_9 ref NI_1 NS_9 0 2.7287627710402444e-02
GC_1_10 ref NI_1 NS_10 0 1.9163926202842867e-04
GC_1_11 ref NI_1 NS_11 0 -4.7681723327813123e-04
GC_1_12 ref NI_1 NS_12 0 4.7065491042353898e-05
GC_1_13 ref NI_1 NS_13 0 6.1042100634572339e-03
GC_1_14 ref NI_1 NS_14 0 2.8305605033791220e-03
GC_1_15 ref NI_1 NS_15 0 -3.4133128950425569e-04
GC_1_16 ref NI_1 NS_16 0 1.0715268353537330e-03
GC_1_17 ref NI_1 NS_17 0 3.0800531138445914e-02
GC_1_18 ref NI_1 NS_18 0 -3.7224849994240234e-03
GC_1_19 ref NI_1 NS_19 0 1.3276257016600419e-03
GC_1_20 ref NI_1 NS_20 0 -1.8068589043615882e-04
GC_1_21 ref NI_1 NS_21 0 2.1981299404187554e-02
GC_1_22 ref NI_1 NS_22 0 7.8862460081120437e-05
GC_1_23 ref NI_1 NS_23 0 1.7039960637604669e-03
GC_1_24 ref NI_1 NS_24 0 -2.1010725703311223e-04
GC_1_25 ref NI_1 NS_25 0 2.8880468072407274e-02
GC_1_26 ref NI_1 NS_26 0 -1.7613031548263944e-03
GC_1_27 ref NI_1 NS_27 0 1.3315673604697928e-03
GC_1_28 ref NI_1 NS_28 0 -2.3091858248262904e-04
GC_1_29 ref NI_1 NS_29 0 7.2511341516953848e-03
GC_1_30 ref NI_1 NS_30 0 1.3645993449794111e-03
GC_1_31 ref NI_1 NS_31 0 -4.3186544923127233e-04
GC_1_32 ref NI_1 NS_32 0 1.1146808083999607e-03
GC_1_33 ref NI_1 NS_33 0 6.2698622840529766e-02
GC_1_34 ref NI_1 NS_34 0 -6.6016933913406383e-03
GC_1_35 ref NI_1 NS_35 0 -4.0615135269193000e-03
GC_1_36 ref NI_1 NS_36 0 -1.4005687110510396e-04
GC_1_37 ref NI_1 NS_37 0 3.5300255928695561e-02
GC_1_38 ref NI_1 NS_38 0 -1.8228117597267554e-03
GC_1_39 ref NI_1 NS_39 0 6.0817511554027075e-05
GC_1_40 ref NI_1 NS_40 0 -2.2998962640539229e-04
GC_1_41 ref NI_1 NS_41 0 3.0730757341659181e-02
GC_1_42 ref NI_1 NS_42 0 3.5881357122341411e-03
GC_1_43 ref NI_1 NS_43 0 -1.6458293887038492e-03
GC_1_44 ref NI_1 NS_44 0 -2.4433226304861793e-04
GC_1_45 ref NI_1 NS_45 0 2.0890907117942843e-02
GC_1_46 ref NI_1 NS_46 0 3.3983544857924051e-03
GC_1_47 ref NI_1 NS_47 0 -1.6019195657764415e-04
GC_1_48 ref NI_1 NS_48 0 8.6855291474723163e-05
GC_1_49 ref NI_1 NS_49 0 2.3245404660625336e-02
GC_1_50 ref NI_1 NS_50 0 1.4174777491423199e-03
GC_1_51 ref NI_1 NS_51 0 1.8459854191256724e-04
GC_1_52 ref NI_1 NS_52 0 8.1164679469716085e-05
GC_1_53 ref NI_1 NS_53 0 2.2072605066998818e-02
GC_1_54 ref NI_1 NS_54 0 -1.8225559884731157e-04
GC_1_55 ref NI_1 NS_55 0 1.0757152549684497e-03
GC_1_56 ref NI_1 NS_56 0 4.1689468599485339e-05
GC_1_57 ref NI_1 NS_57 0 1.4052730017768566e-02
GC_1_58 ref NI_1 NS_58 0 2.9922609656346092e-03
GC_1_59 ref NI_1 NS_59 0 1.5245471530881541e-03
GC_1_60 ref NI_1 NS_60 0 7.4624003195806584e-05
GC_1_61 ref NI_1 NS_61 0 2.3496495310911098e-02
GC_1_62 ref NI_1 NS_62 0 1.2198848176114857e-03
GC_1_63 ref NI_1 NS_63 0 5.1107714980156414e-04
GC_1_64 ref NI_1 NS_64 0 2.9289500522751877e-05
GC_1_65 ref NI_1 NS_65 0 2.4807954334637439e-02
GC_1_66 ref NI_1 NS_66 0 -8.8507144653279508e-04
GC_1_67 ref NI_1 NS_67 0 1.2697124262079061e-03
GC_1_68 ref NI_1 NS_68 0 -1.6394322121647515e-04
GC_1_69 ref NI_1 NS_69 0 3.5961080685743697e-02
GC_1_70 ref NI_1 NS_70 0 -6.2526962775592502e-03
GC_1_71 ref NI_1 NS_71 0 1.1155879142957868e-03
GC_1_72 ref NI_1 NS_72 0 -1.6280087325802077e-04
GC_1_73 ref NI_1 NS_73 0 2.0475770023240313e-02
GC_1_74 ref NI_1 NS_74 0 1.5573454271627144e-03
GC_1_75 ref NI_1 NS_75 0 1.3998233954364879e-03
GC_1_76 ref NI_1 NS_76 0 -1.6637999277238147e-04
GC_1_77 ref NI_1 NS_77 0 2.5524436448400429e-02
GC_1_78 ref NI_1 NS_78 0 -9.2906509412785316e-04
GC_1_79 ref NI_1 NS_79 0 1.2783534900430425e-03
GC_1_80 ref NI_1 NS_80 0 -1.5407700615389434e-04
GD_1_1 ref NI_1 NA_1 0 2.1070043860771159e+00
GD_1_2 ref NI_1 NA_2 0 1.5675353216122454e+00
GD_1_3 ref NI_1 NA_3 0 4.3928129886789624e-02
GD_1_4 ref NI_1 NA_4 0 -3.4488869281654573e-02
GD_1_5 ref NI_1 NA_5 0 4.0173190804192627e-02
GD_1_6 ref NI_1 NA_6 0 2.2329182178810587e-02
GD_1_7 ref NI_1 NA_7 0 5.7013902225522967e-03
GD_1_8 ref NI_1 NA_8 0 9.8571430503154186e-04
GD_1_9 ref NI_1 NA_9 0 4.9398576824016285e-02
GD_1_10 ref NI_1 NA_10 0 8.5874757076427524e-03
GD_1_11 ref NI_1 NA_11 0 4.3114215844157588e-02
GD_1_12 ref NI_1 NA_12 0 -2.3047551997525784e-02
GD_1_13 ref NI_1 NA_13 0 -1.5114423816284556e-02
GD_1_14 ref NI_1 NA_14 0 5.7229644714015164e-03
GD_1_15 ref NI_1 NA_15 0 -2.8110177726122915e-02
GD_1_16 ref NI_1 NA_16 0 -2.5506378562726521e-02
GD_1_17 ref NI_1 NA_17 0 3.7919424646374648e-02
GD_1_18 ref NI_1 NA_18 0 6.4247522435355156e-02
GD_1_19 ref NI_1 NA_19 0 1.2428270969131472e-03
GD_1_20 ref NI_1 NA_20 0 1.8470933065044430e-02
*
* Port 2
VI_2 a_2 NI_2 0
RI_2 NI_2 ref 1.0000000000000001e-01
GC_2_1 ref NI_2 NS_1 0 2.2732988260675649e-01
GC_2_2 ref NI_2 NS_2 0 -1.5461214233121404e-01
GC_2_3 ref NI_2 NS_3 0 1.6888823639681458e-02
GC_2_4 ref NI_2 NS_4 0 -1.2167602264951368e-03
GC_2_5 ref NI_2 NS_5 0 -1.1284508383813413e-01
GC_2_6 ref NI_2 NS_6 0 -1.7771133263149277e-01
GC_2_7 ref NI_2 NS_7 0 1.3814312870201512e-02
GC_2_8 ref NI_2 NS_8 0 -1.8196976024345201e-03
GC_2_9 ref NI_2 NS_9 0 8.1946631051656865e-03
GC_2_10 ref NI_2 NS_10 0 1.6528371516125691e-02
GC_2_11 ref NI_2 NS_11 0 -1.6475623873204049e-03
GC_2_12 ref NI_2 NS_12 0 -4.4172769641341425e-05
GC_2_13 ref NI_2 NS_13 0 1.2391740995361835e-02
GC_2_14 ref NI_2 NS_14 0 2.4133822432850895e-03
GC_2_15 ref NI_2 NS_15 0 3.5455424002424780e-04
GC_2_16 ref NI_2 NS_16 0 6.9224552564775370e-04
GC_2_17 ref NI_2 NS_17 0 1.0815437288206987e-02
GC_2_18 ref NI_2 NS_18 0 9.8034476752421797e-03
GC_2_19 ref NI_2 NS_19 0 1.9032477733718715e-04
GC_2_20 ref NI_2 NS_20 0 1.4476510149550597e-04
GC_2_21 ref NI_2 NS_21 0 3.5857438191901807e-03
GC_2_22 ref NI_2 NS_22 0 1.0941513148369469e-02
GC_2_23 ref NI_2 NS_23 0 1.0414960181158014e-03
GC_2_24 ref NI_2 NS_24 0 6.7969366133977817e-05
GC_2_25 ref NI_2 NS_25 0 9.9257808914278919e-03
GC_2_26 ref NI_2 NS_26 0 1.0930820596768536e-02
GC_2_27 ref NI_2 NS_27 0 1.8376176542888629e-04
GC_2_28 ref NI_2 NS_28 0 5.2519150054682665e-05
GC_2_29 ref NI_2 NS_29 0 6.4717037412899822e-03
GC_2_30 ref NI_2 NS_30 0 4.0093724408049496e-03
GC_2_31 ref NI_2 NS_31 0 4.7301445856162369e-04
GC_2_32 ref NI_2 NS_32 0 7.5550556401404788e-04
GC_2_33 ref NI_2 NS_33 0 3.5397600224328619e-02
GC_2_34 ref NI_2 NS_34 0 2.1222989314372231e-02
GC_2_35 ref NI_2 NS_35 0 -8.0766523121571475e-03
GC_2_36 ref NI_2 NS_36 0 1.1956288887657145e-04
GC_2_37 ref NI_2 NS_37 0 1.3866286769338263e-02
GC_2_38 ref NI_2 NS_38 0 1.4152647096997770e-02
GC_2_39 ref NI_2 NS_39 0 -1.6235257157520835e-03
GC_2_40 ref NI_2 NS_40 0 3.9161762226263281e-05
GC_2_41 ref NI_2 NS_41 0 4.8822471696421399e-03
GC_2_42 ref NI_2 NS_42 0 2.1700206332533438e-02
GC_2_43 ref NI_2 NS_43 0 -3.1208018989529805e-03
GC_2_44 ref NI_2 NS_44 0 -2.9176326894002830e-05
GC_2_45 ref NI_2 NS_45 0 1.5045715079444516e-02
GC_2_46 ref NI_2 NS_46 0 1.2496351178937867e-02
GC_2_47 ref NI_2 NS_47 0 -1.2154106851102991e-03
GC_2_48 ref NI_2 NS_48 0 -7.4606075806837014e-05
GC_2_49 ref NI_2 NS_49 0 1.8643367013038564e-02
GC_2_50 ref NI_2 NS_50 0 1.1142246964277722e-02
GC_2_51 ref NI_2 NS_51 0 -1.2390393939128023e-03
GC_2_52 ref NI_2 NS_52 0 -6.8247452797139680e-05
GC_2_53 ref NI_2 NS_53 0 9.1746116426501510e-03
GC_2_54 ref NI_2 NS_54 0 1.2592484234849164e-02
GC_2_55 ref NI_2 NS_55 0 -1.3674938162457762e-04
GC_2_56 ref NI_2 NS_56 0 -1.0211672166455922e-04
GC_2_57 ref NI_2 NS_57 0 9.1041555182570823e-03
GC_2_58 ref NI_2 NS_58 0 1.0253529241282493e-02
GC_2_59 ref NI_2 NS_59 0 7.8149322092152930e-04
GC_2_60 ref NI_2 NS_60 0 -1.2695829024515919e-04
GC_2_61 ref NI_2 NS_61 0 1.5645045847924883e-02
GC_2_62 ref NI_2 NS_62 0 1.2393230833014047e-02
GC_2_63 ref NI_2 NS_63 0 -1.1490298668933581e-03
GC_2_64 ref NI_2 NS_64 0 -1.0230887407810761e-04
GC_2_65 ref NI_2 NS_65 0 4.7249550526693562e-03
GC_2_66 ref NI_2 NS_66 0 1.1274453946886242e-02
GC_2_67 ref NI_2 NS_67 0 4.3557723544805421e-04
GC_2_68 ref NI_2 NS_68 0 1.5416182726153850e-04
GC_2_69 ref NI_2 NS_69 0 1.4558612967700193e-02
GC_2_70 ref NI_2 NS_70 0 9.6202173048610170e-03
GC_2_71 ref NI_2 NS_71 0 -4.8167311486819195e-04
GC_2_72 ref NI_2 NS_72 0 1.9129804866779916e-04
GC_2_73 ref NI_2 NS_73 0 2.3931977131267778e-03
GC_2_74 ref NI_2 NS_74 0 1.0896258676897254e-02
GC_2_75 ref NI_2 NS_75 0 1.0690557431168770e-03
GC_2_76 ref NI_2 NS_76 0 1.2809304778945877e-04
GC_2_77 ref NI_2 NS_77 0 6.8217285204043229e-03
GC_2_78 ref NI_2 NS_78 0 1.0238220629848803e-02
GC_2_79 ref NI_2 NS_79 0 5.8329927628138841e-04
GC_2_80 ref NI_2 NS_80 0 1.5808726873139681e-04
GD_2_1 ref NI_2 NA_1 0 1.5675353216122461e+00
GD_2_2 ref NI_2 NA_2 0 4.6235533474406640e+00
GD_2_3 ref NI_2 NA_3 0 -1.5086991998440083e-01
GD_2_4 ref NI_2 NA_4 0 -8.6141665172653731e-02
GD_2_5 ref NI_2 NA_5 0 -1.6095592796106586e-01
GD_2_6 ref NI_2 NA_6 0 -1.2063202910628848e-01
GD_2_7 ref NI_2 NA_7 0 -1.6094907825298524e-01
GD_2_8 ref NI_2 NA_8 0 -6.9846834196939114e-02
GD_2_9 ref NI_2 NA_9 0 -3.3274040102333113e-01
GD_2_10 ref NI_2 NA_10 0 -1.9572297682691150e-01
GD_2_11 ref NI_2 NA_11 0 -1.6802929370865707e-01
GD_2_12 ref NI_2 NA_12 0 -1.5058928154930429e-01
GD_2_13 ref NI_2 NA_13 0 -1.6478736593179344e-01
GD_2_14 ref NI_2 NA_14 0 -1.3161625957332709e-01
GD_2_15 ref NI_2 NA_15 0 -1.0830089809736908e-01
GD_2_16 ref NI_2 NA_16 0 -1.5462706622743563e-01
GD_2_17 ref NI_2 NA_17 0 -1.2601415973134156e-01
GD_2_18 ref NI_2 NA_18 0 -1.7805371858609487e-01
GD_2_19 ref NI_2 NA_19 0 -1.1839062106996963e-01
GD_2_20 ref NI_2 NA_20 0 -1.4174393374458732e-01
*
* Port 3
VI_3 a_3 NI_3 0
RI_3 NI_3 ref 1.0000000000000001e-01
GC_3_1 ref NI_3 NS_1 0 2.7287627710402128e-02
GC_3_2 ref NI_3 NS_2 0 1.9163926202873599e-04
GC_3_3 ref NI_3 NS_3 0 -4.7681723327827093e-04
GC_3_4 ref NI_3 NS_4 0 4.7065491042376537e-05
GC_3_5 ref NI_3 NS_5 0 8.1946631051659728e-03
GC_3_6 ref NI_3 NS_6 0 1.6528371516125556e-02
GC_3_7 ref NI_3 NS_7 0 -1.6475623873203895e-03
GC_3_8 ref NI_3 NS_8 0 -4.4172769641330949e-05
GC_3_9 ref NI_3 NS_9 0 3.4672400069724392e-02
GC_3_10 ref NI_3 NS_10 0 -9.8283271522358592e-02
GC_3_11 ref NI_3 NS_11 0 -5.6797365552508042e-02
GC_3_12 ref NI_3 NS_12 0 -3.2642052044915249e-03
GC_3_13 ref NI_3 NS_13 0 3.4397259272921530e-03
GC_3_14 ref NI_3 NS_14 0 -5.6723535613342584e-03
GC_3_15 ref NI_3 NS_15 0 5.7609531707274574e-03
GC_3_16 ref NI_3 NS_16 0 4.6164370812149652e-04
GC_3_17 ref NI_3 NS_17 0 1.5168691226590146e-03
GC_3_18 ref NI_3 NS_18 0 -3.9134389996755463e-03
GC_3_19 ref NI_3 NS_19 0 3.1372407020997589e-03
GC_3_20 ref NI_3 NS_20 0 1.1788287649727644e-03
GC_3_21 ref NI_3 NS_21 0 3.5356119909877989e-03
GC_3_22 ref NI_3 NS_22 0 -6.1006623088120165e-03
GC_3_23 ref NI_3 NS_23 0 3.7432300714135731e-03
GC_3_24 ref NI_3 NS_24 0 1.1694440777703726e-03
GC_3_25 ref NI_3 NS_25 0 3.0948090937715691e-03
GC_3_26 ref NI_3 NS_26 0 -5.6371240394201723e-03
GC_3_27 ref NI_3 NS_27 0 4.0141701465338060e-03
GC_3_28 ref NI_3 NS_28 0 1.0676775874453566e-03
GC_3_29 ref NI_3 NS_29 0 6.6045693125662205e-03
GC_3_30 ref NI_3 NS_30 0 -9.3078903439629025e-03
GC_3_31 ref NI_3 NS_31 0 6.1433384350446599e-03
GC_3_32 ref NI_3 NS_32 0 6.4366379403570746e-04
GC_3_33 ref NI_3 NS_33 0 -4.2108175524613678e-03
GC_3_34 ref NI_3 NS_34 0 2.2776004800834020e-04
GC_3_35 ref NI_3 NS_35 0 5.5686764430899960e-03
GC_3_36 ref NI_3 NS_36 0 2.8023549539201706e-04
GC_3_37 ref NI_3 NS_37 0 2.0125844021828161e-03
GC_3_38 ref NI_3 NS_38 0 -4.9505556486213655e-03
GC_3_39 ref NI_3 NS_39 0 4.5566183859647967e-03
GC_3_40 ref NI_3 NS_40 0 8.9409047230438771e-04
GC_3_41 ref NI_3 NS_41 0 1.9783677022342820e-03
GC_3_42 ref NI_3 NS_42 0 -5.7843038207411853e-03
GC_3_43 ref NI_3 NS_43 0 5.5950990458403169e-03
GC_3_44 ref NI_3 NS_44 0 6.8600530258373601e-04
GC_3_45 ref NI_3 NS_45 0 -1.4133305763290900e-02
GC_3_46 ref NI_3 NS_46 0 9.2490272023657893e-02
GC_3_47 ref NI_3 NS_47 0 -2.4172888850526909e-02
GC_3_48 ref NI_3 NS_48 0 -2.3819788906323139e-03
GC_3_49 ref NI_3 NS_49 0 -6.7211142615438257e-02
GC_3_50 ref NI_3 NS_50 0 7.3088889541796459e-02
GC_3_51 ref NI_3 NS_51 0 -6.1413861132133931e-03
GC_3_52 ref NI_3 NS_52 0 -2.4253664588183544e-03
GC_3_53 ref NI_3 NS_53 0 3.7766523581972311e-03
GC_3_54 ref NI_3 NS_54 0 -9.4081075663775809e-03
GC_3_55 ref NI_3 NS_55 0 1.2567822443224153e-02
GC_3_56 ref NI_3 NS_56 0 -9.9865451082318331e-04
GC_3_57 ref NI_3 NS_57 0 -7.4872282222575596e-04
GC_3_58 ref NI_3 NS_58 0 -6.7184231947763091e-03
GC_3_59 ref NI_3 NS_59 0 1.2707458562367739e-02
GC_3_60 ref NI_3 NS_60 0 -1.1691623196492759e-03
GC_3_61 ref NI_3 NS_61 0 8.6217280066174812e-03
GC_3_62 ref NI_3 NS_62 0 -1.4009637667686025e-02
GC_3_63 ref NI_3 NS_63 0 1.2983917821292230e-02
GC_3_64 ref NI_3 NS_64 0 -7.5128632329688947e-04
GC_3_65 ref NI_3 NS_65 0 1.5823738456716009e-03
GC_3_66 ref NI_3 NS_66 0 -4.2505904597126918e-03
GC_3_67 ref NI_3 NS_67 0 3.0795510439949776e-03
GC_3_68 ref NI_3 NS_68 0 1.2249711975605216e-03
GC_3_69 ref NI_3 NS_69 0 5.9827130079451011e-04
GC_3_70 ref NI_3 NS_70 0 -2.7712286663723225e-03
GC_3_71 ref NI_3 NS_71 0 2.8470699832577892e-03
GC_3_72 ref NI_3 NS_72 0 1.1717919047069480e-03
GC_3_73 ref NI_3 NS_73 0 1.9870314009311149e-03
GC_3_74 ref NI_3 NS_74 0 -4.9374058249808386e-03
GC_3_75 ref NI_3 NS_75 0 3.2044337894823458e-03
GC_3_76 ref NI_3 NS_76 0 1.2443837648645189e-03
GC_3_77 ref NI_3 NS_77 0 1.2873404056634786e-03
GC_3_78 ref NI_3 NS_78 0 -4.0674404680095724e-03
GC_3_79 ref NI_3 NS_79 0 3.0279236075188691e-03
GC_3_80 ref NI_3 NS_80 0 1.2292064663537822e-03
GD_3_1 ref NI_3 NA_1 0 4.3928129886790408e-02
GD_3_2 ref NI_3 NA_2 0 -1.5086991998440263e-01
GD_3_3 ref NI_3 NA_3 0 5.9991769784550266e+00
GD_3_4 ref NI_3 NA_4 0 -1.6743770124373815e-02
GD_3_5 ref NI_3 NA_5 0 -1.6396071349163512e-02
GD_3_6 ref NI_3 NA_6 0 -2.1338031142625238e-02
GD_3_7 ref NI_3 NA_7 0 -2.4509378598671833e-02
GD_3_8 ref NI_3 NA_8 0 -2.5775349303804741e-02
GD_3_9 ref NI_3 NA_9 0 -1.3864624577581069e-02
GD_3_10 ref NI_3 NA_10 0 -2.4445185729973170e-02
GD_3_11 ref NI_3 NA_11 0 -2.2732275935450099e-02
GD_3_12 ref NI_3 NA_12 0 8.2666297656549773e-02
GD_3_13 ref NI_3 NA_13 0 2.1461440026343814e-01
GD_3_14 ref NI_3 NA_14 0 -2.8642766459704826e-02
GD_3_15 ref NI_3 NA_15 0 -7.6297535594225417e-03
GD_3_16 ref NI_3 NA_16 0 -5.2529152860283077e-02
GD_3_17 ref NI_3 NA_17 0 -1.3111410194084109e-02
GD_3_18 ref NI_3 NA_18 0 -1.5093998692479205e-02
GD_3_19 ref NI_3 NA_19 0 -1.2587813845330781e-02
GD_3_20 ref NI_3 NA_20 0 -1.1797238496385648e-02
*
* Port 4
VI_4 a_4 NI_4 0
RI_4 NI_4 ref 1.0000000000000001e-01
GC_4_1 ref NI_4 NS_1 0 6.1042100634570310e-03
GC_4_2 ref NI_4 NS_2 0 2.8305605033793614e-03
GC_4_3 ref NI_4 NS_3 0 -3.4133128950437160e-04
GC_4_4 ref NI_4 NS_4 0 1.0715268353537512e-03
GC_4_5 ref NI_4 NS_5 0 1.2391740995361888e-02
GC_4_6 ref NI_4 NS_6 0 2.4133822432850097e-03
GC_4_7 ref NI_4 NS_7 0 3.5455424002429073e-04
GC_4_8 ref NI_4 NS_8 0 6.9224552564774644e-04
GC_4_9 ref NI_4 NS_9 0 3.4397259272921825e-03
GC_4_10 ref NI_4 NS_10 0 -5.6723535613341846e-03
GC_4_11 ref NI_4 NS_11 0 5.7609531707273750e-03
GC_4_12 ref NI_4 NS_12 0 4.6164370812152986e-04
GC_4_13 ref NI_4 NS_13 0 7.7258535565564279e-02
GC_4_14 ref NI_4 NS_14 0 -1.2665683259394817e-01
GC_4_15 ref NI_4 NS_15 0 -1.7195309738479179e-02
GC_4_16 ref NI_4 NS_16 0 -1.3028871172014551e-02
GC_4_17 ref NI_4 NS_17 0 -7.6930772688825295e-03
GC_4_18 ref NI_4 NS_18 0 6.0157411177286721e-03
GC_4_19 ref NI_4 NS_19 0 -3.6453676538828416e-03
GC_4_20 ref NI_4 NS_20 0 2.2434612216794807e-03
GC_4_21 ref NI_4 NS_21 0 -6.6610171388799206e-03
GC_4_22 ref NI_4 NS_22 0 5.1420497402954492e-03
GC_4_23 ref NI_4 NS_23 0 -3.4368225013292389e-03
GC_4_24 ref NI_4 NS_24 0 2.2386539824820004e-03
GC_4_25 ref NI_4 NS_25 0 -6.3322831860603271e-03
GC_4_26 ref NI_4 NS_26 0 4.7355673360764163e-03
GC_4_27 ref NI_4 NS_27 0 -3.0089563977518832e-03
GC_4_28 ref NI_4 NS_28 0 2.1557780405953540e-03
GC_4_29 ref NI_4 NS_29 0 -3.3290930191091486e-02
GC_4_30 ref NI_4 NS_30 0 9.6383930150077346e-02
GC_4_31 ref NI_4 NS_31 0 1.8362471057866446e-02
GC_4_32 ref NI_4 NS_32 0 -1.3591174682870697e-02
GC_4_33 ref NI_4 NS_33 0 -4.4921743102789239e-03
GC_4_34 ref NI_4 NS_34 0 2.0855634270100574e-03
GC_4_35 ref NI_4 NS_35 0 6.5673507695185566e-06
GC_4_36 ref NI_4 NS_36 0 1.5555813522360076e-03
GC_4_37 ref NI_4 NS_37 0 -5.7192896340154207e-03
GC_4_38 ref NI_4 NS_38 0 3.8980870444920630e-03
GC_4_39 ref NI_4 NS_39 0 -2.2697609724513963e-03
GC_4_40 ref NI_4 NS_40 0 2.0300554188219574e-03
GC_4_41 ref NI_4 NS_41 0 -4.3767440590430067e-03
GC_4_42 ref NI_4 NS_42 0 2.2487859502334970e-03
GC_4_43 ref NI_4 NS_43 0 -1.3342767205596958e-03
GC_4_44 ref NI_4 NS_44 0 1.8944632171983482e-03
GC_4_45 ref NI_4 NS_45 0 5.6895046926430399e-03
GC_4_46 ref NI_4 NS_46 0 -3.1113158734168180e-03
GC_4_47 ref NI_4 NS_47 0 5.4327540308618675e-03
GC_4_48 ref NI_4 NS_48 0 1.5906969542682403e-04
GC_4_49 ref NI_4 NS_49 0 4.0920465417140055e-03
GC_4_50 ref NI_4 NS_50 0 -3.0820297983492418e-03
GC_4_51 ref NI_4 NS_51 0 5.3129225597143533e-03
GC_4_52 ref NI_4 NS_52 0 2.6954244845996426e-04
GC_4_53 ref NI_4 NS_53 0 3.4314381408652511e-03
GC_4_54 ref NI_4 NS_54 0 -5.2264261226606587e-03
GC_4_55 ref NI_4 NS_55 0 3.4663806718806174e-03
GC_4_56 ref NI_4 NS_56 0 1.0691112406959939e-03
GC_4_57 ref NI_4 NS_57 0 4.5627880432428727e-03
GC_4_58 ref NI_4 NS_58 0 -4.9307190726753762e-03
GC_4_59 ref NI_4 NS_59 0 3.7401978753444161e-03
GC_4_60 ref NI_4 NS_60 0 9.0808849179363136e-04
GC_4_61 ref NI_4 NS_61 0 3.3783480201501738e-03
GC_4_62 ref NI_4 NS_62 0 -4.3975700746047737e-03
GC_4_63 ref NI_4 NS_63 0 3.0525318943087744e-03
GC_4_64 ref NI_4 NS_64 0 1.0981200611904799e-03
GC_4_65 ref NI_4 NS_65 0 -7.1688600691476121e-03
GC_4_66 ref NI_4 NS_66 0 5.7927373998503517e-03
GC_4_67 ref NI_4 NS_67 0 -3.7591875589617959e-03
GC_4_68 ref NI_4 NS_68 0 2.2802718416962691e-03
GC_4_69 ref NI_4 NS_69 0 -7.4123331612425273e-03
GC_4_70 ref NI_4 NS_70 0 5.9560591705942103e-03
GC_4_71 ref NI_4 NS_71 0 -3.5896425813921862e-03
GC_4_72 ref NI_4 NS_72 0 2.2303338460917029e-03
GC_4_73 ref NI_4 NS_73 0 -8.0792148327104851e-03
GC_4_74 ref NI_4 NS_74 0 6.2719081529662062e-03
GC_4_75 ref NI_4 NS_75 0 -3.9277570222395856e-03
GC_4_76 ref NI_4 NS_76 0 2.2960074463073900e-03
GC_4_77 ref NI_4 NS_77 0 -8.4745687638862165e-03
GC_4_78 ref NI_4 NS_78 0 6.5235844516796553e-03
GC_4_79 ref NI_4 NS_79 0 -3.9021153738953689e-03
GC_4_80 ref NI_4 NS_80 0 2.2802694154489514e-03
GD_4_1 ref NI_4 NA_1 0 -3.4488869281654497e-02
GD_4_2 ref NI_4 NA_2 0 -8.6141665172653578e-02
GD_4_3 ref NI_4 NA_3 0 -1.6743770124374543e-02
GD_4_4 ref NI_4 NA_4 0 5.8944705440784730e+00
GD_4_5 ref NI_4 NA_5 0 3.2424310961931178e-02
GD_4_6 ref NI_4 NA_6 0 2.8940484577498871e-02
GD_4_7 ref NI_4 NA_7 0 2.6315763753899702e-02
GD_4_8 ref NI_4 NA_8 0 6.7076240434047266e-02
GD_4_9 ref NI_4 NA_9 0 1.2253643099282011e-02
GD_4_10 ref NI_4 NA_10 0 2.2526736349065990e-02
GD_4_11 ref NI_4 NA_11 0 1.7683553767405713e-02
GD_4_12 ref NI_4 NA_12 0 -3.3507876002519629e-02
GD_4_13 ref NI_4 NA_13 0 -2.8159291305993504e-02
GD_4_14 ref NI_4 NA_14 0 -1.5313752925023559e-02
GD_4_15 ref NI_4 NA_15 0 -2.2320566692916953e-02
GD_4_16 ref NI_4 NA_16 0 -1.7813835475817896e-02
GD_4_17 ref NI_4 NA_17 0 2.9413652076038077e-02
GD_4_18 ref NI_4 NA_18 0 2.8560476114317185e-02
GD_4_19 ref NI_4 NA_19 0 3.7323276250192536e-02
GD_4_20 ref NI_4 NA_20 0 3.8821612103278023e-02
*
* Port 5
VI_5 a_5 NI_5 0
RI_5 NI_5 ref 1.0000000000000001e-01
GC_5_1 ref NI_5 NS_1 0 3.0800531138445709e-02
GC_5_2 ref NI_5 NS_2 0 -3.7224849994238070e-03
GC_5_3 ref NI_5 NS_3 0 1.3276257016599437e-03
GC_5_4 ref NI_5 NS_4 0 -1.8068589043614681e-04
GC_5_5 ref NI_5 NS_5 0 1.0815437288206879e-02
GC_5_6 ref NI_5 NS_6 0 9.8034476752422196e-03
GC_5_7 ref NI_5 NS_7 0 1.9032477733718354e-04
GC_5_8 ref NI_5 NS_8 0 1.4476510149550979e-04
GC_5_9 ref NI_5 NS_9 0 1.5168691226590033e-03
GC_5_10 ref NI_5 NS_10 0 -3.9134389996755697e-03
GC_5_11 ref NI_5 NS_11 0 3.1372407020997814e-03
GC_5_12 ref NI_5 NS_12 0 1.1788287649727549e-03
GC_5_13 ref NI_5 NS_13 0 -7.6930772688825391e-03
GC_5_14 ref NI_5 NS_14 0 6.0157411177287762e-03
GC_5_15 ref NI_5 NS_15 0 -3.6453676538829383e-03
GC_5_16 ref NI_5 NS_16 0 2.2434612216795172e-03
GC_5_17 ref NI_5 NS_17 0 2.7334691442232776e-02
GC_5_18 ref NI_5 NS_18 0 -1.9859175736233142e-01
GC_5_19 ref NI_5 NS_19 0 -1.5886072944862103e-02
GC_5_20 ref NI_5 NS_20 0 -2.1426562720803489e-03
GC_5_21 ref NI_5 NS_21 0 -1.7021294761517106e-03
GC_5_22 ref NI_5 NS_22 0 2.2138437115420930e-02
GC_5_23 ref NI_5 NS_23 0 2.4956401300958166e-04
GC_5_24 ref NI_5 NS_24 0 -1.0978677718092612e-03
GC_5_25 ref NI_5 NS_25 0 -6.4330634802556349e-03
GC_5_26 ref NI_5 NS_26 0 1.4692669600354378e-02
GC_5_27 ref NI_5 NS_27 0 3.9218979519369101e-03
GC_5_28 ref NI_5 NS_28 0 -9.8303049186357111e-04
GC_5_29 ref NI_5 NS_29 0 -8.2498210451806674e-03
GC_5_30 ref NI_5 NS_30 0 6.8109418823218476e-03
GC_5_31 ref NI_5 NS_31 0 -3.9784316488722616e-03
GC_5_32 ref NI_5 NS_32 0 2.2574978314152190e-03
GC_5_33 ref NI_5 NS_33 0 -8.6893335841662072e-04
GC_5_34 ref NI_5 NS_34 0 -2.8262964782450688e-03
GC_5_35 ref NI_5 NS_35 0 7.3812020871220560e-03
GC_5_36 ref NI_5 NS_36 0 -1.6749418613412155e-05
GC_5_37 ref NI_5 NS_37 0 -3.4557571966527200e-03
GC_5_38 ref NI_5 NS_38 0 3.3074243264716156e-03
GC_5_39 ref NI_5 NS_39 0 7.5517159711084832e-03
GC_5_40 ref NI_5 NS_40 0 -7.3193387690631182e-04
GC_5_41 ref NI_5 NS_41 0 3.0537391296894629e-03
GC_5_42 ref NI_5 NS_42 0 -6.8974795324519712e-03
GC_5_43 ref NI_5 NS_43 0 9.5434041250033099e-03
GC_5_44 ref NI_5 NS_44 0 -3.5651837161929182e-04
GC_5_45 ref NI_5 NS_45 0 1.8124447107722387e-03
GC_5_46 ref NI_5 NS_46 0 -4.5302166173685080e-03
GC_5_47 ref NI_5 NS_47 0 3.0220262885295628e-03
GC_5_48 ref NI_5 NS_48 0 1.2552603319923509e-03
GC_5_49 ref NI_5 NS_49 0 1.9541286934145396e-03
GC_5_50 ref NI_5 NS_50 0 -4.4230415141581752e-03
GC_5_51 ref NI_5 NS_51 0 2.9774565016640895e-03
GC_5_52 ref NI_5 NS_52 0 1.2545138409760681e-03
GC_5_53 ref NI_5 NS_53 0 3.3938498142750111e-03
GC_5_54 ref NI_5 NS_54 0 -5.5187471984684709e-03
GC_5_55 ref NI_5 NS_55 0 3.2360152210149161e-03
GC_5_56 ref NI_5 NS_56 0 1.2515226812614970e-03
GC_5_57 ref NI_5 NS_57 0 3.9849116159676977e-03
GC_5_58 ref NI_5 NS_58 0 -6.2062606058573052e-03
GC_5_59 ref NI_5 NS_59 0 2.9925217592493445e-03
GC_5_60 ref NI_5 NS_60 0 1.3765645277039572e-03
GC_5_61 ref NI_5 NS_61 0 3.0094685014422588e-03
GC_5_62 ref NI_5 NS_62 0 -5.5150368964654506e-03
GC_5_63 ref NI_5 NS_63 0 3.5989493937649743e-03
GC_5_64 ref NI_5 NS_64 0 1.1693019957226636e-03
GC_5_65 ref NI_5 NS_65 0 2.6439600791595397e-02
GC_5_66 ref NI_5 NS_66 0 4.5824398150362378e-02
GC_5_67 ref NI_5 NS_67 0 -1.3917954941543487e-02
GC_5_68 ref NI_5 NS_68 0 -1.4213188300155103e-03
GC_5_69 ref NI_5 NS_69 0 -4.0282981521570053e-02
GC_5_70 ref NI_5 NS_70 0 4.3322863037911316e-02
GC_5_71 ref NI_5 NS_71 0 -2.2238509782850817e-04
GC_5_72 ref NI_5 NS_72 0 -1.7186790076418712e-03
GC_5_73 ref NI_5 NS_73 0 1.7831615795746887e-02
GC_5_74 ref NI_5 NS_74 0 4.2248121099051891e-02
GC_5_75 ref NI_5 NS_75 0 -1.0781224979931905e-02
GC_5_76 ref NI_5 NS_76 0 -1.4837851408901585e-03
GC_5_77 ref NI_5 NS_77 0 -3.8238863412928870e-02
GC_5_78 ref NI_5 NS_78 0 4.5085666036361043e-02
GC_5_79 ref NI_5 NS_79 0 -1.2945523806431425e-03
GC_5_80 ref NI_5 NS_80 0 -1.7318341761359765e-03
GD_5_1 ref NI_5 NA_1 0 4.0173190804192828e-02
GD_5_2 ref NI_5 NA_2 0 -1.6095592796106475e-01
GD_5_3 ref NI_5 NA_3 0 -1.6396071349163210e-02
GD_5_4 ref NI_5 NA_4 0 3.2424310961930602e-02
GD_5_5 ref NI_5 NA_5 0 6.0071609353267270e+00
GD_5_6 ref NI_5 NA_6 0 -9.2600078827809393e-03
GD_5_7 ref NI_5 NA_7 0 8.7808514271752835e-04
GD_5_8 ref NI_5 NA_8 0 3.4637790010880083e-02
GD_5_9 ref NI_5 NA_9 0 -2.6685764030310200e-02
GD_5_10 ref NI_5 NA_10 0 -1.3882099964497267e-02
GD_5_11 ref NI_5 NA_11 0 -3.1959869344687711e-02
GD_5_12 ref NI_5 NA_12 0 -1.4728953020019050e-02
GD_5_13 ref NI_5 NA_13 0 -1.6358666854833476e-02
GD_5_14 ref NI_5 NA_14 0 -2.1412775271736878e-02
GD_5_15 ref NI_5 NA_15 0 -2.0437452046785719e-02
GD_5_16 ref NI_5 NA_16 0 -2.1169785893764809e-02
GD_5_17 ref NI_5 NA_17 0 -7.9540422698816407e-02
GD_5_18 ref NI_5 NA_18 0 1.1859205560610958e-01
GD_5_19 ref NI_5 NA_19 0 -4.1868639551126338e-02
GD_5_20 ref NI_5 NA_20 0 1.1047644595379777e-01
*
* Port 6
VI_6 a_6 NI_6 0
RI_6 NI_6 ref 1.0000000000000001e-01
GC_6_1 ref NI_6 NS_1 0 2.1981299404187356e-02
GC_6_2 ref NI_6 NS_2 0 7.8862460081368665e-05
GC_6_3 ref NI_6 NS_3 0 1.7039960637603392e-03
GC_6_4 ref NI_6 NS_4 0 -2.1010725703308930e-04
GC_6_5 ref NI_6 NS_5 0 3.5857438191901347e-03
GC_6_6 ref NI_6 NS_6 0 1.0941513148369454e-02
GC_6_7 ref NI_6 NS_7 0 1.0414960181158264e-03
GC_6_8 ref NI_6 NS_8 0 6.7969366133972423e-05
GC_6_9 ref NI_6 NS_9 0 3.5356119909875972e-03
GC_6_10 ref NI_6 NS_10 0 -6.1006623088119194e-03
GC_6_11 ref NI_6 NS_11 0 3.7432300714135571e-03
GC_6_12 ref NI_6 NS_12 0 1.1694440777703710e-03
GC_6_13 ref NI_6 NS_13 0 -6.6610171388798312e-03
GC_6_14 ref NI_6 NS_14 0 5.1420497402955012e-03
GC_6_15 ref NI_6 NS_15 0 -3.4368225013293218e-03
GC_6_16 ref NI_6 NS_16 0 2.2386539824820360e-03
GC_6_17 ref NI_6 NS_17 0 -1.7021294761512397e-03
GC_6_18 ref NI_6 NS_18 0 2.2138437115420666e-02
GC_6_19 ref NI_6 NS_19 0 2.4956401300963924e-04
GC_6_20 ref NI_6 NS_20 0 -1.0978677718092651e-03
GC_6_21 ref NI_6 NS_21 0 6.4249276926122145e-02
GC_6_22 ref NI_6 NS_22 0 -1.4127960592145919e-01
GC_6_23 ref NI_6 NS_23 0 -4.8397126860844596e-02
GC_6_24 ref NI_6 NS_24 0 -1.8545571405779713e-03
GC_6_25 ref NI_6 NS_25 0 -2.2664325700732495e-03
GC_6_26 ref NI_6 NS_26 0 7.7338235019593818e-02
GC_6_27 ref NI_6 NS_27 0 -2.2626763755261570e-02
GC_6_28 ref NI_6 NS_28 0 -1.3074090674364167e-03
GC_6_29 ref NI_6 NS_29 0 -7.3362445687021431e-03
GC_6_30 ref NI_6 NS_30 0 5.9737997132403567e-03
GC_6_31 ref NI_6 NS_31 0 -3.7793940535306349e-03
GC_6_32 ref NI_6 NS_32 0 2.2565179269651361e-03
GC_6_33 ref NI_6 NS_33 0 -6.2501246902084799e-03
GC_6_34 ref NI_6 NS_34 0 2.0432730056218224e-04
GC_6_35 ref NI_6 NS_35 0 8.2199682018176210e-03
GC_6_36 ref NI_6 NS_36 0 -4.0841906476607616e-04
GC_6_37 ref NI_6 NS_37 0 -3.2513403327967989e-02
GC_6_38 ref NI_6 NS_38 0 4.0637144512179285e-02
GC_6_39 ref NI_6 NS_39 0 -1.2445969503756110e-03
GC_6_40 ref NI_6 NS_40 0 -1.4335829208614891e-03
GC_6_41 ref NI_6 NS_41 0 -1.3593690102206981e-02
GC_6_42 ref NI_6 NS_42 0 8.2347913525564892e-03
GC_6_43 ref NI_6 NS_43 0 8.1222550384176494e-03
GC_6_44 ref NI_6 NS_44 0 -1.0583222716344404e-03
GC_6_45 ref NI_6 NS_45 0 3.8433824797016593e-03
GC_6_46 ref NI_6 NS_46 0 -6.5259366081641878e-03
GC_6_47 ref NI_6 NS_47 0 3.5833843505263595e-03
GC_6_48 ref NI_6 NS_48 0 1.2367113098639604e-03
GC_6_49 ref NI_6 NS_49 0 3.8141437193378990e-03
GC_6_50 ref NI_6 NS_50 0 -6.3192296704365648e-03
GC_6_51 ref NI_6 NS_51 0 3.5368066292874975e-03
GC_6_52 ref NI_6 NS_52 0 1.2321909041048088e-03
GC_6_53 ref NI_6 NS_53 0 5.0503748811481699e-03
GC_6_54 ref NI_6 NS_54 0 -7.3020885204683767e-03
GC_6_55 ref NI_6 NS_55 0 3.8451873143253890e-03
GC_6_56 ref NI_6 NS_56 0 1.2117850680241180e-03
GC_6_57 ref NI_6 NS_57 0 5.8031003550059312e-03
GC_6_58 ref NI_6 NS_58 0 -7.9205298786990848e-03
GC_6_59 ref NI_6 NS_59 0 3.5454218964847688e-03
GC_6_60 ref NI_6 NS_60 0 1.3388087989644974e-03
GC_6_61 ref NI_6 NS_61 0 4.4373974845945494e-03
GC_6_62 ref NI_6 NS_62 0 -7.1497056457109623e-03
GC_6_63 ref NI_6 NS_63 0 4.2593157897623437e-03
GC_6_64 ref NI_6 NS_64 0 1.1052024623049996e-03
GC_6_65 ref NI_6 NS_65 0 -9.3215621474439358e-03
GC_6_66 ref NI_6 NS_66 0 5.6163983689876736e-03
GC_6_67 ref NI_6 NS_67 0 8.6987488509594948e-03
GC_6_68 ref NI_6 NS_68 0 -1.1019629252771582e-03
GC_6_69 ref NI_6 NS_69 0 -3.7766461724706669e-03
GC_6_70 ref NI_6 NS_70 0 -3.5617664869836874e-03
GC_6_71 ref NI_6 NS_71 0 1.1265636071570920e-02
GC_6_72 ref NI_6 NS_72 0 -9.7980487268147908e-04
GC_6_73 ref NI_6 NS_73 0 -5.2707513012163684e-03
GC_6_74 ref NI_6 NS_74 0 7.5829654929260408e-03
GC_6_75 ref NI_6 NS_75 0 7.0872636724291001e-03
GC_6_76 ref NI_6 NS_76 0 -1.1019959745780712e-03
GC_6_77 ref NI_6 NS_77 0 -3.7404799734124462e-03
GC_6_78 ref NI_6 NS_78 0 -1.9964535126366613e-04
GC_6_79 ref NI_6 NS_79 0 9.9816757390110127e-03
GC_6_80 ref NI_6 NS_80 0 -1.0376959519005683e-03
GD_6_1 ref NI_6 NA_1 0 2.2329182178810619e-02
GD_6_2 ref NI_6 NA_2 0 -1.2063202910628758e-01
GD_6_3 ref NI_6 NA_3 0 -2.1338031142623580e-02
GD_6_4 ref NI_6 NA_4 0 2.8940484577497757e-02
GD_6_5 ref NI_6 NA_5 0 -9.2600078827844851e-03
GD_6_6 ref NI_6 NA_6 0 5.9361163709167153e+00
GD_6_7 ref NI_6 NA_7 0 -2.4247211166121819e-02
GD_6_8 ref NI_6 NA_8 0 3.1683296837398643e-02
GD_6_9 ref NI_6 NA_9 0 2.4113956430124941e-03
GD_6_10 ref NI_6 NA_10 0 8.3381485695516552e-02
GD_6_11 ref NI_6 NA_11 0 3.6230712403045748e-02
GD_6_12 ref NI_6 NA_12 0 -2.0495386470083258e-02
GD_6_13 ref NI_6 NA_13 0 -2.1369596643510316e-02
GD_6_14 ref NI_6 NA_14 0 -2.5869224674451418e-02
GD_6_15 ref NI_6 NA_15 0 -2.6380933309178210e-02
GD_6_16 ref NI_6 NA_16 0 -2.4354270941023968e-02
GD_6_17 ref NI_6 NA_17 0 1.5970622605968824e-02
GD_6_18 ref NI_6 NA_18 0 1.2254048974525344e-03
GD_6_19 ref NI_6 NA_19 0 8.8381679428595865e-03
GD_6_20 ref NI_6 NA_20 0 3.0146271583512694e-03
*
* Port 7
VI_7 a_7 NI_7 0
RI_7 NI_7 ref 1.0000000000000001e-01
GC_7_1 ref NI_7 NS_1 0 2.8880468072407049e-02
GC_7_2 ref NI_7 NS_2 0 -1.7613031548261375e-03
GC_7_3 ref NI_7 NS_3 0 1.3315673604696650e-03
GC_7_4 ref NI_7 NS_4 0 -2.3091858248260586e-04
GC_7_5 ref NI_7 NS_5 0 9.9257808914277774e-03
GC_7_6 ref NI_7 NS_6 0 1.0930820596768561e-02
GC_7_7 ref NI_7 NS_7 0 1.8376176542890505e-04
GC_7_8 ref NI_7 NS_8 0 5.2519150054676729e-05
GC_7_9 ref NI_7 NS_9 0 3.0948090937714945e-03
GC_7_10 ref NI_7 NS_10 0 -5.6371240394201914e-03
GC_7_11 ref NI_7 NS_11 0 4.0141701465338528e-03
GC_7_12 ref NI_7 NS_12 0 1.0676775874453358e-03
GC_7_13 ref NI_7 NS_13 0 -6.3322831860604259e-03
GC_7_14 ref NI_7 NS_14 0 4.7355673360765412e-03
GC_7_15 ref NI_7 NS_15 0 -3.0089563977519582e-03
GC_7_16 ref NI_7 NS_16 0 2.1557780405953796e-03
GC_7_17 ref NI_7 NS_17 0 -6.4330634802554718e-03
GC_7_18 ref NI_7 NS_18 0 1.4692669600354310e-02
GC_7_19 ref NI_7 NS_19 0 3.9218979519369136e-03
GC_7_20 ref NI_7 NS_20 0 -9.8303049186356677e-04
GC_7_21 ref NI_7 NS_21 0 -2.2664325700732213e-03
GC_7_22 ref NI_7 NS_22 0 7.7338235019593790e-02
GC_7_23 ref NI_7 NS_23 0 -2.2626763755261563e-02
GC_7_24 ref NI_7 NS_24 0 -1.3074090674364198e-03
GC_7_25 ref NI_7 NS_25 0 4.6566530364198555e-02
GC_7_26 ref NI_7 NS_26 0 -1.8076806216633187e-01
GC_7_27 ref NI_7 NS_27 0 -2.7926721343475111e-02
GC_7_28 ref NI_7 NS_28 0 -1.8689458332269509e-03
GC_7_29 ref NI_7 NS_29 0 -6.9744662478077833e-03
GC_7_30 ref NI_7 NS_30 0 5.5012399720434065e-03
GC_7_31 ref NI_7 NS_31 0 -3.3434544156706238e-03
GC_7_32 ref NI_7 NS_32 0 2.1774759749322260e-03
GC_7_33 ref NI_7 NS_33 0 -1.1506298684227955e-02
GC_7_34 ref NI_7 NS_34 0 9.1042540781969186e-03
GC_7_35 ref NI_7 NS_35 0 5.8042521921213988e-03
GC_7_36 ref NI_7 NS_36 0 -5.4152510480103987e-04
GC_7_37 ref NI_7 NS_37 0 1.6766532677835308e-05
GC_7_38 ref NI_7 NS_38 0 5.6459367849473967e-02
GC_7_39 ref NI_7 NS_39 0 -1.4407681139667066e-02
GC_7_40 ref NI_7 NS_40 0 -1.1771792834565815e-03
GC_7_41 ref NI_7 NS_41 0 -2.1544433468959297e-02
GC_7_42 ref NI_7 NS_42 0 2.4870396809032917e-02
GC_7_43 ref NI_7 NS_43 0 2.7727335732368741e-03
GC_7_44 ref NI_7 NS_44 0 -1.1730602873328100e-03
GC_7_45 ref NI_7 NS_45 0 3.4351767862185771e-03
GC_7_46 ref NI_7 NS_46 0 -6.0244061666890327e-03
GC_7_47 ref NI_7 NS_47 0 3.8458910738338940e-03
GC_7_48 ref NI_7 NS_48 0 1.1308730070171567e-03
GC_7_49 ref NI_7 NS_49 0 3.4483930809770923e-03
GC_7_50 ref NI_7 NS_50 0 -5.7542113990179788e-03
GC_7_51 ref NI_7 NS_51 0 3.7731804906642476e-03
GC_7_52 ref NI_7 NS_52 0 1.1245823164990430e-03
GC_7_53 ref NI_7 NS_53 0 4.6257826837515174e-03
GC_7_54 ref NI_7 NS_54 0 -6.6972772335583087e-03
GC_7_55 ref NI_7 NS_55 0 4.1506548112436878e-03
GC_7_56 ref NI_7 NS_56 0 1.0821124489479356e-03
GC_7_57 ref NI_7 NS_57 0 5.5770602373817462e-03
GC_7_58 ref NI_7 NS_58 0 -7.5791734693404058e-03
GC_7_59 ref NI_7 NS_59 0 3.9400999270260270e-03
GC_7_60 ref NI_7 NS_60 0 1.2051193901602812e-03
GC_7_61 ref NI_7 NS_61 0 3.7428528149185225e-03
GC_7_62 ref NI_7 NS_62 0 -6.0056543013332492e-03
GC_7_63 ref NI_7 NS_63 0 4.3878011981279526e-03
GC_7_64 ref NI_7 NS_64 0 9.7328639049147918e-04
GC_7_65 ref NI_7 NS_65 0 -6.4452358248694901e-03
GC_7_66 ref NI_7 NS_66 0 2.9535039186696856e-03
GC_7_67 ref NI_7 NS_67 0 8.8499100129558594e-03
GC_7_68 ref NI_7 NS_68 0 -9.3232096682907594e-04
GC_7_69 ref NI_7 NS_69 0 -2.6124153785729268e-03
GC_7_70 ref NI_7 NS_70 0 -2.0585711506192535e-03
GC_7_71 ref NI_7 NS_71 0 9.9646608709839483e-03
GC_7_72 ref NI_7 NS_72 0 -8.1704215057116581e-04
GC_7_73 ref NI_7 NS_73 0 3.4812635592882581e-03
GC_7_74 ref NI_7 NS_74 0 3.5923320526777304e-03
GC_7_75 ref NI_7 NS_75 0 6.7257590310251482e-03
GC_7_76 ref NI_7 NS_76 0 -9.2318887696721437e-04
GC_7_77 ref NI_7 NS_77 0 2.5873021123291547e-03
GC_7_78 ref NI_7 NS_78 0 -4.9149279322601846e-04
GC_7_79 ref NI_7 NS_79 0 8.5034518775250287e-03
GC_7_80 ref NI_7 NS_80 0 -8.5900212224291294e-04
GD_7_1 ref NI_7 NA_1 0 5.7013902225525864e-03
GD_7_2 ref NI_7 NA_2 0 -1.6094907825298380e-01
GD_7_3 ref NI_7 NA_3 0 -2.4509378598670913e-02
GD_7_4 ref NI_7 NA_4 0 2.6315763753899955e-02
GD_7_5 ref NI_7 NA_5 0 8.7808514271635633e-04
GD_7_6 ref NI_7 NA_6 0 -2.4247211166122183e-02
GD_7_7 ref NI_7 NA_7 0 5.9576539267331992e+00
GD_7_8 ref NI_7 NA_8 0 2.9185337039560211e-02
GD_7_9 ref NI_7 NA_9 0 1.0583093297008985e-02
GD_7_10 ref NI_7 NA_10 0 -4.1790232041077992e-02
GD_7_11 ref NI_7 NA_11 0 5.1079430671427860e-02
GD_7_12 ref NI_7 NA_12 0 -2.3627300682350135e-02
GD_7_13 ref NI_7 NA_13 0 -2.4940606503880160e-02
GD_7_14 ref NI_7 NA_14 0 -2.9378908534236962e-02
GD_7_15 ref NI_7 NA_15 0 -3.0017146172326620e-02
GD_7_16 ref NI_7 NA_16 0 -2.7408144878012693e-02
GD_7_17 ref NI_7 NA_17 0 -2.3129481324455493e-03
GD_7_18 ref NI_7 NA_18 0 -1.4452605156499801e-02
GD_7_19 ref NI_7 NA_19 0 -2.3687795263157990e-02
GD_7_20 ref NI_7 NA_20 0 -2.8346307236843449e-02
*
* Port 8
VI_8 a_8 NI_8 0
RI_8 NI_8 ref 1.0000000000000001e-01
GC_8_1 ref NI_8 NS_1 0 7.2511341516952313e-03
GC_8_2 ref NI_8 NS_2 0 1.3645993449796071e-03
GC_8_3 ref NI_8 NS_3 0 -4.3186544923137202e-04
GC_8_4 ref NI_8 NS_4 0 1.1146808083999772e-03
GC_8_5 ref NI_8 NS_5 0 6.4717037412901513e-03
GC_8_6 ref NI_8 NS_6 0 4.0093724408047874e-03
GC_8_7 ref NI_8 NS_7 0 4.7301445856169757e-04
GC_8_8 ref NI_8 NS_8 0 7.5550556401403259e-04
GC_8_9 ref NI_8 NS_9 0 6.6045693125661121e-03
GC_8_10 ref NI_8 NS_10 0 -9.3078903439627325e-03
GC_8_11 ref NI_8 NS_11 0 6.1433384350445368e-03
GC_8_12 ref NI_8 NS_12 0 6.4366379403575213e-04
GC_8_13 ref NI_8 NS_13 0 -3.3290930191092249e-02
GC_8_14 ref NI_8 NS_14 0 9.6383930150077735e-02
GC_8_15 ref NI_8 NS_15 0 1.8362471057866384e-02
GC_8_16 ref NI_8 NS_16 0 -1.3591174682870698e-02
GC_8_17 ref NI_8 NS_17 0 -8.2498210451804662e-03
GC_8_18 ref NI_8 NS_18 0 6.8109418823216377e-03
GC_8_19 ref NI_8 NS_19 0 -3.9784316488721445e-03
GC_8_20 ref NI_8 NS_20 0 2.2574978314151813e-03
GC_8_21 ref NI_8 NS_21 0 -7.3362445687021527e-03
GC_8_22 ref NI_8 NS_22 0 5.9737997132402526e-03
GC_8_23 ref NI_8 NS_23 0 -3.7793940535305387e-03
GC_8_24 ref NI_8 NS_24 0 2.2565179269650997e-03
GC_8_25 ref NI_8 NS_25 0 -6.9744662478075561e-03
GC_8_26 ref NI_8 NS_26 0 5.5012399720431836e-03
GC_8_27 ref NI_8 NS_27 0 -3.3434544156705033e-03
GC_8_28 ref NI_8 NS_28 0 2.1774759749321891e-03
GC_8_29 ref NI_8 NS_29 0 7.0220632628483437e-02
GC_8_30 ref NI_8 NS_30 0 -1.1400882205141838e-01
GC_8_31 ref NI_8 NS_31 0 -1.6611039638613961e-02
GC_8_32 ref NI_8 NS_32 0 -1.4299595281344104e-02
GC_8_33 ref NI_8 NS_33 0 -4.7126612773672983e-03
GC_8_34 ref NI_8 NS_34 0 2.4426257261020616e-03
GC_8_35 ref NI_8 NS_35 0 -3.5862074547302790e-04
GC_8_36 ref NI_8 NS_36 0 1.6154598358735590e-03
GC_8_37 ref NI_8 NS_37 0 -6.3021389779337545e-03
GC_8_38 ref NI_8 NS_38 0 4.6254879891721879e-03
GC_8_39 ref NI_8 NS_39 0 -2.6319214328583635e-03
GC_8_40 ref NI_8 NS_40 0 2.0613237244251400e-03
GC_8_41 ref NI_8 NS_41 0 -4.9309689044060075e-03
GC_8_42 ref NI_8 NS_42 0 3.0473208621305580e-03
GC_8_43 ref NI_8 NS_43 0 -1.7691674296866162e-03
GC_8_44 ref NI_8 NS_44 0 1.9371633264307279e-03
GC_8_45 ref NI_8 NS_45 0 6.3195581310555356e-03
GC_8_46 ref NI_8 NS_46 0 -7.6156079559330575e-03
GC_8_47 ref NI_8 NS_47 0 6.6803199385641436e-03
GC_8_48 ref NI_8 NS_48 0 3.1399492158784358e-04
GC_8_49 ref NI_8 NS_49 0 5.7610812779094380e-03
GC_8_50 ref NI_8 NS_50 0 -7.6297226262606608e-03
GC_8_51 ref NI_8 NS_51 0 6.3760337437813452e-03
GC_8_52 ref NI_8 NS_52 0 4.3045866187553739e-04
GC_8_53 ref NI_8 NS_53 0 4.4949561704545329e-03
GC_8_54 ref NI_8 NS_54 0 -6.3748202000862052e-03
GC_8_55 ref NI_8 NS_55 0 3.1660934946836183e-03
GC_8_56 ref NI_8 NS_56 0 1.2373550340829978e-03
GC_8_57 ref NI_8 NS_57 0 5.2119267243593273e-03
GC_8_58 ref NI_8 NS_58 0 -6.7571440092749823e-03
GC_8_59 ref NI_8 NS_59 0 3.7932615329423851e-03
GC_8_60 ref NI_8 NS_60 0 1.0759872890618368e-03
GC_8_61 ref NI_8 NS_61 0 3.7074343237607933e-03
GC_8_62 ref NI_8 NS_62 0 -5.3480977123048345e-03
GC_8_63 ref NI_8 NS_63 0 2.8281786996317113e-03
GC_8_64 ref NI_8 NS_64 0 1.2527065436869448e-03
GC_8_65 ref NI_8 NS_65 0 -7.8042579904758196e-03
GC_8_66 ref NI_8 NS_66 0 6.6092955589321482e-03
GC_8_67 ref NI_8 NS_67 0 -4.0561765071095305e-03
GC_8_68 ref NI_8 NS_68 0 2.2849940534899601e-03
GC_8_69 ref NI_8 NS_69 0 -7.8994735490146694e-03
GC_8_70 ref NI_8 NS_70 0 6.7193716584213045e-03
GC_8_71 ref NI_8 NS_71 0 -3.8940930736695565e-03
GC_8_72 ref NI_8 NS_72 0 2.2363896194431965e-03
GC_8_73 ref NI_8 NS_73 0 -8.8076707852050417e-03
GC_8_74 ref NI_8 NS_74 0 7.0978193992156926e-03
GC_8_75 ref NI_8 NS_75 0 -4.2225572625164956e-03
GC_8_76 ref NI_8 NS_76 0 2.3035439019103913e-03
GC_8_77 ref NI_8 NS_77 0 -9.1099944525113875e-03
GC_8_78 ref NI_8 NS_78 0 7.3168617076742075e-03
GC_8_79 ref NI_8 NS_79 0 -4.2014474506384195e-03
GC_8_80 ref NI_8 NS_80 0 2.2885937279566366e-03
GD_8_1 ref NI_8 NA_1 0 9.8571430503143409e-04
GD_8_2 ref NI_8 NA_2 0 -6.9846834196939697e-02
GD_8_3 ref NI_8 NA_3 0 -2.5775349303804564e-02
GD_8_4 ref NI_8 NA_4 0 6.7076240434053178e-02
GD_8_5 ref NI_8 NA_5 0 3.4637790010879119e-02
GD_8_6 ref NI_8 NA_6 0 3.1683296837399177e-02
GD_8_7 ref NI_8 NA_7 0 2.9185337039559001e-02
GD_8_8 ref NI_8 NA_8 0 5.9141366291730737e+00
GD_8_9 ref NI_8 NA_9 0 1.4675677567576709e-02
GD_8_10 ref NI_8 NA_10 0 2.5421596992394699e-02
GD_8_11 ref NI_8 NA_11 0 2.0365080672640562e-02
GD_8_12 ref NI_8 NA_12 0 -2.9671662570504270e-02
GD_8_13 ref NI_8 NA_13 0 -2.7370723391798753e-02
GD_8_14 ref NI_8 NA_14 0 -1.6449927443025460e-02
GD_8_15 ref NI_8 NA_15 0 -2.0423685320009696e-02
GD_8_16 ref NI_8 NA_16 0 -1.5353633696290886e-02
GD_8_17 ref NI_8 NA_17 0 3.1775822556127042e-02
GD_8_18 ref NI_8 NA_18 0 3.0481182338155496e-02
GD_8_19 ref NI_8 NA_19 0 4.0076536096936254e-02
GD_8_20 ref NI_8 NA_20 0 4.1261705189653435e-02
*
* Port 9
VI_9 a_9 NI_9 0
RI_9 NI_9 ref 1.0000000000000001e-01
GC_9_1 ref NI_9 NS_1 0 6.2698622840529558e-02
GC_9_2 ref NI_9 NS_2 0 -6.6016933913403833e-03
GC_9_3 ref NI_9 NS_3 0 -4.0615135269194205e-03
GC_9_4 ref NI_9 NS_4 0 -1.4005687110508436e-04
GC_9_5 ref NI_9 NS_5 0 3.5397600224328675e-02
GC_9_6 ref NI_9 NS_6 0 2.1222989314372196e-02
GC_9_7 ref NI_9 NS_7 0 -8.0766523121571423e-03
GC_9_8 ref NI_9 NS_8 0 1.1956288887657665e-04
GC_9_9 ref NI_9 NS_9 0 -4.2108175524612681e-03
GC_9_10 ref NI_9 NS_10 0 2.2776004800827750e-04
GC_9_11 ref NI_9 NS_11 0 5.5686764430900168e-03
GC_9_12 ref NI_9 NS_12 0 2.8023549539201370e-04
GC_9_13 ref NI_9 NS_13 0 -4.4921743102790150e-03
GC_9_14 ref NI_9 NS_14 0 2.0855634270101164e-03
GC_9_15 ref NI_9 NS_15 0 6.5673507694972596e-06
GC_9_16 ref NI_9 NS_16 0 1.5555813522360128e-03
GC_9_17 ref NI_9 NS_17 0 -8.6893335841658321e-04
GC_9_18 ref NI_9 NS_18 0 -2.8262964782450623e-03
GC_9_19 ref NI_9 NS_19 0 7.3812020871220395e-03
GC_9_20 ref NI_9 NS_20 0 -1.6749418613404582e-05
GC_9_21 ref NI_9 NS_21 0 -6.2501246902085363e-03
GC_9_22 ref NI_9 NS_22 0 2.0432730056220270e-04
GC_9_23 ref NI_9 NS_23 0 8.2199682018176262e-03
GC_9_24 ref NI_9 NS_24 0 -4.0841906476607974e-04
GC_9_25 ref NI_9 NS_25 0 -1.1506298684228103e-02
GC_9_26 ref NI_9 NS_26 0 9.1042540781969723e-03
GC_9_27 ref NI_9 NS_27 0 5.8042521921214067e-03
GC_9_28 ref NI_9 NS_28 0 -5.4152510480105103e-04
GC_9_29 ref NI_9 NS_29 0 -4.7126612773673226e-03
GC_9_30 ref NI_9 NS_30 0 2.4426257261021007e-03
GC_9_31 ref NI_9 NS_31 0 -3.5862074547305224e-04
GC_9_32 ref NI_9 NS_32 0 1.6154598358735662e-03
GC_9_33 ref NI_9 NS_33 0 6.7296007105796668e-02
GC_9_34 ref NI_9 NS_34 0 -1.2495594658884912e-01
GC_9_35 ref NI_9 NS_35 0 -5.7555957770129396e-02
GC_9_36 ref NI_9 NS_36 0 -1.3770815866459029e-03
GC_9_37 ref NI_9 NS_37 0 -2.3799275494484219e-02
GC_9_38 ref NI_9 NS_38 0 2.8584229202616263e-02
GC_9_39 ref NI_9 NS_39 0 3.6451178247917171e-04
GC_9_40 ref NI_9 NS_40 0 -7.8755642893899697e-04
GC_9_41 ref NI_9 NS_41 0 -4.0034559535178059e-02
GC_9_42 ref NI_9 NS_42 0 6.7666886178897281e-02
GC_9_43 ref NI_9 NS_43 0 -1.2622380715487895e-02
GC_9_44 ref NI_9 NS_44 0 -1.1545719612689616e-03
GC_9_45 ref NI_9 NS_45 0 -3.9737649900542932e-03
GC_9_46 ref NI_9 NS_46 0 1.3298120804668091e-04
GC_9_47 ref NI_9 NS_47 0 5.4930965540928032e-03
GC_9_48 ref NI_9 NS_48 0 2.8225934303419646e-04
GC_9_49 ref NI_9 NS_49 0 -3.7890241397484283e-03
GC_9_50 ref NI_9 NS_50 0 1.1495651768148041e-03
GC_9_51 ref NI_9 NS_51 0 5.1179440105098561e-03
GC_9_52 ref NI_9 NS_52 0 2.6340887789767960e-04
GC_9_53 ref NI_9 NS_53 0 -4.7855586187970896e-03
GC_9_54 ref NI_9 NS_54 0 3.3859033406878143e-03
GC_9_55 ref NI_9 NS_55 0 5.0193707039400612e-03
GC_9_56 ref NI_9 NS_56 0 5.9096083740027456e-05
GC_9_57 ref NI_9 NS_57 0 -2.5881094292971281e-03
GC_9_58 ref NI_9 NS_58 0 -4.9523518650743776e-04
GC_9_59 ref NI_9 NS_59 0 6.0430818904056082e-03
GC_9_60 ref NI_9 NS_60 0 1.3262105589348445e-04
GC_9_61 ref NI_9 NS_61 0 -8.6249305942563675e-03
GC_9_62 ref NI_9 NS_62 0 9.5116690432882275e-03
GC_9_63 ref NI_9 NS_63 0 3.3636798381535917e-03
GC_9_64 ref NI_9 NS_64 0 -3.6757071659970669e-05
GC_9_65 ref NI_9 NS_65 0 1.4198897895959656e-03
GC_9_66 ref NI_9 NS_66 0 -5.8951949654418457e-03
GC_9_67 ref NI_9 NS_67 0 7.9793550269088628e-03
GC_9_68 ref NI_9 NS_68 0 7.3387546993831761e-05
GC_9_69 ref NI_9 NS_69 0 6.0135320188511258e-04
GC_9_70 ref NI_9 NS_70 0 -3.4543081293025380e-03
GC_9_71 ref NI_9 NS_71 0 7.0304741467414021e-03
GC_9_72 ref NI_9 NS_72 0 1.1121183651789441e-04
GC_9_73 ref NI_9 NS_73 0 1.1782157597895898e-03
GC_9_74 ref NI_9 NS_74 0 -5.8096785960481965e-03
GC_9_75 ref NI_9 NS_75 0 7.9857356184302505e-03
GC_9_76 ref NI_9 NS_76 0 5.1440432425063742e-05
GC_9_77 ref NI_9 NS_77 0 6.9282457846123093e-04
GC_9_78 ref NI_9 NS_78 0 -4.8628200190158786e-03
GC_9_79 ref NI_9 NS_79 0 7.5480990277941949e-03
GC_9_80 ref NI_9 NS_80 0 9.7480696973505651e-05
GD_9_1 ref NI_9 NA_1 0 4.9398576824016563e-02
GD_9_2 ref NI_9 NA_2 0 -3.3274040102333124e-01
GD_9_3 ref NI_9 NA_3 0 -1.3864624577581799e-02
GD_9_4 ref NI_9 NA_4 0 1.2253643099282613e-02
GD_9_5 ref NI_9 NA_5 0 -2.6685764030310741e-02
GD_9_6 ref NI_9 NA_6 0 2.4113956430128042e-03
GD_9_7 ref NI_9 NA_7 0 1.0583093297010250e-02
GD_9_8 ref NI_9 NA_8 0 1.4675677567576715e-02
GD_9_9 ref NI_9 NA_9 0 5.8569952893362451e+00
GD_9_10 ref NI_9 NA_10 0 4.7017075822653014e-02
GD_9_11 ref NI_9 NA_11 0 1.0529038397549960e-01
GD_9_12 ref NI_9 NA_12 0 -1.1917937042953609e-02
GD_9_13 ref NI_9 NA_13 0 -1.4782461685196554e-02
GD_9_14 ref NI_9 NA_14 0 -1.0227387935318832e-02
GD_9_15 ref NI_9 NA_15 0 -1.2488464997111939e-02
GD_9_16 ref NI_9 NA_16 0 9.1729737038995034e-04
GD_9_17 ref NI_9 NA_17 0 -3.1487307812491157e-02
GD_9_18 ref NI_9 NA_18 0 -3.8739194995304239e-02
GD_9_19 ref NI_9 NA_19 0 -2.4318213563856692e-02
GD_9_20 ref NI_9 NA_20 0 -2.6415626636980643e-02
*
* Port 10
VI_10 a_10 NI_10 0
RI_10 NI_10 ref 1.0000000000000001e-01
GC_10_1 ref NI_10 NS_1 0 3.5300255928695366e-02
GC_10_2 ref NI_10 NS_2 0 -1.8228117597264997e-03
GC_10_3 ref NI_10 NS_3 0 6.0817511553891428e-05
GC_10_4 ref NI_10 NS_4 0 -2.2998962640536662e-04
GC_10_5 ref NI_10 NS_5 0 1.3866286769338263e-02
GC_10_6 ref NI_10 NS_6 0 1.4152647096997751e-02
GC_10_7 ref NI_10 NS_7 0 -1.6235257157520759e-03
GC_10_8 ref NI_10 NS_8 0 3.9161762226266276e-05
GC_10_9 ref NI_10 NS_9 0 2.0125844021826513e-03
GC_10_10 ref NI_10 NS_10 0 -4.9505556486212996e-03
GC_10_11 ref NI_10 NS_11 0 4.5566183859647915e-03
GC_10_12 ref NI_10 NS_12 0 8.9409047230438359e-04
GC_10_13 ref NI_10 NS_13 0 -5.7192896340153400e-03
GC_10_14 ref NI_10 NS_14 0 3.8980870444920951e-03
GC_10_15 ref NI_10 NS_15 0 -2.2697609724514570e-03
GC_10_16 ref NI_10 NS_16 0 2.0300554188219830e-03
GC_10_17 ref NI_10 NS_17 0 -3.4557571966529819e-03
GC_10_18 ref NI_10 NS_18 0 3.3074243264717904e-03
GC_10_19 ref NI_10 NS_19 0 7.5517159711084234e-03
GC_10_20 ref NI_10 NS_20 0 -7.3193387690629718e-04
GC_10_21 ref NI_10 NS_21 0 -3.2513403327967753e-02
GC_10_22 ref NI_10 NS_22 0 4.0637144512179146e-02
GC_10_23 ref NI_10 NS_23 0 -1.2445969503755725e-03
GC_10_24 ref NI_10 NS_24 0 -1.4335829208614956e-03
GC_10_25 ref NI_10 NS_25 0 1.6766532677482542e-05
GC_10_26 ref NI_10 NS_26 0 5.6459367849474140e-02
GC_10_27 ref NI_10 NS_27 0 -1.4407681139667094e-02
GC_10_28 ref NI_10 NS_28 0 -1.1771792834565841e-03
GC_10_29 ref NI_10 NS_29 0 -6.3021389779339366e-03
GC_10_30 ref NI_10 NS_30 0 4.6254879891723623e-03
GC_10_31 ref NI_10 NS_31 0 -2.6319214328584567e-03
GC_10_32 ref NI_10 NS_32 0 2.0613237244251677e-03
GC_10_33 ref NI_10 NS_33 0 -2.3799275494484344e-02
GC_10_34 ref NI_10 NS_34 0 2.8584229202616329e-02
GC_10_35 ref NI_10 NS_35 0 3.6451178247916315e-04
GC_10_36 ref NI_10 NS_36 0 -7.8755642893899892e-04
GC_10_37 ref NI_10 NS_37 0 7.6364007232966241e-02
GC_10_38 ref NI_10 NS_38 0 -1.7221722953535062e-01
GC_10_39 ref NI_10 NS_39 0 -3.8918845291447624e-02
GC_10_40 ref NI_10 NS_40 0 -1.3906383914060660e-03
GC_10_41 ref NI_10 NS_41 0 -2.8699068396547914e-02
GC_10_42 ref NI_10 NS_42 0 6.2707538189573545e-02
GC_10_43 ref NI_10 NS_43 0 -1.1998368051964962e-02
GC_10_44 ref NI_10 NS_44 0 -1.2714093963233366e-03
GC_10_45 ref NI_10 NS_45 0 2.3833972625282862e-03
GC_10_46 ref NI_10 NS_46 0 -5.3891919316781675e-03
GC_10_47 ref NI_10 NS_47 0 4.4496587308969285e-03
GC_10_48 ref NI_10 NS_48 0 9.4396545991761696e-04
GC_10_49 ref NI_10 NS_49 0 2.3950787433509495e-03
GC_10_50 ref NI_10 NS_50 0 -5.0039932709443216e-03
GC_10_51 ref NI_10 NS_51 0 4.3409736444867302e-03
GC_10_52 ref NI_10 NS_52 0 9.3447599889797805e-04
GC_10_53 ref NI_10 NS_53 0 3.4171544782188304e-03
GC_10_54 ref NI_10 NS_54 0 -5.8207178317326745e-03
GC_10_55 ref NI_10 NS_55 0 4.7996209783072010e-03
GC_10_56 ref NI_10 NS_56 0 8.5940052816394072e-04
GC_10_57 ref NI_10 NS_57 0 4.8130093804475676e-03
GC_10_58 ref NI_10 NS_58 0 -7.2577364750834299e-03
GC_10_59 ref NI_10 NS_59 0 4.7705124745569243e-03
GC_10_60 ref NI_10 NS_60 0 9.7637323198938332e-04
GC_10_61 ref NI_10 NS_61 0 1.7603841854069403e-03
GC_10_62 ref NI_10 NS_62 0 -4.1795704581023907e-03
GC_10_63 ref NI_10 NS_63 0 4.7782823297094108e-03
GC_10_64 ref NI_10 NS_64 0 7.4433171287451765e-04
GC_10_65 ref NI_10 NS_65 0 2.6992685525341575e-04
GC_10_66 ref NI_10 NS_66 0 -5.1517203510348820e-03
GC_10_67 ref NI_10 NS_67 0 1.0174794657264617e-02
GC_10_68 ref NI_10 NS_68 0 -6.1608520665440371e-04
GC_10_69 ref NI_10 NS_69 0 2.3188214060741344e-03
GC_10_70 ref NI_10 NS_70 0 -6.6584866541215806e-03
GC_10_71 ref NI_10 NS_71 0 1.0156223417292333e-02
GC_10_72 ref NI_10 NS_72 0 -5.1022842417697311e-04
GC_10_73 ref NI_10 NS_73 0 4.3296140607308803e-03
GC_10_74 ref NI_10 NS_74 0 -3.1552548145022704e-03
GC_10_75 ref NI_10 NS_75 0 8.6404586501765916e-03
GC_10_76 ref NI_10 NS_76 0 -6.3411557087872448e-04
GC_10_77 ref NI_10 NS_77 0 4.7651189479677074e-03
GC_10_78 ref NI_10 NS_78 0 -5.3959114748145963e-03
GC_10_79 ref NI_10 NS_79 0 9.3116685425726885e-03
GC_10_80 ref NI_10 NS_80 0 -5.5516023351185999e-04
GD_10_1 ref NI_10 NA_1 0 8.5874757076426344e-03
GD_10_2 ref NI_10 NA_2 0 -1.9572297682691117e-01
GD_10_3 ref NI_10 NA_3 0 -2.4445185729971779e-02
GD_10_4 ref NI_10 NA_4 0 2.2526736349065019e-02
GD_10_5 ref NI_10 NA_5 0 -1.3882099964495617e-02
GD_10_6 ref NI_10 NA_6 0 8.3381485695514568e-02
GD_10_7 ref NI_10 NA_7 0 -4.1790232041075341e-02
GD_10_8 ref NI_10 NA_8 0 2.5421596992395747e-02
GD_10_9 ref NI_10 NA_9 0 4.7017075822654054e-02
GD_10_10 ref NI_10 NA_10 0 5.8742026576188859e+00
GD_10_11 ref NI_10 NA_11 0 6.9397932809537710e-02
GD_10_12 ref NI_10 NA_12 0 -2.3474374273053173e-02
GD_10_13 ref NI_10 NA_13 0 -2.5080415819632041e-02
GD_10_14 ref NI_10 NA_14 0 -2.8833961571312249e-02
GD_10_15 ref NI_10 NA_15 0 -3.0505785949084731e-02
GD_10_16 ref NI_10 NA_16 0 -2.4319825593754330e-02
GD_10_17 ref NI_10 NA_17 0 -2.6271162204425470e-02
GD_10_18 ref NI_10 NA_18 0 -3.7155511238500062e-02
GD_10_19 ref NI_10 NA_19 0 -3.7065419688575255e-02
GD_10_20 ref NI_10 NA_20 0 -4.2309809193900282e-02
*
* Port 11
VI_11 a_11 NI_11 0
RI_11 NI_11 ref 1.0000000000000001e-01
GC_11_1 ref NI_11 NS_1 0 3.0730757341658907e-02
GC_11_2 ref NI_11 NS_2 0 3.5881357122344347e-03
GC_11_3 ref NI_11 NS_3 0 -1.6458293887039934e-03
GC_11_4 ref NI_11 NS_4 0 -2.4433226304859131e-04
GC_11_5 ref NI_11 NS_5 0 4.8822471696422353e-03
GC_11_6 ref NI_11 NS_6 0 2.1700206332533348e-02
GC_11_7 ref NI_11 NS_7 0 -3.1208018989529454e-03
GC_11_8 ref NI_11 NS_8 0 -2.9176326894006279e-05
GC_11_9 ref NI_11 NS_9 0 1.9783677022343037e-03
GC_11_10 ref NI_11 NS_10 0 -5.7843038207411905e-03
GC_11_11 ref NI_11 NS_11 0 5.5950990458403099e-03
GC_11_12 ref NI_11 NS_12 0 6.8600530258373937e-04
GC_11_13 ref NI_11 NS_13 0 -4.3767440590430267e-03
GC_11_14 ref NI_11 NS_14 0 2.2487859502335790e-03
GC_11_15 ref NI_11 NS_15 0 -1.3342767205597641e-03
GC_11_16 ref NI_11 NS_16 0 1.8944632171983733e-03
GC_11_17 ref NI_11 NS_17 0 3.0537391296893189e-03
GC_11_18 ref NI_11 NS_18 0 -6.8974795324519009e-03
GC_11_19 ref NI_11 NS_19 0 9.5434041250032960e-03
GC_11_20 ref NI_11 NS_20 0 -3.5651837161929220e-04
GC_11_21 ref NI_11 NS_21 0 -1.3593690102206731e-02
GC_11_22 ref NI_11 NS_22 0 8.2347913525563296e-03
GC_11_23 ref NI_11 NS_23 0 8.1222550384177014e-03
GC_11_24 ref NI_11 NS_24 0 -1.0583222716344515e-03
GC_11_25 ref NI_11 NS_25 0 -2.1544433468959418e-02
GC_11_26 ref NI_11 NS_26 0 2.4870396809032986e-02
GC_11_27 ref NI_11 NS_27 0 2.7727335732368550e-03
GC_11_28 ref NI_11 NS_28 0 -1.1730602873328078e-03
GC_11_29 ref NI_11 NS_29 0 -4.9309689044062530e-03
GC_11_30 ref NI_11 NS_30 0 3.0473208621307306e-03
GC_11_31 ref NI_11 NS_31 0 -1.7691674296866858e-03
GC_11_32 ref NI_11 NS_32 0 1.9371633264307455e-03
GC_11_33 ref NI_11 NS_33 0 -4.0034559535178149e-02
GC_11_34 ref NI_11 NS_34 0 6.7666886178897365e-02
GC_11_35 ref NI_11 NS_35 0 -1.2622380715487932e-02
GC_11_36 ref NI_11 NS_36 0 -1.1545719612689523e-03
GC_11_37 ref NI_11 NS_37 0 -2.8699068396547848e-02
GC_11_38 ref NI_11 NS_38 0 6.2707538189573545e-02
GC_11_39 ref NI_11 NS_39 0 -1.1998368051964973e-02
GC_11_40 ref NI_11 NS_40 0 -1.2714093963233290e-03
GC_11_41 ref NI_11 NS_41 0 6.1010463734019929e-02
GC_11_42 ref NI_11 NS_42 0 -1.0850298276455250e-01
GC_11_43 ref NI_11 NS_43 0 -6.3889258410653127e-02
GC_11_44 ref NI_11 NS_44 0 -1.4007391571715245e-03
GC_11_45 ref NI_11 NS_45 0 2.2987874092542829e-03
GC_11_46 ref NI_11 NS_46 0 -6.3083293230259451e-03
GC_11_47 ref NI_11 NS_47 0 5.5839584887896459e-03
GC_11_48 ref NI_11 NS_48 0 7.2070833728793491e-04
GC_11_49 ref NI_11 NS_49 0 2.1031331874007530e-03
GC_11_50 ref NI_11 NS_50 0 -5.7233831069176937e-03
GC_11_51 ref NI_11 NS_51 0 5.4448519448358429e-03
GC_11_52 ref NI_11 NS_52 0 7.0481243758772688e-04
GC_11_53 ref NI_11 NS_53 0 2.6878651348358038e-03
GC_11_54 ref NI_11 NS_54 0 -6.0847668246233159e-03
GC_11_55 ref NI_11 NS_55 0 5.9391386578784991e-03
GC_11_56 ref NI_11 NS_56 0 5.8233794460757558e-04
GC_11_57 ref NI_11 NS_57 0 4.7999397300632577e-03
GC_11_58 ref NI_11 NS_58 0 -8.3239129882662320e-03
GC_11_59 ref NI_11 NS_59 0 6.1458024741616844e-03
GC_11_60 ref NI_11 NS_60 0 6.9736427317387199e-04
GC_11_61 ref NI_11 NS_61 0 -3.5778628075749626e-04
GC_11_62 ref NI_11 NS_62 0 -3.2971051866954506e-03
GC_11_63 ref NI_11 NS_63 0 5.7059095057665514e-03
GC_11_64 ref NI_11 NS_64 0 4.4939342967574645e-04
GC_11_65 ref NI_11 NS_65 0 7.4723866500227259e-03
GC_11_66 ref NI_11 NS_66 0 -1.2537106852881164e-02
GC_11_67 ref NI_11 NS_67 0 1.0694376695554491e-02
GC_11_68 ref NI_11 NS_68 0 -2.0432355780195354e-04
GC_11_69 ref NI_11 NS_69 0 7.2899952132675135e-03
GC_11_70 ref NI_11 NS_70 0 -1.1543212827061900e-02
GC_11_71 ref NI_11 NS_71 0 1.0097481090059816e-02
GC_11_72 ref NI_11 NS_72 0 -1.3054092763372483e-04
GC_11_73 ref NI_11 NS_73 0 6.8902809822532054e-03
GC_11_74 ref NI_11 NS_74 0 -1.0942560764763532e-02
GC_11_75 ref NI_11 NS_75 0 1.0203154810632321e-02
GC_11_76 ref NI_11 NS_76 0 -2.4370254070188338e-04
GC_11_77 ref NI_11 NS_77 0 7.3108635505052654e-03
GC_11_78 ref NI_11 NS_78 0 -1.1476378703946620e-02
GC_11_79 ref NI_11 NS_79 0 1.0134094938095967e-02
GC_11_80 ref NI_11 NS_80 0 -1.6812720609381377e-04
GD_11_1 ref NI_11 NA_1 0 4.3114215844158033e-02
GD_11_2 ref NI_11 NA_2 0 -1.6802929370865735e-01
GD_11_3 ref NI_11 NA_3 0 -2.2732275935450318e-02
GD_11_4 ref NI_11 NA_4 0 1.7683553767405394e-02
GD_11_5 ref NI_11 NA_5 0 -3.1959869344686635e-02
GD_11_6 ref NI_11 NA_6 0 3.6230712403043999e-02
GD_11_7 ref NI_11 NA_7 0 5.1079430671428686e-02
GD_11_8 ref NI_11 NA_8 0 2.0365080672642252e-02
GD_11_9 ref NI_11 NA_9 0 1.0529038397549988e-01
GD_11_10 ref NI_11 NA_10 0 6.9397932809537086e-02
GD_11_11 ref NI_11 NA_11 0 5.9662625683140424e+00
GD_11_12 ref NI_11 NA_12 0 -2.1437864244857906e-02
GD_11_13 ref NI_11 NA_13 0 -2.2261621175918775e-02
GD_11_14 ref NI_11 NA_14 0 -2.4444572918059952e-02
GD_11_15 ref NI_11 NA_15 0 -2.8904755063643497e-02
GD_11_16 ref NI_11 NA_16 0 -1.3982201493589603e-02
GD_11_17 ref NI_11 NA_17 0 -4.6072814553023492e-02
GD_11_18 ref NI_11 NA_18 0 -5.1069747722208181e-02
GD_11_19 ref NI_11 NA_19 0 -4.1635650943180655e-02
GD_11_20 ref NI_11 NA_20 0 -4.5196968090929025e-02
*
* Port 12
VI_12 a_12 NI_12 0
RI_12 NI_12 ref 1.0000000000000001e-01
GC_12_1 ref NI_12 NS_1 0 2.0890907117942632e-02
GC_12_2 ref NI_12 NS_2 0 3.3983544857926411e-03
GC_12_3 ref NI_12 NS_3 0 -1.6019195657775831e-04
GC_12_4 ref NI_12 NS_4 0 8.6855291474740565e-05
GC_12_5 ref NI_12 NS_5 0 1.5045715079444574e-02
GC_12_6 ref NI_12 NS_6 0 1.2496351178937826e-02
GC_12_7 ref NI_12 NS_7 0 -1.2154106851102893e-03
GC_12_8 ref NI_12 NS_8 0 -7.4606075806831349e-05
GC_12_9 ref NI_12 NS_9 0 -1.4133305763291174e-02
GC_12_10 ref NI_12 NS_10 0 9.2490272023658074e-02
GC_12_11 ref NI_12 NS_11 0 -2.4172888850526951e-02
GC_12_12 ref NI_12 NS_12 0 -2.3819788906323091e-03
GC_12_13 ref NI_12 NS_13 0 5.6895046926430668e-03
GC_12_14 ref NI_12 NS_14 0 -3.1113158734169819e-03
GC_12_15 ref NI_12 NS_15 0 5.4327540308620088e-03
GC_12_16 ref NI_12 NS_16 0 1.5906969542676963e-04
GC_12_17 ref NI_12 NS_17 0 1.8124447107723345e-03
GC_12_18 ref NI_12 NS_18 0 -4.5302166173685236e-03
GC_12_19 ref NI_12 NS_19 0 3.0220262885295363e-03
GC_12_20 ref NI_12 NS_20 0 1.2552603319923666e-03
GC_12_21 ref NI_12 NS_21 0 3.8433824797016462e-03
GC_12_22 ref NI_12 NS_22 0 -6.5259366081641314e-03
GC_12_23 ref NI_12 NS_23 0 3.5833843505263105e-03
GC_12_24 ref NI_12 NS_24 0 1.2367113098639792e-03
GC_12_25 ref NI_12 NS_25 0 3.4351767862184921e-03
GC_12_26 ref NI_12 NS_26 0 -6.0244061666889590e-03
GC_12_27 ref NI_12 NS_27 0 3.8458910738338598e-03
GC_12_28 ref NI_12 NS_28 0 1.1308730070171660e-03
GC_12_29 ref NI_12 NS_29 0 6.3195581310557846e-03
GC_12_30 ref NI_12 NS_30 0 -7.6156079559333125e-03
GC_12_31 ref NI_12 NS_31 0 6.6803199385642893e-03
GC_12_32 ref NI_12 NS_32 0 3.1399492158779696e-04
GC_12_33 ref NI_12 NS_33 0 -3.9737649900544372e-03
GC_12_34 ref NI_12 NS_34 0 1.3298120804677618e-04
GC_12_35 ref NI_12 NS_35 0 5.4930965540927702e-03
GC_12_36 ref NI_12 NS_36 0 2.8225934303420280e-04
GC_12_37 ref NI_12 NS_37 0 2.3833972625281097e-03
GC_12_38 ref NI_12 NS_38 0 -5.3891919316780635e-03
GC_12_39 ref NI_12 NS_39 0 4.4496587308968999e-03
GC_12_40 ref NI_12 NS_40 0 9.4396545991762130e-04
GC_12_41 ref NI_12 NS_41 0 2.2987874092542612e-03
GC_12_42 ref NI_12 NS_42 0 -6.3083293230259121e-03
GC_12_43 ref NI_12 NS_43 0 5.5839584887896233e-03
GC_12_44 ref NI_12 NS_44 0 7.2070833728794391e-04
GC_12_45 ref NI_12 NS_45 0 -4.9725204200568043e-02
GC_12_46 ref NI_12 NS_46 0 -1.4363401759672864e-01
GC_12_47 ref NI_12 NS_47 0 -2.2253036757557392e-02
GC_12_48 ref NI_12 NS_48 0 -3.0721294306542603e-03
GC_12_49 ref NI_12 NS_49 0 5.4788621179337998e-02
GC_12_50 ref NI_12 NS_50 0 7.0241749816857171e-02
GC_12_51 ref NI_12 NS_51 0 -2.8493073476513031e-02
GC_12_52 ref NI_12 NS_52 0 -1.7604439653255003e-03
GC_12_53 ref NI_12 NS_53 0 -7.8784533833870275e-03
GC_12_54 ref NI_12 NS_54 0 5.3965065096110701e-03
GC_12_55 ref NI_12 NS_55 0 9.1554001760759535e-03
GC_12_56 ref NI_12 NS_56 0 -1.3022933340093663e-03
GC_12_57 ref NI_12 NS_57 0 -9.0681263686072412e-03
GC_12_58 ref NI_12 NS_58 0 1.1772179180006474e-02
GC_12_59 ref NI_12 NS_59 0 7.0859055937608894e-03
GC_12_60 ref NI_12 NS_60 0 -1.4383331969161567e-03
GC_12_61 ref NI_12 NS_61 0 4.7884464570020123e-04
GC_12_62 ref NI_12 NS_62 0 -3.4318541482594297e-03
GC_12_63 ref NI_12 NS_63 0 1.0874717164699885e-02
GC_12_64 ref NI_12 NS_64 0 -1.0795808965021214e-03
GC_12_65 ref NI_12 NS_65 0 1.9893018287280347e-03
GC_12_66 ref NI_12 NS_66 0 -4.8548737679848866e-03
GC_12_67 ref NI_12 NS_67 0 2.9262707456127099e-03
GC_12_68 ref NI_12 NS_68 0 1.3065195298795126e-03
GC_12_69 ref NI_12 NS_69 0 8.0121234530679156e-04
GC_12_70 ref NI_12 NS_70 0 -3.4687840049621270e-03
GC_12_71 ref NI_12 NS_71 0 2.7706646379340233e-03
GC_12_72 ref NI_12 NS_72 0 1.2507239570749410e-03
GC_12_73 ref NI_12 NS_73 0 2.5678327653704093e-03
GC_12_74 ref NI_12 NS_74 0 -5.4747865744941655e-03
GC_12_75 ref NI_12 NS_75 0 2.9931323184627435e-03
GC_12_76 ref NI_12 NS_76 0 1.3266047254382818e-03
GC_12_77 ref NI_12 NS_77 0 1.7723258086459826e-03
GC_12_78 ref NI_12 NS_78 0 -4.6671288428874044e-03
GC_12_79 ref NI_12 NS_79 0 2.8624624997162364e-03
GC_12_80 ref NI_12 NS_80 0 1.3098463919863352e-03
GD_12_1 ref NI_12 NA_1 0 -2.3047551997525714e-02
GD_12_2 ref NI_12 NA_2 0 -1.5058928154930445e-01
GD_12_3 ref NI_12 NA_3 0 8.2666297656551466e-02
GD_12_4 ref NI_12 NA_4 0 -3.3507876002518963e-02
GD_12_5 ref NI_12 NA_5 0 -1.4728953020019826e-02
GD_12_6 ref NI_12 NA_6 0 -2.0495386470083414e-02
GD_12_7 ref NI_12 NA_7 0 -2.3627300682349521e-02
GD_12_8 ref NI_12 NA_8 0 -2.9671662570505505e-02
GD_12_9 ref NI_12 NA_9 0 -1.1917937042952534e-02
GD_12_10 ref NI_12 NA_10 0 -2.3474374273051872e-02
GD_12_11 ref NI_12 NA_11 0 -2.1437864244857840e-02
GD_12_12 ref NI_12 NA_12 0 6.1991413475888875e+00
GD_12_13 ref NI_12 NA_13 0 -1.3245848305299526e-01
GD_12_14 ref NI_12 NA_14 0 1.0996513438093243e-02
GD_12_15 ref NI_12 NA_15 0 1.3831442436260853e-02
GD_12_16 ref NI_12 NA_16 0 -2.4251784857637484e-02
GD_12_17 ref NI_12 NA_17 0 -1.2289005267980740e-02
GD_12_18 ref NI_12 NA_18 0 -1.2795726212045113e-02
GD_12_19 ref NI_12 NA_19 0 -1.2577407169882633e-02
GD_12_20 ref NI_12 NA_20 0 -1.1194418651189877e-02
*
* Port 13
VI_13 a_13 NI_13 0
RI_13 NI_13 ref 1.0000000000000001e-01
GC_13_1 ref NI_13 NS_1 0 2.3245404660625121e-02
GC_13_2 ref NI_13 NS_2 0 1.4174777491425857e-03
GC_13_3 ref NI_13 NS_3 0 1.8459854191243079e-04
GC_13_4 ref NI_13 NS_4 0 8.1164679469741699e-05
GC_13_5 ref NI_13 NS_5 0 1.8643367013038543e-02
GC_13_6 ref NI_13 NS_6 0 1.1142246964277725e-02
GC_13_7 ref NI_13 NS_7 0 -1.2390393939128068e-03
GC_13_8 ref NI_13 NS_8 0 -6.8247452797132321e-05
GC_13_9 ref NI_13 NS_9 0 -6.7211142615438438e-02
GC_13_10 ref NI_13 NS_10 0 7.3088889541796515e-02
GC_13_11 ref NI_13 NS_11 0 -6.1413861132133636e-03
GC_13_12 ref NI_13 NS_12 0 -2.4253664588183696e-03
GC_13_13 ref NI_13 NS_13 0 4.0920465417143854e-03
GC_13_14 ref NI_13 NS_14 0 -3.0820297983495675e-03
GC_13_15 ref NI_13 NS_15 0 5.3129225597145103e-03
GC_13_16 ref NI_13 NS_16 0 2.6954244845991845e-04
GC_13_17 ref NI_13 NS_17 0 1.9541286934144099e-03
GC_13_18 ref NI_13 NS_18 0 -4.4230415141580650e-03
GC_13_19 ref NI_13 NS_19 0 2.9774565016640357e-03
GC_13_20 ref NI_13 NS_20 0 1.2545138409760840e-03
GC_13_21 ref NI_13 NS_21 0 3.8141437193379936e-03
GC_13_22 ref NI_13 NS_22 0 -6.3192296704365743e-03
GC_13_23 ref NI_13 NS_23 0 3.5368066292874732e-03
GC_13_24 ref NI_13 NS_24 0 1.2321909041048205e-03
GC_13_25 ref NI_13 NS_25 0 3.4483930809772428e-03
GC_13_26 ref NI_13 NS_26 0 -5.7542113990180221e-03
GC_13_27 ref NI_13 NS_27 0 3.7731804906642290e-03
GC_13_28 ref NI_13 NS_28 0 1.1245823164990560e-03
GC_13_29 ref NI_13 NS_29 0 5.7610812779098786e-03
GC_13_30 ref NI_13 NS_30 0 -7.6297226262610329e-03
GC_13_31 ref NI_13 NS_31 0 6.3760337437815248e-03
GC_13_32 ref NI_13 NS_32 0 4.3045866187548551e-04
GC_13_33 ref NI_13 NS_33 0 -3.7890241397483633e-03
GC_13_34 ref NI_13 NS_34 0 1.1495651768147883e-03
GC_13_35 ref NI_13 NS_35 0 5.1179440105098475e-03
GC_13_36 ref NI_13 NS_36 0 2.6340887789768589e-04
GC_13_37 ref NI_13 NS_37 0 2.3950787433510627e-03
GC_13_38 ref NI_13 NS_38 0 -5.0039932709443806e-03
GC_13_39 ref NI_13 NS_39 0 4.3409736444867415e-03
GC_13_40 ref NI_13 NS_40 0 9.3447599889797913e-04
GC_13_41 ref NI_13 NS_41 0 2.1031331874007955e-03
GC_13_42 ref NI_13 NS_42 0 -5.7233831069177250e-03
GC_13_43 ref NI_13 NS_43 0 5.4448519448358542e-03
GC_13_44 ref NI_13 NS_44 0 7.0481243758772503e-04
GC_13_45 ref NI_13 NS_45 0 5.4788621179338033e-02
GC_13_46 ref NI_13 NS_46 0 7.0241749816857157e-02
GC_13_47 ref NI_13 NS_47 0 -2.8493073476513024e-02
GC_13_48 ref NI_13 NS_48 0 -1.7604439653255003e-03
GC_13_49 ref NI_13 NS_49 0 8.1470682745678116e-03
GC_13_50 ref NI_13 NS_50 0 -1.5610027215866715e-01
GC_13_51 ref NI_13 NS_51 0 -2.8127549263050312e-02
GC_13_52 ref NI_13 NS_52 0 -2.7506612508277858e-03
GC_13_53 ref NI_13 NS_53 0 -1.0255880288030273e-02
GC_13_54 ref NI_13 NS_54 0 1.6347071190100235e-02
GC_13_55 ref NI_13 NS_55 0 5.3070920104960869e-03
GC_13_56 ref NI_13 NS_56 0 -1.4527750312452138e-03
GC_13_57 ref NI_13 NS_57 0 -7.7487420878625760e-03
GC_13_58 ref NI_13 NS_58 0 2.3423589692400333e-02
GC_13_59 ref NI_13 NS_59 0 2.1591746845103297e-03
GC_13_60 ref NI_13 NS_60 0 -1.5535815789288199e-03
GC_13_61 ref NI_13 NS_61 0 -4.6597505273712871e-03
GC_13_62 ref NI_13 NS_62 0 5.1213989345414287e-03
GC_13_63 ref NI_13 NS_63 0 8.7256693544454974e-03
GC_13_64 ref NI_13 NS_64 0 -1.2801987749607386e-03
GC_13_65 ref NI_13 NS_65 0 2.0665297464134529e-03
GC_13_66 ref NI_13 NS_66 0 -4.7280634257412793e-03
GC_13_67 ref NI_13 NS_67 0 2.8740190573868919e-03
GC_13_68 ref NI_13 NS_68 0 1.3083616081940223e-03
GC_13_69 ref NI_13 NS_69 0 1.0437257079902184e-03
GC_13_70 ref NI_13 NS_70 0 -3.4220404463263603e-03
GC_13_71 ref NI_13 NS_71 0 2.7225127641638566e-03
GC_13_72 ref NI_13 NS_72 0 1.2538608937224182e-03
GC_13_73 ref NI_13 NS_73 0 2.6011510182231967e-03
GC_13_74 ref NI_13 NS_74 0 -5.3073592837168402e-03
GC_13_75 ref NI_13 NS_75 0 2.9359449644377113e-03
GC_13_76 ref NI_13 NS_76 0 1.3270599671737489e-03
GC_13_77 ref NI_13 NS_77 0 1.8735924149847719e-03
GC_13_78 ref NI_13 NS_78 0 -4.5375108567869173e-03
GC_13_79 ref NI_13 NS_79 0 2.8123169727800692e-03
GC_13_80 ref NI_13 NS_80 0 1.3098865418518686e-03
GD_13_1 ref NI_13 NA_1 0 -1.5114423816284439e-02
GD_13_2 ref NI_13 NA_2 0 -1.6478736593179308e-01
GD_13_3 ref NI_13 NA_3 0 2.1461440026343936e-01
GD_13_4 ref NI_13 NA_4 0 -2.8159291305995732e-02
GD_13_5 ref NI_13 NA_5 0 -1.6358666854832726e-02
GD_13_6 ref NI_13 NA_6 0 -2.1369596643511259e-02
GD_13_7 ref NI_13 NA_7 0 -2.4940606503881479e-02
GD_13_8 ref NI_13 NA_8 0 -2.7370723391801438e-02
GD_13_9 ref NI_13 NA_9 0 -1.4782461685197066e-02
GD_13_10 ref NI_13 NA_10 0 -2.5080415819632981e-02
GD_13_11 ref NI_13 NA_11 0 -2.2261621175918955e-02
GD_13_12 ref NI_13 NA_12 0 -1.3245848305299529e-01
GD_13_13 ref NI_13 NA_13 0 6.0127498560777264e+00
GD_13_14 ref NI_13 NA_14 0 2.4616981151566922e-02
GD_13_15 ref NI_13 NA_15 0 1.7585519207223007e-02
GD_13_16 ref NI_13 NA_16 0 -3.8355138064905458e-03
GD_13_17 ref NI_13 NA_17 0 -1.3525697348552308e-02
GD_13_18 ref NI_13 NA_18 0 -1.4835380924528019e-02
GD_13_19 ref NI_13 NA_19 0 -1.3706728238871297e-02
GD_13_20 ref NI_13 NA_20 0 -1.2675100876624107e-02
*
* Port 14
VI_14 a_14 NI_14 0
RI_14 NI_14 ref 1.0000000000000001e-01
GC_14_1 ref NI_14 NS_1 0 2.2072605066998600e-02
GC_14_2 ref NI_14 NS_2 0 -1.8225559884705100e-04
GC_14_3 ref NI_14 NS_3 0 1.0757152549683167e-03
GC_14_4 ref NI_14 NS_4 0 4.1689468599510527e-05
GC_14_5 ref NI_14 NS_5 0 9.1746116426500730e-03
GC_14_6 ref NI_14 NS_6 0 1.2592484234849174e-02
GC_14_7 ref NI_14 NS_7 0 -1.3674938162456835e-04
GC_14_8 ref NI_14 NS_8 0 -1.0211672166455946e-04
GC_14_9 ref NI_14 NS_9 0 3.7766523581971075e-03
GC_14_10 ref NI_14 NS_10 0 -9.4081075663775549e-03
GC_14_11 ref NI_14 NS_11 0 1.2567822443224177e-02
GC_14_12 ref NI_14 NS_12 0 -9.9865451082319394e-04
GC_14_13 ref NI_14 NS_13 0 3.4314381408652654e-03
GC_14_14 ref NI_14 NS_14 0 -5.2264261226607879e-03
GC_14_15 ref NI_14 NS_15 0 3.4663806718807314e-03
GC_14_16 ref NI_14 NS_16 0 1.0691112406959510e-03
GC_14_17 ref NI_14 NS_17 0 3.3938498142749912e-03
GC_14_18 ref NI_14 NS_18 0 -5.5187471984684015e-03
GC_14_19 ref NI_14 NS_19 0 3.2360152210148601e-03
GC_14_20 ref NI_14 NS_20 0 1.2515226812615172e-03
GC_14_21 ref NI_14 NS_21 0 5.0503748811482063e-03
GC_14_22 ref NI_14 NS_22 0 -7.3020885204683750e-03
GC_14_23 ref NI_14 NS_23 0 3.8451873143253794e-03
GC_14_24 ref NI_14 NS_24 0 1.2117850680241221e-03
GC_14_25 ref NI_14 NS_25 0 4.6257826837517091e-03
GC_14_26 ref NI_14 NS_26 0 -6.6972772335583686e-03
GC_14_27 ref NI_14 NS_27 0 4.1506548112436731e-03
GC_14_28 ref NI_14 NS_28 0 1.0821124489479488e-03
GC_14_29 ref NI_14 NS_29 0 4.4949561704546647e-03
GC_14_30 ref NI_14 NS_30 0 -6.3748202000864290e-03
GC_14_31 ref NI_14 NS_31 0 3.1660934946837757e-03
GC_14_32 ref NI_14 NS_32 0 1.2373550340829403e-03
GC_14_33 ref NI_14 NS_33 0 -4.7855586187971070e-03
GC_14_34 ref NI_14 NS_34 0 3.3859033406878278e-03
GC_14_35 ref NI_14 NS_35 0 5.0193707039400542e-03
GC_14_36 ref NI_14 NS_36 0 5.9096083740029408e-05
GC_14_37 ref NI_14 NS_37 0 3.4171544782190290e-03
GC_14_38 ref NI_14 NS_38 0 -5.8207178317328028e-03
GC_14_39 ref NI_14 NS_39 0 4.7996209783072426e-03
GC_14_40 ref NI_14 NS_40 0 8.5940052816393334e-04
GC_14_41 ref NI_14 NS_41 0 2.6878651348360098e-03
GC_14_42 ref NI_14 NS_42 0 -6.0847668246234330e-03
GC_14_43 ref NI_14 NS_43 0 5.9391386578785243e-03
GC_14_44 ref NI_14 NS_44 0 5.8233794460757526e-04
GC_14_45 ref NI_14 NS_45 0 -7.8784533833870622e-03
GC_14_46 ref NI_14 NS_46 0 5.3965065096110640e-03
GC_14_47 ref NI_14 NS_47 0 9.1554001760759743e-03
GC_14_48 ref NI_14 NS_48 0 -1.3022933340093744e-03
GC_14_49 ref NI_14 NS_49 0 -1.0255880288030197e-02
GC_14_50 ref NI_14 NS_50 0 1.6347071190100190e-02
GC_14_51 ref NI_14 NS_51 0 5.3070920104961007e-03
GC_14_52 ref NI_14 NS_52 0 -1.4527750312452164e-03
GC_14_53 ref NI_14 NS_53 0 5.2496404752642035e-02
GC_14_54 ref NI_14 NS_54 0 -1.3988672939738805e-01
GC_14_55 ref NI_14 NS_55 0 -4.4466824862615842e-02
GC_14_56 ref NI_14 NS_56 0 -2.7715285666569116e-03
GC_14_57 ref NI_14 NS_57 0 -3.2286686478383189e-02
GC_14_58 ref NI_14 NS_58 0 1.0063539718062306e-01
GC_14_59 ref NI_14 NS_59 0 -2.2422803424863347e-02
GC_14_60 ref NI_14 NS_60 0 -2.7897416288769749e-03
GC_14_61 ref NI_14 NS_61 0 -4.3141058420375751e-02
GC_14_62 ref NI_14 NS_62 0 7.0171606571633210e-02
GC_14_63 ref NI_14 NS_63 0 -6.7829367159875685e-03
GC_14_64 ref NI_14 NS_64 0 -2.9356589033107021e-03
GC_14_65 ref NI_14 NS_65 0 3.2733641015907956e-03
GC_14_66 ref NI_14 NS_66 0 -5.6551903867827881e-03
GC_14_67 ref NI_14 NS_67 0 3.0659822389508566e-03
GC_14_68 ref NI_14 NS_68 0 1.3136713538388787e-03
GC_14_69 ref NI_14 NS_69 0 2.4249329379295872e-03
GC_14_70 ref NI_14 NS_70 0 -4.5029732525733281e-03
GC_14_71 ref NI_14 NS_71 0 2.9435998879807522e-03
GC_14_72 ref NI_14 NS_72 0 1.2605412696997153e-03
GC_14_73 ref NI_14 NS_73 0 3.8945005840188653e-03
GC_14_74 ref NI_14 NS_74 0 -6.2286294869521542e-03
GC_14_75 ref NI_14 NS_75 0 3.1581077456663722e-03
GC_14_76 ref NI_14 NS_76 0 1.3218361122516605e-03
GC_14_77 ref NI_14 NS_77 0 3.3493992356642258e-03
GC_14_78 ref NI_14 NS_78 0 -5.5904386022897082e-03
GC_14_79 ref NI_14 NS_79 0 3.0449479909304394e-03
GC_14_80 ref NI_14 NS_80 0 1.3093765671989195e-03
GD_14_1 ref NI_14 NA_1 0 5.7229644714016968e-03
GD_14_2 ref NI_14 NA_2 0 -1.3161625957332615e-01
GD_14_3 ref NI_14 NA_3 0 -2.8642766459703692e-02
GD_14_4 ref NI_14 NA_4 0 -1.5313752925022978e-02
GD_14_5 ref NI_14 NA_5 0 -2.1412775271737100e-02
GD_14_6 ref NI_14 NA_6 0 -2.5869224674451803e-02
GD_14_7 ref NI_14 NA_7 0 -2.9378908534238680e-02
GD_14_8 ref NI_14 NA_8 0 -1.6449927443025560e-02
GD_14_9 ref NI_14 NA_9 0 -1.0227387935318777e-02
GD_14_10 ref NI_14 NA_10 0 -2.8833961571313616e-02
GD_14_11 ref NI_14 NA_11 0 -2.4444572918061448e-02
GD_14_12 ref NI_14 NA_12 0 1.0996513438093568e-02
GD_14_13 ref NI_14 NA_13 0 2.4616981151566474e-02
GD_14_14 ref NI_14 NA_14 0 6.0190785745279207e+00
GD_14_15 ref NI_14 NA_15 0 7.9129839022774401e-02
GD_14_16 ref NI_14 NA_16 0 1.1585494769968427e-01
GD_14_17 ref NI_14 NA_17 0 -1.7249528247694577e-02
GD_14_18 ref NI_14 NA_18 0 -1.8883836975774046e-02
GD_14_19 ref NI_14 NA_19 0 -1.9002417245316410e-02
GD_14_20 ref NI_14 NA_20 0 -1.8686717022526975e-02
*
* Port 15
VI_15 a_15 NI_15 0
RI_15 NI_15 ref 1.0000000000000001e-01
GC_15_1 ref NI_15 NS_1 0 1.4052730017768326e-02
GC_15_2 ref NI_15 NS_2 0 2.9922609656348955e-03
GC_15_3 ref NI_15 NS_3 0 1.5245471530880043e-03
GC_15_4 ref NI_15 NS_4 0 7.4624003195837593e-05
GC_15_5 ref NI_15 NS_5 0 9.1041555182570250e-03
GC_15_6 ref NI_15 NS_6 0 1.0253529241282502e-02
GC_15_7 ref NI_15 NS_7 0 7.8149322092153537e-04
GC_15_8 ref NI_15 NS_8 0 -1.2695829024515767e-04
GC_15_9 ref NI_15 NS_9 0 -7.4872282222549673e-04
GC_15_10 ref NI_15 NS_10 0 -6.7184231947764791e-03
GC_15_11 ref NI_15 NS_11 0 1.2707458562367803e-02
GC_15_12 ref NI_15 NS_12 0 -1.1691623196492895e-03
GC_15_13 ref NI_15 NS_13 0 4.5627880432430384e-03
GC_15_14 ref NI_15 NS_14 0 -4.9307190726755722e-03
GC_15_15 ref NI_15 NS_15 0 3.7401978753445323e-03
GC_15_16 ref NI_15 NS_16 0 9.0808849179359417e-04
GC_15_17 ref NI_15 NS_17 0 3.9849116159675563e-03
GC_15_18 ref NI_15 NS_18 0 -6.2062606058572037e-03
GC_15_19 ref NI_15 NS_19 0 2.9925217592493003e-03
GC_15_20 ref NI_15 NS_20 0 1.3765645277039698e-03
GC_15_21 ref NI_15 NS_21 0 5.8031003550059268e-03
GC_15_22 ref NI_15 NS_22 0 -7.9205298786990501e-03
GC_15_23 ref NI_15 NS_23 0 3.5454218964847410e-03
GC_15_24 ref NI_15 NS_24 0 1.3388087989645069e-03
GC_15_25 ref NI_15 NS_25 0 5.5770602373815693e-03
GC_15_26 ref NI_15 NS_26 0 -7.5791734693402835e-03
GC_15_27 ref NI_15 NS_27 0 3.9400999270259827e-03
GC_15_28 ref NI_15 NS_28 0 1.2051193901602912e-03
GC_15_29 ref NI_15 NS_29 0 5.2119267243591763e-03
GC_15_30 ref NI_15 NS_30 0 -6.7571440092750621e-03
GC_15_31 ref NI_15 NS_31 0 3.7932615329425148e-03
GC_15_32 ref NI_15 NS_32 0 1.0759872890617811e-03
GC_15_33 ref NI_15 NS_33 0 -2.5881094292967660e-03
GC_15_34 ref NI_15 NS_34 0 -4.9523518650762912e-04
GC_15_35 ref NI_15 NS_35 0 6.0430818904056499e-03
GC_15_36 ref NI_15 NS_36 0 1.3262105589348415e-04
GC_15_37 ref NI_15 NS_37 0 4.8130093804475875e-03
GC_15_38 ref NI_15 NS_38 0 -7.2577364750834126e-03
GC_15_39 ref NI_15 NS_39 0 4.7705124745569061e-03
GC_15_40 ref NI_15 NS_40 0 9.7637323198939091e-04
GC_15_41 ref NI_15 NS_41 0 4.7999397300633956e-03
GC_15_42 ref NI_15 NS_42 0 -8.3239129882662979e-03
GC_15_43 ref NI_15 NS_43 0 6.1458024741616931e-03
GC_15_44 ref NI_15 NS_44 0 6.9736427317387448e-04
GC_15_45 ref NI_15 NS_45 0 -9.0681263686074667e-03
GC_15_46 ref NI_15 NS_46 0 1.1772179180006602e-02
GC_15_47 ref NI_15 NS_47 0 7.0859055937608634e-03
GC_15_48 ref NI_15 NS_48 0 -1.4383331969161576e-03
GC_15_49 ref NI_15 NS_49 0 -7.7487420878622751e-03
GC_15_50 ref NI_15 NS_50 0 2.3423589692400149e-02
GC_15_51 ref NI_15 NS_51 0 2.1591746845103770e-03
GC_15_52 ref NI_15 NS_52 0 -1.5535815789288251e-03
GC_15_53 ref NI_15 NS_53 0 -3.2286686478382898e-02
GC_15_54 ref NI_15 NS_54 0 1.0063539718062285e-01
GC_15_55 ref NI_15 NS_55 0 -2.2422803424863254e-02
GC_15_56 ref NI_15 NS_56 0 -2.7897416288769974e-03
GC_15_57 ref NI_15 NS_57 0 5.5232185090000045e-02
GC_15_58 ref NI_15 NS_58 0 -1.3161221600482931e-01
GC_15_59 ref NI_15 NS_59 0 -4.6878490477024193e-02
GC_15_60 ref NI_15 NS_60 0 -3.2377621397471899e-03
GC_15_61 ref NI_15 NS_61 0 -4.1812781105656581e-02
GC_15_62 ref NI_15 NS_62 0 5.4910336220481373e-02
GC_15_63 ref NI_15 NS_63 0 -5.4137374614050924e-04
GC_15_64 ref NI_15 NS_64 0 -2.9566239519097370e-03
GC_15_65 ref NI_15 NS_65 0 3.8531689703658533e-03
GC_15_66 ref NI_15 NS_66 0 -6.2284604185174966e-03
GC_15_67 ref NI_15 NS_67 0 2.7723923120199774e-03
GC_15_68 ref NI_15 NS_68 0 1.4404732110080169e-03
GC_15_69 ref NI_15 NS_69 0 2.8620459539446118e-03
GC_15_70 ref NI_15 NS_70 0 -5.2279600016026393e-03
GC_15_71 ref NI_15 NS_71 0 2.7572790971243338e-03
GC_15_72 ref NI_15 NS_72 0 1.3795941015075038e-03
GC_15_73 ref NI_15 NS_73 0 4.6711976940286568e-03
GC_15_74 ref NI_15 NS_74 0 -6.7919877388281317e-03
GC_15_75 ref NI_15 NS_75 0 2.8094129355960714e-03
GC_15_76 ref NI_15 NS_76 0 1.4551160623703591e-03
GC_15_77 ref NI_15 NS_77 0 4.0467570375298670e-03
GC_15_78 ref NI_15 NS_78 0 -6.2248604670729736e-03
GC_15_79 ref NI_15 NS_79 0 2.7620601480314445e-03
GC_15_80 ref NI_15 NS_80 0 1.4352948766820570e-03
GD_15_1 ref NI_15 NA_1 0 -2.8110177726122662e-02
GD_15_2 ref NI_15 NA_2 0 -1.0830089809736822e-01
GD_15_3 ref NI_15 NA_3 0 -7.6297535594242105e-03
GD_15_4 ref NI_15 NA_4 0 -2.2320566692917546e-02
GD_15_5 ref NI_15 NA_5 0 -2.0437452046784706e-02
GD_15_6 ref NI_15 NA_6 0 -2.6380933309178345e-02
GD_15_7 ref NI_15 NA_7 0 -3.0017146172325523e-02
GD_15_8 ref NI_15 NA_8 0 -2.0423685320007615e-02
GD_15_9 ref NI_15 NA_9 0 -1.2488464997114578e-02
GD_15_10 ref NI_15 NA_10 0 -3.0505785949085127e-02
GD_15_11 ref NI_15 NA_11 0 -2.8904755063644635e-02
GD_15_12 ref NI_15 NA_12 0 1.3831442436262656e-02
GD_15_13 ref NI_15 NA_13 0 1.7585519207220807e-02
GD_15_14 ref NI_15 NA_14 0 7.9129839022772180e-02
GD_15_15 ref NI_15 NA_15 0 5.9884383498506049e+00
GD_15_16 ref NI_15 NA_16 0 1.2424418210145242e-01
GD_15_17 ref NI_15 NA_17 0 -1.6652515681361321e-02
GD_15_18 ref NI_15 NA_18 0 -1.6763590063090895e-02
GD_15_19 ref NI_15 NA_19 0 -1.9583568446912208e-02
GD_15_20 ref NI_15 NA_20 0 -1.8643746090246396e-02
*
* Port 16
VI_16 a_16 NI_16 0
RI_16 NI_16 ref 1.0000000000000001e-01
GC_16_1 ref NI_16 NS_1 0 2.3496495310910935e-02
GC_16_2 ref NI_16 NS_2 0 1.2198848176116965e-03
GC_16_3 ref NI_16 NS_3 0 5.1107714980145496e-04
GC_16_4 ref NI_16 NS_4 0 2.9289500522770647e-05
GC_16_5 ref NI_16 NS_5 0 1.5645045847925008e-02
GC_16_6 ref NI_16 NS_6 0 1.2393230833013953e-02
GC_16_7 ref NI_16 NS_7 0 -1.1490298668933279e-03
GC_16_8 ref NI_16 NS_8 0 -1.0230887407810805e-04
GC_16_9 ref NI_16 NS_9 0 8.6217280066175281e-03
GC_16_10 ref NI_16 NS_10 0 -1.4009637667686080e-02
GC_16_11 ref NI_16 NS_11 0 1.2983917821292263e-02
GC_16_12 ref NI_16 NS_12 0 -7.5128632329690042e-04
GC_16_13 ref NI_16 NS_13 0 3.3783480201502003e-03
GC_16_14 ref NI_16 NS_14 0 -4.3975700746049619e-03
GC_16_15 ref NI_16 NS_15 0 3.0525318943089375e-03
GC_16_16 ref NI_16 NS_16 0 1.0981200611904186e-03
GC_16_17 ref NI_16 NS_17 0 3.0094685014424071e-03
GC_16_18 ref NI_16 NS_18 0 -5.5150368964655113e-03
GC_16_19 ref NI_16 NS_19 0 3.5989493937649709e-03
GC_16_20 ref NI_16 NS_20 0 1.1693019957226716e-03
GC_16_21 ref NI_16 NS_21 0 4.4373974845944939e-03
GC_16_22 ref NI_16 NS_22 0 -7.1497056457109154e-03
GC_16_23 ref NI_16 NS_23 0 4.2593157897623177e-03
GC_16_24 ref NI_16 NS_24 0 1.1052024623050077e-03
GC_16_25 ref NI_16 NS_25 0 3.7428528149185025e-03
GC_16_26 ref NI_16 NS_26 0 -6.0056543013332249e-03
GC_16_27 ref NI_16 NS_27 0 4.3878011981279370e-03
GC_16_28 ref NI_16 NS_28 0 9.7328639049148416e-04
GC_16_29 ref NI_16 NS_29 0 3.7074343237608557e-03
GC_16_30 ref NI_16 NS_30 0 -5.3480977123049455e-03
GC_16_31 ref NI_16 NS_31 0 2.8281786996317915e-03
GC_16_32 ref NI_16 NS_32 0 1.2527065436869159e-03
GC_16_33 ref NI_16 NS_33 0 -8.6249305942566259e-03
GC_16_34 ref NI_16 NS_34 0 9.5116690432883750e-03
GC_16_35 ref NI_16 NS_35 0 3.3636798381535544e-03
GC_16_36 ref NI_16 NS_36 0 -3.6757071659965363e-05
GC_16_37 ref NI_16 NS_37 0 1.7603841854068731e-03
GC_16_38 ref NI_16 NS_38 0 -4.1795704581023456e-03
GC_16_39 ref NI_16 NS_39 0 4.7782823297093970e-03
GC_16_40 ref NI_16 NS_40 0 7.4433171287452068e-04
GC_16_41 ref NI_16 NS_41 0 -3.5778628075749860e-04
GC_16_42 ref NI_16 NS_42 0 -3.2971051866954415e-03
GC_16_43 ref NI_16 NS_43 0 5.7059095057665462e-03
GC_16_44 ref NI_16 NS_44 0 4.4939342967574851e-04
GC_16_45 ref NI_16 NS_45 0 4.7884464570009108e-04
GC_16_46 ref NI_16 NS_46 0 -3.4318541482593816e-03
GC_16_47 ref NI_16 NS_47 0 1.0874717164699879e-02
GC_16_48 ref NI_16 NS_48 0 -1.0795808965021224e-03
GC_16_49 ref NI_16 NS_49 0 -4.6597505273712732e-03
GC_16_50 ref NI_16 NS_50 0 5.1213989345413949e-03
GC_16_51 ref NI_16 NS_51 0 8.7256693544455234e-03
GC_16_52 ref NI_16 NS_52 0 -1.2801987749607481e-03
GC_16_53 ref NI_16 NS_53 0 -4.3141058420375529e-02
GC_16_54 ref NI_16 NS_54 0 7.0171606571633086e-02
GC_16_55 ref NI_16 NS_55 0 -6.7829367159875451e-03
GC_16_56 ref NI_16 NS_56 0 -2.9356589033107008e-03
GC_16_57 ref NI_16 NS_57 0 -4.1812781105656505e-02
GC_16_58 ref NI_16 NS_58 0 5.4910336220481269e-02
GC_16_59 ref NI_16 NS_59 0 -5.4137374614046240e-04
GC_16_60 ref NI_16 NS_60 0 -2.9566239519097535e-03
GC_16_61 ref NI_16 NS_61 0 5.7070270330761612e-02
GC_16_62 ref NI_16 NS_62 0 -8.6567324141906862e-02
GC_16_63 ref NI_16 NS_63 0 -6.9779825670304677e-02
GC_16_64 ref NI_16 NS_64 0 -2.3612529789497792e-03
GC_16_65 ref NI_16 NS_65 0 3.0917228926109841e-03
GC_16_66 ref NI_16 NS_66 0 -5.8563597421857193e-03
GC_16_67 ref NI_16 NS_67 0 3.4860256405961540e-03
GC_16_68 ref NI_16 NS_68 0 1.2310430008680860e-03
GC_16_69 ref NI_16 NS_69 0 2.0673598020167941e-03
GC_16_70 ref NI_16 NS_70 0 -4.5367792280738449e-03
GC_16_71 ref NI_16 NS_71 0 3.3062297804548543e-03
GC_16_72 ref NI_16 NS_72 0 1.1833576904345877e-03
GC_16_73 ref NI_16 NS_73 0 3.8022463497064955e-03
GC_16_74 ref NI_16 NS_74 0 -6.4025507241007567e-03
GC_16_75 ref NI_16 NS_75 0 3.5289437999330240e-03
GC_16_76 ref NI_16 NS_76 0 1.2441055351755208e-03
GC_16_77 ref NI_16 NS_77 0 3.1283830397293472e-03
GC_16_78 ref NI_16 NS_78 0 -5.6782544699017319e-03
GC_16_79 ref NI_16 NS_79 0 3.3937686347777045e-03
GC_16_80 ref NI_16 NS_80 0 1.2341070532323583e-03
GD_16_1 ref NI_16 NA_1 0 -2.5506378562726598e-02
GD_16_2 ref NI_16 NA_2 0 -1.5462706622743616e-01
GD_16_3 ref NI_16 NA_3 0 -5.2529152860283222e-02
GD_16_4 ref NI_16 NA_4 0 -1.7813835475817219e-02
GD_16_5 ref NI_16 NA_5 0 -2.1169785893765961e-02
GD_16_6 ref NI_16 NA_6 0 -2.4354270941023735e-02
GD_16_7 ref NI_16 NA_7 0 -2.7408144878012582e-02
GD_16_8 ref NI_16 NA_8 0 -1.5353633696290855e-02
GD_16_9 ref NI_16 NA_9 0 9.1729737039170979e-04
GD_16_10 ref NI_16 NA_10 0 -2.4319825593753851e-02
GD_16_11 ref NI_16 NA_11 0 -1.3982201493589511e-02
GD_16_12 ref NI_16 NA_12 0 -2.4251784857636804e-02
GD_16_13 ref NI_16 NA_13 0 -3.8355138064905068e-03
GD_16_14 ref NI_16 NA_14 0 1.1585494769968269e-01
GD_16_15 ref NI_16 NA_15 0 1.2424418210145198e-01
GD_16_16 ref NI_16 NA_16 0 5.9900019363580563e+00
GD_16_17 ref NI_16 NA_17 0 -1.7872304942353340e-02
GD_16_18 ref NI_16 NA_18 0 -1.9273156974411267e-02
GD_16_19 ref NI_16 NA_19 0 -1.9278888072583017e-02
GD_16_20 ref NI_16 NA_20 0 -1.8695058969764408e-02
*
* Port 17
VI_17 a_17 NI_17 0
RI_17 NI_17 ref 1.0000000000000001e-01
GC_17_1 ref NI_17 NS_1 0 2.4807954334637249e-02
GC_17_2 ref NI_17 NS_2 0 -8.8507144653257271e-04
GC_17_3 ref NI_17 NS_3 0 1.2697124262077935e-03
GC_17_4 ref NI_17 NS_4 0 -1.6394322121645634e-04
GC_17_5 ref NI_17 NS_5 0 4.7249550526694403e-03
GC_17_6 ref NI_17 NS_6 0 1.1274453946886162e-02
GC_17_7 ref NI_17 NS_7 0 4.3557723544808695e-04
GC_17_8 ref NI_17 NS_8 0 1.5416182726153593e-04
GC_17_9 ref NI_17 NS_9 0 1.5823738456717024e-03
GC_17_10 ref NI_17 NS_10 0 -4.2505904597127855e-03
GC_17_11 ref NI_17 NS_11 0 3.0795510439950223e-03
GC_17_12 ref NI_17 NS_12 0 1.2249711975605092e-03
GC_17_13 ref NI_17 NS_13 0 -7.1688600691476633e-03
GC_17_14 ref NI_17 NS_14 0 5.7927373998504809e-03
GC_17_15 ref NI_17 NS_15 0 -3.7591875589619004e-03
GC_17_16 ref NI_17 NS_16 0 2.2802718416963068e-03
GC_17_17 ref NI_17 NS_17 0 2.6439600791595248e-02
GC_17_18 ref NI_17 NS_18 0 4.5824398150362433e-02
GC_17_19 ref NI_17 NS_19 0 -1.3917954941543478e-02
GC_17_20 ref NI_17 NS_20 0 -1.4213188300155190e-03
GC_17_21 ref NI_17 NS_21 0 -9.3215621474440399e-03
GC_17_22 ref NI_17 NS_22 0 5.6163983689877404e-03
GC_17_23 ref NI_17 NS_23 0 8.6987488509594670e-03
GC_17_24 ref NI_17 NS_24 0 -1.1019629252771511e-03
GC_17_25 ref NI_17 NS_25 0 -6.4452358248696219e-03
GC_17_26 ref NI_17 NS_26 0 2.9535039186697402e-03
GC_17_27 ref NI_17 NS_27 0 8.8499100129558594e-03
GC_17_28 ref NI_17 NS_28 0 -9.3232096682908223e-04
GC_17_29 ref NI_17 NS_29 0 -7.8042579904760703e-03
GC_17_30 ref NI_17 NS_30 0 6.6092955589324154e-03
GC_17_31 ref NI_17 NS_31 0 -4.0561765071096849e-03
GC_17_32 ref NI_17 NS_32 0 2.2849940534900091e-03
GC_17_33 ref NI_17 NS_33 0 1.4198897895960232e-03
GC_17_34 ref NI_17 NS_34 0 -5.8951949654418613e-03
GC_17_35 ref NI_17 NS_35 0 7.9793550269088576e-03
GC_17_36 ref NI_17 NS_36 0 7.3387546993837155e-05
GC_17_37 ref NI_17 NS_37 0 2.6992685525353176e-04
GC_17_38 ref NI_17 NS_38 0 -5.1517203510349696e-03
GC_17_39 ref NI_17 NS_39 0 1.0174794657264657e-02
GC_17_40 ref NI_17 NS_40 0 -6.1608520665441455e-04
GC_17_41 ref NI_17 NS_41 0 7.4723866500228629e-03
GC_17_42 ref NI_17 NS_42 0 -1.2537106852881274e-02
GC_17_43 ref NI_17 NS_43 0 1.0694376695554540e-02
GC_17_44 ref NI_17 NS_44 0 -2.0432355780196566e-04
GC_17_45 ref NI_17 NS_45 0 1.9893018287281674e-03
GC_17_46 ref NI_17 NS_46 0 -4.8548737679849742e-03
GC_17_47 ref NI_17 NS_47 0 2.9262707456127403e-03
GC_17_48 ref NI_17 NS_48 0 1.3065195298795067e-03
GC_17_49 ref NI_17 NS_49 0 2.0665297464135539e-03
GC_17_50 ref NI_17 NS_50 0 -4.7280634257413721e-03
GC_17_51 ref NI_17 NS_51 0 2.8740190573869348e-03
GC_17_52 ref NI_17 NS_52 0 1.3083616081940100e-03
GC_17_53 ref NI_17 NS_53 0 3.2733641015907839e-03
GC_17_54 ref NI_17 NS_54 0 -5.6551903867828237e-03
GC_17_55 ref NI_17 NS_55 0 3.0659822389508917e-03
GC_17_56 ref NI_17 NS_56 0 1.3136713538388647e-03
GC_17_57 ref NI_17 NS_57 0 3.8531689703660355e-03
GC_17_58 ref NI_17 NS_58 0 -6.2284604185176258e-03
GC_17_59 ref NI_17 NS_59 0 2.7723923120200286e-03
GC_17_60 ref NI_17 NS_60 0 1.4404732110080032e-03
GC_17_61 ref NI_17 NS_61 0 3.0917228926111056e-03
GC_17_62 ref NI_17 NS_62 0 -5.8563597421857931e-03
GC_17_63 ref NI_17 NS_63 0 3.4860256405961762e-03
GC_17_64 ref NI_17 NS_64 0 1.2310430008680817e-03
GC_17_65 ref NI_17 NS_65 0 -7.2918747099089479e-02
GC_17_66 ref NI_17 NS_66 0 -1.7379163899196065e-01
GC_17_67 ref NI_17 NS_67 0 -6.4024345308788871e-03
GC_17_68 ref NI_17 NS_68 0 -2.7770828434056905e-03
GC_17_69 ref NI_17 NS_69 0 -6.6714181914806743e-03
GC_17_70 ref NI_17 NS_70 0 5.3892475974102516e-02
GC_17_71 ref NI_17 NS_71 0 -1.0655370511964158e-02
GC_17_72 ref NI_17 NS_72 0 -1.7600224301588465e-03
GC_17_73 ref NI_17 NS_73 0 6.9993579909703618e-02
GC_17_74 ref NI_17 NS_74 0 3.5805524197032056e-02
GC_17_75 ref NI_17 NS_75 0 -1.7755075185827182e-02
GC_17_76 ref NI_17 NS_76 0 -1.5604202454260268e-03
GC_17_77 ref NI_17 NS_77 0 -1.9730571406450046e-02
GC_17_78 ref NI_17 NS_78 0 5.9845379524242980e-02
GC_17_79 ref NI_17 NS_79 0 -1.0258553389293833e-02
GC_17_80 ref NI_17 NS_80 0 -1.8022687183814790e-03
GD_17_1 ref NI_17 NA_1 0 3.7919424646374641e-02
GD_17_2 ref NI_17 NA_2 0 -1.2601415973134178e-01
GD_17_3 ref NI_17 NA_3 0 -1.3111410194084707e-02
GD_17_4 ref NI_17 NA_4 0 2.9413652076037945e-02
GD_17_5 ref NI_17 NA_5 0 -7.9540422698815519e-02
GD_17_6 ref NI_17 NA_6 0 1.5970622605969410e-02
GD_17_7 ref NI_17 NA_7 0 -2.3129481324446082e-03
GD_17_8 ref NI_17 NA_8 0 3.1775822556128187e-02
GD_17_9 ref NI_17 NA_9 0 -3.1487307812491649e-02
GD_17_10 ref NI_17 NA_10 0 -2.6271162204426119e-02
GD_17_11 ref NI_17 NA_11 0 -4.6072814553024255e-02
GD_17_12 ref NI_17 NA_12 0 -1.2289005267981531e-02
GD_17_13 ref NI_17 NA_13 0 -1.3525697348552761e-02
GD_17_14 ref NI_17 NA_14 0 -1.7249528247694258e-02
GD_17_15 ref NI_17 NA_15 0 -1.6652515681362477e-02
GD_17_16 ref NI_17 NA_16 0 -1.7872304942354079e-02
GD_17_17 ref NI_17 NA_17 0 6.2263374846966926e+00
GD_17_18 ref NI_17 NA_18 0 3.8211796419829767e-02
GD_17_19 ref NI_17 NA_19 0 -7.7274555662480246e-02
GD_17_20 ref NI_17 NA_20 0 1.4743254957864221e-02
*
* Port 18
VI_18 a_18 NI_18 0
RI_18 NI_18 ref 1.0000000000000001e-01
GC_18_1 ref NI_18 NS_1 0 3.5961080685743510e-02
GC_18_2 ref NI_18 NS_2 0 -6.2526962775590169e-03
GC_18_3 ref NI_18 NS_3 0 1.1155879142956643e-03
GC_18_4 ref NI_18 NS_4 0 -1.6280087325799733e-04
GC_18_5 ref NI_18 NS_5 0 1.4558612967700252e-02
GC_18_6 ref NI_18 NS_6 0 9.6202173048609632e-03
GC_18_7 ref NI_18 NS_7 0 -4.8167311486817390e-04
GC_18_8 ref NI_18 NS_8 0 1.9129804866780092e-04
GC_18_9 ref NI_18 NS_9 0 5.9827130079407372e-04
GC_18_10 ref NI_18 NS_10 0 -2.7712286663721174e-03
GC_18_11 ref NI_18 NS_11 0 2.8470699832577632e-03
GC_18_12 ref NI_18 NS_12 0 1.1717919047069410e-03
GC_18_13 ref NI_18 NS_13 0 -7.4123331612423399e-03
GC_18_14 ref NI_18 NS_14 0 5.9560591705941903e-03
GC_18_15 ref NI_18 NS_15 0 -3.5896425813922439e-03
GC_18_16 ref NI_18 NS_16 0 2.2303338460917341e-03
GC_18_17 ref NI_18 NS_17 0 -4.0282981521570255e-02
GC_18_18 ref NI_18 NS_18 0 4.3322863037911385e-02
GC_18_19 ref NI_18 NS_19 0 -2.2238509782851313e-04
GC_18_20 ref NI_18 NS_20 0 -1.7186790076418753e-03
GC_18_21 ref NI_18 NS_21 0 -3.7766461724705333e-03
GC_18_22 ref NI_18 NS_22 0 -3.5617664869837624e-03
GC_18_23 ref NI_18 NS_23 0 1.1265636071570937e-02
GC_18_24 ref NI_18 NS_24 0 -9.7980487268148125e-04
GC_18_25 ref NI_18 NS_25 0 -2.6124153785732841e-03
GC_18_26 ref NI_18 NS_26 0 -2.0585711506190601e-03
GC_18_27 ref NI_18 NS_27 0 9.9646608709839015e-03
GC_18_28 ref NI_18 NS_28 0 -8.1704215057116245e-04
GC_18_29 ref NI_18 NS_29 0 -7.8994735490149730e-03
GC_18_30 ref NI_18 NS_30 0 6.7193716584215872e-03
GC_18_31 ref NI_18 NS_31 0 -3.8940930736697014e-03
GC_18_32 ref NI_18 NS_32 0 2.2363896194432385e-03
GC_18_33 ref NI_18 NS_33 0 6.0135320188525439e-04
GC_18_34 ref NI_18 NS_34 0 -3.4543081293026286e-03
GC_18_35 ref NI_18 NS_35 0 7.0304741467414281e-03
GC_18_36 ref NI_18 NS_36 0 1.1121183651789208e-04
GC_18_37 ref NI_18 NS_37 0 2.3188214060739717e-03
GC_18_38 ref NI_18 NS_38 0 -6.6584866541215069e-03
GC_18_39 ref NI_18 NS_39 0 1.0156223417292323e-02
GC_18_40 ref NI_18 NS_40 0 -5.1022842417697614e-04
GC_18_41 ref NI_18 NS_41 0 7.2899952132675213e-03
GC_18_42 ref NI_18 NS_42 0 -1.1543212827061921e-02
GC_18_43 ref NI_18 NS_43 0 1.0097481090059830e-02
GC_18_44 ref NI_18 NS_44 0 -1.3054092763372863e-04
GC_18_45 ref NI_18 NS_45 0 8.0121234530677735e-04
GC_18_46 ref NI_18 NS_46 0 -3.4687840049621543e-03
GC_18_47 ref NI_18 NS_47 0 2.7706646379340592e-03
GC_18_48 ref NI_18 NS_48 0 1.2507239570749261e-03
GC_18_49 ref NI_18 NS_49 0 1.0437257079900324e-03
GC_18_50 ref NI_18 NS_50 0 -3.4220404463262779e-03
GC_18_51 ref NI_18 NS_51 0 2.7225127641638544e-03
GC_18_52 ref NI_18 NS_52 0 1.2538608937224104e-03
GC_18_53 ref NI_18 NS_53 0 2.4249329379295282e-03
GC_18_54 ref NI_18 NS_54 0 -4.5029732525733255e-03
GC_18_55 ref NI_18 NS_55 0 2.9435998879807699e-03
GC_18_56 ref NI_18 NS_56 0 1.2605412696997068e-03
GC_18_57 ref NI_18 NS_57 0 2.8620459539445680e-03
GC_18_58 ref NI_18 NS_58 0 -5.2279600016026696e-03
GC_18_59 ref NI_18 NS_59 0 2.7572790971243863e-03
GC_18_60 ref NI_18 NS_60 0 1.3795941015074815e-03
GC_18_61 ref NI_18 NS_61 0 2.0673598020168912e-03
GC_18_62 ref NI_18 NS_62 0 -4.5367792280739446e-03
GC_18_63 ref NI_18 NS_63 0 3.3062297804549085e-03
GC_18_64 ref NI_18 NS_64 0 1.1833576904345710e-03
GC_18_65 ref NI_18 NS_65 0 -6.6714181914811132e-03
GC_18_66 ref NI_18 NS_66 0 5.3892475974102842e-02
GC_18_67 ref NI_18 NS_67 0 -1.0655370511964296e-02
GC_18_68 ref NI_18 NS_68 0 -1.7600224301588076e-03
GC_18_69 ref NI_18 NS_69 0 -4.1704991589045518e-02
GC_18_70 ref NI_18 NS_70 0 -1.6801061753422980e-01
GC_18_71 ref NI_18 NS_71 0 -1.4670174884677197e-02
GC_18_72 ref NI_18 NS_72 0 -2.7156732736930305e-03
GC_18_73 ref NI_18 NS_73 0 -1.0974053851682729e-02
GC_18_74 ref NI_18 NS_74 0 5.6724997798334960e-02
GC_18_75 ref NI_18 NS_75 0 -1.0891116606744349e-02
GC_18_76 ref NI_18 NS_76 0 -1.7101488398723042e-03
GC_18_77 ref NI_18 NS_77 0 7.7509849532164610e-02
GC_18_78 ref NI_18 NS_78 0 4.5158289974792189e-02
GC_18_79 ref NI_18 NS_79 0 -2.2817681373110247e-02
GC_18_80 ref NI_18 NS_80 0 -1.5051809061545252e-03
GD_18_1 ref NI_18 NA_1 0 6.4247522435355101e-02
GD_18_2 ref NI_18 NA_2 0 -1.7805371858609495e-01
GD_18_3 ref NI_18 NA_3 0 -1.5093998692475798e-02
GD_18_4 ref NI_18 NA_4 0 2.8560476114315298e-02
GD_18_5 ref NI_18 NA_5 0 1.1859205560611079e-01
GD_18_6 ref NI_18 NA_6 0 1.2254048974515755e-03
GD_18_7 ref NI_18 NA_7 0 -1.4452605156497300e-02
GD_18_8 ref NI_18 NA_8 0 3.0481182338156970e-02
GD_18_9 ref NI_18 NA_9 0 -3.8739194995305294e-02
GD_18_10 ref NI_18 NA_10 0 -3.7155511238498570e-02
GD_18_11 ref NI_18 NA_11 0 -5.1069747722208139e-02
GD_18_12 ref NI_18 NA_12 0 -1.2795726212044854e-02
GD_18_13 ref NI_18 NA_13 0 -1.4835380924526289e-02
GD_18_14 ref NI_18 NA_14 0 -1.8883836975773463e-02
GD_18_15 ref NI_18 NA_15 0 -1.6763590063090361e-02
GD_18_16 ref NI_18 NA_16 0 -1.9273156974411815e-02
GD_18_17 ref NI_18 NA_17 0 3.8211796419832536e-02
GD_18_18 ref NI_18 NA_18 0 6.1387324185058230e+00
GD_18_19 ref NI_18 NA_19 0 4.4801648146067441e-03
GD_18_20 ref NI_18 NA_20 0 -1.5459281469273684e-01
*
* Port 19
VI_19 a_19 NI_19 0
RI_19 NI_19 ref 1.0000000000000001e-01
GC_19_1 ref NI_19 NS_1 0 2.0475770023240046e-02
GC_19_2 ref NI_19 NS_2 0 1.5573454271629894e-03
GC_19_3 ref NI_19 NS_3 0 1.3998233954363593e-03
GC_19_4 ref NI_19 NS_4 0 -1.6637999277236017e-04
GC_19_5 ref NI_19 NS_5 0 2.3931977131267661e-03
GC_19_6 ref NI_19 NS_6 0 1.0896258676897226e-02
GC_19_7 ref NI_19 NS_7 0 1.0690557431169007e-03
GC_19_8 ref NI_19 NS_8 0 1.2809304778945663e-04
GC_19_9 ref NI_19 NS_9 0 1.9870314009311266e-03
GC_19_10 ref NI_19 NS_10 0 -4.9374058249808724e-03
GC_19_11 ref NI_19 NS_11 0 3.2044337894823662e-03
GC_19_12 ref NI_19 NS_12 0 1.2443837648645128e-03
GC_19_13 ref NI_19 NS_13 0 -8.0792148327105424e-03
GC_19_14 ref NI_19 NS_14 0 6.2719081529663415e-03
GC_19_15 ref NI_19 NS_15 0 -3.9277570222396897e-03
GC_19_16 ref NI_19 NS_16 0 2.2960074463074269e-03
GC_19_17 ref NI_19 NS_17 0 1.7831615795746533e-02
GC_19_18 ref NI_19 NS_18 0 4.2248121099052051e-02
GC_19_19 ref NI_19 NS_19 0 -1.0781224979931933e-02
GC_19_20 ref NI_19 NS_20 0 -1.4837851408901590e-03
GC_19_21 ref NI_19 NS_21 0 -5.2707513012161750e-03
GC_19_22 ref NI_19 NS_22 0 7.5829654929259185e-03
GC_19_23 ref NI_19 NS_23 0 7.0872636724291357e-03
GC_19_24 ref NI_19 NS_24 0 -1.1019959745780788e-03
GC_19_25 ref NI_19 NS_25 0 3.4812635592882451e-03
GC_19_26 ref NI_19 NS_26 0 3.5923320526777122e-03
GC_19_27 ref NI_19 NS_27 0 6.7257590310251698e-03
GC_19_28 ref NI_19 NS_28 0 -9.2318887696722315e-04
GC_19_29 ref NI_19 NS_29 0 -8.8076707852049081e-03
GC_19_30 ref NI_19 NS_30 0 7.0978193992157516e-03
GC_19_31 ref NI_19 NS_31 0 -4.2225572625166023e-03
GC_19_32 ref NI_19 NS_32 0 2.3035439019104382e-03
GC_19_33 ref NI_19 NS_33 0 1.1782157597897182e-03
GC_19_34 ref NI_19 NS_34 0 -5.8096785960482606e-03
GC_19_35 ref NI_19 NS_35 0 7.9857356184302591e-03
GC_19_36 ref NI_19 NS_36 0 5.1440432425066250e-05
GC_19_37 ref NI_19 NS_37 0 4.3296140607311032e-03
GC_19_38 ref NI_19 NS_38 0 -3.1552548145024023e-03
GC_19_39 ref NI_19 NS_39 0 8.6404586501766297e-03
GC_19_40 ref NI_19 NS_40 0 -6.3411557087872958e-04
GC_19_41 ref NI_19 NS_41 0 6.8902809822531030e-03
GC_19_42 ref NI_19 NS_42 0 -1.0942560764763505e-02
GC_19_43 ref NI_19 NS_43 0 1.0203154810632335e-02
GC_19_44 ref NI_19 NS_44 0 -2.4370254070189105e-04
GC_19_45 ref NI_19 NS_45 0 2.5678327653706106e-03
GC_19_46 ref NI_19 NS_46 0 -5.4747865744943251e-03
GC_19_47 ref NI_19 NS_47 0 2.9931323184628112e-03
GC_19_48 ref NI_19 NS_48 0 1.3266047254382645e-03
GC_19_49 ref NI_19 NS_49 0 2.6011510182230367e-03
GC_19_50 ref NI_19 NS_50 0 -5.3073592837167959e-03
GC_19_51 ref NI_19 NS_51 0 2.9359449644377274e-03
GC_19_52 ref NI_19 NS_52 0 1.3270599671737363e-03
GC_19_53 ref NI_19 NS_53 0 3.8945005840186281e-03
GC_19_54 ref NI_19 NS_54 0 -6.2286294869520744e-03
GC_19_55 ref NI_19 NS_55 0 3.1581077456663909e-03
GC_19_56 ref NI_19 NS_56 0 1.3218361122516449e-03
GC_19_57 ref NI_19 NS_57 0 4.6711976940291824e-03
GC_19_58 ref NI_19 NS_58 0 -6.7919877388284535e-03
GC_19_59 ref NI_19 NS_59 0 2.8094129355961733e-03
GC_19_60 ref NI_19 NS_60 0 1.4551160623703415e-03
GC_19_61 ref NI_19 NS_61 0 3.8022463497067436e-03
GC_19_62 ref NI_19 NS_62 0 -6.4025507241009284e-03
GC_19_63 ref NI_19 NS_63 0 3.5289437999330864e-03
GC_19_64 ref NI_19 NS_64 0 1.2441055351755071e-03
GC_19_65 ref NI_19 NS_65 0 6.9993579909703771e-02
GC_19_66 ref NI_19 NS_66 0 3.5805524197032021e-02
GC_19_67 ref NI_19 NS_67 0 -1.7755075185827193e-02
GC_19_68 ref NI_19 NS_68 0 -1.5604202454260201e-03
GC_19_69 ref NI_19 NS_69 0 -1.0974053851683046e-02
GC_19_70 ref NI_19 NS_70 0 5.6724997798335272e-02
GC_19_71 ref NI_19 NS_71 0 -1.0891116606744498e-02
GC_19_72 ref NI_19 NS_72 0 -1.7101488398722589e-03
GC_19_73 ref NI_19 NS_73 0 -1.2193422478007938e-01
GC_19_74 ref NI_19 NS_74 0 -1.6119342403923215e-01
GC_19_75 ref NI_19 NS_75 0 -1.3461271214443729e-03
GC_19_76 ref NI_19 NS_76 0 -2.9497642170694996e-03
GC_19_77 ref NI_19 NS_77 0 3.6779808407715095e-02
GC_19_78 ref NI_19 NS_78 0 4.0655869829023326e-02
GC_19_79 ref NI_19 NS_79 0 -1.3470161105229741e-02
GC_19_80 ref NI_19 NS_80 0 -1.6688671152429821e-03
GD_19_1 ref NI_19 NA_1 0 1.2428270969137012e-03
GD_19_2 ref NI_19 NA_2 0 -1.1839062106996917e-01
GD_19_3 ref NI_19 NA_3 0 -1.2587813845330555e-02
GD_19_4 ref NI_19 NA_4 0 3.7323276250192328e-02
GD_19_5 ref NI_19 NA_5 0 -4.1868639551123681e-02
GD_19_6 ref NI_19 NA_6 0 8.8381679428583357e-03
GD_19_7 ref NI_19 NA_7 0 -2.3687795263157754e-02
GD_19_8 ref NI_19 NA_8 0 4.0076536096934449e-02
GD_19_9 ref NI_19 NA_9 0 -2.4318213563857716e-02
GD_19_10 ref NI_19 NA_10 0 -3.7065419688576899e-02
GD_19_11 ref NI_19 NA_11 0 -4.1635650943179711e-02
GD_19_12 ref NI_19 NA_12 0 -1.2577407169883878e-02
GD_19_13 ref NI_19 NA_13 0 -1.3706728238869660e-02
GD_19_14 ref NI_19 NA_14 0 -1.9002417245314505e-02
GD_19_15 ref NI_19 NA_15 0 -1.9583568446915882e-02
GD_19_16 ref NI_19 NA_16 0 -1.9278888072584571e-02
GD_19_17 ref NI_19 NA_17 0 -7.7274555662481759e-02
GD_19_18 ref NI_19 NA_18 0 4.4801648146084207e-03
GD_19_19 ref NI_19 NA_19 0 6.2458887369370935e+00
GD_19_20 ref NI_19 NA_20 0 -1.5853962770723293e-02
*
* Port 20
VI_20 a_20 NI_20 0
RI_20 NI_20 ref 1.0000000000000001e-01
GC_20_1 ref NI_20 NS_1 0 2.5524436448400193e-02
GC_20_2 ref NI_20 NS_2 0 -9.2906509412759794e-04
GC_20_3 ref NI_20 NS_3 0 1.2783534900429208e-03
GC_20_4 ref NI_20 NS_4 0 -1.5407700615387499e-04
GC_20_5 ref NI_20 NS_5 0 6.8217285204043724e-03
GC_20_6 ref NI_20 NS_6 0 1.0238220629848738e-02
GC_20_7 ref NI_20 NS_7 0 5.8329927628142137e-04
GC_20_8 ref NI_20 NS_8 0 1.5808726873139242e-04
GC_20_9 ref NI_20 NS_9 0 1.2873404056636156e-03
GC_20_10 ref NI_20 NS_10 0 -4.0674404680096548e-03
GC_20_11 ref NI_20 NS_11 0 3.0279236075188899e-03
GC_20_12 ref NI_20 NS_12 0 1.2292064663537807e-03
GC_20_13 ref NI_20 NS_13 0 -8.4745687638865218e-03
GC_20_14 ref NI_20 NS_14 0 6.5235844516799216e-03
GC_20_15 ref NI_20 NS_15 0 -3.9021153738954964e-03
GC_20_16 ref NI_20 NS_16 0 2.2802694154489865e-03
GC_20_17 ref NI_20 NS_17 0 -3.8238863412929168e-02
GC_20_18 ref NI_20 NS_18 0 4.5085666036361279e-02
GC_20_19 ref NI_20 NS_19 0 -1.2945523806432212e-03
GC_20_20 ref NI_20 NS_20 0 -1.7318341761359589e-03
GC_20_21 ref NI_20 NS_21 0 -3.7404799734124848e-03
GC_20_22 ref NI_20 NS_22 0 -1.9964535126366117e-04
GC_20_23 ref NI_20 NS_23 0 9.9816757390110179e-03
GC_20_24 ref NI_20 NS_24 0 -1.0376959519005733e-03
GC_20_25 ref NI_20 NS_25 0 2.5873021123293130e-03
GC_20_26 ref NI_20 NS_26 0 -4.9149279322611007e-04
GC_20_27 ref NI_20 NS_27 0 8.5034518775250513e-03
GC_20_28 ref NI_20 NS_28 0 -8.5900212224291478e-04
GC_20_29 ref NI_20 NS_29 0 -9.1099944525115956e-03
GC_20_30 ref NI_20 NS_30 0 7.3168617076744468e-03
GC_20_31 ref NI_20 NS_31 0 -4.2014474506385660e-03
GC_20_32 ref NI_20 NS_32 0 2.2885937279566834e-03
GC_20_33 ref NI_20 NS_33 0 6.9282457846135020e-04
GC_20_34 ref NI_20 NS_34 0 -4.8628200190159671e-03
GC_20_35 ref NI_20 NS_35 0 7.5480990277942278e-03
GC_20_36 ref NI_20 NS_36 0 9.7480696973497872e-05
GC_20_37 ref NI_20 NS_37 0 4.7651189479674307e-03
GC_20_38 ref NI_20 NS_38 0 -5.3959114748144688e-03
GC_20_39 ref NI_20 NS_39 0 9.3116685425726747e-03
GC_20_40 ref NI_20 NS_40 0 -5.5516023351186519e-04
GC_20_41 ref NI_20 NS_41 0 7.3108635505055490e-03
GC_20_42 ref NI_20 NS_42 0 -1.1476378703946778e-02
GC_20_43 ref NI_20 NS_43 0 1.0134094938096005e-02
GC_20_44 ref NI_20 NS_44 0 -1.6812720609381588e-04
GC_20_45 ref NI_20 NS_45 0 1.7723258086458421e-03
GC_20_46 ref NI_20 NS_46 0 -4.6671288428873550e-03
GC_20_47 ref NI_20 NS_47 0 2.8624624997162481e-03
GC_20_48 ref NI_20 NS_48 0 1.3098463919863242e-03
GC_20_49 ref NI_20 NS_49 0 1.8735924149849302e-03
GC_20_50 ref NI_20 NS_50 0 -4.5375108567870309e-03
GC_20_51 ref NI_20 NS_51 0 2.8123169727801152e-03
GC_20_52 ref NI_20 NS_52 0 1.3098865418518578e-03
GC_20_53 ref NI_20 NS_53 0 3.3493992356641231e-03
GC_20_54 ref NI_20 NS_54 0 -5.5904386022896891e-03
GC_20_55 ref NI_20 NS_55 0 3.0449479909304615e-03
GC_20_56 ref NI_20 NS_56 0 1.3093765671989062e-03
GC_20_57 ref NI_20 NS_57 0 4.0467570375301107e-03
GC_20_58 ref NI_20 NS_58 0 -6.2248604670731358e-03
GC_20_59 ref NI_20 NS_59 0 2.7620601480314987e-03
GC_20_60 ref NI_20 NS_60 0 1.4352948766820463e-03
GC_20_61 ref NI_20 NS_61 0 3.1283830397296790e-03
GC_20_62 ref NI_20 NS_62 0 -5.6782544699019600e-03
GC_20_63 ref NI_20 NS_63 0 3.3937686347777856e-03
GC_20_64 ref NI_20 NS_64 0 1.2341070532323408e-03
GC_20_65 ref NI_20 NS_65 0 -1.9730571406449550e-02
GC_20_66 ref NI_20 NS_66 0 5.9845379524242612e-02
GC_20_67 ref NI_20 NS_67 0 -1.0258553389293676e-02
GC_20_68 ref NI_20 NS_68 0 -1.8022687183815180e-03
GC_20_69 ref NI_20 NS_69 0 7.7509849532164499e-02
GC_20_70 ref NI_20 NS_70 0 4.5158289974792196e-02
GC_20_71 ref NI_20 NS_71 0 -2.2817681373110226e-02
GC_20_72 ref NI_20 NS_72 0 -1.5051809061545338e-03
GC_20_73 ref NI_20 NS_73 0 3.6779808407714859e-02
GC_20_74 ref NI_20 NS_74 0 4.0655869829023548e-02
GC_20_75 ref NI_20 NS_75 0 -1.3470161105229866e-02
GC_20_76 ref NI_20 NS_76 0 -1.6688671152429453e-03
GC_20_77 ref NI_20 NS_77 0 -7.1072109815294382e-02
GC_20_78 ref NI_20 NS_78 0 -1.6392425117883208e-01
GC_20_79 ref NI_20 NS_79 0 -1.0056435017798919e-02
GC_20_80 ref NI_20 NS_80 0 -2.9055330748146342e-03
GD_20_1 ref NI_20 NA_1 0 1.8470933065044746e-02
GD_20_2 ref NI_20 NA_2 0 -1.4174393374458713e-01
GD_20_3 ref NI_20 NA_3 0 -1.1797238496386662e-02
GD_20_4 ref NI_20 NA_4 0 3.8821612103279730e-02
GD_20_5 ref NI_20 NA_5 0 1.1047644595379985e-01
GD_20_6 ref NI_20 NA_6 0 3.0146271583517694e-03
GD_20_7 ref NI_20 NA_7 0 -2.8346307236844649e-02
GD_20_8 ref NI_20 NA_8 0 4.1261705189654233e-02
GD_20_9 ref NI_20 NA_9 0 -2.6415626636981385e-02
GD_20_10 ref NI_20 NA_10 0 -4.2309809193898262e-02
GD_20_11 ref NI_20 NA_11 0 -4.5196968090931003e-02
GD_20_12 ref NI_20 NA_12 0 -1.1194418651188682e-02
GD_20_13 ref NI_20 NA_13 0 -1.2675100876625163e-02
GD_20_14 ref NI_20 NA_14 0 -1.8686717022526125e-02
GD_20_15 ref NI_20 NA_15 0 -1.8643746090247958e-02
GD_20_16 ref NI_20 NA_16 0 -1.8695058969766646e-02
GD_20_17 ref NI_20 NA_17 0 1.4743254957861005e-02
GD_20_18 ref NI_20 NA_18 0 -1.5459281469273567e-01
GD_20_19 ref NI_20 NA_19 0 -1.5853962770722478e-02
GD_20_20 ref NI_20 NA_20 0 6.1767715807726811e+00
*
******************************************

********************************
* Synthesis of impinging waves *
********************************

* Impinging wave, port 1
RA_1 NA_1 0 1.5811388300841897e-01
FA_1 0 NA_1 VI_1 1.0
GA_1 0 NA_1 a_1 ref 1.0000000000000000e+01
*
* Impinging wave, port 2
RA_2 NA_2 0 1.5811388300841897e-01
FA_2 0 NA_2 VI_2 1.0
GA_2 0 NA_2 a_2 ref 1.0000000000000000e+01
*
* Impinging wave, port 3
RA_3 NA_3 0 1.5811388300841897e-01
FA_3 0 NA_3 VI_3 1.0
GA_3 0 NA_3 a_3 ref 1.0000000000000000e+01
*
* Impinging wave, port 4
RA_4 NA_4 0 1.5811388300841897e-01
FA_4 0 NA_4 VI_4 1.0
GA_4 0 NA_4 a_4 ref 1.0000000000000000e+01
*
* Impinging wave, port 5
RA_5 NA_5 0 1.5811388300841897e-01
FA_5 0 NA_5 VI_5 1.0
GA_5 0 NA_5 a_5 ref 1.0000000000000000e+01
*
* Impinging wave, port 6
RA_6 NA_6 0 1.5811388300841897e-01
FA_6 0 NA_6 VI_6 1.0
GA_6 0 NA_6 a_6 ref 1.0000000000000000e+01
*
* Impinging wave, port 7
RA_7 NA_7 0 1.5811388300841897e-01
FA_7 0 NA_7 VI_7 1.0
GA_7 0 NA_7 a_7 ref 1.0000000000000000e+01
*
* Impinging wave, port 8
RA_8 NA_8 0 1.5811388300841897e-01
FA_8 0 NA_8 VI_8 1.0
GA_8 0 NA_8 a_8 ref 1.0000000000000000e+01
*
* Impinging wave, port 9
RA_9 NA_9 0 1.5811388300841897e-01
FA_9 0 NA_9 VI_9 1.0
GA_9 0 NA_9 a_9 ref 1.0000000000000000e+01
*
* Impinging wave, port 10
RA_10 NA_10 0 1.5811388300841897e-01
FA_10 0 NA_10 VI_10 1.0
GA_10 0 NA_10 a_10 ref 1.0000000000000000e+01
*
* Impinging wave, port 11
RA_11 NA_11 0 1.5811388300841897e-01
FA_11 0 NA_11 VI_11 1.0
GA_11 0 NA_11 a_11 ref 1.0000000000000000e+01
*
* Impinging wave, port 12
RA_12 NA_12 0 1.5811388300841897e-01
FA_12 0 NA_12 VI_12 1.0
GA_12 0 NA_12 a_12 ref 1.0000000000000000e+01
*
* Impinging wave, port 13
RA_13 NA_13 0 1.5811388300841897e-01
FA_13 0 NA_13 VI_13 1.0
GA_13 0 NA_13 a_13 ref 1.0000000000000000e+01
*
* Impinging wave, port 14
RA_14 NA_14 0 1.5811388300841897e-01
FA_14 0 NA_14 VI_14 1.0
GA_14 0 NA_14 a_14 ref 1.0000000000000000e+01
*
* Impinging wave, port 15
RA_15 NA_15 0 1.5811388300841897e-01
FA_15 0 NA_15 VI_15 1.0
GA_15 0 NA_15 a_15 ref 1.0000000000000000e+01
*
* Impinging wave, port 16
RA_16 NA_16 0 1.5811388300841897e-01
FA_16 0 NA_16 VI_16 1.0
GA_16 0 NA_16 a_16 ref 1.0000000000000000e+01
*
* Impinging wave, port 17
RA_17 NA_17 0 1.5811388300841897e-01
FA_17 0 NA_17 VI_17 1.0
GA_17 0 NA_17 a_17 ref 1.0000000000000000e+01
*
* Impinging wave, port 18
RA_18 NA_18 0 1.5811388300841897e-01
FA_18 0 NA_18 VI_18 1.0
GA_18 0 NA_18 a_18 ref 1.0000000000000000e+01
*
* Impinging wave, port 19
RA_19 NA_19 0 1.5811388300841897e-01
FA_19 0 NA_19 VI_19 1.0
GA_19 0 NA_19 a_19 ref 1.0000000000000000e+01
*
* Impinging wave, port 20
RA_20 NA_20 0 1.5811388300841897e-01
FA_20 0 NA_20 VI_20 1.0
GA_20 0 NA_20 a_20 ref 1.0000000000000000e+01
*
********************************

***************************************
* Synthesis of real and complex poles *
***************************************

* Real pole n. 1
CS_1 NS_1 0 9.9999999999999998e-13
RS_1 NS_1 0 1.3134931756431877e+02
GS_1_1 0 NS_1 NA_1 0 1.7156443727063664e-01
*
* Real pole n. 2
CS_2 NS_2 0 9.9999999999999998e-13
RS_2 NS_2 0 2.8052679419306548e+02
GS_2_1 0 NS_2 NA_1 0 1.7156443727063664e-01
*
* Real pole n. 3
CS_3 NS_3 0 9.9999999999999998e-13
RS_3 NS_3 0 6.3958727121695881e+02
GS_3_1 0 NS_3 NA_1 0 1.7156443727063664e-01
*
* Real pole n. 4
CS_4 NS_4 0 9.9999999999999998e-13
RS_4 NS_4 0 2.0924006540342843e+03
GS_4_1 0 NS_4 NA_1 0 1.7156443727063664e-01
*
* Real pole n. 5
CS_5 NS_5 0 9.9999999999999998e-13
RS_5 NS_5 0 1.3134931756431877e+02
GS_5_2 0 NS_5 NA_2 0 1.7156443727063664e-01
*
* Real pole n. 6
CS_6 NS_6 0 9.9999999999999998e-13
RS_6 NS_6 0 2.8052679419306548e+02
GS_6_2 0 NS_6 NA_2 0 1.7156443727063664e-01
*
* Real pole n. 7
CS_7 NS_7 0 9.9999999999999998e-13
RS_7 NS_7 0 6.3958727121695881e+02
GS_7_2 0 NS_7 NA_2 0 1.7156443727063664e-01
*
* Real pole n. 8
CS_8 NS_8 0 9.9999999999999998e-13
RS_8 NS_8 0 2.0924006540342843e+03
GS_8_2 0 NS_8 NA_2 0 1.7156443727063664e-01
*
* Real pole n. 9
CS_9 NS_9 0 9.9999999999999998e-13
RS_9 NS_9 0 1.3134931756431877e+02
GS_9_3 0 NS_9 NA_3 0 1.7156443727063664e-01
*
* Real pole n. 10
CS_10 NS_10 0 9.9999999999999998e-13
RS_10 NS_10 0 2.8052679419306548e+02
GS_10_3 0 NS_10 NA_3 0 1.7156443727063664e-01
*
* Real pole n. 11
CS_11 NS_11 0 9.9999999999999998e-13
RS_11 NS_11 0 6.3958727121695881e+02
GS_11_3 0 NS_11 NA_3 0 1.7156443727063664e-01
*
* Real pole n. 12
CS_12 NS_12 0 9.9999999999999998e-13
RS_12 NS_12 0 2.0924006540342843e+03
GS_12_3 0 NS_12 NA_3 0 1.7156443727063664e-01
*
* Real pole n. 13
CS_13 NS_13 0 9.9999999999999998e-13
RS_13 NS_13 0 1.3134931756431877e+02
GS_13_4 0 NS_13 NA_4 0 1.7156443727063664e-01
*
* Real pole n. 14
CS_14 NS_14 0 9.9999999999999998e-13
RS_14 NS_14 0 2.8052679419306548e+02
GS_14_4 0 NS_14 NA_4 0 1.7156443727063664e-01
*
* Real pole n. 15
CS_15 NS_15 0 9.9999999999999998e-13
RS_15 NS_15 0 6.3958727121695881e+02
GS_15_4 0 NS_15 NA_4 0 1.7156443727063664e-01
*
* Real pole n. 16
CS_16 NS_16 0 9.9999999999999998e-13
RS_16 NS_16 0 2.0924006540342843e+03
GS_16_4 0 NS_16 NA_4 0 1.7156443727063664e-01
*
* Real pole n. 17
CS_17 NS_17 0 9.9999999999999998e-13
RS_17 NS_17 0 1.3134931756431877e+02
GS_17_5 0 NS_17 NA_5 0 1.7156443727063664e-01
*
* Real pole n. 18
CS_18 NS_18 0 9.9999999999999998e-13
RS_18 NS_18 0 2.8052679419306548e+02
GS_18_5 0 NS_18 NA_5 0 1.7156443727063664e-01
*
* Real pole n. 19
CS_19 NS_19 0 9.9999999999999998e-13
RS_19 NS_19 0 6.3958727121695881e+02
GS_19_5 0 NS_19 NA_5 0 1.7156443727063664e-01
*
* Real pole n. 20
CS_20 NS_20 0 9.9999999999999998e-13
RS_20 NS_20 0 2.0924006540342843e+03
GS_20_5 0 NS_20 NA_5 0 1.7156443727063664e-01
*
* Real pole n. 21
CS_21 NS_21 0 9.9999999999999998e-13
RS_21 NS_21 0 1.3134931756431877e+02
GS_21_6 0 NS_21 NA_6 0 1.7156443727063664e-01
*
* Real pole n. 22
CS_22 NS_22 0 9.9999999999999998e-13
RS_22 NS_22 0 2.8052679419306548e+02
GS_22_6 0 NS_22 NA_6 0 1.7156443727063664e-01
*
* Real pole n. 23
CS_23 NS_23 0 9.9999999999999998e-13
RS_23 NS_23 0 6.3958727121695881e+02
GS_23_6 0 NS_23 NA_6 0 1.7156443727063664e-01
*
* Real pole n. 24
CS_24 NS_24 0 9.9999999999999998e-13
RS_24 NS_24 0 2.0924006540342843e+03
GS_24_6 0 NS_24 NA_6 0 1.7156443727063664e-01
*
* Real pole n. 25
CS_25 NS_25 0 9.9999999999999998e-13
RS_25 NS_25 0 1.3134931756431877e+02
GS_25_7 0 NS_25 NA_7 0 1.7156443727063664e-01
*
* Real pole n. 26
CS_26 NS_26 0 9.9999999999999998e-13
RS_26 NS_26 0 2.8052679419306548e+02
GS_26_7 0 NS_26 NA_7 0 1.7156443727063664e-01
*
* Real pole n. 27
CS_27 NS_27 0 9.9999999999999998e-13
RS_27 NS_27 0 6.3958727121695881e+02
GS_27_7 0 NS_27 NA_7 0 1.7156443727063664e-01
*
* Real pole n. 28
CS_28 NS_28 0 9.9999999999999998e-13
RS_28 NS_28 0 2.0924006540342843e+03
GS_28_7 0 NS_28 NA_7 0 1.7156443727063664e-01
*
* Real pole n. 29
CS_29 NS_29 0 9.9999999999999998e-13
RS_29 NS_29 0 1.3134931756431877e+02
GS_29_8 0 NS_29 NA_8 0 1.7156443727063664e-01
*
* Real pole n. 30
CS_30 NS_30 0 9.9999999999999998e-13
RS_30 NS_30 0 2.8052679419306548e+02
GS_30_8 0 NS_30 NA_8 0 1.7156443727063664e-01
*
* Real pole n. 31
CS_31 NS_31 0 9.9999999999999998e-13
RS_31 NS_31 0 6.3958727121695881e+02
GS_31_8 0 NS_31 NA_8 0 1.7156443727063664e-01
*
* Real pole n. 32
CS_32 NS_32 0 9.9999999999999998e-13
RS_32 NS_32 0 2.0924006540342843e+03
GS_32_8 0 NS_32 NA_8 0 1.7156443727063664e-01
*
* Real pole n. 33
CS_33 NS_33 0 9.9999999999999998e-13
RS_33 NS_33 0 1.3134931756431877e+02
GS_33_9 0 NS_33 NA_9 0 1.7156443727063664e-01
*
* Real pole n. 34
CS_34 NS_34 0 9.9999999999999998e-13
RS_34 NS_34 0 2.8052679419306548e+02
GS_34_9 0 NS_34 NA_9 0 1.7156443727063664e-01
*
* Real pole n. 35
CS_35 NS_35 0 9.9999999999999998e-13
RS_35 NS_35 0 6.3958727121695881e+02
GS_35_9 0 NS_35 NA_9 0 1.7156443727063664e-01
*
* Real pole n. 36
CS_36 NS_36 0 9.9999999999999998e-13
RS_36 NS_36 0 2.0924006540342843e+03
GS_36_9 0 NS_36 NA_9 0 1.7156443727063664e-01
*
* Real pole n. 37
CS_37 NS_37 0 9.9999999999999998e-13
RS_37 NS_37 0 1.3134931756431877e+02
GS_37_10 0 NS_37 NA_10 0 1.7156443727063664e-01
*
* Real pole n. 38
CS_38 NS_38 0 9.9999999999999998e-13
RS_38 NS_38 0 2.8052679419306548e+02
GS_38_10 0 NS_38 NA_10 0 1.7156443727063664e-01
*
* Real pole n. 39
CS_39 NS_39 0 9.9999999999999998e-13
RS_39 NS_39 0 6.3958727121695881e+02
GS_39_10 0 NS_39 NA_10 0 1.7156443727063664e-01
*
* Real pole n. 40
CS_40 NS_40 0 9.9999999999999998e-13
RS_40 NS_40 0 2.0924006540342843e+03
GS_40_10 0 NS_40 NA_10 0 1.7156443727063664e-01
*
* Real pole n. 41
CS_41 NS_41 0 9.9999999999999998e-13
RS_41 NS_41 0 1.3134931756431877e+02
GS_41_11 0 NS_41 NA_11 0 1.7156443727063664e-01
*
* Real pole n. 42
CS_42 NS_42 0 9.9999999999999998e-13
RS_42 NS_42 0 2.8052679419306548e+02
GS_42_11 0 NS_42 NA_11 0 1.7156443727063664e-01
*
* Real pole n. 43
CS_43 NS_43 0 9.9999999999999998e-13
RS_43 NS_43 0 6.3958727121695881e+02
GS_43_11 0 NS_43 NA_11 0 1.7156443727063664e-01
*
* Real pole n. 44
CS_44 NS_44 0 9.9999999999999998e-13
RS_44 NS_44 0 2.0924006540342843e+03
GS_44_11 0 NS_44 NA_11 0 1.7156443727063664e-01
*
* Real pole n. 45
CS_45 NS_45 0 9.9999999999999998e-13
RS_45 NS_45 0 1.3134931756431877e+02
GS_45_12 0 NS_45 NA_12 0 1.7156443727063664e-01
*
* Real pole n. 46
CS_46 NS_46 0 9.9999999999999998e-13
RS_46 NS_46 0 2.8052679419306548e+02
GS_46_12 0 NS_46 NA_12 0 1.7156443727063664e-01
*
* Real pole n. 47
CS_47 NS_47 0 9.9999999999999998e-13
RS_47 NS_47 0 6.3958727121695881e+02
GS_47_12 0 NS_47 NA_12 0 1.7156443727063664e-01
*
* Real pole n. 48
CS_48 NS_48 0 9.9999999999999998e-13
RS_48 NS_48 0 2.0924006540342843e+03
GS_48_12 0 NS_48 NA_12 0 1.7156443727063664e-01
*
* Real pole n. 49
CS_49 NS_49 0 9.9999999999999998e-13
RS_49 NS_49 0 1.3134931756431877e+02
GS_49_13 0 NS_49 NA_13 0 1.7156443727063664e-01
*
* Real pole n. 50
CS_50 NS_50 0 9.9999999999999998e-13
RS_50 NS_50 0 2.8052679419306548e+02
GS_50_13 0 NS_50 NA_13 0 1.7156443727063664e-01
*
* Real pole n. 51
CS_51 NS_51 0 9.9999999999999998e-13
RS_51 NS_51 0 6.3958727121695881e+02
GS_51_13 0 NS_51 NA_13 0 1.7156443727063664e-01
*
* Real pole n. 52
CS_52 NS_52 0 9.9999999999999998e-13
RS_52 NS_52 0 2.0924006540342843e+03
GS_52_13 0 NS_52 NA_13 0 1.7156443727063664e-01
*
* Real pole n. 53
CS_53 NS_53 0 9.9999999999999998e-13
RS_53 NS_53 0 1.3134931756431877e+02
GS_53_14 0 NS_53 NA_14 0 1.7156443727063664e-01
*
* Real pole n. 54
CS_54 NS_54 0 9.9999999999999998e-13
RS_54 NS_54 0 2.8052679419306548e+02
GS_54_14 0 NS_54 NA_14 0 1.7156443727063664e-01
*
* Real pole n. 55
CS_55 NS_55 0 9.9999999999999998e-13
RS_55 NS_55 0 6.3958727121695881e+02
GS_55_14 0 NS_55 NA_14 0 1.7156443727063664e-01
*
* Real pole n. 56
CS_56 NS_56 0 9.9999999999999998e-13
RS_56 NS_56 0 2.0924006540342843e+03
GS_56_14 0 NS_56 NA_14 0 1.7156443727063664e-01
*
* Real pole n. 57
CS_57 NS_57 0 9.9999999999999998e-13
RS_57 NS_57 0 1.3134931756431877e+02
GS_57_15 0 NS_57 NA_15 0 1.7156443727063664e-01
*
* Real pole n. 58
CS_58 NS_58 0 9.9999999999999998e-13
RS_58 NS_58 0 2.8052679419306548e+02
GS_58_15 0 NS_58 NA_15 0 1.7156443727063664e-01
*
* Real pole n. 59
CS_59 NS_59 0 9.9999999999999998e-13
RS_59 NS_59 0 6.3958727121695881e+02
GS_59_15 0 NS_59 NA_15 0 1.7156443727063664e-01
*
* Real pole n. 60
CS_60 NS_60 0 9.9999999999999998e-13
RS_60 NS_60 0 2.0924006540342843e+03
GS_60_15 0 NS_60 NA_15 0 1.7156443727063664e-01
*
* Real pole n. 61
CS_61 NS_61 0 9.9999999999999998e-13
RS_61 NS_61 0 1.3134931756431877e+02
GS_61_16 0 NS_61 NA_16 0 1.7156443727063664e-01
*
* Real pole n. 62
CS_62 NS_62 0 9.9999999999999998e-13
RS_62 NS_62 0 2.8052679419306548e+02
GS_62_16 0 NS_62 NA_16 0 1.7156443727063664e-01
*
* Real pole n. 63
CS_63 NS_63 0 9.9999999999999998e-13
RS_63 NS_63 0 6.3958727121695881e+02
GS_63_16 0 NS_63 NA_16 0 1.7156443727063664e-01
*
* Real pole n. 64
CS_64 NS_64 0 9.9999999999999998e-13
RS_64 NS_64 0 2.0924006540342843e+03
GS_64_16 0 NS_64 NA_16 0 1.7156443727063664e-01
*
* Real pole n. 65
CS_65 NS_65 0 9.9999999999999998e-13
RS_65 NS_65 0 1.3134931756431877e+02
GS_65_17 0 NS_65 NA_17 0 1.7156443727063664e-01
*
* Real pole n. 66
CS_66 NS_66 0 9.9999999999999998e-13
RS_66 NS_66 0 2.8052679419306548e+02
GS_66_17 0 NS_66 NA_17 0 1.7156443727063664e-01
*
* Real pole n. 67
CS_67 NS_67 0 9.9999999999999998e-13
RS_67 NS_67 0 6.3958727121695881e+02
GS_67_17 0 NS_67 NA_17 0 1.7156443727063664e-01
*
* Real pole n. 68
CS_68 NS_68 0 9.9999999999999998e-13
RS_68 NS_68 0 2.0924006540342843e+03
GS_68_17 0 NS_68 NA_17 0 1.7156443727063664e-01
*
* Real pole n. 69
CS_69 NS_69 0 9.9999999999999998e-13
RS_69 NS_69 0 1.3134931756431877e+02
GS_69_18 0 NS_69 NA_18 0 1.7156443727063664e-01
*
* Real pole n. 70
CS_70 NS_70 0 9.9999999999999998e-13
RS_70 NS_70 0 2.8052679419306548e+02
GS_70_18 0 NS_70 NA_18 0 1.7156443727063664e-01
*
* Real pole n. 71
CS_71 NS_71 0 9.9999999999999998e-13
RS_71 NS_71 0 6.3958727121695881e+02
GS_71_18 0 NS_71 NA_18 0 1.7156443727063664e-01
*
* Real pole n. 72
CS_72 NS_72 0 9.9999999999999998e-13
RS_72 NS_72 0 2.0924006540342843e+03
GS_72_18 0 NS_72 NA_18 0 1.7156443727063664e-01
*
* Real pole n. 73
CS_73 NS_73 0 9.9999999999999998e-13
RS_73 NS_73 0 1.3134931756431877e+02
GS_73_19 0 NS_73 NA_19 0 1.7156443727063664e-01
*
* Real pole n. 74
CS_74 NS_74 0 9.9999999999999998e-13
RS_74 NS_74 0 2.8052679419306548e+02
GS_74_19 0 NS_74 NA_19 0 1.7156443727063664e-01
*
* Real pole n. 75
CS_75 NS_75 0 9.9999999999999998e-13
RS_75 NS_75 0 6.3958727121695881e+02
GS_75_19 0 NS_75 NA_19 0 1.7156443727063664e-01
*
* Real pole n. 76
CS_76 NS_76 0 9.9999999999999998e-13
RS_76 NS_76 0 2.0924006540342843e+03
GS_76_19 0 NS_76 NA_19 0 1.7156443727063664e-01
*
* Real pole n. 77
CS_77 NS_77 0 9.9999999999999998e-13
RS_77 NS_77 0 1.3134931756431877e+02
GS_77_20 0 NS_77 NA_20 0 1.7156443727063664e-01
*
* Real pole n. 78
CS_78 NS_78 0 9.9999999999999998e-13
RS_78 NS_78 0 2.8052679419306548e+02
GS_78_20 0 NS_78 NA_20 0 1.7156443727063664e-01
*
* Real pole n. 79
CS_79 NS_79 0 9.9999999999999998e-13
RS_79 NS_79 0 6.3958727121695881e+02
GS_79_20 0 NS_79 NA_20 0 1.7156443727063664e-01
*
* Real pole n. 80
CS_80 NS_80 0 9.9999999999999998e-13
RS_80 NS_80 0 2.0924006540342843e+03
GS_80_20 0 NS_80 NA_20 0 1.7156443727063664e-01
*
******************************

.ends
*******************
* End of subcircuit
*******************
