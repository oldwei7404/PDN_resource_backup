*** LIN ***
.ac POI 451
+            0      1.04713      1.09648      1.14815      1.20226      1.25893      1.31826      1.38038      1.44544      1.51356
+      1.58489      1.65959       1.7378       1.8197      1.90546      1.99526       2.0893      2.18776      2.29087      2.39883
+      2.51189      2.63027      2.75423      2.88403      3.01995      3.16228      3.31131      3.46737      3.63078      3.80189
+      3.98107      4.16869      4.36516      4.57088       4.7863      5.01187      5.24807      5.49541       5.7544       6.0256
+      6.30957      6.60693      6.91831      7.24436      7.58578      7.94328      8.31764      8.70964      9.12011      9.54993
+           10      10.4713      10.9648      11.4815      12.0226      12.5893      13.1826      13.8038      14.4544      15.1356
+      15.8489      16.5959       17.378       18.197      19.0546      19.9526       20.893      21.8776      22.9087      23.9883
+      25.1189      26.3027      27.5423      28.8403      30.1995      31.6228      33.1131      34.6737      36.3078      38.0189
+      39.8107      41.6869      43.6516      45.7088       47.863      50.1187      52.4807      54.9541       57.544       60.256
+      63.0957      66.0693      69.1831      72.4436      75.8578      79.4328      83.1764      87.0964      91.2011      95.4993
+          100      104.713      109.648      114.815      120.226      125.893      131.826      138.038      144.544      151.356
+      158.489      165.959       173.78       181.97      190.546      199.526       208.93      218.776      229.087      239.883
+      251.189      263.027      275.423      288.403      301.995      316.228      331.131      346.737      363.078      380.189
+      398.107      416.869      436.516      457.088       478.63      501.187      524.807      549.541       575.44       602.56
+      630.957      660.693      691.831      724.436      758.578      794.328      831.764      870.964      912.011      954.993
+         1000      1047.13      1096.48      1148.15      1202.26      1258.93      1318.26      1380.38      1445.44      1513.56
+      1584.89      1659.59       1737.8       1819.7      1905.46      1995.26       2089.3      2187.76      2290.87      2398.83
+      2511.89      2630.27      2754.23      2884.03      3019.95      3162.28      3311.31      3467.37      3630.78      3801.89
+      3981.07      4168.69      4365.16      4570.88       4786.3      5011.87      5248.07      5495.41       5754.4       6025.6
+      6309.57      6606.93      6918.31      7244.36      7585.78      7943.28      8317.64      8709.64      9120.11      9549.93
+        10000      10471.3      10964.8      11481.5      12022.6      12589.3      13182.6      13803.8      14454.4      15135.6
+      15848.9      16595.9        17378        18197      19054.6      19952.6        20893      21877.6      22908.7      23988.3
+      25118.9      26302.7      27542.3      28840.3      30199.5      31622.8      33113.1      34673.7      36307.8      38018.9
+      39810.7      41686.9      43651.6      45708.8        47863      50118.7      52480.7      54954.1        57544        60256
+      63095.7      66069.3      69183.1      72443.6      75857.8      79432.8      83176.4      87096.4      91201.1      95499.3
+       100000       104713       109648       114815       120226       125893       131826       138038       144544       151356
+       158489       165959       173780       181970       190546       199526       208930       218776       229087       239883
+       251189       263027       275423       288403       301995       316228       331131       346737       363078       380189
+       398107       416869       436516       457088       478630       501187       524807       549541       575440       602560
+       630957       660693       691831       724436       758578       794328       831764       870964       912011       954993
+        1e+06  1.04713e+06  1.09648e+06  1.14815e+06  1.20226e+06  1.25893e+06  1.31826e+06  1.38038e+06  1.44544e+06  1.51356e+06
+  1.58489e+06  1.65959e+06   1.7378e+06   1.8197e+06  1.90546e+06  1.99526e+06   2.0893e+06  2.18776e+06  2.29087e+06  2.39883e+06
+  2.51189e+06  2.63027e+06  2.75423e+06  2.88403e+06  3.01995e+06  3.16228e+06  3.31131e+06  3.46737e+06  3.63078e+06  3.80189e+06
+  3.98107e+06  4.16869e+06  4.36516e+06  4.57088e+06   4.7863e+06  5.01187e+06  5.24807e+06  5.49541e+06   5.7544e+06   6.0256e+06
+  6.30957e+06  6.60693e+06  6.91831e+06  7.24436e+06  7.58578e+06  7.94328e+06  8.31764e+06  8.70964e+06  9.12011e+06  9.54993e+06
+        1e+07  1.04713e+07  1.09648e+07  1.14815e+07  1.20226e+07  1.25893e+07  1.31826e+07  1.38038e+07  1.44544e+07  1.51356e+07
+  1.58489e+07  1.65959e+07   1.7378e+07   1.8197e+07  1.90546e+07  1.99526e+07   2.0893e+07  2.18776e+07  2.29087e+07  2.39883e+07
+  2.51189e+07  2.63027e+07  2.75423e+07  2.88403e+07  3.01995e+07  3.16228e+07  3.31131e+07  3.46737e+07  3.63078e+07  3.80189e+07
+  3.98107e+07  4.16869e+07  4.36516e+07  4.57088e+07   4.7863e+07  5.01187e+07  5.24807e+07  5.49541e+07   5.7544e+07   6.0256e+07
+  6.30957e+07  6.60693e+07  6.91831e+07  7.24436e+07  7.58578e+07  7.94328e+07  8.31764e+07  8.70964e+07  9.12011e+07  9.54993e+07
+        1e+08  1.04713e+08  1.09648e+08  1.14815e+08  1.20226e+08  1.25893e+08  1.31826e+08  1.38038e+08  1.44544e+08  1.51356e+08
+  1.58489e+08  1.65959e+08   1.7378e+08   1.8197e+08  1.90546e+08  1.99526e+08   2.0893e+08  2.18776e+08  2.29087e+08  2.39883e+08
+  2.51189e+08  2.63027e+08  2.75423e+08  2.88403e+08  3.01995e+08  3.16228e+08  3.31131e+08  3.46737e+08  3.63078e+08  3.80189e+08
+  3.98107e+08  4.16869e+08  4.36516e+08  4.57088e+08   4.7863e+08  5.01187e+08  5.24807e+08  5.49541e+08   5.7544e+08   6.0256e+08
+  6.30957e+08  6.60693e+08  6.91831e+08  7.24436e+08  7.58578e+08  7.94328e+08  8.31764e+08  8.70964e+08  9.12011e+08  9.54993e+08
+        1e+09
.lin format=touchstone
+ PORTS=P1 P2 P3
.option lis_new=1 post probe

.model s_model S
+ TSTONEFILE = 'Z_plot_NNE_PCB_vf_reduceModel.s5p'

S1
+   n1   n2   n3   n4   n5
+ mname = s_model

P1   n1 0   port=1   z0=0.1
P2   n2 0   port=2   z0=0.1
P3   n3 0   port=3   z0=0.1
XCP4   n4 0  GCM155D70E106ME36_DC0V_125degC $port=4   z0=0.1
XCP5   n5 0  GCM155D70E106ME36_DC0V_125degC $port=5   z0=0.1

.inc GCM155D70E106ME36_DC0V_125degC_0402_10uF.mod

.end
